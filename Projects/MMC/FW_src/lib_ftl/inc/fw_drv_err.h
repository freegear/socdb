/*----------------------------------------------------------
	 MMC controller SOC
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2007 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File Name   : fw_drv_err.h 
	Description : Firmware error return type define file
	Created by  : SHMT SOC Team
-----------------------------------------------------------*/

#ifndef __FW_ERROR_H__
#define __FW_ERROR_H__

/*
/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// 
*/



/*
/////////////////////////////////////////////////////////
        DEFINITION
///////////////////////////////////////////////////////// 
*/


/*--------------------------------------------------------
        Reed Solomon
--------------------------------------------------------*/
typedef enum
{
	RS_NO_ERR,
	RS_ENABLE_ERR,
	RS_DISABLE_ERR,
} RS_ERR;


#endif // __FW_ERROR_H__