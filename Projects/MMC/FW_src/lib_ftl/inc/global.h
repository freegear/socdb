/*----------------------------------------------------------
	 MMC controller SOC
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2007 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File name		: global.h
	Description	: Firmware global variable header file
----------------------------------------------------------*/
#ifndef __GLOBAL_VAR_H__
#define __GLOBAL_VAR_H__

/*
/////////////////////////////////////////////////////////
	INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"
#include "structdef.h"

/*
/////////////////////////////////////////////////////////
	GLOBAL VARIABLE DECLARATION
///////////////////////////////////////////////////////// 
*/

#ifdef GLOBAL_DEFINE
#define GLOBAL_VAR
#else
#define GLOBAL_VAR  extern
#endif

/*---------------------------------------------------------
        MEMEORY
--------------------------------------------------------- */

/*---------------------------------------------------------
        FTL
--------------------------------------------------------- */

/*---------------------------------------------------------
        POWER MANAGEMENT
--------------------------------------------------------- */
GLOBAL_VAR smtUint16 ftlGvar = 0;
GLOBAL_VAR smtUint16 nandGvar = 0;

#endif /* __GLOBAL_VAR_H__ */
