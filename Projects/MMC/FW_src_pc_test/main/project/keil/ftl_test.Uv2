### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0000 // Tools: 'MCS-51'

Group (inc)
Group (lib_ftl)
Group (lib_nand)
Group (main)
Group (sys)

File 1,5,<..\..\..\inc\commonmacro.h><commonmacro.h> 0x0 
File 1,5,<..\..\..\inc\ftl.h><ftl.h> 0x0 
File 1,5,<..\..\..\inc\fw_drv_err.h><fw_drv_err.h> 0x0 
File 1,5,<..\..\..\inc\global.h><global.h> 0x0 
File 1,5,<..\..\..\inc\lib.h><lib.h> 0x0 
File 1,5,<..\..\..\inc\nand.h><nand.h> 0x0 
File 1,5,<..\..\..\inc\sdmmc.h><sdmmc.h> 0x0 
File 1,5,<..\..\..\inc\structdef.h><structdef.h> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl.c><ftl.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_c_core.c><ftl_c_core.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_g_var.c><ftl_g_var.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_build.c><ftl_o_build.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_format.c><ftl_o_format.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_garbage.c><ftl_o_garbage.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_init.c><ftl_o_init.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_lowinit.c><ftl_o_lowinit.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_o_rw.c><ftl_o_rw.c> 0x0 
File 2,1,<..\..\..\lib_ftl\ftl_w_wear.c><ftl_w_wear.c> 0x0 
File 3,1,<..\..\..\lib_nand\ftl_l_memorynand.c><ftl_l_memorynand.c> 0x0 
File 3,1,<..\..\..\lib_nand\lld_k9w8g08u1m.c><lld_k9w8g08u1m.c> 0x0 
File 3,1,<..\..\..\lib_nand\nand_pre_drv.c><nand_pre_drv.c> 0x0 
File 3,1,<..\..\..\lib_nand\nand_post_drv.c><nand_post_drv.c> 0x0 
File 4,2,<.\STARTUP.A51><STARTUP.A51> 0x0 
File 4,1,<..\..\main.c><main.c> 0x0 
File 5,5,<..\..\..\sys\syscfg.h><syscfg.h> 0x0 
File 5,5,<..\..\..\sys\sysdatadef.h><sysdatadef.h> 0x0 
File 5,5,<..\..\..\sys\sysinc.h><sysinc.h> 0x0 
File 5,5,<..\..\..\sys\sysreg.h><sysreg.h> 0x0 


Options 1,0,0  // Target 'Target 1'
 Device (M8052)
 Vendor (Mentor Graphics Co.)
 Cpu (IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000))
 FlashUt ()
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 DevID (3225)
 Rgf (REG52.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg ()
 OrgReg ()
 TgStat=16
 OutDir (.\obj\)
 OutName (ftl_test)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\lst\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=98416
 XT51FL=0
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,176,0,0,0,40,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,0,1,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,0,1,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 IROM512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=17452304
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 (..\..\..\sys; ..\..\..\inc)
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL (\~)
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB (0X0000-0X7FFF)
 LX51XDB (0X8000-0XFFFF)
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-p52)(S8051.DLL)()(TP51.DLL)(-p52)
  OPTDBG 48125,-1,()()()()()()()()()() ()()()()
 FLASH1 { 0,0,0,0,0,0,0,0,255,255,255,255,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ()
 FLASH4 ()
EndOpt

Options 1,3,19  // File 'ftl_l_memorynand.c'
 PropFld { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=0
 AlwaysBuild=2
 GenAsm=2
 AsmAsm=2
 PublicsOnly=2
 StopCode=11
 CustArgs ()
 LibMods ()
 BankNo=65535
 C51FL=177119914
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
EndOpt

