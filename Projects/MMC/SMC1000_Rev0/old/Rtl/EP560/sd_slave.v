// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
`timescale 1ns / 100ps

module sd_slave(
clk,
cmdin,
cmdout,
dtin,
dtout,
oe_cmd,
oe_dt,

abort_b,
addr,
ads_b,
be_b,
blast_b,
cs_b,
drd,
dwr,
error,
rdy_b,
size,
wr,


card_ecc_disabled,
card_ecc_failed,
cid,
csd,
dsr,
ecsd_a,
ecsd_b,
ecsd_c,
ecsd_d,
ecsd_e,
ecsd_f,
ecsd_g,
ecsd_h,
ecsd_i,
ecsd_j,
ecsd_k,
ecsd_l,
ecsd_m,
ecsd_n,
ecsd_o,
ecsd_p,
ecsd_q,
ecsd_r,
ecsd_s,
hreset_b,
ocr_mem,
oe_card_detect,
pwdin,
pwd_len,
rd_thd,
scr,
sel_mmc,
sresetm_b,

dtbuf_raddr,
dtbuf_rdata,
dtbuf_waddr,
dtbuf_wdata,
dtbuf_wren

);
input clk;
input cmdin;
output cmdout;
output oe_cmd;
input[7:0] dtin;
output[7:0] dtout;
output[7:0] oe_dt;
output abort_b;
output[40:0] addr;
output ads_b;
output[3:0] be_b;
output blast_b;
output[1:0] cs_b;
input[31:0] drd;
output[31:0] dwr;
input error;
input rdy_b;
output[9:0] size;
output wr;
input card_ecc_disabled;
input card_ecc_failed;
input[127:0] cid;
input[127:0] csd;
output[15:0] dsr;
input[7:0] ecsd_a;
input[31:0] ecsd_b;
input[7:0] ecsd_c;
input[7:0] ecsd_d;
input[7:0] ecsd_e;
input[7:0] ecsd_f;
input[7:0] ecsd_g;
input[7:0] ecsd_h;
input[7:0] ecsd_i;
input[7:0] ecsd_j;
input[7:0] ecsd_k;
input[7:0] ecsd_l;
input[7:0] ecsd_m;
input[7:0] ecsd_n;
input[7:0] ecsd_o;
input[7:0] ecsd_p;
input[7:0] ecsd_q;
output[7:0] ecsd_r;
output[7:0] ecsd_s;
input hreset_b;
input[31:0] ocr_mem;
output oe_card_detect;
input[127:0] pwdin;
input[7:0] pwd_len;
input[2:0] rd_thd;
input[63:0] scr;
input sel_mmc;
output sresetm_b;
output[9:0] dtbuf_raddr;
input[31:0] dtbuf_rdata;
output[9:0] dtbuf_waddr;
output[31:0] dtbuf_wdata;
output dtbuf_wren;
wire[31:0] I1lO0IOIl0IOIl0;wire lO10IlO10IlIO10;wire OI01lIlO01OOl1I;wire lO10IO01IlIOIl0;wire OI01lI1lO0lIO10;wire[31:0] IIO0lO1lIOOOl1I;
wire[15:0] OI01ll0IO1IOIl0;wire IIO0lOOl1IlIO10;wire OOIl1IlI0OOOl1I;wire IO0lIIO01lIOIl0;wire OOIl1IO0lIlIO10;wire I01lOOIl01OOl1I;
wire OOIl1OlI1OIOIl0;wire I01lOOI01llIO10;wire lIO10l10IOOOl1I;wire[9:0] O01IlOOIl1IlI0O;wire lIO10lO10IlIO10;wire OlI01IlO01OOl1I;
wire[7:0] IOIl0IIO0lIlI0O;wire[127:0] OlI01I1lO0lIO10;wire IOIl0O1lIOOOl1I;wire OlI1OOlI01IlI0O;wire IOIl0OOl1IlIO10;wire OlI1OIlI0OOOl1I;
wire IO01llIO10IlI0O;wire[3:0] OlI1OIO0lIlIO10;wire IO01lOIl01OOl1I;wire l0IO1I01lOIlI0O;wire[12:0] OIl01O1lIOl0IO1;wire l0IO1l10IOOOl1I;
wire OIl01OOIl1IlI0O;wire[15:0] IlI0OIlI0Ol0IO1;wire[31:0] O01IlIlO01OOl1I;wire IlI0OIIO0lIlI0O;wire O1lIOOIl01l0IO1;wire IlI0OO1lIOOOl1I;
wire O1lIOOlI01IlI0O;wire[7:0] IlO01l10IOl0IO1;wire O1lIOIlI0OOOl1I;wire[31:0] IlO01lIO10IlI0O;wire l10IOIlO01l0IO1;wire lO10IIOIl0OOIl1;
wire l10IOI01lOIlI0O;wire lO10IO1lIOl0IO1;wire OI01lO01IlOOIl1;wire lO10IOOIl1IlI0O;wire OI01lIlI0Ol0IO1;wire IO0lIl0IO1OOIl1;wire OI01lIIO0lIlI0O;
wire IO0lIOIl01l0IO1;wire OOl1IIO01lOOIl1;wire[31:0] IO0lIOlI01IlI0O;wire OOl1Il10IOl0IO1;wire[31:0] I01lOOlI1OOOIl1;wire[10:0] lIO10OI01lOI01l;
wire I1lO0IlO01l0IO1;wire lIO10IOIl0OOIl1;wire OlI01lO10IOI01l;wire lIO10O1lIOl0IO1;wire OlI01O01IlOOIl1;wire IIO0lI1lO0OI01l;wire OlI01IlI0Ol0IO1;
wire IIO0ll0IO1OOIl1;wire OlI1OOOl1IOI01l;wire IIO0lOIl01l0IO1;wire OOIl1IO01lOOIl1;wire IO01lIO0lIOI01l;wire l0IO1O01Ill10IO;wire IO01lOlI1OOOIl1;
wire l0IO1OI01lOI01l;wire[15:0] O01Ill0IO1l10IO;wire l0IO1IOIl0OOIl1;wire O01IllO10IOI01l;wire IOIl0IO01ll10IO;wire[6:0] O01IlO01IlOOIl1;
wire IOIl0I1lO0OI01l;wire[7:0] O1lIOOlI1Ol10IO;wire IOIl0l0IO1OOIl1;wire[7:0] O1lIOOOl1IOI01l;wire IlO01IOIl0l10IO;wire IlO01IO0lIOI01l;
wire l10IOO01Ill10IO;wire OIl01I01lOOlI1O;wire l10IOOI01lOI01l;wire OIl01l0IO1l10IO;wire OI01lOOIl1OlI1O;wire[15:0] OIl01lO10IOI01l;
wire IlI0OIO01ll10IO;wire IO0lIIIO0lOlI1O;wire IlI0OI1lO0OI01l;wire[31:0] IO0lIOlI1Ol10IO;wire OOl1IOlI01OlI1O;wire[40:0] IO0lIOOl1IOI01l;
wire[1:0] OOl1IIOIl0l10IO;wire I1lO0lIO10OlI1O;wire[8:0] lO10IIlO01OlI01;wire I1lO0O01Ill10IO;wire lO10II01lOOlI1O;wire OlI01O1lIOOlI01;
wire lO10Il0IO1l10IO;wire OlI01OOIl1OlI1O;wire IIO0lIlI0OOlI01;wire OI01lIO01ll10IO;wire[7:0] IIO0lIIO0lOlI1O;wire OOIl1OIl01OlI01;
wire IIO0lOlI1Ol10IO;wire OOIl1OlI01OlI1O;wire I01lOl10IOOlI01;wire[11:0] l0IO1OOIl1I1lO0;wire I01lOlIO10OlI1O;wire lIO10IlO01OlI01;
wire[15:0] O01IlIIO0lI1lO0;wire lIO10I01lOOlI1O;wire O01IlO1lIOOlI01;wire[31:0] IOIl0OlI01I1lO0;wire O01IlOOIl1OlI1O;wire[31:0] IOIl0IlI0OOlI01;
wire[31:0] OlI1OlIO10I1lO0;wire IOIl0IIO0lOlI1O;wire OlI1OOIl01OlI01;wire IO01lI01lOI1lO0;wire l10IOIO0lIO1lIO;wire IO01ll10IOOlI01;
wire l10IOOOIl1I1lO0;wire OIl01OI01lO1lIO;wire l0IO1IlO01OlI01;wire OIl01IIO0lI1lO0;wire IlI0OlO10IO1lIO;wire OIl01O1lIOOlI01;wire IlI0OOlI01I1lO0;
wire O1lIOI1lO0O1lIO;wire IlI0OIlI0OOlI01;wire O1lIOlIO10I1lO0;wire[3:0] OOl1IOOl1IO1lIO;wire[10:0] I1lO0IOIl0O01Il;wire IlO01I01lOI1lO0;
wire I1lO0IO0lIO1lIO;wire lO10IO01IlO01Il;wire I1lO0OOIl1I1lO0;wire lO10IOI01lO1lIO;wire[1:0] OI01ll0IO1O01Il;wire lO10IIIO0lI1lO0;
wire OI01llO10IO1lIO;wire IO0lIIO01lO01Il;wire OI01lOlI01I1lO0;wire IO0lII1lO0O1lIO;wire OOIl1OlI1OO01Il;wire I01lOOI01lI01lO;wire[3:0] OOIl1OOl1IO1lIO;
wire I01lOIOIl0O01Il;wire lIO10lO10II01lO;wire I01lOIO0lIO1lIO;wire lIO10O01IlO01Il;wire OlI01I1lO0I01lO;wire[7:0] lIO10OI01lO1lIO;
wire OlI01l0IO1O01Il;wire[7:0] IOIl0OOl1II01lO;wire OlI01lO10IO1lIO;wire IIO0lIO01lO01Il;wire OlI1OIO0lII01lO;wire[14:0] OlI1OOlI1OO01Il;
wire IO01lOI01lI01lO;wire l0IO1l10IOIO0lI;wire IO01lIOIl0O01Il;wire[31:9] l0IO1lO10II01lO;wire O01IlIlO01IO0lI;wire[15:0] l0IO1O01IlO01Il;
wire O01IlI1lO0I01lO;wire[1:0] IlI0OO1lIOIO0lI;wire O01Ill0IO1O01Il;wire IlI0OOOl1II01lO;wire O1lIOIlI0OIO0lI;wire[31:0] IOIl0IO01lO01Il;
wire O1lIOIO0lII01lO;wire IlO01OIl01IO0lI;wire[11:0] l10IOI01lOOIl01;wire IlO01OI01lI01lO;wire l10IOl10IOIO0lI;wire lO10IOOIl1OIl01;
wire[3:0] l10IOlO10II01lO;wire OIl01IlO01IO0lI;wire OI01lIIO0lOIl01;wire OIl01I1lO0I01lO;wire OI01lO1lIOIO0lI;wire IO0lIOlI01OIl01;
wire OI01lOOl1II01lO;wire IO0lIIlI0OIO0lI;wire OOl1IlIO10OIl01;wire[12:0] I1lO0IlO01IO01l;wire OOl1IOIl01IO0lI;wire I1lO0I01lOOIl01;
wire[15:0] lIO10O1lIOIO01l;wire[31:0] I1lO0l10IOIO0lI;wire lIO10OOIl1OIl01;wire[15:0] OlI01IlI0OIO01l;wire lO10IIlO01IO0lI;wire OlI01IIO0lOIl01;
wire[31:0] IIO0lOIl01IO01l;wire OlI01O1lIOIO0lI;wire IIO0lOlI01OIl01;wire OOIl1l10IOIO01l;wire IO01lOlI1OIIO0l;wire OOIl1lIO10OIl01;
wire I01lOIlO01IO01l;wire l0IO1IOIl0IIO0l;wire I01lOI01lOOIl01;wire l0IO1O1lIOIO01l;wire O01IlO01IlIIO0l;wire l0IO1OOIl1OIl01;wire[7:0] O01IlIlI0OIO01l;
wire IOIl0l0IO1IIO0l;wire O01IlIIO0lOIl01;wire[31:0] IOIl0OIl01IO01l;wire OlI1OIO01lIIO0l;wire[9:0] IlO01IO0lIlO10I;wire OlI1Ol10IOIO01l;
wire IlO01OlI1OIIO0l;wire[7:0] l10IOOI01llO10I;wire IO01lIlO01IO01l;wire l10IOIOIl0IIO0l;wire OIl01lO10IlO10I;wire l10IOO1lIOIO01l;
wire OIl01O01IlIIO0l;wire IlI0OI1lO0lO10I;wire OIl01IlI0OIO01l;wire IlI0Ol0IO1IIO0l;wire IO0lIOOl1IlO10I;wire OOl1IIOIl0IlO01;wire[6:0] O1lIOIO01lIIO0l;
wire OOl1IIO0lIlO10I;wire[3:0] I1lO0O01IlIlO01;wire OOl1IOlI1OIIO0l;wire I1lO0OI01llO10I;wire lO10Il0IO1IlO01;wire[6:0] I1lO0IOIl0IIO0l;
wire lO10IlO10IlO10I;wire OI01lIO01lIlO01;wire lO10IO01IlIIO0l;wire[9:0] OI01lI1lO0lO10I;wire IIO0lOlI1OIlO01;wire[31:0] IIO0lOOl1IlO10I;
wire[63:0] OOIl1IOIl0IlO01;wire[15:0] I01lOlIO10IOIl0;wire OOIl1IO0lIlO10I;wire I01lOO01IlIlO01;wire lIO10I01lOIOIl0;wire[15:0] I01lOOI01llO10I;
wire lIO10l0IO1IlO01;wire[1:0] O01IlOOIl1IOIl0;wire[31:0] lIO10lO10IlO10I;wire OlI01IO01lIlO01;wire IOIl0IIO0lIOIl0;wire[31:0] OlI01I1lO0lO10I;
wire IOIl0OlI1OIlO01;wire OlI1OOlI01IOIl0;wire[11:0] IO01ll10IOlIO10;wire OlI1OIOIl0IlO01;wire IO01llIO10IOIl0;wire l0IO1IlO01lIO10;
wire[31:0] IO01lO01IlIlO01;wire l0IO1I01lOIOIl0;wire OIl01O1lIOlIO10;wire l0IO1l0IO1IlO01;wire[3:0] OIl01OOIl1IOIl0;wire IlI0OIlI0OlIO10;
wire O01IlIO01lIlO01;wire IlI0OIIO0lIOIl0;wire O1lIOOIl01lIO10;wire[11:0] IlO01IO01lOOl1I;wire O1lIOOlI01IOIl0;wire IlO01l10IOlIO10;
wire[15:0] I1lO0OlI1OOOl1I;wire[3:0] IlO01lIO10IOIl0;wire[5:0] l10IOIlO01lIO10;wire lO10IIOIl0OOl1I;wire l10IOI01lOIOIl0;wire lO10IO1lIOlIO10;
wire OI01lO01IlOOl1I;wire lO10IOOIl1IOIl0;wire OI01lIlI0OlIO10;wire IO0lIl0IO1OOl1I;wire[12:0] OOIl1OOl1IIlI0O;wire IO0lIOIl01lIO10;
wire OOl1IIO01lOOl1I;wire[1:0] I01lOIO0lIIlI0O;wire OOl1Il10IOlIO10;wire I01lOOlI1OOOl1I;wire lIO10OI01lIlI0O;wire I1lO0IlO01lIO10;
wire lIO10IOIl0OOl1I;wire OlI01lO10IIlI0O;wire lIO10O1lIOlIO10;wire[7:0] OlI01O01IlOOl1I;wire IIO0lI1lO0IlI0O;wire[9:0] OlI1OOlI1Ol0IO1;
wire IIO0ll0IO1OOl1I;wire OlI1OOOl1IIlI0O;wire IO01lIOIl0l0IO1;wire OOIl1IO01lOOl1I;wire IO01lIO0lIIlI0O;wire l0IO1O01Ill0IO1;wire IO01lOlI1OOOl1I;
wire[10:0] l0IO1OI01lIlI0O;wire[2:0] O01Ill0IO1l0IO1;wire l0IO1IOIl0OOl1I;wire O01IllO10IIlI0O;wire IOIl0IO01ll0IO1;wire O1lIOIIO0lOOIl1;
wire[127:0] IOIl0I1lO0IlI0O;wire O1lIOOlI1Ol0IO1;wire IlO01OlI01OOIl1;wire O1lIOOOl1IIlI0O;wire IlO01IOIl0l0IO1;wire l10IOlIO10OOIl1;
wire IlO01IO0lIIlI0O;wire l10IOO01Ill0IO1;wire[31:0] OIl01I01lOOOIl1;wire l10IOOI01lIlI0O;wire OIl01l0IO1l0IO1;wire OI01lOOIl1OOIl1;
wire[3:0] IlI0OIO01ll0IO1;wire[12:0] IO0lIIIO0lOOIl1;wire OOl1IOIl01OI01l;wire IO0lIOlI1Ol0IO1;wire OOl1IOlI01OOIl1;wire I1lO0l10IOOI01l;
wire[15:0] OOl1IIOIl0l0IO1;wire I1lO0lIO10OOIl1;wire lO10IIlO01OI01l;wire I1lO0O01Ill0IO1;wire lO10II01lOOOIl1;wire OlI01O1lIOOI01l;
wire lO10Il0IO1l0IO1;wire OlI01OOIl1OOIl1;wire IIO0lIlI0OOI01l;wire OOIl1lIO10l10IO;wire IIO0lIIO0lOOIl1;wire OOIl1OIl01OI01l;wire I01lOI01lOl10IO;
wire OOIl1OlI01OOIl1;wire[15:0] I01lOl10IOOI01l;wire[31:0] l0IO1OOIl1l10IO;wire I01lOlIO10OOIl1;wire lIO10IlO01OI01l;wire O01IlIIO0ll10IO;
wire lIO10I01lOOOIl1;wire O01IlO1lIOOI01l;wire IOIl0OlI01l10IO;wire[10:0] OlI1OI1lO0OlI1O;wire IOIl0IlI0OOI01l;wire OlI1OlIO10l10IO;
wire[7:0] IlO01OOl1IOlI1O;wire OlI1OOIl01OI01l;wire[31:0] IO01lI01lOl10IO;wire l10IOIO0lIOlI1O;wire IO01ll10IOOI01l;wire l10IOOOIl1l10IO;
wire OIl01OI01lOlI1O;wire[15:0] l0IO1IlO01OI01l;wire OIl01IIO0ll10IO;wire IlI0OlO10IOlI1O;wire O1lIOIO01lOlI01;wire IlI0OOlI01l10IO;
wire O1lIOI1lO0OlI1O;wire[31:0] OOl1IOlI1OOlI01;wire O1lIOlIO10l10IO;wire OOl1IOOl1IOlI1O;wire I1lO0IOIl0OlI01;wire IlO01I01lOl10IO;
wire I1lO0IO0lIOlI1O;wire lO10IO01IlOlI01;wire I1lO0OOIl1l10IO;wire lO10IOI01lOlI1O;wire OI01ll0IO1OlI01;wire[9:0] IIO0lOOl1II1lO0;
wire OI01llO10IOlI1O;wire IO0lIIO01lOlI01;wire[7:0] OOIl1IO0lII1lO0;wire IO0lII1lO0OlI1O;wire OOIl1OlI1OOlI01;wire I01lOOI01lI1lO0;
wire OOIl1OOl1IOlI1O;wire I01lOIOIl0OlI01;wire[9:0] lIO10lO10II1lO0;wire I01lOIO0lIOlI1O;wire lIO10O01IlOlI01;wire[1:0] OlI01I1lO0I1lO0;
wire IOIl0O1lIOO1lIO;wire OlI01l0IO1OlI01;wire IOIl0OOl1II1lO0;wire OlI1OIlI0OO1lIO;wire IIO0lIO01lOlI01;wire OlI1OIO0lII1lO0;wire IO01lOIl01O1lIO;
wire OlI1OOlI1OOlI01;wire IO01lOI01lI1lO0;wire l0IO1l10IOO1lIO;wire IO01lIOIl0OlI01;wire[31:0] l0IO1lO10II1lO0;wire O01IlIlO01O1lIO;
wire O01IlI1lO0I1lO0;wire[31:0] IlI0OO1lIOO1lIO;wire[7:0] O1lIOOlI01O01Il;wire IlI0OOOl1II1lO0;wire O1lIOIlI0OO1lIO;wire IlO01lIO10O01Il;
wire[15:0] O1lIOIO0lII1lO0;wire IlO01OIl01O1lIO;wire l10IOI01lOO01Il;wire IlO01OI01lI1lO0;wire l10IOl10IOO1lIO;wire lO10IOOIl1O01Il;
wire l10IOlO10II1lO0;wire OIl01IlO01O1lIO;wire[31:0] OI01lIIO0lO01Il;wire IO0lIOIl01I01lO;wire OI01lO1lIOO1lIO;wire IO0lIOlI01O01Il;
wire OOl1Il10IOI01lO;wire[31:0] IO0lIIlI0OO1lIO;wire[1:0] OOl1IlIO10O01Il;wire[4:0] I1lO0IlO01I01lO;wire OOl1IOIl01O1lIO;wire I1lO0I01lOO01Il;
wire lIO10O1lIOI01lO;wire I1lO0l10IOO1lIO;wire lIO10OOIl1O01Il;wire OlI01IlI0OI01lO;wire[9:0] IIO0ll0IO1IO0lI;wire OlI01IIO0lO01Il;
wire IIO0lOIl01I01lO;wire OOIl1IO01lIO0lI;wire IIO0lOlI01O01Il;wire[31:0] OOIl1l10IOI01lO;wire IO01lOlI1OIO0lI;wire OOIl1lIO10O01Il;
wire I01lOIlO01I01lO;wire[7:0] l0IO1IOIl0IO0lI;wire[15:0] I01lOI01lOO01Il;wire l0IO1O1lIOI01lO;wire O01IlO01IlIO0lI;wire IOIl0I1lO0OIl01;
wire O01IlIlI0OI01lO;wire IOIl0l0IO1IO0lI;wire[15:0] O1lIOOOl1IOIl01;wire IOIl0OIl01I01lO;wire OlI1OIO01lIO0lI;wire[31:0] IlO01IO0lIOIl01;
wire OlI1Ol10IOI01lO;wire IlO01OlI1OIO0lI;wire l10IOOI01lOIl01;wire IO01lIlO01I01lO;wire l10IOIOIl0IO0lI;wire OIl01lO10IOIl01;wire IlI0OIO01lIO01l;
wire OIl01O01IlIO0lI;wire IlI0OI1lO0OIl01;wire IO0lIOlI1OIO01l;wire IlI0Ol0IO1IO0lI;wire IO0lIOOl1IOIl01;wire OOl1IIOIl0IO01l;wire O1lIOIO01lIO0lI;
wire OOl1IIO0lIOIl01;wire[31:0] I1lO0O01IlIO01l;wire OOl1IOlI1OIO0lI;wire I1lO0OI01lOIl01;wire[31:0] lO10Il0IO1IO01l;wire[7:0] OlI01OOIl1IIO0l;
wire lO10IlO10IOIl01;wire OI01lIO01lIO01l;wire[4:0] IIO0lIIO0lIIO0l;wire OI01lI1lO0OIl01;wire IIO0lOlI1OIO01l;wire OOIl1OlI01IIO0l;
wire IIO0lOOl1IOIl01;wire OOIl1IOIl0IO01l;wire I01lOlIO10IIO0l;wire OOIl1IO0lIOIl01;wire I01lOO01IlIO01l;wire lIO10I01lOIIO0l;wire[7:0] lIO10l0IO1IO01l;
wire[31:0] O01IlOOIl1IIO0l;wire[4:0] IOIl0IlI0OlO10I;wire OlI01IO01lIO01l;wire IOIl0IIO0lIIO0l;wire OlI1OOIl01lO10I;wire IOIl0OlI1OIO01l;
wire OlI1OOlI01IIO0l;wire IO01ll10IOlO10I;wire OlI1OIOIl0IO01l;wire IO01llIO10IIO0l;wire[31:0] l0IO1IlO01lO10I;wire IO01lO01IlIO01l;
wire[31:0] l0IO1I01lOIIO0l;wire OIl01O1lIOlO10I;wire IlI0OOlI01IlO01;wire OIl01OOIl1IIO0l;wire IlI0OIlI0OlO10I;wire[31:0] O1lIOlIO10IlO01;
wire[15:0] IlI0OIIO0lIIO0l;wire O1lIOOIl01lO10I;wire IlO01I01lOIlO01;wire O1lIOOlI01IIO0l;wire IlO01l10IOlO10I;wire I1lO0OOIl1IlO01;
wire IlO01lIO10IIO0l;wire l10IOIlO01lO10I;wire lO10IIIO0lIlO01;wire[9:0] OI01llO10IIOIl0;wire lO10IO1lIOlO10I;wire OI01lOlI01IlO01;
wire[7:0] IO0lII1lO0IOIl0;wire[7:0] OI01lIlI0OlO10I;wire IO0lIlIO10IlO01;wire OOIl1OOl1IIOIl0;wire IO0lIOIl01lO10I;wire[5:0] OOl1II01lOIlO01;
wire I01lOIO0lIIOIl0;wire OOl1Il10IOlO10I;wire I01lOOOIl1IlO01;wire lIO10OI01lIOIl0;wire[7:0] OlI01l0IO1lIO10;wire lIO10IIO0lIlO01;
wire OlI01lO10IIOIl0;wire[15:0] IIO0lIO01llIO10;wire OlI01OlI01IlO01;wire IIO0lI1lO0IOIl0;wire OlI1OOlI1OlIO10;wire IIO0llIO10IlO01;
wire[31:0] OlI1OOOl1IIOIl0;wire IO01lIOIl0lIO10;wire OOIl1I01lOIlO01;wire IO01lIO0lIIOIl0;wire l0IO1O01IllIO10;wire O01IlI01lOOOl1I;
wire l0IO1OI01lIOIl0;wire O01Ill0IO1lIO10;wire IlI0OOOIl1OOl1I;wire O01IllO10IIOIl0;wire IOIl0IO01llIO10;wire[22:0] O1lIOIIO0lOOl1I;
wire IOIl0I1lO0IOIl0;wire O1lIOOlI1OlIO10;wire IlO01OlI01OOl1I;wire O1lIOOOl1IIOIl0;wire IlO01IOIl0lIO10;wire[5:0] l10IOlIO10OOl1I;
wire OIl01IlO01IlI0O;wire l10IOO01IllIO10;wire OIl01I01lOOOl1I;wire OI01lO1lIOIlI0O;wire OIl01l0IO1lIO10;wire OI01lOOIl1OOl1I;wire IO0lIIlI0OIlI0O;
wire IlI0OIO01llIO10;wire IO0lIIIO0lOOl1I;wire[7:0] OOl1IOIl01IlI0O;wire IO0lIOlI1OlIO10;wire OOl1IOlI01OOl1I;wire I1lO0l10IOIlI0O;
wire lIO10OOIl1l0IO1;wire[7:0] I1lO0lIO10OOl1I;wire lO10IIlO01IlI0O;wire[15:0] OlI01IIO0ll0IO1;wire lO10II01lOOOl1I;wire OlI01O1lIOIlI0O;
wire IIO0lOlI01l0IO1;wire[6:0] OlI01OOIl1OOl1I;wire IIO0lIlI0OIlI0O;wire OOIl1lIO10l0IO1;wire IIO0lIIO0lOOl1I;wire[7:0] OOIl1OIl01IlI0O;
wire I01lOI01lOl0IO1;wire I01lOl10IOIlI0O;wire l0IO1OOIl1l0IO1;wire O01IlOI01lOOIl1;wire lIO10IlO01IlI0O;wire O01IlIIO0ll0IO1;wire[31:0] IOIl0lO10IOOIl1;
wire[15:0] O01IlO1lIOIlI0O;wire[7:0] IOIl0OlI01l0IO1;wire OlI1OI1lO0OOIl1;wire IOIl0IlI0OIlI0O;wire OlI1OlIO10l0IO1;wire IlO01OOl1IOOIl1;
wire OlI1OOIl01IlI0O;wire[1:0] IO01lI01lOl0IO1;wire l10IOIO0lIOOIl1;wire[11:0] OIl01O01IlOI01l;wire l10IOOOIl1l0IO1;wire OIl01OI01lOOIl1;
wire[15:0] IlI0Ol0IO1OI01l;wire OIl01IIO0ll0IO1;wire IlI0OlO10IOOIl1;wire O1lIOIO01lOI01l;wire IlI0OOlI01l0IO1;wire[7:0] O1lIOI1lO0OOIl1;
wire OOl1IOlI1OOI01l;wire O1lIOlIO10l0IO1;wire OOl1IOOl1IOOIl1;wire I1lO0IOIl0OI01l;wire[11:0] lO10IlO10Il10IO;wire I1lO0IO0lIOOIl1;
wire lO10IO01IlOI01l;wire[15:0] OI01lI1lO0l10IO;wire lO10IOI01lOOIl1;wire OI01ll0IO1OI01l;wire IIO0lOOl1Il10IO;wire OI01llO10IOOIl1;
wire[7:0] IO0lIIO01lOI01l;wire[7:0] OOIl1IO0lIl10IO;wire IO0lII1lO0OOIl1;wire[31:0] OOIl1OlI1OOI01l;wire I01lOOI01ll10IO;wire lIO10l10IOOlI1O;
wire I01lOIOIl0OI01l;wire lIO10lO10Il10IO;wire OlI01IlO01OlI1O;wire lIO10O01IlOI01l;wire OlI01I1lO0l10IO;wire IOIl0O1lIOOlI1O;wire OlI01l0IO1OI01l;
wire IOIl0OOl1Il10IO;wire OlI1OIlI0OOlI1O;wire IIO0lIO01lOI01l;wire OlI1OIO0lIl10IO;wire[31:0] IO01lOIl01OlI1O;wire[10:0] l0IO1I01lOOlI01;
wire IO01lOI01ll10IO;wire l0IO1l10IOOlI1O;wire OIl01OOIl1OlI01;wire l0IO1lO10Il10IO;wire O01IlIlO01OlI1O;wire IlI0OIIO0lOlI01;wire O01IlI1lO0l10IO;
wire IlI0OO1lIOOlI1O;wire O1lIOOlI01OlI01;wire IlI0OOOl1Il10IO;wire O1lIOIlI0OOlI1O;wire IlO01lIO10OlI01;wire l10IOIlO01I1lO0;wire[3:0] IlO01OIl01OlI1O;
wire l10IOI01lOOlI01;wire lO10IO1lIOI1lO0;wire l10IOl10IOOlI1O;wire lO10IOOIl1OlI01;wire OI01lIlI0OI1lO0;wire[7:0] OIl01IlO01OlI1O;
wire OI01lIIO0lOlI01;wire[7:0] IO0lIOIl01I1lO0;wire OI01lO1lIOOlI1O;wire IO0lIOlI01OlI01;wire OOl1Il10IOI1lO0;wire[14:0] OOl1IlIO10OlI01;
wire I1lO0IlO01I1lO0;wire lIO10IOIl0O1lIO;wire I1lO0I01lOOlI01;wire[31:9] lIO10O1lIOI1lO0;wire OlI01O01IlO1lIO;wire[15:0] lIO10OOIl1OlI01;
wire[7:0] OlI01IlI0OI1lO0;wire[1:0] IIO0ll0IO1O1lIO;wire OlI01IIO0lOlI01;wire IIO0lOIl01I1lO0;wire OOIl1IO01lO1lIO;wire[31:0] IIO0lOlI01OlI01;
wire OOIl1l10IOI1lO0;wire IO01lOlI1OO1lIO;wire[9:0] l0IO1OI01lO01Il;wire I01lOIlO01I1lO0;wire l0IO1IOIl0O1lIO;wire O01IllO10IO01Il;
wire[2:0] l0IO1O1lIOI1lO0;wire O01IlO01IlO1lIO;wire IOIl0I1lO0O01Il;wire O01IlIlI0OI1lO0;wire IOIl0l0IO1O1lIO;wire O1lIOOOl1IO01Il;
wire IOIl0OIl01I1lO0;wire OlI1OIO01lO1lIO;wire IlO01IO0lIO01Il;wire[11:0] l10IOO01IlI01lO;wire IlO01OlI1OO1lIO;wire l10IOOI01lO01Il;
wire[15:0] OIl01l0IO1I01lO;wire[1:0] l10IOIOIl0O1lIO;wire OIl01lO10IO01Il;wire IlI0OIO01lI01lO;wire OIl01O01IlO1lIO;wire[31:0] IlI0OI1lO0O01Il;
wire[31:0] IO0lIOlI1OI01lO;wire IlI0Ol0IO1O1lIO;wire IO0lIOOl1IO01Il;wire OOl1IIOIl0I01lO;wire I1lO0lIO10IO0lI;wire OOl1IIO0lIO01Il;
wire I1lO0O01IlI01lO;wire lO10II01lOIO0lI;wire I1lO0OI01lO01Il;wire lO10Il0IO1I01lO;wire OlI01OOIl1IO0lI;wire lO10IlO10IO01Il;wire OI01lIO01lI01lO;
wire IIO0lIIO0lIO0lI;wire OI01lI1lO0O01Il;wire IIO0lOlI1OI01lO;wire[6:0] OOIl1OlI01IO0lI;wire[10:0] I01lOl10IOOIl01;wire OOIl1IOIl0I01lO;
wire I01lOlIO10IO0lI;wire lIO10IlO01OIl01;wire I01lOO01IlI01lO;wire lIO10I01lOIO0lI;wire O01IlO1lIOOIl01;wire lIO10l0IO1I01lO;wire O01IlOOIl1IO0lI;
wire IOIl0IlI0OOIl01;wire[127:0] OlI01IO01lI01lO;wire IOIl0IIO0lIO0lI;wire OlI1OOIl01OIl01;wire IO01lI01lOIO01l;wire[6:0] OlI1OOlI01IO0lI;
wire IO01ll10IOOIl01;wire l10IOOOIl1IO01l;wire IO01llIO10IO0lI;wire l0IO1IlO01OIl01;wire OIl01IIO0lIO01l;wire[3:0] l0IO1I01lOIO0lI;
wire OIl01O1lIOOIl01;wire[31:0] IlI0OOlI01IO01l;wire OIl01OOIl1IO0lI;wire IlI0OIlI0OOIl01;wire O1lIOlIO10IO01l;wire[14:0] O1lIOOIl01OIl01;
wire IlO01I01lOIO01l;wire I1lO0IO0lIIIO0l;wire IlO01l10IOOIl01;wire I1lO0OOIl1IO01l;wire lO10IOI01lIIO0l;wire[15:0] l10IOIlO01OIl01;
wire[3:0] lO10IIIO0lIO01l;wire OI01llO10IIIO0l;wire lO10IO1lIOOIl01;wire OI01lOlI01IO01l;wire IO0lII1lO0IIO0l;wire OI01lIlI0OOIl01;
wire IO0lIlIO10IO01l;wire OOIl1OOl1IIIO0l;wire[11:0] I01lOIOIl0lO10I;wire OOl1II01lOIO01l;wire I01lOIO0lIIIO0l;wire lIO10O01IllO10I;
wire[3:0] I01lOOOIl1IO01l;wire lIO10OI01lIIO0l;wire[31:0] OlI01l0IO1lO10I;wire lIO10IIO0lIO01l;wire OlI01lO10IIIO0l;wire IIO0lIO01llO10I;
wire OlI01OlI01IO01l;wire IIO0lI1lO0IIO0l;wire OlI1OOlI1OlO10I;wire[12:0] IO01lOI01lIlO01;wire OlI1OOOl1IIIO0l;wire IO01lIOIl0lO10I;
wire[15:0] l0IO1lO10IIlO01;wire[31:0] IO01lIO0lIIIO0l;wire l0IO1O01IllO10I;wire[15:0] O01IlI1lO0IlO01;wire l0IO1OI01lIIO0l;wire O01Ill0IO1lO10I;
wire[31:0] IlI0OOOl1IIlO01;wire O01IllO10IIIO0l;wire IOIl0IO01llO10I;wire O1lIOIO0lIIlO01;wire IlO01OIl01IOIl0;wire O1lIOOlI1OlO10I;
wire IlO01OI01lIlO01;wire[1:0] l10IOl10IOIOIl0;wire IlO01IOIl0lO10I;wire l10IOlO10IIlO01;wire OIl01IlO01IOIl0;wire l10IOO01IllO10I;
wire OIl01I1lO0IlO01;wire OI01lO1lIOIOIl0;wire OIl01l0IO1lO10I;wire OI01lOOl1IIlO01;wire IO0lIIlI0OIOIl0;wire[9:0] OOl1IlIO10lIO10;
wire IO0lIIO0lIIlO01;wire OOl1IOIl01IOIl0;wire I1lO0I01lOlIO10;wire OOl1IOI01lIlO01;wire I1lO0l10IOIOIl0;wire lIO10OOIl1lIO10;wire I1lO0lO10IIlO01;
wire lO10IIlO01IOIl0;wire OlI01IIO0llIO10;wire lO10II1lO0IlO01;wire OlI01O1lIOIOIl0;wire IIO0lOlI01lIO10;wire OOIl1I1lO0OOl1I;wire[127:0] IIO0lIlI0OIOIl0;
wire OOIl1lIO10lIO10;wire[7:0] IO01lOOl1IOOl1I;wire OOIl1OIl01IOIl0;wire I01lOI01lOlIO10;wire l0IO1IO0lIOOl1I;wire[6:0] I01lOl10IOIOIl0;
wire l0IO1OOIl1lIO10;wire O01IlOI01lOOl1I;wire lIO10IlO01IOIl0;wire[1:0] O01IlIIO0llIO10;wire IOIl0lO10IOOl1I;wire[31:0] IOIl0OlI01lIO10;
wire[7:0] OlI1OI1lO0OOl1I;wire[15:0] IlO01OlI1OIlI0O;wire OlI1OlIO10lIO10;wire IlO01OOl1IOOl1I;wire l10IOIOIl0IlI0O;wire[15:0] IO01lI01lOlIO10;
wire l10IOIO0lIOOl1I;wire[1:0] OIl01O01IlIlI0O;wire l10IOOOIl1lIO10;wire OIl01OI01lOOl1I;wire IlI0Ol0IO1IlI0O;wire OIl01IIO0llIO10;
wire IlI0OlO10IOOl1I;wire O1lIOIO01lIlI0O;wire OOl1IIO0lIl0IO1;wire O1lIOI1lO0OOl1I;wire OOl1IOlI1OIlI0O;wire[9:0] I1lO0OI01ll0IO1;
wire OOl1IOOl1IOOl1I;wire[15:0] I1lO0IOIl0IlI0O;wire lO10IlO10Il0IO1;wire I1lO0IO0lIOOl1I;wire lO10IO01IlIlI0O;wire OI01lI1lO0l0IO1;
wire lO10IOI01lOOl1I;wire OI01ll0IO1IlI0O;wire IIO0lOOl1Il0IO1;wire[11:0] OOIl1IlI0OOOIl1;wire IO0lIIO01lIlI0O;wire OOIl1IO0lIl0IO1;
wire[15:0] I01lOOIl01OOIl1;wire OOIl1OlI1OIlI0O;wire I01lOOI01ll0IO1;wire lIO10l10IOOOIl1;wire I01lOIOIl0IlI0O;wire lIO10lO10Il0IO1;
wire OlI01IlO01OOIl1;wire lIO10O01IlIlI0O;wire OlI01I1lO0l0IO1;wire IOIl0O1lIOOOIl1;wire[12:0] OlI1OOlI01OI01l;wire IOIl0OOl1Il0IO1;
wire OlI1OIlI0OOOIl1;wire[31:0] IO01llIO10OI01l;wire OlI1OIO0lIl0IO1;wire IO01lOIl01OOIl1;wire l0IO1I01lOOI01l;wire IO01lOI01ll0IO1;
wire l0IO1l10IOOOIl1;wire OIl01OOIl1OI01l;wire l0IO1lO10Il0IO1;wire[7:0] O01IlIlO01OOIl1;wire IlI0OIIO0lOI01l;wire[9:0] O1lIOOIl01l10IO;
wire IlI0OO1lIOOOIl1;wire O1lIOOlI01OI01l;wire[1:0] IlO01l10IOl10IO;wire O1lIOIlI0OOOIl1;wire IlO01lIO10OI01l;wire l10IOIlO01l10IO;
wire IlO01OIl01OOIl1;wire[10:0] l10IOI01lOOI01l;wire[2:0] lO10IO1lIOl10IO;wire l10IOl10IOOOIl1;wire lO10IOOIl1OI01l;wire[31:0] OI01lIlI0Ol10IO;
wire[7:0] IO0lIl0IO1OlI1O;wire[7:0] OI01lIIO0lOI01l;wire IO0lIOIl01l10IO;wire OOl1IIO01lOlI1O;wire IO0lIOlI01OI01l;wire OOl1Il10IOl10IO;
wire I01lOOlI1OOlI1O;wire OOl1IlIO10OI01l;wire I1lO0IlO01l10IO;wire[31:0] lIO10IOIl0OlI1O;wire I1lO0I01lOOI01l;wire[3:0] lIO10O1lIOl10IO;
wire OlI01O01IlOlI1O;wire OlI01IlI0Ol10IO;wire[31:0] IIO0ll0IO1OlI1O;wire OlI1OOOl1IOlI01;wire IIO0lOIl01l10IO;wire OOIl1IO01lOlI1O;
wire IO01lIO0lIOlI01;wire[15:0] OOIl1l10IOl10IO;wire IO01lOlI1OOlI1O;wire l0IO1OI01lOlI01;wire I01lOIlO01l10IO;wire l0IO1IOIl0OlI1O;
wire O01IllO10IOlI01;wire l0IO1O1lIOl10IO;wire O01IlO01IlOlI1O;wire[31:0] IOIl0I1lO0OlI01;wire O1lIOOlI1OI1lO0;wire IOIl0l0IO1OlI1O;
wire O1lIOOOl1IOlI01;wire IlO01IOIl0I1lO0;wire OlI1OIO01lOlI1O;wire[15:0] IlO01IO0lIOlI01;wire l10IOO01IlI1lO0;wire IlO01OlI1OOlI1O;
wire l10IOOI01lOlI01;wire OIl01l0IO1I1lO0;wire l10IOIOIl0OlI1O;wire OIl01lO10IOlI01;wire IlI0OIO01lI1lO0;wire[10:0] IO0lIIIO0lO1lIO;
wire IlI0OI1lO0OlI01;wire IO0lIOlI1OI1lO0;wire[4:0] OOl1IOlI01O1lIO;wire IO0lIOOl1IOlI01;wire[31:0] OOl1IIOIl0I1lO0;wire I1lO0lIO10O1lIO;
wire OOl1IIO0lIOlI01;wire I1lO0O01IlI1lO0;wire lO10II01lOO1lIO;wire I1lO0OI01lOlI01;wire lO10Il0IO1I1lO0;wire OlI01OOIl1O1lIO;wire IIO0lIlI0OO01Il;
wire OI01lIO01lI1lO0;wire IIO0lIIO0lO1lIO;wire[15:0] OOIl1OIl01O01Il;wire IIO0lOlI1OI1lO0;wire OOIl1OlI01O1lIO;wire I01lOl10IOO01Il;
wire OOIl1IOIl0I1lO0;wire I01lOlIO10O1lIO;wire lIO10IlO01O01Il;wire I01lOO01IlI1lO0;wire[3:0] lIO10I01lOO1lIO;wire O01IlO1lIOO01Il;
wire IOIl0OlI01I01lO;wire O01IlOOIl1O1lIO;wire IOIl0IlI0OO01Il;wire OlI1OlIO10I01lO;wire IOIl0IIO0lO1lIO;wire OlI1OOIl01O01Il;wire IO01lI01lOI01lO;
wire OlI1OOlI01O1lIO;wire IO01ll10IOO01Il;wire[31:0] l10IOOOIl1I01lO;wire IO01llIO10O1lIO;wire l0IO1IlO01O01Il;wire[1:0] OIl01IIO0lI01lO;
wire[7:0] IlI0OlO10IIO0lI;wire OIl01O1lIOO01Il;wire[7:0] IlI0OOlI01I01lO;wire[7:0] O1lIOI1lO0IO0lI;wire IlI0OIlI0OO01Il;wire O1lIOlIO10I01lO;
wire OOl1IOOl1IIO0lI;wire O1lIOOIl01O01Il;wire IlO01I01lOI01lO;wire I1lO0IO0lIIO0lI;wire IlO01l10IOO01Il;wire I1lO0OOIl1I01lO;wire lO10IOI01lIO0lI;
wire[7:0] lO10IIIO0lI01lO;wire[31:0] OI01llO10IIO0lI;wire IO0lIIO01lOIl01;wire OI01lOlI01I01lO;wire IO0lII1lO0IO0lI;wire OOIl1OlI1OOIl01;
wire IO0lIlIO10I01lO;wire OOIl1OOl1IIO0lI;wire I01lOIOIl0OIl01;wire OOl1II01lOI01lO;wire I01lOIO0lIIO0lI;wire lIO10O01IlOIl01;wire I01lOOOIl1I01lO;
wire[31:0] lIO10OI01lIO0lI;wire[1:0] OlI01l0IO1OIl01;wire IOIl0OOl1IIO01l;wire OlI01lO10IIO0lI;wire IIO0lIO01lOIl01;wire OlI1OIO0lIIO01l;
wire[7:0] IIO0lI1lO0IO0lI;wire OlI1OOlI1OOIl01;wire[4:0] IO01lOI01lIO01l;wire OlI1OOOl1IIO0lI;wire[31:0] IO01lIOIl0OIl01;wire l0IO1lO10IIO01l;
wire IO01lIO0lIIO0lI;wire l0IO1O01IlOIl01;wire O01IlI1lO0IO01l;wire[9:0] IlI0OO1lIOIIO0l;wire O01Ill0IO1OIl01;wire IlI0OOOl1IIO01l;
wire[7:0] O1lIOIlI0OIIO0l;wire[127:0] IOIl0IO01lOIl01;wire O1lIOIO0lIIO01l;wire IlO01OIl01IIO0l;wire O1lIOOlI1OOIl01;wire IlO01OI01lIO01l;
wire[7:0] l10IOl10IOIIO0l;wire[15:0] IlO01IOIl0OIl01;wire l10IOlO10IIO01l;wire OIl01IlO01IIO0l;wire OI01lIIO0llO10I;wire OIl01I1lO0IO01l;
wire OI01lO1lIOIIO0l;wire[15:0] IO0lIOlI01lO10I;wire OI01lOOl1IIO01l;wire IO0lIIlI0OIIO0l;wire[11:0] OOl1IlIO10lO10I;wire IO0lIIO0lIIO01l;
wire OOl1IOIl01IIO0l;wire I1lO0I01lOlO10I;wire OOl1IOI01lIO01l;wire I1lO0l10IOIIO0l;wire lIO10OOIl1lO10I;wire OlI01IlI0OIlO01;wire lO10IIlO01IIO0l;
wire OlI01IIO0llO10I;wire IIO0lOIl01IlO01;wire OlI01O1lIOIIO0l;wire IIO0lOlI01lO10I;wire[22:0] OOIl1l10IOIlO01;wire IIO0lIlI0OIIO0l;
wire OOIl1lIO10lO10I;wire I01lOIlO01IlO01;wire OOIl1OIl01IIO0l;wire I01lOI01lOlO10I;wire[5:0] l0IO1O1lIOIlO01;wire[10:0] O01IlO01IlIOIl0;
wire l0IO1OOIl1lO10I;wire O01IlIlI0OIlO01;wire[7:0] IOIl0l0IO1IOIl0;wire O01IlIIO0llO10I;wire IOIl0OIl01IlO01;wire OlI1OIO01lIOIl0;
wire IOIl0OlI01lO10I;wire OlI1Ol10IOIlO01;wire IlO01OlI1OIOIl0;wire OlI1OlIO10lO10I;wire IO01lIlO01IlO01;wire l10IOIOIl0IOIl0;wire[7:0] l10IOO1lIOIlO01;
wire[31:0] OIl01O01IlIOIl0;wire IlI0OI1lO0lIO10;wire OIl01IlI0OIlO01;wire IlI0Ol0IO1IOIl0;wire IO0lIOOl1IlIO10;wire IlI0OOIl01IlO01;
wire O1lIOIO01lIOIl0;wire OOl1IIO0lIlIO10;wire O1lIOl10IOIlO01;wire OOl1IOlI1OIOIl0;wire I1lO0OI01llIO10;wire IlO01IlO01IlO01;
assign l10IOOI01lOlI01=(OlI1OOOl1IIOIl0[30:29]==2'b10)?1'b1:1'b0;assign I01lOI01lOlO10I
=IlO01OI01lI01lO&IO0lIlIO10IO01l&OOIl1OlI01OOIl1;assign IlO01IOIl0l0IO1=OlI1OIO0lII1lO0&~sel_mmc;assign I01lOOI01llO10I[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[3];assign l10IOIO0lIO1lIO
=(~lO10IIlO01OI01l&IlO01OIl01IOIl0&(OI01lIIO0lOIl01&OIl01l0IO1lIO10)&I1lO0OOIl1I01lO);assign OlI01IO01lI01lO[0]=1'b1;dff II01lOl10IOlO10I
(I1lO0IOIl0OlI01,l0IO1I01lOOI01l,clk,hreset_b,1'b1);assign l10IOO01IlI01lO
=(I01lOl10IOO01Il)?(l0IO1OOIl1I1lO0-12'h001):(l0IO1OOIl1I1lO0+12'h001);assign IOIl0IO01lOIl01[75:74]=2'b00;assign IlO01lIO10IIO0l
=(IOIl0OlI01lIO10==IO01lIOIl0OIl01)?1'b1:1'b0;assign IIO0ll0IO1OOIl1
=(O01IlOOIl1IO0lI&lIO10O01IlOlI01)|
(IlI0OO1lIOOlI1O&~O1lIOOOl1IIOIl0);dff IOlI01lO10IOlI01
(IIO0lOOl1Il10IO,O1lIOOIl01l0IO1,clk,hreset_b,1'b1);assign lIO10OOIl1OlI01[6]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[5];dff9 IIO01ll10IOl10IO
(addr[40:32],IO0lIOOl1IOI01l[40:32],clk,1'b1,1'b1);dff Il0IO1lIO10OOl1I(O1lIOIO0lIIlO01,OOl1IIOIl0I01lO,clk,hreset_b,1'b1);assign IlI0OIlI0OlO10I
=(O01IlIIO0ll10IO&OlI1OIO01lIO0lI)|(~l0IO1l0IO1IlO01&OI01lI1lO0lIO10);assign IlO01OOl1IOOIl1
=OOIl1OlI1OOlI01|
l0IO1lO10Il0IO1|
(IO0lIOIl01I01lO&OlI01lO10IIO0lI&~OIl01OOIl1IIO0l&OOIl1OlI1OIOIl0&l10IOIOIl0OlI1O)|
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OI01lOlI01IlO01&OOIl1OlI1OIOIl0)|
l0IO1IlO01lO10I[26]|
l0IO1IlO01lO10I[17];dffe IOOIl1OlI01IOIl0
(dsr[3],IO01lI01lOl10IO[19],clk,hreset_b,1'b1,IlI0OOOl1II1lO0);assign IlI0Ol0IO1O1lIO
=(IlO01lIO10IlI0O[13]!=I1lO0IOIl0IOIl0[13])?1'b1:1'b0;dff IIlO01OOl1IIO0lI(IlO01OIl01O1lIO,IO01lOlI1OOlI1O,clk,hreset_b,1'b1);assign IOIl0l0IO1OOIl1
=IOIl0IO01lOIl01[93]&OI01lO1lIOOlI1O;assign OI01ll0IO1IOIl0[8]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[7];dff IIlI0OO1lIOIlI0O
(blast_b,OOl1Il10IOlO10I,clk,1'b1,hreset_b);assign l10IOl10IOOOIl1
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OOIl1OlI01O1lIO&l0IO1I01lOIOIl0;assign lO10IO1lIOl0IO1
=(O01IlIIO0ll10IO&OOl1IOlI01OOIl1&IO01lI01lOl10IO[0])|(~l0IO1l0IO1IlO01&lIO10lO10Il10IO);assign IO0lIIO01lOIl01
=OOl1IOIl01OI01l|
(IO0lIOIl01I01lO&~O1lIOOOl1IOlI01&OOl1IIO0lIO01Il)|
(O1lIOOOl1IOlI01&~IlO01IOIl0I1lO0);assign I01lOl10IOOI01l
=(lO10IIlO01OI01l|l0IO1OI01lOlI01|I01lOIOIl0O01Il)?{15'h0000,sel_mmc}:
(IIO0lIlI0OIIO0l&O01IlO1lIOOlI01)?I1lO0IOIl0IlI0O:
IlO01IO0lIOlI01;assign IO01lI01lOI01lO
=(OI01lIIO0lO01Il>O1lIOlIO10IlO01)?1'b1:1'b0;assign OlI01lO10IIlI0O=(OOIl1IO0lIl10IO==8'h07)?1'b1:1'b0;assign IOIl0OlI1OIlO01
=(l10IOl10IOIIO0l==8'b00000001)?1'b1:1'b0;assign I1lO0OlI1OOOl1I[10]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[9];dff II01lOOOl1IOOl1I
(wr,O01IlO1lIOOIl01,clk,1'b1,1'b1);assign IlI0OIIO0lOI01l
=I1lO0IO0lIIO0lI&(lIO10OOIl1OIl01|I01lOO01IlIlO01|I1lO0OOIl1IO01l|
(~sel_mmc&(OOl1IOOl1IOlI1O|IOIl0O1lIOOOl1I)));dff IO01IlO1lIOlIO10
(OIl01OOIl1IlI0O,OlI01lO10IIOIl0,clk,hreset_b,1'b1);assign I01lOO01IlI01lO
=(IO0lIOIl01I01lO&~l10IOOOIl1l10IO&
(OIl01I1lO0IO01l|((OI01lIO01lI1lO0|I01lOIOIl0OI01l)&lO10IO01IlIlI0O&~O1lIOOlI1OI1lO0))&
((O1lIOOOl1IOlI01&~IO01lIO0lIIIO0l[18])|I01lOIO0lIIIO0l|l0IO1IOIl0O1lIO));assign lIO10lO10IlO10I[26]
=IlO01OI01lI1lO0|OI01lIO01ll10IO;assign O1lIOOlI01IOIl0
=(I1lO0O01Ill10IO&~O01Ill0IO1lO10I&IO0lIlIO10IO01l)|
(~l10IOI01lOO01Il&IlI0OI1lO0OlI01)|
(~l10IOI01lOO01Il&OlI1OlIO10lIO10&lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&IlO01l10IOOIl01&lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&IO0lIlIO10IO01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I);dff IO01IlIIO0lIO01l
(O1lIOOIl01lO10I,OlI1OOlI1OOIl01,clk,hreset_b,1'b1);dff IlO10IO1lIOI01lO(O1lIOlIO10IO01l,OlI1OIO0lII01lO,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[11]^IIO0lI1lO0IO0lI[5]^lIO10O1lIOIO01l[15];assign dtbuf_wdata
=(OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)?l0IO1OOIl1l10IO:
(O01IlI01lOOOl1I)?32'hffffffff:drd;assign IIO0llIO10IlO01
=(OI01lIIO0lIlI0O&IOIl0OlI1OIlO01)|
(OOIl1OOl1IOlI1O&~I1lO0IO0lIIO0lI)|
(IO01lOlI1OOOl1I&~I1lO0IO0lIIO0lI&IO0lIl0IO1OOIl1)|
(OlI01IlI0Ol0IO1&~I1lO0IO0lIIO0lI&IIO0lIO01lO01Il)|
(OlI01I1lO0I01lO&~rdy_b)|
(IlI0OO1lIOOOl1I&~IOIl0OlI1OIlO01);dff32 IOI01lIlI0OIO01l
(IOIl0I1lO0IlI0O[95:64],IIO0lIlI0OIOIl0[95:64],clk,1'b1,hreset_b);dff10 IIO01lOOl1IOlI1O
(IlI0OO1lIOIIO0l,IIO0ll0IO1IO0lI,clk,hreset_b,1'b1);assign I1lO0l10IOIO0lI[26]
=l0IO1IlO01lO10I[26]|(~lIO10lO10IlO10I[26]&IO01lIO0lIIIO0l[26]);dff II01lOIOIl0lIO10
(IIO0lOIl01l10IO,IO0lIOlI1Ol0IO1,clk,1'b1,hreset_b);assign OOl1IOlI01O1lIO[1]
=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&~lO10IO01IlO01Il);assign lO10Il0IO1IO01l
=(l10IOlO10IIlO01)?OI01llO10IIO0lI:O01IlOOIl1IIO0l;assign IlI0OIlI0Ol0IO1[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[13];dff IIlO01l10IOI1lO0
(IOIl0IO01ll10IO,IIO0lOlI01l0IO1,clk,hreset_b,1'b1);assign lIO10l0IO1IO01l
=(l10IOl10IOO1lIO)?lO10IIIO0lI01lO:
(IlI0OIlI0OOlI01&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?{I1lO0lIO10OOl1I[3:0],4'b1111}:{I1lO0lIO10OOl1I[6:0],1'b1};assign IO0lIOOl1IlIO10
=I01lOIOIl0OlI01&IlO01l10IOlIO10;assign IO01lIO0lIIIO0l[19]=1'b0;dff IOlI01l0IO1l0IO1
(OI01lIO01lI1lO0,IlI0OOlI01l10IO,clk,hreset_b,1'b1);assign I1lO0O01IlIlO01[2]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[10]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[10])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[10])?1'b0:
IO01lOOl1IOOl1I[2];assign OOIl1lIO10l0IO1
=IO01lIO0lIIIO0l[31]|IO01lIO0lIIIO0l[29];dffe16 IOOl1Il10IOIlO01
(IO0lIOlI01lO10I,O1lIOOOl1IOIl01,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign OIl01IIO0lI1lO0=(l10IOIlO01lIO10==6'h0c)?1'b1:1'b0;assign dtout[4]
=I1lO0lIO10OOl1I[4];dff IOlI1OOOl1IOIl01(I1lO0lIO10OOIl1,IlO01OIl01O1lIO,clk,hreset_b,1'b1);assign I1lO0OI01llIO10
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&l0IO1I01lOIOIl0&OOIl1IO01lOlI1O);assign lO10IIlO01IlI0O
=
(IO0lIOIl01I01lO)?OI01lIIO0llO10I:
1'b0;dffe IlO10II01lOIOIl0
(OOIl1IO0lII1lO0[1],IlO01l10IOl10IO[1],clk,hreset_b,1'b1,I1lO0I01lOlIO10);assign OlI01OOIl1OOl1I[3]
=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[2]^IlI0OOIl01IlO01^O01IlO01IlOOIl1[6];assign OOl1IOlI1OOlI01[23:20]
={IO0lIOlI01lO10I[6],OI01lI1lO0l10IO[6],lIO10O1lIOIO01l[6],I01lOOIl01OOIl1[6]};assign O1lIOlIO10I01lO
=(l10IOIlO01lIO10==6'h22)?1'b1:1'b0;assign O01IlIlI0OIO01l[5]
=~l10IOI01lOO01Il&(l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO;assign IO0lII1lO0IIO0l
=lIO10l10IOOOIl1&~rdy_b&OI01lO1lIOIIO0l;assign I01lOlIO10O1lIO=OlI1OOlI01IOIl0&~OlI01OOIl1IIO0l[7];assign OIl01O01IlIIO0l
=OIl01IlO01IOIl0&~I01lOIlO01I01lO;assign l10IOIlO01I1lO0=1'b0;assign lO10Il0IO1IlO01=(cmdin!=IIO0lOOl1IOIl01)?1'b1:1'b0;assign O01IlIIO0lI1lO0
=
{IOIl0I1lO0IlI0O[125],IOIl0I1lO0IlI0O[117],IOIl0I1lO0IlI0O[109],IOIl0I1lO0IlI0O[101],IOIl0I1lO0IlI0O[93],
IOIl0I1lO0IlI0O[85],IOIl0I1lO0IlI0O[77],IOIl0I1lO0IlI0O[69],IOIl0I1lO0IlI0O[61],
IOIl0I1lO0IlI0O[53],IOIl0I1lO0IlI0O[45],IOIl0I1lO0IlI0O[37],IOIl0I1lO0IlI0O[29],
IOIl0I1lO0IlI0O[21],IOIl0I1lO0IlI0O[13],IOIl0I1lO0IlI0O[5]};assign IlI0OlO10IOOIl1
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h17))?1'b1:1'b0;assign OOIl1l10IOl10IO[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[12];assign IIO0lOlI1OI1lO0
=O01IllO10IOlI01|(~O01Ill0IO1O01Il&IOIl0OIl01I01lO);assign OlI1OOOl1IIOIl0[28:24]=5'b00000;assign I1lO0IO0lIOOl1I
=(OIl01OOIl1IIO0l&((l10IOO01IlI1lO0&O01IlO01IlOlI1O)|IO0lIlIO10IO01l)&OI01lOlI01IlO01)|
(IlO01OI01lI01lO&IO0lIlIO10IO01l&OOIl1OlI01OOIl1);assign I01lOIO0lIIO0lI
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l;assign IOIl0IO01lOIl01[103:96]=csd[103:96];dff32 IOOIl1lIO10I1lO0
(I1lO0IOIl0IOIl0,l0IO1I01lOIIO0l,clk,hreset_b,1'b1);assign OIl01IIO0ll10IO=IOIl0IO01llO10I&~error;assign lIO10I01lOOlI1O
=IO0lIIlI0OIIO0l|lO10IOI01lO1lIO|IlI0Ol0IO1IOIl0;assign I01lOOI01llO10I[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[14];assign lO10IIlO01OlI01=(9'b111111111-l0IO1lO10II1lO0[8:0]);assign lIO10OI01lIOIl0
=(IO01lI01lOI1lO0&IO01lIO0lIIOIl0&(IO0lIIlI0OIIO0l|O01IlIlO01OlI1O|OlI01O01IlOOIl1|lO10IOOIl1OlI01))|
(OIl01IlO01IIO0l&(l0IO1O1lIOl10IO|OOIl1lIO10lO10I))|
(lO10IIIO0lIlO01&l10IOl10IOOOIl1)|
(I1lO0IOIl0OI01l&~l10IOI01lOOlI01&~OOIl1OIl01IIO0l&~l0IO1IlO01O01Il&~OOIl1lIO10lO10I&
~lIO10I01lOOlI1O&~O01Ill0IO1lO10I&~OlI1OIO01lIOIl0);dff IlIO10OI01lOlI01
(OlI01OlI01IlO01,OI01lOOl1IIO01l,clk,hreset_b,1'b1);assign OOIl1OOl1IIlI0O
=(l10IOI01lOO01Il|lIO10O01IlOIl01|O1lIOIO01lOlI01)?13'b0000000000000:
(IO0lIOIl01I01lO&OlI1OlIO10lIO10)?IO01lOI01lIlO01:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OI01lOlI01IlO01&l10IOO01IlI1lO0&~OlI01IIO0lOIl01&~O1lIOIlI0OOlI1O&OOl1IOIl01OI01l)?
{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OI01lOlI01IlO01&~l10IOO01IlI1lO0&~OlI01IIO0lOIl01&
~O1lIOIlI0OOlI1O&IO0lIlIO10IO01l&OOl1IOIl01OI01l)?{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(~((IlO01OI01lI01lO&IO0lIlIO10IO01l))&l0IO1O1lIOl10IO)?IO01lOI01lIlO01:
(IO0lIOIl01I01lO&I1lO0I01lOOlI01&lIO10I01lOOlI1O)?13'h0000:
(l10IOO01Ill0IO1&~lO10IlO10IlO10I)?{11'b00000000001,OOl1IlIO10O01Il}:
(l10IOO01Ill0IO1&O1lIOIO0lII01lO)?13'b0000000000000:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&O01IlO01IlOlI1O&~O1lIOIlI0OOlI1O&IIO0lI1lO0OI01l)?(OlI1OOlI01OI01l-13'h0001):
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&O01IlO01IlOlI1O&~O1lIOIlI0OOlI1O&OI01lOlI01IlO01&l10IOO01IlI1lO0)?(OlI1OOlI01OI01l+13'h0001):
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&IO0lIlIO10IO01l&~O1lIOIlI0OOlI1O&(~lIO10I01lOOlI1O|l10IOO01Ill0IO1))?
{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&O01IlO01IlOlI1O&~O1lIOIlI0OOlI1O&(~lIO10I01lOOlI1O|l10IOO01Ill0IO1))?(OlI1OOlI01OI01l+13'h0001):
(IO0lIOIl01I01lO&OI01lO1lIOO1lIO&IO0lIlIO10IO01l&IIO0lI1lO0OI01l)?(OIl01O1lIOl0IO1+13'h0001):
OlI1OOlI01OI01l;assign IOIl0IO01lOIl01[7:1]
=csd[7:1];assign I01lOOI01lI1lO0=~IOIl0IO01lOIl01[78]&l10IOIlO01l10IO;dff IO01IllO10IlO10I
(IlI0OO1lIOOlI1O,IIO0ll0IO1OOIl1,clk,hreset_b,1'b1);assign IIO0lIIO0lOOl1I
=IIO0lI1lO0IOIl0|O1lIOlIO10I01lO|IlO01IOIl0l0IO1|l0IO1IlO01OIl01|lIO10O01IlO01Il|
IOIl0IIO0lIIO0l|IlO01OOl1IOOl1I;assign OI01ll0IO1IOIl0[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[3]^O01IlO1lIOIlI0O[15];assign O01IlIO01lIlO01
=lO10IIlO01OI01l|
~(O1lIOIO01lOI01l|l10IOIO0lIOlI1O);assign O1lIOOlI01IlI0O
=((IO01lI01lOl10IO[23:15]&OlI1OOOl1IIOIl0[23:15])!=9'h000)?1'b1:1'b0;assign l10IOOI01lO01Il
=(O01IlIIO0ll10IO&lO10IOI01lO1lIO)|(~l0IO1l0IO1IlO01&I1lO0I01lOOIl01);dff2 IlIO10IlO01lIO10
(OOl1IIOIl0l10IO,IO01lI01lOl0IO1,clk,hreset_b,1'b1);assign O1lIOIIO0lOOIl1=
l0IO1O01IllIO10;assign IO0lIOlI1Ol10IO
=(sel_mmc)?IOIl0lO10IOOIl1:32'h00000200;assign O1lIOIO0lII01lO=IO01lIOIl0lIO10&O1lIOOOl1IIOIl0;dffe32 IIIO0lIIO0lIOIl0
(IO01lI01lOl10IO,IlI0OOOl1IIlO01,clk,hreset_b,1'b1,O01IlO1lIOOI01l);assign I1lO0OlI1OOOl1I[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[1];assign lIO10lO10II1lO0
=(OI01lIIO0lOIl01&I01lOO01IlI01lO&O01IlIlI0OIlO01)?l0IO1OI01lO01Il:
(OI01lIIO0lOIl01&((I01lOO01IlI01lO&~O01IlIlI0OIlO01)|I1lO0OOIl1I1lO0|OOIl1IO01lOOl1I|OOl1IOI01lIlO01))?O01IlOOIl1IlI0O:
(OI01lIIO0lOIl01&IO01lIlO01IO01l)?OlI1OI1lO0OlI1O[9:0]:
(OI01lIIO0lOIl01&(l10IOl10IOOlI1O|IO0lIOOl1IlIO10))?10'h004:
(OI01lIIO0lOIl01&(l0IO1IOIl0OOIl1|O01IlIIO0llO10I|lO10II01lOOOl1I))?10'h010:
(OI01lIIO0lOIl01&l0IO1lO10Il10IO)?10'h001:
(O1lIOIO01lIOIl0)?{4'h0,OOl1II01lOIlO01}:
OI01lI1lO0lO10I;assign O01IlO01IlIO0lI
=OIl01IlO01IIO0l&(l0IO1O01IllO10I|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|IOIl0IO01llIO10|OOIl1IO01lOlI1O);dff IOOIl1I1lO0OOIl1
(l0IO1IOIl0O1lIO,lO10II01lOOlI1O,clk,hreset_b,1'b1);assign l10IOIO0lIOlI1O=(~lO10IIlO01OI01l&OI01lIIO0lOIl01&OI01lOlI01I01lO);assign lIO10lO10IlO10I[15]
=IlO01OI01lI1lO0|OI01lIO01ll10IO;assign IOIl0l0IO1OlI1O
=(~l10IOI01lOO01Il&OIl01OOIl1IIO0l&~lO10Il0IO1l0IO1&IO0lIlIO10IO01l&~OIl01OI01lOOIl1&~OI01lOlI01IlO01)|
(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&~lO10Il0IO1l0IO1&~IO0lIlIO10IO01l);assign OlI1OIlI0OOOl1I
=(IO01lOlI1OOlI1O&~IlO01OIl01O1lIO);assign IIO0lOlI1OIlO01
=(~I1lO0IO0lIIO0lI|~OlI1OOOl1IOI01l)&(OlI01O1lIOIlI0O|IO0lII1lO0IO0lI|O1lIOIlI0OO1lIO);assign OIl01l0IO1I01lO[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[3];dff10 IOIl01O1lIOI1lO0
(OI01llO10IIOIl0,O01IlOOIl1IlI0O,clk,1'b1,1'b1);assign IOIl0I1lO0IOIl0
=(OIl01O1lIOOlI01&I01lOIO0lIOlI1O)|
(OI01lIIO0lIlI0O&~IOIl0OlI1OIlO01);assign OlI01lO10IIIO0l=OlI1OlIO10l10IO;assign l10IOl10IOOlI1O
=OI01lOlI01IlO01&l10IOO01IlI1lO0&O01IllO10IO01Il;assign I1lO0l10IOIO0lI[17]
=l0IO1IlO01lO10I[17]|(~lIO10lO10IlO10I[17]&IO01lIO0lIIIO0l[17]);assign O01IlOOIl1O1lIO
=(~l10IOI01lOO01Il&l0IO1OI01lIOIl0&~lO10Il0IO1l0IO1&IO0lIlIO10IO01l);assign OlI01lO10IOI01l
=(IO01lI01lOl10IO[2:0]==3'b011)?1'b1:1'b0;dff32 IIlI0OI1lO0l0IO1(IO01lOIl01OlI1O,I01lOOlI1OOOIl1,clk,hreset_b,1'b1);assign IlI0OIlI0Ol0IO1[6]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[5];assign OlI01O1lIOOlI01=(OlI1OI1lO0OlI1O>=11'h010)?1'b1:1'b0;dff IOIl01OI01lIO0lI
(OIl01O1lIOOlI01,OlI01l0IO1OI01l,clk,hreset_b,1'b1);assign OlI01l0IO1lO10I[31:24]
=(OI01ll0IO1O01Il==2'b11)?IOIl0I1lO0IlI0O[7:0]:8'h00;assign OI01lIO01lIO01l
=~lO10IIlO01OI01l&(OI01lI1lO0l0IO1|(~IIO0lOIl01l10IO&O01IlIlI0OIlO01));assign IO01lIO0lIIIO0l[6]=1'b0;dff IOOIl1IlI0OOlI1O
(lIO10lO10IlIO10,lO10IO1lIOlO10I,clk,hreset_b,1'b1);dff IIIO0lIO01ll10IO
(IOIl0l0IO1IOIl0[2],IIO0lIIO0lIIO0l[2],clk,hreset_b,1'b1);dff IIO0lIIO01llO10I
(O01IlI1lO0l10IO,lIO10l0IO1I01lO,clk,hreset_b,1'b1);assign O1lIOOOl1IOIl01[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[7];assign OI01ll0IO1OI01l=(l10IOIlO01lIO10==6'h04)?1'b1:1'b0;dff4 IOOIl1OlI1OlIO10
(I01lOOOIl1IO01l,l10IOlO10II01lO,clk,1'b1,1'b1);assign OOIl1IO01lOOl1I=IIO0lIlI0OIIO0l&OOl1IOlI01OOIl1&IO01lI01lOl10IO[0];dff IOlI01O01IlIO0lI
(IO01lIO0lIIIO0l[30],I1lO0l10IOIO0lI[30],clk,hreset_b,1'b1);dff IlIO10l10IOO1lIO
(I1lO0IlO01l0IO1,l10IOO01IllIO10,clk,hreset_b,1'b1);dffe Il10IOl10IOOI01l
(O1lIOI1lO0IO0lI[0],OlI1OIlI0OO1lIO,clk,hreset_b,1'b1,IlO01OlI01OOIl1);dff Il0IO1l10IOIIO0l
(l0IO1l10IOOOIl1,lIO10IOIl0OOl1I,IlO01IlO01IlO01,hreset_b,1'b1);assign IO01lO01IlIlO01[23:20]
={IO0lIOlI01lO10I[10],OI01lI1lO0l10IO[10],lIO10O1lIOIO01l[10],I01lOOIl01OOIl1[10]};assign l10IOIOIl0IIO0l
=(l10IOIlO01lIO10==6'h19)?1'b1:1'b0;assign O01IlIIO0lOIl01
=~l10IOI01lOO01Il&(OOl1IOlI1OIO0lI|(~l0IO1IOIl0OOl1I&OIl01l0IO1lO10I));assign IlO01IOIl0lO10I
=IlI0Ol0IO1IlI0O|(~IlI0OI1lO0OI01l&OOl1Il10IOlIO10);assign IOIl0I1lO0OlI01
=(lO10IIlO01OI01l)?32'h00000200:
(IIO0lIlI0OIIO0l&IIO0lOlI01lO10I)?IO01lI01lOl10IO:
OI01lIIO0lO01Il;assign OOl1IOIl01O1lIO
=(IlO01I01lOl10IO&IOIl0OlI1OIlO01)|
((IlO01OI01lI01lO&IO0lIlIO10IO01l&~lIO10IlO01OI01l)|I1lO0O01Ill10IO);assign OOIl1IO01lIO0lI
=OIl01OOIl1IIO0l&IO0lIlIO10IO01l&OIl01OI01lOOIl1;assign l0IO1OI01lOI01l=~l10IOI01lOOlI01;assign IO01llIO10OI01l[11:8]
={O01IlO1lIOIlI0O[1],l0IO1O01IlO01Il[1],IO01lI01lOlIO10[1],O1lIOIO0lII1lO0[1]};assign OOIl1IO01lOlI1O
=(l10IOIlO01lIO10==6'h37)?1'b1:1'b0;assign OOIl1l10IOl10IO[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[4]^IIO0lI1lO0IO0lI[0]^O1lIOIO0lII1lO0[15];assign lIO10O1lIOI01lO
=(~rdy_b);assign OlI01IO01lIlO01=1'b1;dff15 IOlI1OOlI1Ol10IO(O1lIOOIl01OIl01,OOl1IlIO10OlI01,clk,1'b1,1'b1);assign I01lOlIO10IOIl0
=(IlI0OOlI01IlO01)?16'h0200:
(I1lO0IO0lIIIO0l)?OI01lIIO0lO01Il[15:0]:
(OI01lIlO01OOl1I)?16'h0040:
(O01IlOI01lOOIl1)?16'h0010:
(OIl01I01lOOlI1O)?16'h0008:
(lIO10IOIl0O1lIO)?16'h0004:
IlO01OlI1OIlI0O;assign IIO0lOlI01O01Il
=(lO10IIlO01OI01l|(OI01lIIO0lOlI01&OOl1Il10IOl0IO1))?1'b0:
(I01lOlIO10OlI1O&~IlO01OlI1OO1lIO&I1lO0I01lOOIl01&~IO01lIO0lIIIO0l[16])?I1lO0O01IlIO01l[12]:
IOIl0IO01lOIl01[12];assign OOl1IOlI1OIOIl0
=IO0lIOOl1IOIl01|OlI1OOIl01O01Il|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|O01IlIlO01OlI1O|
OlI01O01IlOOIl1|OI01lOOIl1OOl1I|IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I;assign IO01lOIl01OOl1I
=(~lO10IIlO01OI01l&OlI1OIO01lO1lIO&~IIO0lOlI01OIl01&OlI01I1lO0l0IO1)|
(~lO10IIlO01OI01l&OOl1IOOl1IOOIl1&~IIO0lOlI01OIl01&~OIl01IIO0ll10IO);assign I1lO0OI01llO10I
=I01lOI01lOlIO10&sel_mmc;assign I01lOOI01llO10I[7]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[6];dff IO01IlOI01lO1lIO
(IlO01OIl01IOIl0,IO01lOlI1OIIO0l,clk,1'b1,hreset_b);assign OOIl1IOIl0IlO01[31:0]=scr[31:0];assign IOIl0l0IO1O1lIO
=I01lOOIl01OOl1I|(~I01lOlIO10OOIl1&OI01lO1lIOIO0lI);assign I01lOl10IOO01Il=(OI01lI1lO0lIO10|OI01lO1lIOIIO0l|IlI0OI1lO0OIl01);assign IOIl0IO01lOIl01[30:29]
=(sel_mmc)?csd[30:29]:2'b00;assign I1lO0l10IOO1lIO=O1lIOOOl1IOlI01|l0IO1IOIl0O1lIO;assign I1lO0IlO01l10IO
=(OOIl1IOIl0IO01l&O1lIOOOl1IIOIl0&~I1lO0O01IlI1lO0)|
(IO01lOI01lI1lO0&~O1lIOIO0lII01lO&~O1lIOOIl01lO10I);assign OI01lOlI01I1lO0
=l0IO1O01IllO10I|OIl01lO10IO01Il|O01IlO1lIOOlI01|OI01ll0IO1OI01l|OOIl1OlI01O1lIO|OOl1IOOl1IOlI1O|
l10IOlO10IIlO01|l0IO1O1lIOIO01l|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|IOIl0IO01llIO10|
lIO10OOIl1OIl01|I01lOO01IlIlO01|I1lO0OOIl1IO01l;assign lIO10OOIl1OlI01[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[8];assign OIl01I1lO0I01lO
=~I1lO0OOIl1I01lO|
(IlO01OIl01IIO0l&~OlI1OOlI01IlI0O&~lO10IO01IlIlI0O)|IO0lIIlI0OIlI0O|
(I1lO0IOIl0OI01l&~I01lOIOIl0OlI01&~OOl1IOlI01OOl1I);dff IO01IlIIO0lI01lO
(OIl01IlO01IIO0l,OlI01OOIl1O1lIO,clk,hreset_b,1'b1);assign IO01llIO10IOIl0
=(O01IlIIO0ll10IO&OI01lIlI0Ol0IO1)|(~l0IO1l0IO1IlO01&OOl1IOlI1OIlI0O);dff Il10IOOI01ll0IO1
(O1lIOIlI0OOlI1O,OOIl1IO01lOOIl1,clk,hreset_b,1'b1);assign dsr[15:12]=4'b0000;assign O1lIOIlI0OOOl1I
=(IlO01lIO10IlI0O[2]!=I1lO0IOIl0IOIl0[2])?1'b1:1'b0;assign O1lIOOOl1IIOIl0=OIl01OOIl1IIO0l&O01IlO01IlOlI1O;assign IOIl0IIO0lIO0lI
=~IlI0OOOl1IIlO01[0]&~I1lO0l10IOIIO0l;assign OI01ll0IO1IOIl0[11]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[10];dff2 IIO0lIIIO0lIIO0l
(cs_b,l10IOIOIl0O1lIO,clk,1'b1,1'b1);assign OlI1OIO01lIOIl0=IO01lIO0lIIIO0l[26]&~OI01lO1lIOIO0lI;assign O1lIOOlI01OI01l
=(O01IlIIO0ll10IO&OlI01OOIl1OlI1O)|(~l0IO1l0IO1IlO01&IO0lIIO01lOlI01);assign OOl1IOlI01OOl1I
=(OIl01OOIl1IIO0l&IO0lIlIO10IO01l&OI01lOlI01IlO01&~l10IOO01IlI1lO0&~O1lIOIlI0OOlI1O)|
(IO0lIOIl01I01lO&IlO01OI01lI01lO&OOIl1OlI01OOIl1&IO0lIlIO10IO01l&~O1lIOIlI0OOlI1O&~OlI1OIlI0OOOIl1)|
(OIl01O1lIOOIl01&I01lOI01lOlO10I);assign I1lO0O01Ill0IO1
=(IlO01I01lOl10IO&IOIl0OlI1OIlO01&(IIO0lOlI01lIO10|IOIl0lO10IOOl1I|O1lIOlIO10IO01l));assign I01lOlIO10IO0lI
=(OI01lIIO0lO01Il>IIO0lO1lIOOOl1I)?1'b1:1'b0;assign IIO0lIIO0lIO0lI=(OOIl1IO0lIl10IO==8'h0a)?1'b1:1'b0;dff7 IOlI1OIlI0OIO0lI
(I01lOl10IOIOIl0,I1lO0IOIl0IIO0l,clk,hreset_b,1'b1);assign I1lO0OlI1OOOl1I[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[12];assign IIO0lOOl1II1lO0=lO10IlO10Il10IO[11:2];assign I1lO0IlO01I1lO0
=I1lO0IO0lIIO0lI&IlO01OlI1OIOIl0&(IlI0OIIO0lIlI0O|I1lO0OOIl1IO01l);dff IIIO0lI1lO0O01Il
(OlI1OIlI0OOOIl1,OOl1IIO01lOOl1I,clk,hreset_b,1'b1);dff16 IIlO01OlI01O1lIO(O01IlI1lO0IlO01,OlI01IlI0OIO01l,clk,hreset_b,1'b1);assign lIO10lO10IlO10I[29]
=IlO01OI01lI1lO0;assign lIO10IIO0lIlO01
=(~l10IOI01lOO01Il&OlI1OOOl1IIIO0l&((OIl01IlO01IOIl0&I01lOIlO01I01lO)|(IO01lIO0lIIIO0l[26]&~OI01lO1lIOIO0lI)|l10IOIlO01I1lO0))|
(~l10IOI01lOO01Il&IlO01OlI1OO1lIO&lO10IIlO01IOIl0);assign lO10IO1lIOI1lO0
=IIO0lIlI0OIIO0l&IO0lIIlI0OIIO0l;assign l10IOIOIl0IOIl0=OIl01lO10IO01Il|l10IOlO10IIlO01|l0IO1O1lIOIO01l;assign OIl01l0IO1I01lO[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[14];assign IO0lIIIO0lO1lIO=O1lIOOIl01l10IO-IIO0lOOl1II1lO0;assign l10IOO01IllO10I
=(OOIl1OOl1IOlI1O&I1lO0IO0lIIO0lI&IlI0OI1lO0lO10I)|
(IO01lOlI1OOOl1I&I1lO0IO0lIIO0lI&IlI0OI1lO0lO10I&IO0lIl0IO1OOIl1)|
(OlI01IlI0Ol0IO1&I1lO0IO0lIIO0lI&IlI0OI1lO0lO10I&IO0lIl0IO1OOIl1)|
(I1lO0IlO01lIO10&~IOIl0OlI1OIlO01);dff4 IIIO0lOlI01I1lO0
(OOIl1OOl1IO1lIO,IlO01OIl01OlI1O,clk,1'b1,hreset_b);assign I01lOIOIl0lO10I
=(l10IOI01lOO01Il)?12'h000:
(OIl01OOIl1IIO0l&OI01lOlI01IlO01&l10IOO01IlI1lO0)?12'hfff:
((IO0lIIO01lIlI0O|(lIO10l10IOOOIl1&~lO10II01lOOOIl1&OIl01IlO01O1lIO))&IO01lIlO01IO01l)?{7'h00,IO01lOI01lIO01l}:
(IOIl0I1lO0OIl01|((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1&OIl01IlO01O1lIO))?I01lOlIO10IOIl0[11:0]:
(IIO0lIlI0OOlI01|I1lO0lIO10O1lIO|((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1))?(IO01ll10IOlIO10-l10IOI01lOOIl01):
(l10IOO01Ill0IO1&O1lIOIO0lII01lO)?{4'h0,IIO0lIIO0lOlI1O}:
IO01ll10IOlIO10;assign I1lO0l10IOIO0lI[29]
=l0IO1IlO01lO10I[29]|(~lIO10lO10IlO10I[29]&IO01lIO0lIIIO0l[29]);dff IlO10IIlO01O01Il
(I1lO0I01lOOlI01,l10IOOI01lOI01l,clk,hreset_b,1'b1);assign OOl1IOlI01O1lIO[4]
=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&~OI01lO1lIOIlI0O);assign OlI01IlO01OOIl1=(l10IOl10IOIIO0l==8'h41)?1'b1:1'b0;assign O1lIOOOl1IOIl01[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[7]^IO0lIOlI01lO10I[15];dff Il10IOOI01llIO10
(IlO01I01lOl10IO,IO01lOI01ll0IO1,clk,hreset_b,1'b1);assign l10IOO1lIOIlO01[2]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[2]);assign lIO10O01IlOI01l=IIO0lIlI0OIIO0l&OlI01O01IlOOIl1;dff IOOIl1OlI1OlO10I
(IO01lIO0lIIIO0l[22],I1lO0l10IOIO0lI[22],clk,hreset_b,1'b1);dff IIIO0lIlI0OOIl01
(OOl1IIO0lIO01Il,IO01ll10IOOlI01,clk,hreset_b,1'b1);dffe IOOl1IOlI1OOIl01
(IO01lOOl1IOOl1I[1],I1lO0O01IlIlO01[1],clk,hreset_b,1'b1,lIO10lO10II01lO);assign IO01ll10IOlO10I
=IO01lIO0lIIIO0l[15]|IO01lIO0lIIIO0l[24];assign IO0lIIlI0OO1lIO[23:20]
=(IlI0OIlI0OOlI01)?{O1lIOOOl1IOIl01[14],IlI0OIlI0Ol0IO1[14],OIl01l0IO1I01lO[14],I1lO0OlI1OOOl1I[14]}:
{IO0lIOlI01lO10I[14],OI01lI1lO0l10IO[14],lIO10O1lIOIO01l[14],I01lOOIl01OOIl1[14]};assign IOIl0IO01llIO10
=(l10IOIlO01lIO10==6'h0f)?1'b1:1'b0;assign IlI0OIO01ll0IO1[1]
=(l10IOI01lOO01Il)?1'b1:
(l10IOlIO10OOIl1&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?l10IOO1lIOIlO01[1]:
l10IOO1lIOIlO01[5];assign OlI1OIO0lIl0IO1
=OlI01O1lIOOI01l|(~OlI01IIO0lOlI01&O1lIOlIO10l10IO);dff IO1lIOl0IO1OOl1I(OI01lOOl1II01lO,IOIl0OIl01I1lO0,clk,hreset_b,1'b1);assign IO0lII1lO0O1lIO
=
(IO0lIOIl01I01lO)?O1lIOOlI1OI1lO0:
1'b0;assign IlI0OOOIl1OOl1I
=~((lIO10IlO01OIl01&ecsd_a[0])|
(lO10IO01IlO01Il&ecsd_a[1])|
(OIl01OOIl1OlI01&ecsd_a[2])|
(OlI01lO10IOI01l&ecsd_a[3])|
(OI01lO1lIOIlI0O&ecsd_a[4]));assign OlI01OOIl1OOl1I[6]
=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[5];assign OOl1IOlI1OOlI01[11:8]
={O01IlO1lIOIlI0O[5],l0IO1O01IlO01Il[5],IO01lI01lOlIO10[5],O1lIOIO0lII1lO0[5]};assign lIO10O01IlO01Il
=(l10IOIlO01lIO10==6'h25)?1'b1:1'b0;dff8 IlO10IOI01lIlI0O(oe_dt,O01IlIlI0OIO01l,clk,hreset_b,1'b1);dff Il0IO1l10IOIOIl0
(IlI0OIlI0OO01Il,IIO0lIO01lOlI01,clk,hreset_b,1'b1);dff IO01IllO10IOIl01(I1lO0IO0lIIO0lI,l0IO1l10IOO1lIO,clk,hreset_b,1'b1);assign IIO0lIlI0OOI01l
=(OIl01O01IlIlI0O==2'b10)?1'b1:1'b0;assign OlI1OlIO10l0IO1=OOIl1IO0lIlIO10|IlO01l10IOlO10I;assign OIl01IIO0lIO01l
=OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&IO01lIO0lIOI01l;assign OlI1OIO01lOlI1O
=((IlI0OIlI0OOlI01==1'b1)&
(OOl1IIOIl0l0IO1==O1lIOIO0lII1lO0)&
(l10IOIlO01OIl01==IO01lI01lOlIO10)&
(OIl01lO10IOI01l==l0IO1O01IlO01Il)&
(IlI0OIIO0lIIO0l==O01IlO1lIOIlI0O))?1'b1:
((l10IOlIO10OOIl1==1'b1)&
(OOl1IIOIl0l0IO1==O1lIOIO0lII1lO0)&
(l10IOIlO01OIl01==IO01lI01lOlIO10)&
(OIl01lO10IOI01l==l0IO1O01IlO01Il)&
(IlI0OIIO0lIIO0l==O01IlO1lIOIlI0O)&
(l0IO1lO10IIlO01==I01lOOIl01OOIl1)&
(O01IlIIO0lI1lO0==lIO10O1lIOIO01l)&
(IIO0lIO01llIO10==OI01lI1lO0l10IO)&
(OOIl1OIl01O01Il==IO0lIOlI01lO10I))?1'b1:
((IlI0OIlI0OOlI01==1'b0)&(OOl1IIOIl0l0IO1==O1lIOIO0lII1lO0))?1'b1:1'b0;assign O1lIOIO0lIIO01l
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h33))?1'b1:1'b0;dffe16 IO01IlIlO01IOIl0
(O1lIOIO0lII1lO0,OOIl1l10IOl10IO,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign IOIl0OIl01IO01l
=(OOIl1l10IOI01lO[1:0]==2'b00)?{24'h000000,IO01lI01lOl10IO[7:0]}:
(OOIl1l10IOI01lO[1:0]==2'b01)?{16'h0000,IO01lI01lOl10IO[7:0],8'h00}:
(OOIl1l10IOI01lO[1:0]==2'b10)?{8'h00,IO01lI01lOl10IO[7:0],16'h0000}:
{IO01lI01lOl10IO[7:0],24'h000000};assign OlI1OOOl1IIOIl0[7]
=ocr_mem[7];assign l0IO1IlO01lO10I[26]=lIO10l10IOOOIl1&~rdy_b&error&O1lIOlIO10l10IO;assign IO0lIOIl01l0IO1
=IIO0lI1lO0IOIl0|IO01lOIl01OOIl1|OI01lIlI0Ol0IO1|IO0lIOOl1IOIl01|OOIl1OlI1OOlI01|I1lO0l10IOIOIl0|
lIO10I01lOIO0lI|lO10IOI01lO1lIO|OI01lOOIl1OOl1I|IlI0Ol0IO1IOIl0|OOl1IOlI01OOIl1|
O01IlO01IlO1lIO|OlI01OOIl1OlI1O|O1lIOIO0lIIO01l|
(I1lO0IO0lIIO0lI&l10IOlO10IIlO01)|(I1lO0IO0lIIO0lI&l0IO1O1lIOIO01l);assign IOIl0IO01lOIl01[92:84]
=9'b110110101;assign IO0lIOlI01IlI0O
=({1'b0,IOIl0IO01lOIl01[73:62]}+13'h0001)<<({1'b0,OIl01OOIl1IOIl0}+{1'b0,IOIl0IO01lOIl01[83:80]});assign l0IO1IlO01lO10I[15]
=IO0lIOOl1IO01Il&error;assign OIl01lO10IOlI01=OIl01O01IlO1lIO&O01IlOOIl1OlI1O;assign lIO10OOIl1OlI01[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[0];dff IO1lIOOlI1OIO01l
(I1lO0OOIl1I01lO,IO01lO01IlIO01l,clk,1'b1,hreset_b);assign lIO10I01lOIOIl0
=(IO01lI01lOI1lO0&IO01lIO0lIIOIl0&OOIl1OlI1OOlI01)|
(l10IOIOIl0IlI0O&~(IO01lIO0lIIOIl0&OI01lIlI0Ol0IO1)&~l10IOI01lOOlI01&~l0IO1IlO01O01Il);assign OlI1OI1lO0OOIl1
=IO0lIOlI01OIl01|(~IlI0OOlI01l0IO1&IO0lIIIO0lOlI1O);assign I1lO0IlO01IO01l
=(l10IOI01lOO01Il|lIO10O01IlOIl01|O1lIOIO01lOlI01)?13'b0000000000000:
(IO0lIOIl01I01lO&(IIO0lOIl01l10IO&lO10IOOIl1OI01l)&IIO0lI1lO0OI01l)?OIl01O1lIOl0IO1:
(IO0lIOIl01I01lO&(IIO0lOIl01l10IO&lO10IOOIl1OI01l)&~IIO0lI1lO0OI01l)?{11'b00000000000,OOIl1l10IOI01lO[1:0]}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OI01lOlI01IlO01&l10IOO01IlI1lO0&~OlI01IIO0lOIl01&~O1lIOIlI0OOlI1O&OOl1IOIl01OI01l)?
{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OI01lOlI01IlO01&~l10IOO01IlI1lO0&~OlI01IIO0lOIl01&
~O1lIOIlI0OOlI1O&IO0lIlIO10IO01l&OOl1IOIl01OI01l)?{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&IO0lIlIO10IO01l&~l10IOO01IlI1lO0&~O1lIOIlI0OOlI1O&OI01lOlI01IlO01)?
{OlI1OOlI01OI01l[12:2]+10'h001,OlI1OOlI01OI01l[1:0]+2'b01}:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&O01IlO01IlOlI1O&l10IOO01IlI1lO0&~O1lIOIlI0OOlI1O&OI01lOlI01IlO01)?(OlI1OOlI01OI01l+13'h0001):
(IO0lIOIl01I01lO&IlO01OI01lI01lO&I01lOl10IOIlI0O&OOIl1OlI01OOIl1&~l0IO1O1lIOl10IO)?OlI1OOlI01OI01l:
IO01lOI01lIlO01;dff2 IIlI0OIIO0lO01Il
(OIl01O01IlIlI0O,O01IlOOIl1IOIl0,clk,hreset_b,1'b1);assign lIO10OOIl1lIO10
=(IOIl0IO01lOIl01[25:22]<=4'b1001)?1'b0:
(IOIl0IO01lOIl01[25:22]==4'b1010)?IO0lII1lO0OOIl1:
(IOIl0IO01lOIl01[25:22]==4'b1011)?O1lIOIlI0OOOl1I:
(IOIl0IO01lOIl01[25:22]==4'b1100)?OOIl1I01lOIlO01:
(IOIl0IO01lOIl01[25:22]==4'b1101)?OOl1IOI01lIO01l:IO01lIlO01I01lO;dff IIOIl0IIO0lOlI01
(IO01lOI01lI1lO0,I1lO0IlO01l10IO,clk,hreset_b,1'b1);assign OOIl1IO0lIOIl01=IOIl0IO01lOIl01[88]&OlI1OlIO10lO10I;assign OI01ll0IO1IOIl0[3]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[2];assign OlI1OIO0lIlIO10
=(OI01lIIO0lOIl01&(IOIl0IIO0lO1lIO|IO0lII1lO0OlI1O))?lIO10I01lOO1lIO:
((OI01lIIO0lOIl01&O1lIOOOl1IIlI0O)|(I01lOI01lOOIl01&~lO10II01lOOOIl1))?
{l0IO1I01lOIO0lI[0],l0IO1I01lOIO0lI[1],l0IO1I01lOIO0lI[2],l0IO1I01lOIO0lI[3]}:
(OI01lIIO0lOIl01&l0IO1IlO01OlI01)?4'b0000:
((OI01lIIO0lOIl01&(OIl01l0IO1lIO10|OI01lOlI01I01lO))|(~lO10II01lOOOIl1&~OIl01IlO01O1lIO))?l0IO1I01lOIO0lI:
lIO10O1lIOl10IO;assign IlO01OlI1OIO0lI
=OIl01O1lIOOlI01&OOl1IIO0lIOIl01&O1lIOOlI01IlI0O&OlI1OOOl1IIOIl0[31];assign IOIl0l0IO1IO0lI
=(O01IlIIO0ll10IO&OI01lOOIl1OOl1I)|(~l0IO1l0IO1IlO01&OI01lO1lIOIIO0l);assign I1lO0IlO01I01lO
=((IO0lIOIl01I01lO&I1lO0I01lOOlI01&~IOIl0I1lO0IlI0O[0])|I01lOOI01llIO10)?5'b00000:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&O01IlO01IlOlI1O)?(IO01lOI01lIO01l+5'b00001):
IO01lOI01lIO01l;assign IO0lIl0IO1OlI1O[7:2]
=6'b000000;assign IIO0lO1lIOOOl1I
=(IOIl0IO01lOIl01[83:80]==4'b0000)?32'h00000001:
(IOIl0IO01lOIl01[83:80]==4'b0001)?32'h00000002:
(IOIl0IO01lOIl01[83:80]==4'b0010)?32'h00000004:
(IOIl0IO01lOIl01[83:80]==4'b0011)?32'h00000008:
(IOIl0IO01lOIl01[83:80]==4'b0100)?32'h00000010:
(IOIl0IO01lOIl01[83:80]==4'b0101)?32'h00000020:
(IOIl0IO01lOIl01[83:80]==4'b0110)?32'h00000040:
(IOIl0IO01lOIl01[83:80]==4'b0111)?32'h00000080:
(IOIl0IO01lOIl01[83:80]==4'b1000)?32'h00000100:
(IOIl0IO01lOIl01[83:80]==4'b1001)?32'h00000200:
(IOIl0IO01lOIl01[83:80]==4'b1010)?32'h00000400:
(IOIl0IO01lOIl01[83:80]==4'b1011)?32'h00000800:
(IOIl0IO01lOIl01[83:80]==4'b1100)?32'h00001000:
(IOIl0IO01lOIl01[83:80]==4'b1101)?32'h00002000:32'h00004000;assign I1lO0I01lOlO10I
=(OOIl1IO0lIl10IO==8'h02)?1'b1:1'b0;assign l0IO1I01lOIOIl0=(IO01lI01lOl10IO[31:16]==IlO01IO0lIOlI01)?1'b1:1'b0;assign I1lO0OlI1OOOl1I[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[4]^IIO0lI1lO0IO0lI[4]^I01lOOIl01OOIl1[15];assign l0IO1lO10Il10IO
=IOIl0IIO0lO1lIO|IlI0OIlI0OO01Il|
IO0lII1lO0OlI1O|IlI0Ol0IO1IO0lI|O01IllO10IIOIl0|OlI01O1lIOIIO0l|lIO10O1lIOl0IO1|
OOl1IOlI1OIIO0l|lIO10O01IlOI01l|IO0lIOlI01OI01l|OI01lI1lO0OIl01|
lO10IOOIl1IlI0O|O1lIOIlI0OOOIl1|OOIl1OIl01IOIl0|OlI01IO01lIO01l|
OlI1OOIl01lO10I;assign lO10IOI01lIIO0l
=l10IOIOIl0IlI0O&(l0IO1O01IllO10I|OlI01I1lO0l10IO|OI01lIlI0Ol0IO1|IOIl0IO01llIO10|OOIl1IO01lOlI1O);dff II01lOOI01lIO01l
(IIO0lOIl01I01lO,IO0lIOlI1OI1lO0,clk,hreset_b,1'b1);dff IIIO0lIIO0lIlI0O(IIO0lIlI0OOlI01,O1lIOIO01lOI01l,clk,hreset_b,1'b1);assign lIO10lO10IlO10I[18]
=IlO01OI01lI1lO0;assign I01lOIlO01I1lO0
=(~l10IOI01lOO01Il&IIO0lIIO0lOOIl1&~lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&OlI1OIOIl0IlO01&IO0lIlIO10IO01l)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&~lO10Il0IO1l0IO1&~IO0lIlIO10IO01l);assign OIl01O1lIOlIO10
=(l10IOIO0lIOOl1I&~lO10IIIO0lIO01l[2])|(OI01lIIO0lOlI01&OOl1Il10IOl0IO1);dff IIlO01OlI01OlI1O
(IIO0lOlI01lIO10,IO0lIOOl1IlO10I,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[7]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[6];assign lIO10OI01lOI01l[9:0]
=(O01IlO01IlIOIl0==I01lOl10IOOIl01)?10'b0000000000:
l0IO1I01lOOlI01[9:0];assign I1lO0lO10IIlO01
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&IOIl0O1lIOOlI1O)|
(IO01lOlI1OOOl1I&~IO0lIl0IO1OOIl1&~IlO01IO0lIIlI0O);assign I01lOIlO01I01lO
=
IlO01l10IOlIO10|I1lO0O01IlI01lO|
(I1lO0I01lOOIl01&IO01lIO0lIIIO0l[16])|
(OlI1OIlI0OOOIl1&((~lO10IIIO0lIO01l[3]&~lO10IIIO0lIO01l[1]&~lO10IIIO0lIO01l[0])|O1lIOlIO10l0IO1|O1lIOOIl01lO10I));assign O01IlOOIl1IlI0O
=(OlI1OIO0lIl10IO)?IlO01OlI1OIlI0O[11:2]:
(OIl01O01IlOI01l[1:0]==2'b00)?OIl01O01IlOI01l[11:2]:
OIl01O01IlOI01l[11:2]+10'h001;assign I1lO0l10IOIO0lI[21]
=card_ecc_failed|(~lIO10lO10IlO10I[21]&IO01lIO0lIIIO0l[21]);assign OOIl1IOIl0I01lO
=(~l10IOI01lOO01Il&IIO0ll0IO1OOl1I&~lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&OlI1Ol10IOIO01l&~lO10Il0IO1l0IO1&~OI01lIIO0lOI01l[2]);assign IOIl0IlI0OlO10I[1]
=lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&lO10IO01IlO01Il&ecsd_a[1];assign IIO0ll0IO1OlI1O
=(sel_mmc)?{IlO01IO0lIOlI01,16'h0000}:
32'h00000000;assign IlI0OIlI0Ol0IO1[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[8];dff IIlI0OOOIl1OOIl1
(OOIl1OOl1IOlI1O,IlO01OIl01OOIl1,clk,hreset_b,1'b1);assign OOIl1l10IOI1lO0
=((O01IlO01IlOlI1O==1'b1)&
((OI01ll0IO1O01Il==2'b11)&(IIO0lI1lO0OI01l==1'b0))|
((OI01ll0IO1O01Il==2'b00)&(IIO0lI1lO0OI01l==1'b1)))?1'b1:1'b0;dff IOlI01IIO0lI1lO0
(IO01lOlI1OIO0lI,IlO01OIl01IIO0l,clk,hreset_b,1'b1);assign IO01lIO0lIIIO0l[14]=(sel_mmc)?1'b0:card_ecc_disabled;dff II1lO0IlO01IlO01
(IO0lIIO01lIlI0O,O1lIOOlI01IOIl0,clk,hreset_b,1'b1);assign IOIl0l0IO1IOIl0[7:5]=3'b000;assign IlI0OOlI01IO01l
=(OlI01O01IlOlI1O|IOIl0lO10IOOl1I)?{IO0lIOIl01I1lO0,24'h000000}:
{IOIl0OOl1II01lO,24'h000000};assign O1lIOOOl1IOIl01[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[10];assign OOIl1OlI01O1lIO=(l10IOIlO01lIO10==6'h07)?1'b1:1'b0;assign lIO10OI01lO1lIO
=(I01lOIOIl0OI01l&IO0lIlIO10IO01l)?O1lIOOOl1IOIl01[15:8]:IO0lIOlI01lO10I[7:0];assign OI01lI1lO0OIl01
=IO01lOlI1OOOl1I&IlI0OlO10IOOIl1;assign l0IO1IlO01lO10I[17]=(OIl01OOIl1IIO0l&OIl01IlO01IlI0O&OI01lOlI01IlO01);assign l10IOI01lOO01Il
=
(IO0lIOIl01I01lO)?lO10IIlO01OI01l:
1'b1;assign I1lO0I01lOlIO10=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&IO01lIOIl0l0IO1);assign OlI1OIO0lIIO01l
=O1lIOOIl01lIO10|IlI0OlO10IOlI1O|IlI0OIO01lI1lO0|OlI01O01IlO1lIO;assign IO01lO01IlIlO01[11:8]
={O01IlO1lIOIlI0O[9],l0IO1O01IlO01Il[9],IO01lI01lOlIO10[9],O1lIOIO0lII1lO0[9]};assign O01IlIlO01OlI1O
=(l10IOIlO01lIO10==6'h1c)?1'b1:1'b0;assign O01IlIlI0OIO01l[0]
=((~l10IOI01lOO01Il&~l0IO1l10IOO1lIO&(OI01lIO01lI01lO|IOIl0OOl1Il10IO))|
(l0IO1l10IOO1lIO&~dtin[3]));assign IO0lIOlI01OI01l
=IIO0lIlI0OIIO0l&OI01lOOIl1OOl1I;dff9 II1lO0OI01ll10IO(OI01lIIO0lO01Il[8:0],IOIl0I1lO0OlI01[8:0],clk,hreset_b,1'b1);assign OOIl1I1lO0OOl1I
=OOl1IIOIl0IlO01&lO10IIlO01IlI0O&IlI0OIIO0lOlI01;assign O1lIOIlI0OIIO0l
={~IlI0Ol0IO1OI01l[7],~IlI0Ol0IO1OI01l[6],~IlI0Ol0IO1OI01l[5],~IlI0Ol0IO1OI01l[4],
~IlI0Ol0IO1OI01l[3],~IlI0Ol0IO1OI01l[2],~IlI0Ol0IO1OI01l[1],~IlI0Ol0IO1OI01l[0]};assign OOIl1IlI0OOOl1I
=((IO01lI01lOl10IO[11:8]==4'b0001)&(OlI1OOOl1IIOIl0[23:15]!=9'b000000000))?1'b1:1'b0;assign OOl1IIOIl0l0IO1
=
(l10IOlIO10OOIl1)?
{IOIl0I1lO0IlI0O[120],IOIl0I1lO0IlI0O[112],IOIl0I1lO0IlI0O[104],IOIl0I1lO0IlI0O[96],IOIl0I1lO0IlI0O[88],
IOIl0I1lO0IlI0O[80],IOIl0I1lO0IlI0O[72],IOIl0I1lO0IlI0O[64],IOIl0I1lO0IlI0O[56],
IOIl0I1lO0IlI0O[48],IOIl0I1lO0IlI0O[40],IOIl0I1lO0IlI0O[32],IOIl0I1lO0IlI0O[24],
IOIl0I1lO0IlI0O[16],IOIl0I1lO0IlI0O[8],IOIl0I1lO0IlI0O[0]}:
(IlI0OIlI0OOlI01)?
{IOIl0I1lO0IlI0O[60],IOIl0I1lO0IlI0O[56],IOIl0I1lO0IlI0O[52],IOIl0I1lO0IlI0O[48],IOIl0I1lO0IlI0O[44],
IOIl0I1lO0IlI0O[40],IOIl0I1lO0IlI0O[36],IOIl0I1lO0IlI0O[32],IOIl0I1lO0IlI0O[28],
IOIl0I1lO0IlI0O[24],IOIl0I1lO0IlI0O[20],IOIl0I1lO0IlI0O[16],IOIl0I1lO0IlI0O[12],
IOIl0I1lO0IlI0O[8],IOIl0I1lO0IlI0O[4],IOIl0I1lO0IlI0O[0]}:
IOIl0I1lO0IlI0O[15:0];assign I01lOO01IlIlO01
=(l10IOIlO01lIO10==6'h3a)?1'b1:1'b0;assign OOIl1l10IOl10IO[8]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[7];assign IOIl0IIO0lO1lIO
=lIO10l0IO1I01lO&O01IllO10IOI01l&~IO01lI01lOl10IO[15];dff IO1lIOIlI0OIOIl0(OOIl1lIO10lIO10,O1lIOOlI1Ol0IO1,clk,hreset_b,1'b1);assign IlI0OlO10IOOl1I
=(O1lIOOIl01OIl01[0]==1'b1)?1'b1:1'b0;assign IlI0OOlI01IlO01
=IO01lOIl01OOIl1|
(OOIl1OOl1IIIO0l&(IO0lIOOl1IOIl01|OlI1OOIl01O01Il|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|OOl1IOlI01OOIl1))|
(IlO01lIO10OI01l&IOIl0IO01lOIl01[21]&l10IOOI01lOlI01);dff2 IOI01ll0IO1OIl01
(I01lOIO0lIIlI0O,l10IOl10IOIOIl0,clk,hreset_b,1'b1);assign I01lOO01IlIO01l
=(~IOIl0IO01ll0IO1&OIl01OOIl1IIO0l&O01IlO01IlOlI1O)|
(IOIl0IO01ll0IO1&OIl01OOIl1IIO0l&IO0lIlIO10IO01l);dff II01lOI01lOI01lO
(OlI1OIO01lO1lIO,OOIl1OlI01OlI1O,clk,1'b1,hreset_b);assign OIl01O1lIOlO10I
=(l0IO1O01IllO10I&((~OI01lIIO0lOI01l[3]&IIO0lOIl01l10IO)|I1lO0IO0lIIO0lI))|O01IlO1lIOOlI01|IIO0lI1lO0IOIl0|
OIl01IIO0lI1lO0|IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO|
O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|O1lIOIlI0OO1lIO|OOl1IOlI01OOIl1|
I01lOO01IlIlO01|I1lO0OOIl1IO01l|
OIl01IlO01IO0lI|O01IlO01IlO1lIO|OlI01OOIl1OlI1O|IO0lIlIO10IlO01|O1lIOIO0lIIO01l|
(~I1lO0IO0lIIO0lI&l0IO1I01lOIOIl0&(OOIl1OlI01O1lIO|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OlI01I1lO0l10IO|OOIl1IO01lOlI1O));assign I01lOOI01llO10I[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[9];dff IIOIl0OOIl1OOl1I
(O01IlI01lOOOl1I,OlI01IlI0OIlO01,clk,hreset_b,1'b1);assign IIO0lOOl1Il0IO1
=(IlI0OlO10IOlI1O&OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&OIl01lO10IO01Il&~IO01lIO0lIOlI01)|
(IlI0OIO01lI1lO0&~l10IOI01lOOlI01&~(IO01lIO0lIIOIl0&O01IlO1lIOOlI01));assign OI01lIO01lIlO01
=IIO0lIO01llO10I|(~(IIO0lOIl01l10IO|OOl1IIO0lIO01Il)&O01IlOI01lOOl1I);assign OlI1OI1lO0OOl1I
=(l0IO1OOIl1I1lO0[2:0]==3'b000)?OOIl1IOIl0IlO01[63:56]:
(l0IO1OOIl1I1lO0[2:0]==3'b001)?OOIl1IOIl0IlO01[55:48]:
(l0IO1OOIl1I1lO0[2:0]==3'b010)?OOIl1IOIl0IlO01[47:40]:
(l0IO1OOIl1I1lO0[2:0]==3'b011)?OOIl1IOIl0IlO01[39:32]:
(l0IO1OOIl1I1lO0[2:0]==3'b100)?OOIl1IOIl0IlO01[31:24]:
(l0IO1OOIl1I1lO0[2:0]==3'b101)?OOIl1IOIl0IlO01[23:16]:
(l0IO1OOIl1I1lO0[2:0]==3'b110)?OOIl1IOIl0IlO01[15:8]:OOIl1IOIl0IlO01[7:0];assign IOIl0IO01lOIl01[16]
=(sel_mmc)?csd[16]:1'b0;assign l0IO1IlO01lO10I[31]=IO01lIO0lIIO0lI|OI01llO10IIIO0l;assign IOIl0I1lO0OI01l
=(OIl01O1lIOOIl01&I01lOI01lOlO10I&lO10IIIO0lIO01l[3])|
(OI01lIIO0lOlI01&~OOl1Il10IOl0IO1);assign IlO01l10IOO01Il
=IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I|lO10IOOIl1OlI01;assign lIO10OOIl1OlI01[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[11]^IIO0lI1lO0IO0lI[2]^l0IO1O01IlO01Il[15];assign IOIl0IO01lO01Il
=(OOIl1OOl1IIIO0l&~IlO01OI01lIlO01)?(OlI01I1lO0lO10I+32'h00000001):
(OI01lOlI01IlO01&l10IOO01IlI1lO0)?{OlI01I1lO0lO10I[31:2]+{20'h00000,OI01lI1lO0lO10I},2'b00}:
(OlI01I1lO0lO10I+IlO01OlI1OIlI0O);dff IIIO0lIO01ll0IO1
(IlO01IO0lIO01Il,I01lOl10IOOlI01,clk,hreset_b,1'b1);assign OlI01IlO01OOl1I
=(O01IlIIO0ll10IO&OOIl1OlI1OOlI01)|(~l0IO1l0IO1IlO01&OIl01OI01lOOIl1);assign OIl01IlI0OIO01l
=((IlI0OIlI0OOlI01==1'b0)&(O1lIOOIl01OIl01[6:0]==7'b1000001))?1'b1:
((IlI0OIlI0OOlI01==1'b1)&(O1lIOOIl01OIl01[4:0]==5'b10001))?1'b1:1'b0;assign O01IlO1lIOO01Il
=(IlI0OOlI01I01lO[3:0]==4'b0001)?1'b1:1'b0;assign IO01lIlO01I01lO=(IlO01lIO10IlI0O[5]!=I1lO0IOIl0IOIl0[5])?1'b1:1'b0;dffe4 II1lO0OlI1OOlI1O
(lO10IIIO0lIO01l,IOIl0I1lO0IlI0O[3:0],clk,hreset_b,1'b1,O01IlI1lO0I01lO);assign IlI0OIIO0lIOIl0
=O1lIOOlI1OOIl01|I01lOIOIl0IlI0O|l0IO1OI01lIIO0l|O01IlOOIl1OlI1O;assign OI01ll0IO1IOIl0[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[13];assign l10IOOOIl1I01lO
=(IlO01OIl01O1lIO)?{24'h000000,O1lIOI1lO0OOIl1}:
(OI01lIIO0lOIl01&l0IO1lO10Il10IO&~lO10IOOIl1IlI0O)?IOIl0OlI01I1lO0:
(OIl01OOIl1IIO0l&IO0lIlIO10IO01l)?{16'h0000,IOIl0I1lO0IlI0O[15:0]}:
I1lO0O01IlIO01l;assign IOIl0O1lIOOOIl1
=IlI0OlO10IOlI1O&(l0IO1O01IllO10I|OIl01lO10IO01Il);dff IOlI01OOIl1IOIl0(OI01lI1lO0lIO10,IlI0OIlI0OlO10I,clk,hreset_b,1'b1);dff11 IOI01lO1lIOOlI01
(l10IOI01lOOI01l,l0IO1OI01lIlI0O,clk,hreset_b,1'b1);assign OI01lIO01ll10IO=(l0IO1OOIl1OIl01&IOIl0OlI1OIlO01&IO01lIO0lIOI01l);assign OOIl1IO0lIlO10I
=(~l10IOI01lOO01Il&IIO0lOIl01l10IO&lO10IOOIl1OI01l)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&IO0lIlIO10IO01l&~lO10Il0IO1l0IO1&lIO10IlO01OI01l);assign OOl1IIO01lOOIl1
=(OOIl1IO0lIl10IO==8'h0d)?1'b1:1'b0;dff32 IOOl1IIO01lO1lIO(IO0lIOlI1OI01lO,OlI1OlIO10I1lO0,clk,1'b1,hreset_b);dffe16 IIIO0lO1lIOOlI1O
(I01lOOIl01OOIl1,I1lO0OlI1OOOl1I,clk,1'b1,1'b1,lIO10OOIl1O01Il);dff11 Il0IO1OOIl1IO01l
(I01lOl10IOOIl01,I1lO0IOIl0O01Il,clk,hreset_b,1'b1);assign l10IOI01lOIOIl0
=(O1lIOOlI1OOIl01&IOIl0IIO0lIO0lI&~IlO01IO0lIO01Il)|
(I01lOIOIl0IlI0O&~IOIl0OlI1OIlO01);dff IOOIl1OlI01IlI0O
(lIO10lO10Il10IO,lO10IO1lIOl0IO1,clk,hreset_b,1'b1);assign lO10IO01IlIlI0O=~IlI0OIO01lI01lO|I1lO0OI01lOlI01;assign I1lO0l10IOIO0lI[5]
=(l0IO1IlO01lO10I[5]|(~lIO10lO10IlO10I[5]&IO01lIO0lIIIO0l[5]));assign IO0lIOIl01lIO10
=(~l10IOI01lOO01Il&IIO0lOIl01l10IO&OlI01O1lIOIOIl0);assign OIl01OI01lO1lIO=(IO01lI01lOl10IO[25:24]==2'b10)?1'b1:1'b0;assign lIO10I01lOIIO0l
=~OlI1OOOl1IOI01l&(OlI01I1lO0l10IO|O01IlO01IlO1lIO);assign IlI0OIlI0Ol0IO1[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[0];assign I1lO0OI01ll0IO1
=(rd_thd==3'b000)?10'h010:
(rd_thd==3'b001)?10'h020:
(rd_thd==3'b010)?10'h040:
(rd_thd==3'b011)?10'h080:10'h001;dff IIO01llIO10OlI01
(I01lOIOIl0IlI0O,l10IOI01lOIOIl0,clk,hreset_b,1'b1);assign IOIl0I1lO0IlI0O[7:0]
=(l10IOlIO10OOIl1|OIl01OI01lOOIl1)?OI01lIIO0lOI01l:
(IlI0OIlI0OOlI01)?{OOIl1OOl1IO1lIO,OI01lIIO0lOI01l[3:0]}:
{O1lIOIO01lIIO0l,IO01lOlI1OOOIl1};assign IIO0ll0IO1O1lIO
=(IOIl0I1lO0OIl01)?OOIl1l10IOI01lO[1:0]:
((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1&OIl01IlO01O1lIO)?IOIl0IO01lO01Il[1:0]:
(IIO0lIlI0OOlI01|I1lO0lIO10O1lIO|((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1))?2'b00:
(l10IOO01Ill0IO1&O1lIOIO0lII01lO)?OOl1IlIO10O01Il:
IlI0OO1lIOIO0lI;assign IO01lIO0lIIIO0l[0]
=1'b0;dff IOI01llO10IIlI0O(OI01lO1lIOO1lIO,IOIl0l0IO1OlI1O,clk,hreset_b,1'b1);assign IIO0lIIO0lIIO0l[2]
=IOIl0IlI0OlO10I[2]|(~OOl1IOlI01O1lIO[2]&IOIl0l0IO1IOIl0[2]);assign IIO0lOlI1OI01lO
=~O01IllO10IOI01l&~OIl01IIO0ll0IO1&IO01lOI01lI01lO;assign O1lIOOOl1IOIl01[3]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[2];assign lIO10OI01lIIO0l=OI01lOOl1II01lO|IO01lIO0lIIIO0l[5];assign l10IOO1lIOIlO01[5]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[5]);assign OlI01O1lIOIIO0l=IIO0lIlI0OIIO0l&lO10IOOIl1OlI01;dff II1lO0l10IOOlI01
(IO01lIO0lIIIO0l[25],I1lO0l10IOIO0lI[25],clk,hreset_b,1'b1);dff IOOIl1OOl1IOI01l
(OIl01O01IlIO0lI,O01IlOOIl1O1lIO,clk,hreset_b,1'b1);assign IO01lOOl1IOOl1I[7:4]=4'b0000;dff II01lOlIO10IlI0O
(O1lIOOIl01O01Il,OlI1OOlI1OOlI01,IlO01IlO01IlO01,1'b1,hreset_b);assign IO0lIIlI0OO1lIO[11:8]
={O01IlO1lIOIlI0O[13],l0IO1O01IlO01Il[13],IO01lI01lOlIO10[13],O1lIOIO0lII1lO0[13]};assign OlI1OOIl01O01Il
=(l10IOIlO01lIO10==6'h12)?1'b1:1'b0;assign OI01lIO01lI01lO
=(OI01lIO01lI1lO0&~lO10Il0IO1l0IO1)|O1lIOOlI1OlO10I|OOl1IIO0lIO01Il|I01lOIOIl0OI01l|l0IO1OI01lIOIl0|
(OIl01O01IlIO0lI&lIO10IlO01OI01l)|(OI01llO10IOlI1O&~lO10Il0IO1l0IO1)|
(IIO0ll0IO1OOl1I&~lO10Il0IO1l0IO1)|(OlI1Ol10IOIO01l&~lO10Il0IO1l0IO1)|(IlO01I01lOI1lO0&~lO10Il0IO1l0IO1);assign IOIl0IlI0OIlI0O
=lIO10l10IOOOIl1&~rdy_b;assign IO0lIIlI0OIO0lI=I1lO0IO0lIIO0lI&IIO0lIlI0OIIO0l&I1lO0OOIl1IO01l;assign OI01ll0IO1O01Il
=
(IO0lIOIl01I01lO)?OlI1OOlI01OI01l[1:0]:
1'b0;assign OI01lO01IlOOIl1=(IO01lI01lOl10IO[15:8]>=8'h03)?1'b1:1'b0;dffe7 IOIl01I01lOO1lIO
(O01IlO01IlOOIl1,OlI01OOIl1OOl1I,clk,hreset_b,1'b1,l0IO1O01IlOIl01);assign IO01llIO10OI01l[31:28]
={IO0lIOlI01lO10I[3],OI01lI1lO0l10IO[3],lIO10O1lIOIO01l[3],I01lOOIl01OOIl1[3]};assign OlI01O1lIOIlI0O
=(l10IOIlO01lIO10==6'h28)?1'b1:1'b0;assign OOIl1l10IOl10IO[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[0]^O1lIOIO0lII1lO0[15];assign IOIl0IO01llO10I
=~rdy_b&(IIO0lOlI1OIO01l|I1lO0OI01llO10I);assign O01Ill0IO1l0IO1
=(l0IO1l10IOO1lIO&~I1lO0IO0lIIO0lI)?3'b111:
(IOIl0IlI0OOIl01&I1lO0IO0lIIO0lI)?3'b101:
(lO10IO1lIOl10IO-3'b001);assign IlI0OI1lO0lIO10
=(OOIl1IO0lII1lO0==8'b00000010)?1'b1:1'b0;dff IOI01lO01IlO1lIO(OOl1IOIl01OI01l,l0IO1O1lIOl10IO,clk,hreset_b,1'b1);assign IOIl0IO01ll0IO1
=(sel_mmc)?l10IOOI01lOlI01:OI01ll0IO1OlI01;assign l0IO1O1lIOI1lO0
=(O1lIOIlI0OOlI1O&~I1lO0IO0lIIO0lI)?3'b111:
(O1lIOIlI0OOlI1O&I1lO0IO0lIIO0lI)?3'b110:
(OOIl1OlI01OOIl1)?3'b010:3'b101;assign I01lOOlI1OOOl1I
=OOl1IOOl1IOlI1O&~sel_mmc;assign I01lOOI01llO10I[2]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[1];dffe8 IOIl01I01lOIO0lI
(O01IlIlO01OOIl1,OlI01O01IlOOl1I,clk,1'b1,1'b1,OI01lOOl1IIlO01);assign OlI01IO01lI01lO[23:20]=(sel_mmc)?cid[23:20]:4'b0000;assign IOIl0OOl1IlIO10
=IIO0lOIl01l10IO&lO10IOOIl1OI01l;assign lO10IlO10Il10IO
=(IO0lIOIl01I01lO&~IO01lI01lOIO01l&(OI01lIO01lI1lO0|(IlO01I01lOI1lO0&OI01lIIO0lOI01l[2])))?OOIl1IlI0OOOIl1:
(O1lIOOlI1OlO10I)?12'h000:
(IO0lIOIl01I01lO&(OOl1IIO0lIO01Il|(I01lOIOIl0OI01l&O01IlO01IlOlI1O&(~IO0lIlIO10IO01l|O1lIOOOl1IOlI01))))?l10IOO01IlI01lO:
l0IO1OOIl1I1lO0;assign IOIl0IO01lOIl01[78:77]
=(OOIl1OOl1IIIO0l)?2'b00:csd[78:77];dff IOOl1IIO0lIl10IO(lIO10I01lOOOIl1,lO10IOI01lOOl1I,clk,hreset_b,1'b1);assign l0IO1IlO01lO10I[13]
=((OOl1IOOl1IOOIl1|I01lOOOIl1IlO01)&
~(OlI01I1lO0l10IO|IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I|lO10IOOIl1OlI01));assign OlI01OlI01IO01l
=((~I1lO0IO0lIIO0lI&OIl01IlO01IO0lI)|O01IlO01IlO1lIO|OlI01OOIl1OlI1O|
IlI0OlO10IOOIl1|IOIl0O1lIOOOl1I|IO0lIlIO10IlO01|O1lIOIO0lIIO01l);assign lIO10OOIl1OlI01[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[3];dff32 IOOl1IIO0lII1lO0
(l0IO1lO10II1lO0,IIO0lOlI01OlI01,clk,hreset_b,1'b1);dff II01lOOIl01OlI1O(IlI0OlO10IOlI1O,IO0lIl0IO1OOl1I,clk,hreset_b,1'b1);assign l0IO1l0IO1IlO01
=IIO0lOIl01l10IO&~(lO10IOOIl1OI01l|OlI01O1lIOIOIl0|IlI0Ol0IO1IIO0l|I1lO0OI01lOIl01);assign IIO0lI1lO0OI01l=lIO10I01lOIO0lI;dffe IIO0lIIlI0OOI01l
(dsr[10],IO01lI01lOl10IO[26],clk,1'b1,hreset_b,IlI0OOOl1II1lO0);assign O01IllO10IIIO0l
=(IlO01lIO10IlI0O[11]!=I1lO0IOIl0IOIl0[11])?1'b1:1'b0;dff IOOIl1IO01lIOIl0(OI01lIIO0lOlI01,IOIl0I1lO0OI01l,clk,hreset_b,1'b1);assign lO10IO01IlIIO0l
=IOIl0IO01lOIl01[91]&lIO10IlO01IOIl0;assign OI01ll0IO1IOIl0[6]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[5];assign OOl1Il10IOlO10I
=(l10IOI01lOO01Il|~I1lO0OOIl1I01lO)?1'b1:
((I1lO0lIO10IO0lI&OlI1OOOl1IOlI01)|(I1lO0lIO10O1lIO&OIl01IlO01O1lIO))?1'b0:
(((lIO10l10IOOlI1O&IOIl0OlI01I01lO)|(lIO10l10IOOOIl1&lIO10O1lIOlIO10))&~lO10II01lOOOIl1)?1'b0:
(((lIO10l10IOOlI1O&OlI1OOOl1IOlI01)|(lIO10l10IOOOIl1&OIl01IlO01O1lIO))&~lO10II01lOOOIl1)?1'b1:
OIl01l0IO1l0IO1;assign l0IO1IlO01O01Il
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&IOIl0IO01llIO10&l0IO1I01lOIOIl0;assign I01lOIlO01IO01l
=(O01IlIIO0ll10IO&O1lIOIlI0OO1lIO)|(~l0IO1l0IO1IlO01&IlO01OI01lIlO01);dff IOIl01OOIl1OIl01
(I01lOOOIl1I01lO,l10IOlO10II1lO0,clk,hreset_b,1'b1);assign IlI0OlO10IIO0lI=8'b00000000;assign I01lOOlI1OOlI1O
=(OI01lIIO0lO01Il==O1lIOlIO10IlO01)?1'b1:1'b0;assign lO10IO01IlOlI01=(OOIl1IO0lIl10IO==8'h05)?1'b1:1'b0;assign l0IO1IOIl0IO0lI
=(O1lIOOlI1OOIl01&IOIl0IIO0lIO0lI)?8'b00000111:
(I01lOIOIl0IlI0O&IOIl0OlI1OIlO01)?8'b00100000:
(l0IO1OI01lIIO0l&IOIl0OlI1OIlO01)?8'b00000111:
(OIl01O1lIOOlI01)?8'b00000100:
(OlI01I1lO0I01lO&IIO0lOlI01l0IO1)?8'b00110000:
(IIO0llIO10IlO01&~IlI0OO1lIOOOl1I)?8'b00001000:
(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01&~IO01lIO0lIOI01l)?8'b00100000:
(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01&IO01lIO0lIOI01l)?8'b10000000:
(OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&~IO01lIO0lIOI01l)?8'b00001000:
(l10IOO01IllO10I&~I1lO0IlO01lIO10)?8'b00001000:
(I1lO0IlO01lIO10&IOIl0OlI1OIlO01&(IO01lIO0lIOI01l|IOIl0lO10IOOl1I))?8'b00001000:
(I1lO0IlO01lIO10&IOIl0OlI1OIlO01&(lO10IOI01lIO0lI|OlI01O01IlOlI1O|OOl1Il10IOI1lO0))?8'b00100000:
(l10IOl10IOIIO0l-8'b00000001);assign I1lO0OlI1OOOl1I[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[7];assign O01IlO1lIOOIl01
=OOl1IOlI1OOI01l|(~IO0lIOIl01lO10I&IlI0OIlI0OOIl01);dff IOOIl1OIl01OIl01(IlO01OlI1OIOIl0,I01lOlIO10IIO0l,clk,1'b1,hreset_b);dff IlIO10OOIl1l10IO
(I1lO0I01lOOIl01,l10IOOI01lO01Il,clk,hreset_b,1'b1);dff IOOl1IIO01lIO0lI(lIO10l10IOOOIl1,lO10IIOIl0OOl1I,clk,hreset_b,1'b1);assign lIO10lO10IlO10I[23]
=I1lO0O01Ill0IO1|O01IlIlI0OI1lO0;assign OlI01IIO0lO01Il
=(~l10IOI01lOO01Il&OIl01OOIl1IIO0l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I)|
(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&~IlO01IO0lIOI01l&~IO0lIlIO10IO01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I);assign OIl01l0IO1I1lO0
=IO01lOI01lI1lO0&O1lIOOOl1IIOIl0&~IlI0OIO01ll10IO;dff Il10IOOOIl1IlO01(OlI01O01IlOlI1O,OI01lOOIl1OOIl1,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[9];assign dtbuf_waddr
=(I1lO0I01lOOlI01|OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)?O01IlO01IlIOIl0[9:0]:O1lIOOIl01l10IO;assign OI01lIlI0OI1lO0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&OlI01O1lIOIlI0O)|
(OlI01I1lO0I01lO&cmdin&rdy_b);dff24 IOIl01IOIl0OOl1I
(IOIl0I1lO0IlI0O[31:8],IIO0lIlI0OIOIl0[31:8],clk,1'b1,hreset_b);assign OOl1II01lOIlO01
=(IIO0lIIO0lOlI1O[1:0]==2'b00)?IIO0lIIO0lOlI1O[7:2]:(IIO0lIIO0lOlI1O[7:2]+6'h01);assign I1lO0l10IOIO0lI[24]
=l0IO1IlO01lO10I[24]|(~lIO10lO10IlO10I[24]&IO01lIO0lIIIO0l[24]);assign lO10IlO10IOIl01
=(~l10IOI01lOO01Il&I1lO0IlO01l0IO1&~lO10Il0IO1l0IO1&IO0lIlIO10IO01l)|
(~l10IOI01lOO01Il&l0IO1OOIl1lO10I&~lO10Il0IO1l0IO1&~IO0lIlIO10IO01l);assign IOIl0IlI0OlO10I[4]
=lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&OI01lO1lIOIlI0O&ecsd_a[4];assign OI01llO10IIO0lI
=(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01)?IOIl0IO01lOIl01[127:96]:
(OI01lO01IlOOl1I)?IOIl0IO01lOIl01[95:64]:
(OlI01IlO01OOIl1)?IOIl0IO01lOIl01[63:32]:
IOIl0IO01lOIl01[31:0];assign IlI0OIlI0Ol0IO1[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[11]^IIO0lI1lO0IO0lI[6]^OI01lI1lO0l10IO[15];dff IOlI1OlIO10IO01l
(OlI01IlI0Ol0IO1,IlI0OIO01llIO10,clk,hreset_b,1'b1);assign lO10IIIO0lI01lO
=(OOl1IIO0lIO01Il|(I01lOIOIl0OI01l&O01IlO01IlOlI1O&(~IO0lIlIO10IO01l|O1lIOOOl1IOlI01)))?IlI0OOlI01I01lO:
(((I01lOIOIl0OI01l&IO0lIlIO10IO01l)|l0IO1OI01lIOIl0)&l10IOlIO10OOIl1)?IlO01OOl1IOlI1O:
(((I01lOIOIl0OI01l&IO0lIlIO10IO01l)|l0IO1OI01lIOIl0)&IlI0OIlI0OOlI01)?OIl01IlO01OlI1O:
(((I01lOIOIl0OI01l&IO0lIlIO10IO01l)|l0IO1OI01lIOIl0)&~IlI0OIlI0OOlI01&~O1lIOOOl1IOlI01)?lIO10OI01lO1lIO:
(lO10IlO10IOIl01&~l0IO1OOIl1lO10I)?OOl1IOIl01IlI0O:
{lO10Il0IO1l10IO,l0IO1O1lIOI1lO0,1'b1,3'b111};assign lIO10lO10Il0IO1
=~lO10IIlO01OI01l&(I1lO0OOIl1IlO01|(~IIO0lOIl01l10IO&l10IOOOIl1l10IO));dff IIIO0lOlI01l10IO
(IO01lIO0lIIIO0l[17],I1lO0l10IOIO0lI[17],clk,hreset_b,1'b1);dff IlO10IlO10II1lO0
(l0IO1l10IOOOl1I,lIO10IIO0lIlO01,clk,hreset_b,1'b1);assign I1lO0O01IlIlO01[0]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[8]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[8])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[8])?1'b0:
IO01lOOl1IOOl1I[0];assign IOIl0OOl1II01lO
={1'b0,OOIl1lIO10l0IO1,IO01lIO0lIIIO0l[30],IO01lIO0lIIIO0l[28],IO01lIO0lIIIO0l[23],OOl1IIO0lIlIO10,IO01lIO0lIIIO0l[13],IlO01OlI1OIOIl0};assign O1lIOOOl1IOIl01[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[13];assign l0IO1O1lIOIO01l=(l10IOIlO01lIO10==6'h0a)?1'b1:1'b0;assign dtout[6]
=I1lO0lIO10OOl1I[6];dff IIO0lIIO01llIO10(IIO0lIlI0OIlI0O,OI01lIIO0lOlI01,clk,hreset_b,1'b1);assign OOIl1OlI1OIlI0O
=(sel_mmc|OOIl1OlI01O1lIO|OlI01I1lO0l10IO|I1lO0l10IOIOIl0|
l10IOIOIl0IIO0l|OOl1IOlI01OOIl1)&IIO0lIlI0OO01Il;assign l0IO1IlO01OI01l
=
(IO0lIOIl01I01lO)?IlO01OlI1OIlI0O:
16'h0000;assign IlO01l10IOl10IO[1]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[9]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[9])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[9])?1'b0:
OOIl1IO0lII1lO0[1];assign OlI01OOIl1OOl1I[1]
=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[0];assign OOl1IOlI1OOlI01[31:28]
={IO0lIOlI01lO10I[7],OI01lI1lO0l10IO[7],lIO10O1lIOIO01l[7],I01lOOIl01OOIl1[7]};assign IOIl0OIl01IlO01
=(l10IOIlO01lIO10==6'h20)?1'b1:1'b0;assign O01IlIlI0OIO01l[3]
=~l10IOI01lOO01Il&(IlI0OIlI0OOlI01|l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO;assign OIl01IlI0OIlO01
=O1lIOIlI0OIO0lI|(~O1lIOOlI01IIO0l&lO10II01lOOOl1I);assign O1lIOIO01lIlI0O=IIO0lIlI0OIIO0l&IO0lIlIO10IlO01;assign I1lO0OI01lOIl01
=((~I1lO0IO0lIIO0lI&OlI1OOlI01O1lIO)|(I1lO0IO0lIIO0lI&I1lO0IlO01lIO10&IOIl0OlI1OIlO01))&
((OIl01l0IO1l10IO|O01IlIlO01OlI1O|OlI01O01IlOOIl1)|l0IO1O1lIOI01lO);assign IO0lIOIl01I01lO
=1'b1;assign OOl1IlIO10lO10I=(OlI1OOlI1OlIO10)?IO01lI01lOl10IO[11:0]:{4'b0000,~IO01lI01lOl10IO[7:0]};assign IlI0OIIO0lIIO0l
=
(l10IOlIO10OOIl1)?
{IOIl0I1lO0IlI0O[123],IOIl0I1lO0IlI0O[115],IOIl0I1lO0IlI0O[107],IOIl0I1lO0IlI0O[99],IOIl0I1lO0IlI0O[91],
IOIl0I1lO0IlI0O[83],IOIl0I1lO0IlI0O[75],IOIl0I1lO0IlI0O[67],IOIl0I1lO0IlI0O[59],
IOIl0I1lO0IlI0O[51],IOIl0I1lO0IlI0O[43],IOIl0I1lO0IlI0O[35],IOIl0I1lO0IlI0O[27],
IOIl0I1lO0IlI0O[19],IOIl0I1lO0IlI0O[11],IOIl0I1lO0IlI0O[3]}:
{IOIl0I1lO0IlI0O[63],IOIl0I1lO0IlI0O[59],IOIl0I1lO0IlI0O[55],IOIl0I1lO0IlI0O[51],IOIl0I1lO0IlI0O[47],
IOIl0I1lO0IlI0O[43],IOIl0I1lO0IlI0O[39],IOIl0I1lO0IlI0O[35],IOIl0I1lO0IlI0O[31],
IOIl0I1lO0IlI0O[27],IOIl0I1lO0IlI0O[23],IOIl0I1lO0IlI0O[19],IOIl0I1lO0IlI0O[15],
IOIl0I1lO0IlI0O[11],IOIl0I1lO0IlI0O[7],IOIl0I1lO0IlI0O[3]};assign O01IlO01IlO1lIO
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h0d))?1'b1:1'b0;assign OOIl1l10IOl10IO[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[10];assign O01IllO10IOlI01=lIO10l0IO1I01lO&O01IllO10IOI01l;assign OlI1OOOl1IIOIl0[31:30]
=ocr_mem[31:30];assign IlO01IO0lIOI01l=(O1lIOOIl01OIl01==15'h0002)?1'b1:1'b0;assign OIl01I01lOOlI1O
=OI01lIlI0Ol0IO1|O1lIOIO0lIIO01l;assign IOIl0IO01lOIl01[121:120]=2'b00;assign l0IO1I01lOIIO0l=(lIO10OI01lIO0lI-32'h00000001);dff IlIO10O01Ill0IO1
(l0IO1O1lIOI01lO,lO10Il0IO1I1lO0,clk,hreset_b,1'b1);assign IOIl0O1lIOOlI1O
=IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I|IlI0OlO10IOOIl1;assign I01lOOI01llO10I[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[12];assign OlI1OOOl1IOlI01=(OOl1IlIO10lIO10==10'b0000000001)?1'b1:1'b0;assign lIO10l10IOOOl1I
=(IO01lI01lOI1lO0&IO01lIO0lIIOIl0&(OlI1OIO01lIO0lI|IO01lOIl01OOIl1|lO10Il0IO1I01lO|IO0lIOOl1IOIl01|
OlI1OOIl01O01Il|OI01lOOIl1OOl1I|(OOl1IOlI01OOIl1&IO01lI01lOl10IO[0])|
O01IlO01IlO1lIO|OlI01OOIl1OlI1O|O1lIOIO0lIIO01l))|
(I1lO0lIO10OlI1O&~l10IOI01lOOlI01&~OOIl1OIl01IIO0l&~l0IO1O1lIOl10IO&~l0IO1IlO01O01Il&~OOIl1lIO10lO10I);assign lO10IO1lIOOIl01
=OlI01OlI01IlO01&IlI0OI1lO0lO10I;assign OI01lIlI0OlO10I
=(l0IO1OOIl1I1lO0[3:0]==4'b0000)?OlI01I1lO0lIO10[127:120]:
(l0IO1OOIl1I1lO0[3:0]==4'b0001)?OlI01I1lO0lIO10[119:112]:
(l0IO1OOIl1I1lO0[3:0]==4'b0010)?OlI01I1lO0lIO10[111:104]:
(l0IO1OOIl1I1lO0[3:0]==4'b0011)?OlI01I1lO0lIO10[103:96]:
(l0IO1OOIl1I1lO0[3:0]==4'b0100)?OlI01I1lO0lIO10[95:88]:
(l0IO1OOIl1I1lO0[3:0]==4'b0101)?OlI01I1lO0lIO10[87:80]:
(l0IO1OOIl1I1lO0[3:0]==4'b0110)?OlI01I1lO0lIO10[79:72]:
(l0IO1OOIl1I1lO0[3:0]==4'b0111)?OlI01I1lO0lIO10[71:64]:
(l0IO1OOIl1I1lO0[3:0]==4'b1000)?OlI01I1lO0lIO10[63:56]:
(l0IO1OOIl1I1lO0[3:0]==4'b1001)?OlI01I1lO0lIO10[55:48]:
(l0IO1OOIl1I1lO0[3:0]==4'b1010)?OlI01I1lO0lIO10[47:40]:
(l0IO1OOIl1I1lO0[3:0]==4'b1011)?OlI01I1lO0lIO10[39:32]:
(l0IO1OOIl1I1lO0[3:0]==4'b1100)?OlI01I1lO0lIO10[31:24]:
(l0IO1OOIl1I1lO0[3:0]==4'b1101)?OlI01I1lO0lIO10[23:16]:
(l0IO1OOIl1I1lO0[3:0]==4'b1110)?OlI01I1lO0lIO10[15:8]:OlI01I1lO0lIO10[7:0];assign IOIl0IO01lOIl01[11:10]
=(OOIl1OOl1IIIO0l)?2'b00:csd[11:10];assign lIO10IOIl0OOIl1
=(IOIl0IO01lOIl01[83:80]<=4'b1001)?lIO10O01IlIlI0O:
(IOIl0IO01lOIl01[83:80]==4'b1010)?lO10IOOIl1IOIl0:
(IOIl0IO01lOIl01[83:80]==4'b1011)?O01IllO10IIIO0l:
(IOIl0IO01lOIl01[83:80]==4'b1100)?OlI01O1lIOIO0lI:
(IOIl0IO01lOIl01[83:80]==4'b1101)?IlI0Ol0IO1O1lIO:IOIl0IIO0lOlI1O;assign lIO10l0IO1IlO01
=(OIl01O1lIOOIl01&I01lOI01lOlO10I&~lO10IIIO0lIO01l[3]&~lO10IIIO0lIO01l[1]&~lO10IIIO0lIO01l[0])|
(IlO01OIl01O1lIO&lIO10O1lIOI01lO);assign OIl01OOIl1IO0lI
=OOIl1IO01lOlI1O|OOl1IOlI01OOIl1|OIl01IlO01IO0lI|O01IlO01IlO1lIO|OlI01OOIl1OlI1O|
IlI0OlO10IOOIl1|IOIl0O1lIOOOl1I|IO0lIlIO10IlO01|O1lIOIO0lIIO01l;assign lIO10OOIl1OlI01[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[14];assign l0IO1IlO01OlI01
=O01IlIIO0llO10I|IlI0OIlI0OO01Il|lO10II01lOOOl1I|
IlI0Ol0IO1IO0lI|O01IllO10IIOIl0|OlI01O1lIOIIO0l|lIO10O1lIOl0IO1|
OOl1IOlI1OIIO0l|lIO10O01IlOI01l|IO0lIOlI01OI01l|OI01lI1lO0OIl01|
lO10IOOIl1IlI0O|O1lIOIlI0OOOIl1|OOIl1OIl01IOIl0|O1lIOOOl1IIlI0O|OlI01IO01lIO01l|
IO0lIOOl1IlIO10|OlI1OOIl01lO10I;assign OOl1IOOl1IO1lIO
=(O1lIOOIl01lIO10)?4'b0000:
(IlI0OlO10IOlI1O)?4'b0001:
(IlI0OIO01lI1lO0)?4'b0010:
(O1lIOIO0lIIlO01)?4'b0011:
(IO01lI01lOI1lO0)?4'b0100:
(I1lO0lIO10OlI1O)?4'b0101:
(OIl01IlO01IIO0l)?4'b0110:
(I1lO0IOIl0OI01l)?4'b0111:
(lO10IIIO0lIlO01)?4'b1000:4'b1001;assign OOIl1IO0lIl0IO1
=(O01IlIIO0ll10IO&l10IOIOIl0IIO0l)|(~l0IO1l0IO1IlO01&OlI1OlIO10l10IO);assign l10IOO01IlI1lO0
=~l10IOOI01lOlI01&IOIl0IO01lOIl01[21];assign lIO10OOIl1lO10I=IlI0OIlI0OlIO10|(~lIO10IIO0lIO01l&l0IO1O01IllIO10);assign l0IO1lO10Il0IO1
=(OlI01lO10IIO0lI&~OIl01OOIl1IIO0l)&(OI01lOlI01IlO01|OlI1OlIO10l10IO)&I01lOOI01lI1lO0;assign IlO01l10IOl0IO1
=(I1lO0IlO01l10IO&~IO01lOI01lI1lO0)?pwd_len:
(OOIl1IOIl0IO01l&O1lIOOOl1IIOIl0&I1lO0O01IlI1lO0)?(IOIl0I1lO0IlI0O[7:0]-pwd_len):
(IO01lOI01lI1lO0&O1lIOIO0lII01lO&lO10IIIO0lIO01l[0])?IIO0lIIO0lOlI1O:
((IO01lOI01lI1lO0|l10IOO01Ill0IO1)&O1lIOOOl1IIOIl0)?(OOIl1IO0lIl10IO-8'h01):
OOIl1IO0lIl10IO;dffe6 IIOIl0l0IO1IlI0O
(l10IOIlO01lIO10,IlI0OOOl1IIlO01[5:0],clk,hreset_b,1'b1,OI01ll0IO1IlI0O);assign I1lO0OlI1OOOl1I[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[4]^I01lOOIl01OOIl1[15];assign IOIl0OlI01I1lO0
=(IO01llIO10IIO0l)?IO01lI01lOl10IO:
(O01IllO10IOI01l)?IOIl0OIl01IO01l:
32'h00000000;assign I01lOOI01ll10IO
=IO01lI01lOI1lO0&(l0IO1O01IllO10I|IIO0lI1lO0IOIl0|OOIl1OlI01O1lIO|OlI01I1lO0l10IO|IOIl0IO01llIO10|
IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO|
((O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I)&IOIl0IO01lOIl01[31])|
lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOIl1IO01lOlI1O|OOl1IOlI01OOIl1)|
(sel_mmc&((OOl1IOOl1IOlI1O|OOIl1OlI1OOlI01|IO01lIO0lIIlI0O|lIO10I01lOIO0lI|OlI1OIO0lII1lO0|I01lOI01lOlIO10)|
(~IlI0OIlI0OOlI01&~l10IOlIO10OOIl1&(lO10Il0IO1I01lO|IlO01lIO10OI01l))))|
(~sel_mmc&(IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OIl01IlO01IO0lI|O01IlO01IlO1lIO|OlI01OOIl1OlI1O|
IlI0OlO10IOOIl1|IO0lIlIO10IlO01|O1lIOIO0lIIO01l));dff IIO0lIl0IO1O1lIO
(OOl1IOlI1OIlI0O,IO01llIO10IOIl0,clk,hreset_b,1'b1);assign O1lIOIO01lOI01l
=(~lO10IIlO01OI01l&OI01lIIO0lOIl01&OIl01l0IO1lIO10&I1lO0OOIl1I01lO);assign lIO10lO10IlO10I[7]=IlO01OI01lI1lO0;assign lO10IO01IlIOIl0
=(I1lO0I01lOOlI01&~IOIl0I1lO0IlI0O[0]&I1lO0IO0lIIO0lI&OlI01lO10IIIO0l);assign OlI01IlI0OI1lO0
=(IO01lIOIl0lIO10)?pwdin[7:0]:
(I1lO0I01lOlO10I)?pwdin[15:8]:
(l10IOOI01lOIl01)?pwdin[23:16]:
(lIO10IlO01O01Il)?pwdin[31:24]:
(lO10IO01IlOlI01)?pwdin[39:32]:
(OIl01OOIl1OI01l)?pwdin[47:40]:
(OlI01lO10IIlI0O)?pwdin[55:48]:
(OI01lO1lIOIOIl0)?pwdin[63:56]:
(IOIl0l0IO1IIO0l)?pwdin[71:64]:
(IIO0lIIO0lIO0lI)?pwdin[79:72]:
(O1lIOI1lO0O1lIO)?pwdin[87:80]:
(OlI1OIlI0OOlI1O)?pwdin[95:88]:
(OOl1IIO01lOOIl1)?pwdin[103:96]:
(IlO01OlI01OOl1I)?pwdin[111:104]:
(I01lOIlO01IlO01)?pwdin[119:112]:pwdin[127:120];assign O01IlIlO01O1lIO
=(I1lO0IO0lIIO0lI&~OlI1OOOl1IOI01l&I01lOO01IlIlO01)|
(~I1lO0IO0lIIO0lI&IOIl0O1lIOOOl1I)|
(~I1lO0IO0lIIO0lI&sel_mmc&lIO10OOIl1OIl01);assign OIl01l0IO1I01lO[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[1];assign IlI0OlO10IO1lIO
=~l10IOI01lOO01Il&(OOIl1OIl01OlI01|O01IlO01IlIIO0l&OlI01OOIl1IO0lI);assign IO01ll10IOOI01l
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&((IlO01IOIl0lIO10&OOl1IlIO10OI01l)|(I1lO0IO0lIIO0lI&~IlO01IOIl0lIO10)));dff II01lOOlI1OIO0lI
(IO0lIIO01lOlI01,O1lIOOlI01OI01l,clk,hreset_b,1'b1);assign I01lOIO0lIO1lIO=IO01lIlO01IO01l|l10IOl10IOOlI1O|l0IO1IOIl0OOIl1;assign I1lO0l10IOIO0lI[15]
=l0IO1IlO01lO10I[15]|(~lIO10lO10IlO10I[15]&IO01lIO0lIIIO0l[15]);assign l10IOI01lOIlI0O
=(~l10IOI01lOO01Il&OOl1IIO0lIO01Il&~lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&I01lOIOIl0OI01l&~lO10Il0IO1l0IO1&(~IO0lIlIO10IO01l|O1lIOOOl1IOlI01));assign lO10IO01IlO01Il
=(IO01lI01lOl10IO[2:0]==3'b001)?1'b1:1'b0;assign I01lOOlI1OOOIl1
=(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&IIO0lOlI01lIO10)?OIl01O01IlIOIl0:
(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&lO10II01lOO1lIO&lO10IOI01lIO0lI)?OlI1OOOl1IIOIl0:
(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&OlI01O01IlOlI1O)?IlI0OO1lIOO1lIO:
(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&IOIl0lO10IOOl1I)?IIO0ll0IO1OlI1O:
(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&O1lIOlIO10IO01l)?{IlO01IO0lIOlI01,IO01lIO0lIIIO0l[23:22],IO01lIO0lIIIO0l[19],IO0lIIIO0lOOIl1}:
(IlI0OO1lIOOOl1I&lO10II01lOO1lIO&OOl1Il10IOI1lO0)?{20'h00000,OOl1IlIO10lO10I}:
IO01lOIl01OlI1O;assign IlI0OIlI0Ol0IO1[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[3];assign lO10IOOIl1OIl01
=((OlI1OI1lO0OlI1O>=11'h001)&(OlI1OI1lO0OlI1O<=11'h004))?1'b1:1'b0;dff Il0IO1IOIl0IOIl0
(O01IlOOIl1OlI1O,OI01llO10IOOIl1,clk,hreset_b,1'b1);assign OlI01l0IO1lO10I[15:8]
=(OI01ll0IO1O01Il==2'b11)?IOIl0I1lO0IlI0O[23:16]:
(OI01ll0IO1O01Il==2'b10)?IOIl0I1lO0IlI0O[15:8]:
(OI01ll0IO1O01Il==2'b01)?IOIl0I1lO0IlI0O[7:0]:8'h00;dff32 IlIO10lO10IIlO01
(IlI0OI1lO0O01Il,IOIl0IlI0OOlI01,clk,1'b1,1'b1);assign IO01lIO0lIIIO0l[3]=1'b0;dff IIO0lIIIO0lIO0lI
(IlO01OI01lI01lO,I01lOIlO01I1lO0,clk,hreset_b,1'b1);dff IOI01lI1lO0I01lO
(IOIl0l0IO1IOIl0[0],IIO0lIIO0lIIO0l[0],clk,1'b1,hreset_b);dff8 IIOIl0IlI0OlIO10
(O1lIOOOl1IOI01l,OOIl1OIl01IlI0O,clk,hreset_b,1'b1);assign O1lIOOOl1IOIl01[6]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[5];assign OIl01lO10IO01Il=(l10IOIlO01lIO10==6'h02)?1'b1:1'b0;dff8 IOlI1OOIl01l0IO1
(I1lO0lIO10OOl1I,l10IOO1lIOIlO01,clk,1'b1,hreset_b);assign OOIl1OIl01IOIl0=IlO01OIl01O1lIO&~I1lO0lIO10OOIl1;dff IlO10IOI01lIOIl0
(IO01lIO0lIIIO0l[28],I1lO0l10IOIO0lI[28],clk,hreset_b,1'b1);dff II1lO0lIO10IIO0l
(OlI1Ol10IOIO01l,OOIl1IOIl0I01lO,clk,hreset_b,1'b1);assign OOl1IIO01lOlI1O=(IO01lI01lOl10IO[23:16]==8'hb9)?1'b1:1'b0;dff II1lO0IO0lIIOIl0
(lIO10IOIl0OOl1I,I1lO0IO0lIOlI1O,clk,hreset_b,1'b1);assign IO01lO01IlIlO01[31:28]
={IO0lIOlI01lO10I[11],OI01lI1lO0l10IO[11],lIO10O1lIOIO01l[11],I01lOOIl01OOIl1[11]};assign IO01lIO0lIIlI0O
=((lIO10OI01lIIO0l==1'b0)&(l10IOIlO01lIO10==6'h17))?1'b1:1'b0;dff IIO01lIO0lIOIl01
(OOl1IOlI1OIO0lI,OOIl1OIl01IIO0l,clk,1'b1,1'b1);assign IlI0Ol0IO1IlI0O=OI01lIIO0lOIl01&lIO10O1lIOl0IO1;assign OlI01I1lO0I1lO0[0]
=(OIl01O1lIOOlI01&OOl1IIO0lIOIl01&O1lIOOlI01IlI0O&OlI1OOOl1IIOIl0[31])|(~(lO10IIlO01OI01l|IlO01IO0lIO01Il)&OIl01IIO0lI01lO[0]);dff IIlI0OIO01lIlO01
(lO10IOOIl1OI01l,O01IllO10IIlI0O,clk,1'b1,1'b1);assign OlI01IIO0ll0IO1
=(lO10IIlO01OI01l)?16'h0000:
(IIO0lIlI0OIIO0l&IO01lIO0lIIlI0O)?IO01lI01lOl10IO[15:0]:
O01Ill0IO1l10IO;assign IO0lIlIO10I01lO
=(I1lO0IO0lIIO0lI&~IIO0lI1lO0IIO0l)|
((~I1lO0IO0lIIO0lI|IIO0lI1lO0IIO0l)&IOIl0OlI1OIO01l);assign IO01llIO10OI01l[19:16]
={O01IlO1lIOIlI0O[2],l0IO1O01IlO01Il[2],IO01lI01lOlIO10[2],O1lIOIO0lII1lO0[2]};assign IO0lII1lO0IO0lI
=(l10IOIlO01lIO10==6'h34)?1'b1:1'b0;assign OOIl1l10IOl10IO[3]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[2];assign lO10IIlO01IOIl0
=(lIO10l10IOOOIl1&~rdy_b&OIl01IlO01O1lIO&IlO01OlI1OO1lIO);assign OlI01IIO0llIO10=(lO10IO1lIOl10IO==3'b001)?1'b1:1'b0;assign OlI1OOlI1OO01Il
=(OI01lIlI0Ol0IO1)?15'h0008:
(OOIl1OlI1OOlI01)?15'h0002:
(IlI0OIlI0OOlI01)?{2'b00,l0IO1IlO01OI01l[11:0],1'b0}:
(l10IOlIO10OOIl1)?{3'b000,l0IO1IlO01OI01l[11:0]}:
{l0IO1IlO01OI01l[11:0],3'b000};dffe IIlI0OOOIl1OlI1O
(OI01lIIO0llO10I,O1lIOIO01lOlI01,clk,1'b1,1'b1,IOIl0I1lO0OIl01);assign IlO01OIl01IO0lI=IO01lOlI1OO1lIO&~sel_mmc;assign IIO0lOOl1IlO10I
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&(OOl1IOlI1OIOIl0|lIO10O01IllO10I))?OOIl1l10IOI01lO:
(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&~(OOl1IOlI1OIOIl0|lIO10O01IllO10I))?32'h00000000:
((IO01lIlO01IlO01|I01lOO01IlIO01l)&~O1lIOOlI1OlIO10)?(IOIl0OlI01lIO10+32'h00001):
IOIl0OlI01lIO10;assign IIO0lOlI1Ol10IO
=IlO01OI01lI01lO&IO0lIlIO10IO01l&~OOIl1OlI01OOIl1;assign OOl1Il10IOl10IO=OlI1OIO0lII1lO0&sel_mmc;assign I01lOOI01llO10I[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[4]^IIO0lI1lO0IO0lI[1]^IO01lI01lOlIO10[15];assign lO10IIOIl0OOIl1
=(~lO10IIlO01OI01l&I1lO0lIO10IO0lI&I1lO0OOIl1I01lO)|
(~lO10IIlO01OI01l&lIO10l10IOOlI1O&I1lO0OOIl1I01lO&(rdy_b|(~OIl01IlO01O1lIO&~OlI1OOOl1IOlI01)));assign OOIl1IOIl0IlO01[63:48]
=scr[63:48];assign I01lOOIl01OOl1I=lIO10l10IOOOIl1&~rdy_b&OIl01IlO01O1lIO&~error;assign IlO01IO01lOOl1I
=(OIl01I1lO0IO01l&(OI01lI1lO0lIO10|IlI0OI1lO0OIl01))?12'h03f:
(OIl01I1lO0IO01l&OI01lO1lIOIIO0l)?12'h003:
(OIl01I1lO0IO01l&~IO01lI01lOIO01l&~I01lOl10IOO01Il)?{10'h000,OOIl1l10IOI01lO[1:0]}:
(I01lOIOIl0OI01l&IO0lIlIO10IO01l&IOIl0OOl1IIO01l)?l0IO1OOIl1I1lO0:
(I01lOIOIl0OI01l&IO0lIlIO10IO01l&~IOIl0OOl1IIO01l&~I01lOl10IOO01Il)?{l0IO1OOIl1I1lO0[11:2]+10'h001,l0IO1OOIl1I1lO0[1:0]}:
(I01lOIOIl0OI01l&IO0lIlIO10IO01l&~IOIl0OOl1IIO01l&I01lOl10IOO01Il)?{l0IO1OOIl1I1lO0[11:2]-10'h001,l0IO1OOIl1I1lO0[1:0]}:
OOIl1IlI0OOOIl1;assign IOIl0IO01lOIl01[73:47]
=(OOIl1OOl1IIIO0l)?{10'b0000000000,csd[63:48],1'b0}:csd[73:47];dff IIO01ll10IOl0IO1
(OOIl1OlI1OIOIl0,IlO01lIO10IIO0l,clk,hreset_b,1'b1);assign OlI1Ol10IOIlO01=(IlI0OO1lIOOlI1O&O1lIOOOl1IIOIl0);assign OI01lOlI01IO01l
=OI01lOlI01I1lO0|lIO10IlO01IOIl0|OOIl1IO01lOlI1O|IOIl0O1lIOOOl1I|IO0lIlIO10IlO01;assign lIO10OOIl1OlI01[7]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[6];dff32 II01lOIOIl0l0IO1
(addr[31:0],IO0lIOOl1IOI01l[31:0],clk,1'b1,1'b1);dff IlIO10O1lIOIlO01(IO01lI01lOI1lO0,l10IOIlO01l0IO1,clk,hreset_b,1'b1);assign IO0lIOlI01O01Il
=(O01IlIIO0ll10IO&IO01lOIl01OOIl1)|(~l0IO1l0IO1IlO01&IIO0lIO01lOIl01);assign IlO01OlI1OOlI1O=O1lIOIO01lOlI01;dffe IOOl1IOOl1IIIO0l
(dsr[2],IO01lI01lOl10IO[18],clk,1'b1,hreset_b,IlI0OOOl1II1lO0);assign IOIl0IIO0lOlI1O
=(IlO01lIO10IlI0O[14]!=I1lO0IOIl0IOIl0[14])?1'b1:1'b0;dff II01lOOIl01O1lIO(l10IOIO0lIOOl1I,lIO10l0IO1IlO01,clk,hreset_b,1'b1);assign O1lIOl10IOIlO01
=IOIl0IO01lOIl01[94]&IIO0lIIO0lOOl1I;assign OI01ll0IO1IOIl0[9]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[8];assign l10IOIOIl0O1lIO
=(OI01lIIO0lOIl01&(I01lOO01IlI01lO|I1lO0OOIl1I1lO0|I01lOIO0lIO1lIO))?2'b10:
(OI01lIIO0lOIl01&(IOIl0IIO0lO1lIO|IO0lII1lO0OlI1O|l0IO1IlO01OlI01|OOIl1IO01lOOl1I|OOl1IOI01lIlO01))?2'b01:
O01IlIIO0llIO10;assign OOIl1OIl01IIO0l
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OOIl1OlI01O1lIO&~l0IO1I01lOIOIl0;assign OlI01IIO0llO10I
=(O01IlIIO0ll10IO&OOl1IOlI01OOIl1&~IO01lI01lOl10IO[0])|(~l0IO1l0IO1IlO01&O01Ill0IO1lIO10);assign OOIl1lIO10l10IO
=~lO10IIlO01OI01l&(IlI0OIO01lIO01l|(~IO0lIIO01lOIl01&O1lIOOlI1OI1lO0));dff16 Il0IO1IO0lIOOIl1
(IlO01IO0lIOlI01,I01lOl10IOOI01l,clk,1'b1,1'b1);assign IlO01OlI1OIIO0l
=(IO0lIOOl1IOIl01|OlI1OOIl01O01Il)&
((~IOIl0IO01lOIl01[79]&(~IO01lOIl01O1lIO|~OOl1IOOl1IIO0lI))|I01lOlIO10IO0lI);assign OI01lO1lIOIOIl0
=(OOIl1IO0lIl10IO==8'h08)?1'b1:1'b0;assign lO10II01lOO1lIO=(l10IOl10IOIIO0l==8'h02)?1'b1:1'b0;assign I1lO0OlI1OOOl1I[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[10];assign OlI1OOlI1Ol0IO1
=(OIl01I1lO0IO01l)?10'b0000000000:
(OlI1OOlI01IlI0O&~lO10II01lOOOIl1)?(O1lIOOIl01l10IO+10'b0000000001):
O1lIOOIl01l10IO;assign IIO0lI1lO0IlI0O
=I1lO0IO0lIIO0lI&~IlO01OlI1OIOIl0&
(l0IO1O01IllO10I|lIO10OOIl1OIl01|IIO0lI1lO0IOIl0|OOl1IOOl1IOlI1O|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|
IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO|
(IOIl0IO01lOIl01[31]&(O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I))|
(~sel_mmc&(IOIl0OIl01IlO01|IIO0lOlI1OIO01l))|
(sel_mmc&(OlI1OIO0lII1lO0|I01lOI01lOlIO10))|
lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOIl1IO01lOlI1O|OOl1IOlI01OOIl1|I01lOO01IlIlO01|I1lO0OOIl1IO01l|
(~sel_mmc&(O01IlO01IlO1lIO|OlI01OOIl1OlI1O|IlI0OlO10IOOIl1|IO0lIlIO10IlO01|O1lIOIO0lIIO01l)));dff IOI01ll0IO1lO10I
(OI01lO1lIOIIO0l,IOIl0l0IO1IO0lI,clk,hreset_b,1'b1);assign IO01llIO10IO0lI
=OOIl1IO01lOOl1I|O01IlIIO0llO10I|IOIl0IIO0lO1lIO|IlI0OIlI0OO01Il|lO10II01lOOOl1I;assign lIO10lO10IlO10I[27]
=I01lOIlO01l10IO|OI01lIO01ll10IO;assign OOl1IOIl01IO0lI
=(~l10IOI01lOO01Il&IIO0lIIO0lOOIl1&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I&~OIl01IlO01IOIl0)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&~IO0lIlIO10IO01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I&~OIl01IlO01IOIl0)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&IO0lIlIO10IO01l&(~lIO10IlO01OI01l|lO10Il0IO1l0IO1)&~OIl01IlO01IOIl0)|
(~l10IOI01lOO01Il&lIO10lO10IlIO10&IOIl0I1lO0IlI0O[0]&~OIl01IlO01IOIl0)|
(~l10IOI01lOO01Il&IO0lIIO01lIlI0O&~OIl01IlO01IOIl0&~IO01lIO0lIIIO0l[26])|
(~l10IOI01lOO01Il&OlI1OOOl1IIIO0l&~OIl01IlO01IOIl0&~IO01lIO0lIIIO0l[26]&~l10IOIlO01I1lO0);assign l0IO1IlO01lO10I[25]
=(I01lOIOIl0O01Il&~I1lO0O01IlI1lO0)|OIl01OI01lOOl1I;dff IO01Ill0IO1I1lO0(OOl1Il10IOI1lO0,IlO01IOIl0l10IO,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[12];assign dtbuf_wren
=(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&~O1lIOIlI0OOlI1O&lO10IlO10Il0IO1)|
(OlI1OOlI01IlI0O&~lO10II01lOOOIl1);assign OOIl1IOIl0I1lO0
=(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01)|
(OlI1Ol10IOI01lO&~IOIl0OlI1OIlO01);dff32 IIOIl0IO01lI01lO
(IOIl0I1lO0IlI0O[127:96],IIO0lIlI0OIOIl0[127:96],clk,1'b1,hreset_b);assign OIl01IlO01O1lIO
=(IlI0OO1lIOIIO0l==10'b0000000001)?1'b1:1'b0;assign I1lO0l10IOIO0lI[27]
=l0IO1IlO01lO10I[27]|(~lIO10lO10IlO10I[27]&IO01lIO0lIIIO0l[27]);dff Il10IOI01lOlO10I
(OlI1OlIO10lIO10,OOIl1IO0lIlO10I,clk,hreset_b,1'b1);assign OOl1IOlI01O1lIO[2]
=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&~OIl01OOIl1OlI01);assign l0IO1IOIl0OlI1O
=(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01)|
(OlI1Ol10IOI01lO&(OI01lO01IlOOl1I|OlI01IlO01OOIl1|OIl01OI01lOlI1O));assign IlI0OIlI0Ol0IO1[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[14];dff IIO01lIOIl0l10IO
(IlI0OO1lIOOOl1I,IIO0llIO10IlO01,clk,hreset_b,1'b1);assign l10IOO1lIOIlO01[0]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[0]);assign lO10IOOIl1IlI0O
=IlO01OlI1OO1lIO&~I1lO0IO0lIOOIl1&I1lO0I01lOOIl01;assign IO01lIO0lIIIO0l[20]=1'b0;dff IOI01lIIO0llIO10
(IOIl0OOl1Il0IO1,IO0lIOIl01lIO10,clk,hreset_b,1'b1);assign I1lO0O01IlIlO01[3]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[11]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[11])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[11])?1'b0:
IO01lOOl1IOOl1I[3];assign OOl1IIO0lIlIO10
=IO01lIO0lIIIO0l[22]|IO01lIO0lIIIO0l[7];assign IO0lIIlI0OO1lIO[31:28]
={O1lIOOOl1IOIl01[15],IlI0OIlI0Ol0IO1[15],OIl01l0IO1I01lO[15],I1lO0OlI1OOOl1I[15]};assign OlI01I1lO0l10IO
=((lIO10OI01lIIO0l==1'b0)&(l10IOIlO01lIO10==6'h0d))?1'b1:1'b0;assign IlI0OIO01ll0IO1[3]
=(l10IOI01lOO01Il)?1'b1:
(l10IOlIO10OOIl1&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?l10IOO1lIOIlO01[3]:l10IOO1lIOIlO01[7];assign OlI01O1lIOOI01l
=OI01lIIO0lOIl01&I1lO0OOIl1I1lO0;assign OOl1II01lOI01lO
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&~(IlO01IOIl0lIO10&l0IO1I01lOIOIl0&OOIl1IO01lOlI1O));assign O1lIOOlI1OlIO10=
1'b0;assign OOIl1IO0lII1lO0[7:2]
=6'b000000;assign OlI01OOIl1OOl1I[4]=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[3];assign OOl1IOlI1OOlI01[19:16]
={O01IlO1lIOIlI0O[6],l0IO1O01IlO01Il[6],IO01lI01lOlIO10[6],O1lIOIO0lII1lO0[6]};assign OlI1OIO0lII1lO0
=(l10IOIlO01lIO10==6'h23)?1'b1:1'b0;assign O01IlIlI0OIO01l[6]
=~l10IOI01lOO01Il&(l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO;assign IO0lIIO01lIOIl0
=OlI1OOlI01IlI0O&OIl01IlO01O1lIO&~rdy_b;dff IlO10IOOIl1lO10I(oe_card_detect,I01lOlIO10O1lIO,clk,1'b1,1'b1);assign IlO01OI01lIO01l
=(OI01lOlI01IlO01|IIO0lOIl01I01lO|OlI1OlIO10l10IO)&~OI01lO1lIOIO0lI;assign OOl1IIOIl0IlO01=1'b0;assign l0IO1IO0lIOOl1I
=(sel_mmc&OIl01lO10IO01Il&lO10Il0IO1IlO01);assign IIO0lIO01llIO10
=
{IOIl0I1lO0IlI0O[126],IOIl0I1lO0IlI0O[118],IOIl0I1lO0IlI0O[110],IOIl0I1lO0IlI0O[102],IOIl0I1lO0IlI0O[94],
IOIl0I1lO0IlI0O[86],IOIl0I1lO0IlI0O[78],IOIl0I1lO0IlI0O[70],IOIl0I1lO0IlI0O[62],
IOIl0I1lO0IlI0O[54],IOIl0I1lO0IlI0O[46],IOIl0I1lO0IlI0O[38],IOIl0I1lO0IlI0O[30],
IOIl0I1lO0IlI0O[22],IOIl0I1lO0IlI0O[14],IOIl0I1lO0IlI0O[6]};assign IOIl0O1lIOOOl1I
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h29))?1'b1:1'b0;assign OOIl1l10IOl10IO[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[13];dff IlIO10IOIl0IIO0l
(IOIl0OIl01I01lO,IIO0lOlI1OI1lO0,clk,hreset_b,1'b1);assign OlI1OOOl1IIOIl0[23:15]=ocr_mem[23:15];assign OlI01IIO0lOIl01
=~l10IOI01lOO01Il&((IIO0lOIl01l10IO&lO10IOOIl1OI01l)|(~I1lO0IO0lIOOl1I&O01Ill0IO1lO10I));assign I01lOI01lOO01Il
=(I01lOIO0lIIO0lI&IO0lIOIl01l0IO1)?16'h0001:
(I01lOIO0lIIO0lI&sel_mmc&IIO0lOIl01I1lO0)?O01Ill0IO1l10IO:
(I01lOIO0lIIO0lI&(lIO10O01IllO10I|(~sel_mmc&IIO0lOIl01I1lO0)))?16'h0000:
(IO0lIOIl01I01lO&(OIl01O01IlIO0lI|(IlO01OI01lI01lO&IO0lIlIO10IO01l)))?(IlO01IOIl0OIl01-16'h0001):
IlO01IOIl0OIl01;assign IOIl0IO01lOIl01[95:94]
=2'b01;assign IO01lIOIl0OIl01=(IOIl0IO01ll0IO1)?OI01lIlI0Ol10IO:IO0lIOlI01IlI0O;assign OI01lIlI0OlIO10
=IIO0lIlI0OIIO0l&lO10IOOIl1OlI01;assign OIl01lO10IlO10I
=OOIl1OlI1OOlI01|IlO01lIO10OI01l|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|lO10IOI01lO1lIO|IlI0Ol0IO1IOIl0|
(O1lIOIlI0OO1lIO&IO01lI01lOl10IO[31])|(OOl1IOlI01OOIl1&~IO01lI01lOl10IO[0]);dffe16 IOlI01O01IlIIO0l
(IO01lI01lOlIO10,I01lOOI01llO10I,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign l0IO1OI01lO01Il={3'b000,lO10IIlO01OlI01[8:2]}+10'h001;assign OlI01IlI0OI01lO
=(I1lO0IOIl0OI01l&OOIl1OIl01IIO0l)|
(lO10IIIO0lIlO01&~l10IOI01lOOlI01&~OOIl1lIO10lO10I&~l10IOl10IOOOIl1&~l0IO1IlO01O01Il);assign IO0lIOlI01OIl01
=OlI01OlI01IlO01&IlI0OI1lO0lO10I;dff13 IIlO01l10IOI01lO(OlI1OOlI01OI01l,OOIl1OOl1IIlI0O,clk,hreset_b,1'b1);assign IOIl0IO01lOIl01[0]
=1'b1;assign l10IOIlO01l10IO=(IOIl0IO01ll0IO1)?lIO10OOIl1lIO10:l0IO1O01Ill0IO1;dff IOlI01O1lIOOIl01
(IO0lIIIO0lOOl1I,OlI1Ol10IOIlO01,clk,hreset_b,1'b1);assign IlI0OOOl1Il10IO=IOIl0IO01lOIl01[84]&OI01lOlI01I1lO0;assign OI01ll0IO1IOIl0[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[0];dff IlO10IIlO01OIl01(ads_b,O01IlIO01lIlO01,clk,1'b1,hreset_b);assign OOl1IOIl01IIO0l
=(IO01lI01lOl10IO==32'h00000000)?1'b1:1'b0;assign lO10IO01IlOI01l
=(O01IlIIO0ll10IO&O01IlIlO01OlI1O)|(~l0IO1l0IO1IlO01&lIO10IlO01OlI01);assign l10IOIlO01lO10I
=(OOl1IIOIl0l10IO==3'b11)?1'b1:1'b0;assign IOIl0O1lIOO1lIO=
(OIl01O01IlIO0lI&l0IO1O01IllIO10);assign IOIl0lO10IOOIl1
=(IOIl0IO01lOIl01[25:22]>IOIl0IO01lOIl01[83:80])?O1lIOlIO10IlO01:IIO0lO1lIOOOl1I;assign IIO0lIIO0lOlI1O
=(IOIl0OlI01l0IO1-pwd_len);assign IlO01IOIl0lIO10=IO0lIlIO10I01lO&IIO0lOOl1Il10IO;assign I1lO0OlI1OOOl1I[3]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[2];dff10 IOOIl1IlI0OO1lIO
(OI01lI1lO0lO10I,lIO10lO10II1lO0,clk,1'b1,1'b1);assign l0IO1I01lOIlI0O
=I1lO0IOIl0OI01l&(l0IO1O01IllO10I|OOIl1OlI01O1lIO|OlI01I1lO0l10IO|IOIl0IO01llIO10|OOIl1IO01lOlI1O);dff IOOl1IIlI0OOOl1I
(OIl01OI01lOOIl1,OlI01IlO01OOl1I,clk,hreset_b,1'b1);assign lO10IIOIl0OOl1I
=(~lO10IIlO01OI01l&I1lO0lIO10O1lIO)|
(~lO10IIlO01OI01l&lIO10l10IOOOIl1&(lO10II01lOOOIl1|(~OIl01IlO01O1lIO&~error))&I1lO0OOIl1I01lO);assign lIO10lO10IlO10I[16]
=IlO01OI01lI1lO0|OI01lIO01ll10IO;assign O1lIOI1lO0OOl1I
=(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&IO0lIlIO10IO01l&~I1lO0IO0lIIO0lI&~lO10Il0IO1l0IO1);dffe8 IOIl01l0IO1IlO01
(O1lIOI1lO0OOIl1,IIO0lIIO0lOlI1O,clk,hreset_b,1'b1,OlI1OIlI0OOOl1I);assign OlI1OIO0lII01lO
=~I1lO0IO0lIIO0lI&~sel_mmc&O01IlO1lIOOlI01;assign OIl01l0IO1I01lO[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[4]^IIO0lI1lO0IO0lI[5]^lIO10O1lIOIO01l[15];assign IIO0lIlI0OO01Il
=(O01IlO01IlIOIl0==I01lOl10IOOIl01)?1'b1:1'b0;assign O1lIOIO01lIO0lI
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&(OIl01O1lIOlO10I|I1lO0I01lOO01Il|O1lIOOlI01OlI01));assign lIO10O1lIOI1lO0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&O1lIOIlI0OO1lIO)?IO01lI01lOl10IO[31:9]:
l0IO1lO10II01lO;assign l0IO1IOIl0OOIl1
=OI01lOlI01IlO01&l10IOO01IlI1lO0&OlI01O1lIOOlI01;assign I1lO0l10IOIO0lI[18]
=l0IO1IlO01lO10I[18]|(~lIO10lO10IlO10I[18]&IO01lIO0lIIIO0l[18]);assign IlI0OO1lIOOOIl1
=(~l10IOI01lOO01Il&OIl01O01IlIO0lI&~lO10Il0IO1l0IO1&lIO10IlO01OI01l&~(I1lO0IO0lIIO0lI&IO01lIO0lIIIO0l[31]));assign OI01lO1lIOIlI0O
=(IO01lI01lOl10IO[2:0]==3'b100)?1'b1:1'b0;assign OIl01O01IlIOIl0=
IO01lIO0lIIIO0l;assign IlI0OIlI0Ol0IO1[7]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[6];assign l0IO1O01Ill10IO=1'b0;dff IOlI01IlO01O1lIO
(OI01lIIO0lIlI0O,IOIl0I1lO0IOIl0,clk,hreset_b,1'b1);assign IlO01IO0lIOIl01=IOIl0I1lO0IlI0O[31:0];dff IlO10IO1lIOIO01l
(O01IlIlI0OIlO01,OI01lIO01lIO01l,clk,hreset_b,1'b1);dff IOIl01IIO0lIlO01
(IO01lIO0lIIIO0l[7],I1lO0l10IOIO0lI[7],clk,hreset_b,1'b1);dff IIlO01IO01lOOIl1
(O01Ill0IO1OIl01,OlI01IIO0lO01Il,clk,hreset_b,1'b1);dff IIO0lIOlI01l0IO1
(IOIl0l0IO1IOIl0[3],IIO0lIIO0lIIO0l[3],clk,hreset_b,1'b1);dff IO1lIOOlI01OIl01
(IOIl0OlI01lO10I,OlI01IlI0Ol0IO1,clk,hreset_b,1'b1);assign O1lIOOOl1IOIl01[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[8];assign IlI0OIIO0lIlI0O=(l10IOIlO01lIO10==6'h05)?1'b1:1'b0;assign IlO01OOl1IOlI1O
=(I01lOIOIl0OI01l&IO0lIlIO10IO01l)?IO0lIIlI0OO1lIO[31:24]:
(I01lOOOIl1IO01l==4'b0001)?IO0lIIlI0OO1lIO[23:16]:
(I01lOOOIl1IO01l==4'b0010)?IO0lIIlI0OO1lIO[15:8]:
(I01lOOOIl1IO01l==4'b0011)?IO0lIIlI0OO1lIO[7:0]:
(I01lOOOIl1IO01l==4'b0100)?IO01lO01IlIlO01[31:24]:
(I01lOOOIl1IO01l==4'b0101)?IO01lO01IlIlO01[23:16]:
(I01lOOOIl1IO01l==4'b0110)?IO01lO01IlIlO01[15:8]:
(I01lOOOIl1IO01l==4'b0111)?IO01lO01IlIlO01[7:0]:
(I01lOOOIl1IO01l==4'b1000)?OOl1IOlI1OOlI01[31:24]:
(I01lOOOIl1IO01l==4'b1001)?OOl1IOlI1OOlI01[23:16]:
(I01lOOOIl1IO01l==4'b1010)?OOl1IOlI1OOlI01[15:8]:
(I01lOOOIl1IO01l==4'b1011)?OOl1IOlI1OOlI01[7:0]:
(I01lOOOIl1IO01l==4'b1100)?IO01llIO10OI01l[31:24]:
(I01lOOOIl1IO01l==4'b1101)?IO01llIO10OI01l[23:16]:
(I01lOOOIl1IO01l==4'b1110)?IO01llIO10OI01l[15:8]:IO01llIO10OI01l[7:0];assign OOl1IOI01lIlO01
=I01lOIOIl0OlI01&OOl1IOlI01OOIl1&~IO01lI01lOl10IO[0];dff IOI01lOOIl1O1lIO
(IO01lIO0lIIIO0l[31],I1lO0l10IOIO0lI[31],clk,hreset_b,1'b1);dff IlO10IIOIl0OlI1O
(l0IO1OOIl1lO10I,lO10IlO10IOIl01,clk,hreset_b,1'b1);assign O1lIOI1lO0IO0lI[7:1]=7'b0000000;assign oe_cmd
=(IO0lIl0IO1OlI1O[1])?lIO10IOIl0OOl1I:l0IO1l10IOOOIl1;assign IO01lO01IlIlO01[19:16]
={O01IlO1lIOIlI0O[10],l0IO1O01IlO01Il[10],IO01lI01lOlIO10[10],O1lIOIO0lII1lO0[10]};assign lIO10I01lOIO0lI
=(l10IOIlO01lIO10==6'h1a)?1'b1:1'b0;dff Il10IOIOIl0OlI01(OIl01l0IO1lO10I,O01IlIIO0lOIl01,clk,hreset_b,1'b1);dff II01lOlIO10OI01l
(OOl1Il10IOlIO10,IlO01IOIl0lO10I,clk,hreset_b,1'b1);dff22 IIlO01IOIl0I01lO
(OI01lIIO0lO01Il[31:10],IOIl0I1lO0OlI01[31:10],clk,hreset_b,1'b1);assign l10IOIOIl0IO0lI
=OOIl1IO01lO1lIO|(~OOl1IOIl01O1lIO&I1lO0l10IOIIO0l);dffe16 IOlI01IlO01IO0lI
(IlI0Ol0IO1OI01l,IOIl0I1lO0IlI0O[15:0],clk,1'b1,1'b1,OOIl1IO01lIO0lI);dff IIlI0OO01IlOOl1I
(sresetm_b,l0IO1OI01lOI01l,clk,1'b1,hreset_b);assign IO01llIO10OI01l[7:4]
={IO0lIOlI01lO10I[0],OI01lI1lO0l10IO[0],lIO10O1lIOIO01l[0],I01lOOIl01OOIl1[0]};assign OOl1IOlI01OOIl1
=(l10IOIlO01lIO10==6'h38)?1'b1:1'b0;assign OOIl1l10IOl10IO[6]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[5];assign OOl1Il10IOl0IO1
=(~rdy_b);dff IIOIl0IIO0lOI01l(IO0lIOIl01l10IO,OlI01IO01lIlO01,clk,hreset_b,1'b1);assign O01IlO01IlOlI1O
=(l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)?OOIl1OlI1OOIl01:
(IlI0OIlI0OOlI01)?IlI0OlO10IOOl1I:
OlI01OOIl1OOIl1;dffe16 IIIO0llO10IOOIl1
(IlO01OlI1OIlI0O,I01lOlIO10IOIl0,clk,hreset_b,1'b1,l0IO1l10IOIO0lI);dff IO01IlO1lIOlO10I
(IOIl0IO01lOIl01[12],IIO0lOlI01O01Il,clk,1'b1,1'b1);assign lIO10O01IllO10I=lO10Il0IO1I01lO|IlO01lIO10OI01l;assign l10IOlO10IIO01l
=(~lO10IIlO01OI01l&OOl1IOOl1IOOIl1&~IIO0lOlI01OIl01&OIl01IIO0ll10IO)|
(~lO10IIlO01OI01l&I01lOOOIl1IlO01&~IIO0lOlI01OIl01&~OI01lIlI0OlIO10);assign lO10IO1lIOlIO10
=(l0IO1O01IllO10I&(OI01lIIO0lOI01l[3]|~IIO0lOIl01l10IO))|OI01ll0IO1OI01l|IOIl0IO01llIO10|
(~l0IO1I01lOIOIl0&(OOIl1OlI01O1lIO|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OlI01I1lO0l10IO|O01IllO10IOI01l|OOIl1IO01lOlI1O));assign I01lOOI01llO10I[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[7];dff IOI01lIlO01OlI1O
(I1lO0lIO10IO0lI,l10IOIO0lIO1lIO,clk,hreset_b,1'b1);assign OOl1IlIO10OIl01
=(IlI0OlO10IOlI1O&l10IOI01lOOlI01)|
(IlI0OIO01lI1lO0&l10IOI01lOOlI01)|
(O1lIOIO0lIIlO01&l10IOI01lOOlI01)|
(IO01lI01lOI1lO0&l10IOI01lOOlI01)|
(I1lO0lIO10OlI1O&l10IOI01lOOlI01)|
(OIl01IlO01IIO0l&l10IOI01lOOlI01)|
(I1lO0IOIl0OI01l&l10IOI01lOOlI01)|
(lO10IIIO0lIlO01&l10IOI01lOOlI01)|
(l10IOIOIl0IlI0O&l10IOI01lOOlI01)|
(O1lIOOIl01lIO10&~IlO01OlI1OIO0lI&~IO01ll10IOO01Il);dff II1lO0IOIl0OIl01
(OI01lO1lIOIO0lI,IOIl0l0IO1O1lIO,clk,hreset_b,1'b1);assign IOIl0OOl1IIO01l=(l0IO1OOIl1I1lO0[1:0]==2'b00)?1'b1:1'b0;assign IOIl0IO01lOIl01[28:21]
=(OOIl1OOl1IIIO0l)?{3'b010,4'h9,1'b0}:csd[28:21];assign IO01lIO0lIIO0lI
=((O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&
((OOl1IOlI1OIOIl0&OlI1OOIl01IlI0O)|(lIO10O01IllO10I&lIO10I01lOOOIl1)))|
(OlI01lO10IIO0lI&~OIl01OOIl1IIO0l&l10IOIOIl0OlI1O&OOIl1OlI1OIOIl0)|
(OIl01OOIl1IIO0l&OI01lOlI01IlO01&OOIl1OlI1OIOIl0)|
((I01lOIOIl0OI01l|l0IO1OI01lIOIl0)&I1lO0l10IOO1lIO&OOIl1OlI1OIOIl0));assign l0IO1OOIl1lIO10
=(OOIl1IOIl0IO01l&O1lIOOOl1IIOIl0&I1lO0O01IlI1lO0)|
(IO01lOI01lI1lO0&O1lIOIO0lII01lO&~O1lIOOIl01lO10I&lO10IIIO0lIO01l[0])|
(l10IOO01Ill0IO1&~O1lIOIO0lII01lO);assign IIO0lOIl01l0IO1
=IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il;assign lIO10OOIl1OlI01[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[9];assign I01lOIO0lIIOIl0
=OOl1IOlI01OlI1O|(~OIl01I1lO0I01lO&IO01llIO10IlI0O);dff IOI01lI1lO0I1lO0(I1lO0IOIl0OI01l,lIO10OI01lIOIl0,clk,hreset_b,1'b1);assign l10IOl10IOIO0lI
=(O01IlIIO0ll10IO&IO0lIOOl1IOIl01)|(~l0IO1l0IO1IlO01&I01lOIO0lIIIO0l);assign OlI1OOIl01OI01l
=(IOIl0I1lO0IlI0O!=IOIl0IO01lOIl01[127:64])?1'b1:1'b0;assign dsr[7:4]=4'b0000;assign OOIl1I01lOIlO01
=(IlO01lIO10IlI0O[3]!=I1lO0IOIl0IOIl0[3])?1'b1:1'b0;assign I1lO0O01IlI1lO0=(pwd_len==8'h00)?1'b1:1'b0;assign I01lOIO0lIOlI1O
=OIl01lO10IO01Il|
(OOl1IIO0lIOIl01&(OOl1IOIl01IIO0l|O1lIOOlI01IlI0O))|(OOl1IOOl1IOlI1O&OlI1OOlI1OlIO10);assign OI01ll0IO1IOIl0[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[11]^IIO0lI1lO0IO0lI[3]^O01IlO1lIOIlI0O[15];assign dwr
=(IOIl0OOl1II1lO0|O1lIOIO01lIOIl0)?dtbuf_rdata:
I1lO0O01IlIO01l;assign OlI1OIO01lIIO0l
=OlI1OOlI1OlO10I|IOIl0O1lIOOOIl1|IOIl0OlI01l10IO|OOIl1l10IOIO01l|
I01lOOI01ll10IO|l10IOIO0lIOOIl1|O01IlO01IlIO0lI|l0IO1I01lOIlI0O|O01IlI1lO0IO01l|
lO10IOI01lIIO0l;assign OOl1IOIl01IOIl0
=(O01IlIIO0ll10IO&O1lIOIO0lIIO01l)|(~l0IO1l0IO1IlO01&OlI1OOOl1IIlI0O);assign lO10IOI01lOOIl1
=IO0lIOIl01I01lO&
((lIO10l10IOOOIl1&~lO10II01lOOOIl1&OIl01IlO01O1lIO&((OI01lOlI01IlO01&~l10IOO01IlI1lO0)|
IIO0lOIl01I01lO|OlI1OlIO10l10IO|IlO01l10IOlIO10|O01Ill0IO1lIO10))&~OOl1Il10IOlIO10)|
(IIO0lIlI0OIlI0O&~OI01lIIO0lOlI01)|l10IOIO0lIOOl1I;assign I01lOIlO01l10IO
=(IlO01I01lOl10IO&IOIl0OlI1OIlO01&(IIO0lOlI01lIO10|IOIl0lO10IOOl1I));assign l0IO1IlO01lO10I[29]
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&
((I01lOOI01ll0IO1&IIO0lOlI01lO10I)|OOl1IIOIl0IO01l|IlO01OlI1OIIO0l);assign O1lIOI1lO0O1lIO
=(OOIl1IO0lIl10IO==8'h0b)?1'b1:1'b0;assign IlO01IO0lIIlI0O=(I01lOl10IOIOIl0==7'b0000001)?1'b1:1'b0;assign I1lO0OlI1OOOl1I[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[13];assign O01IlO01IlIOIl0=OlI1OOlI01OI01l[12:2];assign l10IOO01Ill10IO
=I1lO0IO0lIIO0lI&~IlO01OlI1OIOIl0&(IO0lII1lO0IO0lI|O1lIOIlI0OO1lIO);dff IIO0lIIlI0OOlI01
(IlO01OI01lIlO01,I01lOIlO01IO01l,clk,hreset_b,1'b1);assign IlI0OIO01lI01lO=(O01IlI1lO0IlO01==16'h0000)?1'b1:1'b0;assign lIO10lO10IlO10I[30]
=IlO01OI01lI1lO0;assign O01IlIlI0OI01lO=(~l10IOI01lOO01Il&IIO0lOIl01l10IO&IlI0Ol0IO1IIO0l);assign l0IO1IOIl0IIO0l
=(IO01lI01lOl10IO[25:24]==2'b00)?1'b1:1'b0;assign OlI1OOIl01OIl01
=O01IlO1lIOOlI01|IIO0lI1lO0IOIl0|OOIl1OlI01O1lIO|IO01lOIl01OOIl1|lO10Il0IO1I01lO|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|
OI01lIlI0Ol0IO1|IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|OOIl1OlI1OOlI01|IlO01lIO10OI01l|IO01lIO0lIIlI0O|
I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|lO10IOI01lO1lIO|O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|
OOl1Il10IOl10IO|I1lO0OI01llO10I|lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOIl1IO01lOlI1O|OOl1IOlI01OOIl1;dffe16 IO1lIOl0IO1OOIl1
(lIO10O1lIOIO01l,OIl01l0IO1I01lO,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign IlO01IOIl0I1lO0=(IO0lIIIO0lO1lIO>=10'h200)?1'b1:1'b0;assign lO10IlO10IO01Il
=(I1lO0IlO01lIO10&~IIO0lOlI01lIO10&IOIl0OlI1OIlO01)|
(l0IO1OOIl1OIl01&~IOIl0OlI1OIlO01);assign OlI1OOlI01IO0lI
=(l10IOI01lOO01Il|IlO01l10IOOIl01)?7'b0000000:
((OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)&~(l10IOlIO10OOIl1|OIl01OI01lOOIl1)&~IlI0OIlI0OOlI01)?
{O1lIOIO01lIIO0l[5:0],IO01lOlI1OOOIl1}:
O1lIOIO01lIIO0l;dff12 II1lO0OIl01OOIl1
(IO01ll10IOlIO10,I01lOIOIl0lO10I,clk,hreset_b,1'b1);assign I1lO0l10IOIO0lI[30]
=l0IO1IlO01lO10I[30]|(~lIO10lO10IlO10I[30]&IO01lIO0lIIIO0l[30]);dff IOIl01O01IlOlI01
(lIO10IlO01IlI0O,lO10IO01IlIOIl0,clk,hreset_b,1'b1);assign IIO0lIIO0lIIO0l[0]
=IOIl0IlI0OlO10I[0]|(~OOl1IOlI01O1lIO[0]&IOIl0l0IO1IOIl0[0]);assign OIl01OI01lOlI1O=(l10IOl10IOIIO0l==8'h21)?1'b1:1'b0;assign O1lIOOOl1IOIl01[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[0];dff IlIO10IlO01lO10I
(I1lO0IlO01lIO10,l10IOO01IllO10I,clk,hreset_b,1'b1);assign l10IOO1lIOIlO01[3]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[3]);assign IlI0Ol0IO1IO0lI
=IO01lOlI1OOOl1I&(IOIl0OIl01IlO01|OOl1Il10IOl10IO);dff IIlO01lIO10OIl01
(IO01lIO0lIIIO0l[23],I1lO0l10IOIO0lI[23],clk,hreset_b,1'b1);dff IO1lIOIO01lO01Il
(I01lOIOIl0OI01l,l10IOI01lOIlI0O,clk,hreset_b,1'b1);dffe IIO01llIO10O01Il
(IO01lOOl1IOOl1I[2],I1lO0O01IlIlO01[2],clk,hreset_b,1'b1,lIO10lO10II01lO);assign I01lOIOIl0OIl01
=IO01lIO0lIIIO0l[31]|IO01lIO0lIIIO0l[16];assign IO0lIIlI0OO1lIO[19:16]
={O01IlO1lIOIlI0O[14],l0IO1O01IlO01Il[14],IO01lI01lOlIO10[14],O1lIOIO0lII1lO0[14]};assign IIO0lOlI01lO10I
=(l10IOIlO01lIO10==6'h10)?1'b1:1'b0;assign IlI0OIO01ll0IO1[0]
=(l10IOI01lOO01Il)?1'b1:
(l10IOO01IllO10I|lO10IlO10IO01Il)?OlI1OlIO10I1lO0[31]:
(l10IOlIO10OOIl1&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?l10IOO1lIOIlO01[0]:
(IlI0OIlI0OOlI01&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?l10IOO1lIOIlO01[4]:l10IOO1lIOIlO01[7];dff IOOl1IOIl01O01Il
(O1lIOlIO10l10IO,OlI1OIO0lIl0IO1,clk,hreset_b,1'b1);assign l0IO1IlO01lO10I[5]
=I1lO0OI01llIO10|(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OlI01OlI01IO01l);assign O1lIOlIO10I1lO0=
1'b0;assign IO0lIOlI1OIO01l
=(IO01lI01lOl10IO[15:8]>=8'h0b)?1'b1:1'b0;assign l0IO1O01IlOIl01
=(O1lIOOlI1OOIl01&IOIl0IIO0lIO0lI)|I01lOIOIl0IlI0O|l0IO1OI01lIIO0l|
((IlI0OO1lIOOOl1I|OlI1Ol10IOI01lO)&~IO01lIO0lIOI01l);assign OOl1IOlI1OOlI01[7:4]
={IO0lIOlI01lO10I[4],OI01lI1lO0l10IO[4],lIO10O1lIOIO01l[4],I01lOOIl01OOIl1[4]};assign lO10IOOIl1OlI01
=(l10IOIlO01lIO10==6'h26)?1'b1:1'b0;assign lIO10OOIl1O01Il=OOl1IIO0lIO01Il|I01lOIOIl0OI01l|I1lO0I01lOOlI01|OIl01OOIl1IIO0l;assign IO0lIl0IO1OOIl1
=OlI1OOIl01OlI01|IOIl0IO01llO10I|I01lOI01lOl0IO1;dff IOlI01O1lIOO01Il(IO0lIIO01lO01Il,OI01lIIO0lOI01l[3],clk,1'b1,hreset_b);assign IIO0lIO01lOI01l
=IlO01I01lOIO01l|IIO0lIlI0OOI01l|O01IlIlO01IO0lI;assign OOIl1IO0lIlIO10
=OlI1OIO01lIO0lI|IO01lOIl01OOIl1|lO10Il0IO1I01lO|OI01lIlI0Ol0IO1|
IO0lIOOl1IOIl01|OlI1OOIl01O01Il|OI01lOOIl1OOl1I|(OOl1IOlI01OOIl1&IO01lI01lOl10IO[0])|
O01IlO01IlO1lIO|OlI01OOIl1OlI1O|O1lIOIO0lIIO01l|
(I1lO0IO0lIIO0lI&(l10IOlO10IIlO01|l0IO1O1lIOIO01l));assign I1lO0l10IOOI01l
=l0IO1IlO01lIO10|(~OIl01IIO0lIO01l&IO01lIO0lIOlI01);assign OOl1IOOl1IOOl1I
=(OI01lO1lIOO1lIO&OlI1OIO01lOlI1O)|(~OlI1OlIO10lIO10&OOIl1OlI01OOIl1);assign OlI1OIO01lIO0lI=IIO0lI1lO0IOIl0&~sel_mmc;assign I01lOOI01llO10I[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[1]^IO01lI01lOlIO10[15];assign OI01lOOl1IIlO01
=(OlI1OOlI01IlI0O&~rdy_b&O01IllO10IOI01l);assign OlI1OOOl1IIOIl0[6:0]=7'b0000000;dff IIlO01IO0lIlIO10
(lIO10O01IlOIl01,l0IO1IlO01lO10I[26],clk,hreset_b,1'b1);assign IIO0lOIl01I1lO0=OlI1OOIl01O01Il|l10IOIOIl0IIO0l;assign IOIl0IO01lOIl01[83:80]
=(OOIl1OOl1IIIO0l)?4'h9:csd[83:80];assign OI01lIlI0Ol10IO
=
(sel_mmc)?ecsd_b:
{(IOIl0IO01lOIl01[69:48]+22'h000001),10'b0000000000};assign IIO0lOlI01OIl01
=IO01lIO0lIIIO0l[31]|IO01lIO0lIIIO0l[28]|IO01lIO0lIIIO0l[13];dffe32 IOIl01OOIl1O01Il
(OOIl1l10IOI01lO,OOl1IIOIl0I1lO0,clk,hreset_b,1'b1,OIl01lO10IOlI01);assign lIO10OOIl1OlI01[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[1];dff IOOIl1lIO10I01lO(abort_b,IO01lO01IlIO01l,clk,1'b1,hreset_b);assign OI01lOOIl1OlI1O
=(O1lIOIO0lIIlO01&IO01lIO0lIIOIl0&OlI01O1lIOIlI0O)|
(OlI01O01IlO1lIO&IlI0OOOl1IIlO01[0]);dff IOIl01IlO01OI01l
(IO0lIIIO0lOlI1O,OlI1OI1lO0OOIl1,clk,hreset_b,1'b1);dff13 II1lO0I01lOl10IO(IO01lOI01lIlO01,I1lO0IlO01IO01l,clk,hreset_b,1'b1);assign IlI0OOOl1II1lO0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OI01ll0IO1OI01l&IOIl0IO01lOIl01[76]);assign lIO10O01IlIlI0O
=(IlO01lIO10IlI0O[9]!=I1lO0IOIl0IOIl0[9])?1'b1:1'b0;dff IIO0lII1lO0OI01l(l10IOO01Ill0IO1,l0IO1OOIl1lIO10,clk,hreset_b,1'b1);assign IO01lIOIl0OlI01
=IOIl0IO01lOIl01[89]&IlO01l10IOO01Il;assign OI01ll0IO1IOIl0[4]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[3];dff4 IOIl01O01IlO01Il
(lIO10O1lIOl10IO,OlI1OIO0lIlIO10,clk,1'b1,1'b1);assign IO01lIO0lIIOIl0
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l;assign O1lIOI1lO0OlI1O
=(O01IlIIO0ll10IO&lO10IOOIl1OlI01)|(~l0IO1l0IO1IlO01&IIO0lIIO0lO1lIO);dff5 IlO10IO01IllO10I
(IO01lOI01lIO01l,I1lO0IlO01I01lO,clk,hreset_b,1'b1);assign IO0lIl0IO1OlI1O[0]=1'b0;assign I01lOOI01ll0IO1
=((IO01lI01lOl10IO>IO0lIOlI1Ol10IO)&
((IO01lI01lOl10IO!=32'h00000200)|(IO0lIOlI1Ol10IO>32'h00000200)))?1'b1:1'b0;assign l10IOOI01lOIl01
=(OOIl1IO0lIl10IO==8'h03)?1'b1:1'b0;assign l0IO1IlO01lO10I[22]=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&~IIO0lOOl1Il10IO;assign I1lO0OlI1OOOl1I[6]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[5];assign OOl1IOlI1OOI01l=(OI01lIIO0lOIl01&OI01lOlI01I01lO);assign lO10IlO10IlIO10
=1'b0;dff Il10IOIlO01I01lO(OlI1OlIO10l10IO,OOIl1IO0lIl0IO1,clk,hreset_b,1'b1);dff IO1lIOI1lO0IOIl0
(OlI1OOlI01IlI0O,OOIl1OOl1IIOIl0,clk,hreset_b,1'b1);assign lIO10lO10IlO10I[21]=IlO01OI01lI1lO0;assign l10IOOOIl1l0IO1
=(lIO10IlO01IlI0O&IOIl0I1lO0IlI0O[0])|
(I1lO0O01Ill10IO&~IO0lIlIO10IO01l);assign O1lIOlIO10l0IO1
=((lO10IIIO0lIO01l[3]&~IO01lIO0lIIIO0l[25])|
((lO10IIIO0lIO01l[1]|(lO10IIIO0lIO01l[2]&~lO10IIIO0lIO01l[0]))&I1lO0O01IlI1lO0)|
(~lO10IIIO0lIO01l[3]&~lO10IIIO0lIO01l[2]&~lO10IIIO0lIO01l[1]&~lO10IIIO0lIO01l[0]&~IO01lIO0lIIIO0l[25])|
(lO10IIIO0lIO01l[2]&~lO10IIIO0lIO01l[0]&IO01lIO0lIIIO0l[25])|
~((~lO10IIIO0lIO01l[3]&~lO10IIIO0lIO01l[1])|
(~lO10IIIO0lIO01l[2]&~lO10IIIO0lIO01l[1]&~lO10IIIO0lIO01l[0])|
(~lO10IIIO0lIO01l[3]&~lO10IIIO0lIO01l[2]&~lO10IIIO0lIO01l[0]))|
(lO10IIIO0lIO01l[3]&IOIl0IO01lOIl01[13]));dff IIO01lOOl1IOOIl1
(IO01lIO0lIOI01l,I1lO0l10IOIlI0O,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[7];assign l0IO1I01lOOlI01=I01lOl10IOOIl01-O01IlO01IlIOIl0;assign lO10IIIO0lI1lO0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&lO10IOI01lOlI1O);dff8 IlO10Il10IOOOIl1
(OI01lIIO0lOI01l,dtin,clk,1'b1,hreset_b);assign OIl01O01IlOI01l=IlO01OlI1OIlI0O[11:0]+{10'b0000000000,l0IO1lO10II1lO0[1:0]};assign I1lO0l10IOIO0lI[22]
=l0IO1IlO01lO10I[22]|(~lIO10lO10IlO10I[22]&IO01lIO0lIIIO0l[22]);assign IO01lOI01ll10IO
=(~l10IOI01lOO01Il&OlI1Ol10IOIO01l&~lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&IlO01I01lOI1lO0&~lO10Il0IO1l0IO1&~OI01lIIO0lOI01l[2]&~I01lOOI01lI01lO);assign IOIl0IlI0OlO10I[2]
=lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&OIl01OOIl1OlI01&ecsd_a[2];assign IO0lIIIO0lOOIl1
=(OIl01IIO0lI01lO[0])?IO01lIO0lIIIO0l[12:0]:13'h0000;assign IlI0OIlI0Ol0IO1[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[9];dff IIIO0llO10IOOl1I
(IO01lOlI1OOOl1I,I1lO0lO10IIlO01,clk,hreset_b,1'b1);assign OlI01IlI0Ol10IO
=OOl1IOIl01IO0lI|I01lOlIO10OlI1O|OOIl1OIl01OlI01|OlI01OOIl1IO0lI|
(OI01lO1lIOO1lIO&IO0lIlIO10IO01l&I1lO0IO0lIIO0lI)|
IO01ll10IOOlI01;assign IlO01I01lOIlO01
=(OOIl1OlI1OOI01l==IO01lIOIl0OIl01)?1'b1:1'b0;dff IOI01lIlI0OI01lO(IO01lIO0lIIIO0l[15],I1lO0l10IOIO0lI[15],clk,hreset_b,1'b1);dff Il10IOO01IlIO01l
(OlI1OOOl1IIIO0l,OOl1IOIl01IO0lI,clk,hreset_b,1'b1);assign lIO10lO10II01lO=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l10IOOOIl1IO01l);assign OIl01I01lOOOIl1
=(I1lO0IlO01lIO10&lO10II01lOO1lIO&IO01lIO0lIOI01l)?{O1lIOOlI1Ol10IO,24'h000000}:
(I1lO0IlO01lIO10&lO10II01lOO1lIO&lO10IOI01lIO0lI)?OlI1OOOl1IIOIl0:
(I1lO0IlO01lIO10&lO10II01lOO1lIO&IOIl0lO10IOOl1I)?{O1lIOOOl1IOI01l,24'h000000}:
(I1lO0IlO01lIO10&lO10II01lOO1lIO&OOl1Il10IOI1lO0)?{20'h00000,OOl1IlIO10lO10I}:
lIO10IOIl0OlI1O;assign O1lIOOOl1IOIl01[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[11]^IIO0lI1lO0IO0lI[7]^IO0lIOlI01lO10I[15];assign OOl1IOOl1IOlI1O
=(l10IOIlO01lIO10==6'h08)?1'b1:1'b0;assign OOl1IOIl01IlI0O={4'b0000,IO01lIO0lIIIO0l[31],IO01lIO0lIIIO0l[21:19]};assign lIO10O1lIOl0IO1
=I01lOlIO10OlI1O&~IlO01OlI1OO1lIO&~O01Ill0IO1lO10I;assign IlO01lIO10IOIl0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01)?OOl1IOOl1IO1lIO:
IO01lIO0lIIIO0l[12:9];assign OIl01IIO0llIO10
=
(IO0lIOIl01I01lO)?l0IO1O1lIOl10IO:
1'b0;assign IO01lIOIl0l0IO1=(IO01lI01lOl10IO[23:16]==8'hb7)?1'b1:1'b0;assign l10IOOOIl1lIO10
=O1lIOOlI1OOIl01|(IlI0OO1lIOOOl1I&~IO0lIIO0lIIO01l);assign IO01lO01IlIlO01[7:4]
={IO0lIOlI01lO10I[8],OI01lI1lO0l10IO[8],lIO10O1lIOIO01l[8],I01lOOIl01OOIl1[8]};assign OlI01O01IlOOIl1
=(l10IOIlO01lIO10==6'h1d)?1'b1:1'b0;assign O01IlIlI0OIO01l[1]
=~l10IOI01lOO01Il&(((IlI0OIlI0OOlI01|l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO)|OIl01I1lO0IlO01);assign O1lIOIlI0OIO0lI
=lIO10l10IOOOIl1&~rdy_b&OI01lI1lO0lIO10;assign OOIl1l10IOIlO01
=(l10IOI01lOO01Il)?23'h000000:
(IIO0lIlI0OIIO0l&IlI0OlO10IOOIl1)?IO01lI01lOl10IO[22:0]:
O1lIOIIO0lOOl1I;assign OlI01O1lIOIOIl0
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&
((IO01lOIl01OOIl1|OlI01OOIl1OlI1O|O1lIOIO0lIIO01l)|
(I1lO0IO0lIIO0lI&(l10IOlO10IIlO01|l0IO1O1lIOIO01l))))|
(IlO01I01lOl10IO&IOIl0OlI1OIlO01&OI01lIlI0Ol0IO1);assign IOIl0IIO0lIlI0O
=(l0IO1OOIl1I1lO0[11:0]==12'h000)?IO0lII1lO0IOIl0:
(l0IO1OOIl1I1lO0[11:0]==12'h001)?O1lIOIlI0OIIO0l:
8'b00000000;assign IlI0OOOl1II01lO
=((IO01lI01lOl10IO[11:8]==4'b0010)&(OlI1OOOl1IIOIl0[7]==1'b1))?1'b1:1'b0;assign l10IOIlO01OIl01
=
(l10IOlIO10OOIl1)?
{IOIl0I1lO0IlI0O[121],IOIl0I1lO0IlI0O[113],IOIl0I1lO0IlI0O[105],IOIl0I1lO0IlI0O[97],IOIl0I1lO0IlI0O[89],
IOIl0I1lO0IlI0O[81],IOIl0I1lO0IlI0O[73],IOIl0I1lO0IlI0O[65],IOIl0I1lO0IlI0O[57],
IOIl0I1lO0IlI0O[49],IOIl0I1lO0IlI0O[41],IOIl0I1lO0IlI0O[33],IOIl0I1lO0IlI0O[25],
IOIl0I1lO0IlI0O[17],IOIl0I1lO0IlI0O[9],IOIl0I1lO0IlI0O[1]}:
{IOIl0I1lO0IlI0O[61],IOIl0I1lO0IlI0O[57],IOIl0I1lO0IlI0O[53],IOIl0I1lO0IlI0O[49],IOIl0I1lO0IlI0O[45],
IOIl0I1lO0IlI0O[41],IOIl0I1lO0IlI0O[37],IOIl0I1lO0IlI0O[33],IOIl0I1lO0IlI0O[29],
IOIl0I1lO0IlI0O[25],IOIl0I1lO0IlI0O[21],IOIl0I1lO0IlI0O[17],IOIl0I1lO0IlI0O[13],
IOIl0I1lO0IlI0O[9],IOIl0I1lO0IlI0O[5],IOIl0I1lO0IlI0O[1]};assign I1lO0OOIl1IO01l
=(l10IOIlO01lIO10==6'h3b)?1'b1:1'b0;assign OOIl1l10IOl10IO[9]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[8];assign IO0lII1lO0OlI1O
=lIO10l0IO1I01lO&O01IllO10IOI01l&IO01lI01lOl10IO[15];dff IOOIl1IO01lIIO0l(OOl1IIO0lIlO10I,OOIl1lIO10lIO10,clk,hreset_b,1'b1);assign OOIl1OlI1OOIl01
=OIl01OOIl1IIO0l|I01lOIOIl0OI01l|l0IO1OI01lIOIl0;assign OI01lIlO01OOl1I=OlI1OIO01lIO0lI|lO10Il0IO1I01lO|O01IlO01IlO1lIO;assign IOIl0IO01lOIl01[127:126]
=csd[127:126];assign OOIl1OlI1OOI01l
=(IlO01OIl01IIO0l&~OlI1OOlI01IlI0O)?l0IO1lO10II1lO0:
((l10IOOOIl1l10IO&(OOl1IIO0lIO01Il|OI01llO10IOlI1O|IIO0ll0IO1OOl1I|OlI1Ol10IOIO01l|IlO01I01lOI1lO0|OI01lIO01lI1lO0))|
(OlI01lO10IIO0lI&~OIl01OOIl1IIO0l)|IlO01OI01lI01lO|OlI1OlIO10lIO10|IlO01l10IOOIl01|I1lO0I01lOOlI01)?IOIl0OlI01lIO10:
IO01lI01lOl10IO;dff II1lO0OI01lI1lO0
(OOl1IOOl1IOOIl1,IO01lOIl01OOl1I,clk,hreset_b,1'b1);assign I1lO0I01lOO01Il
=(l0IO1O01IllO10I&((~OI01lIIO0lOI01l[3]&IIO0lOIl01l10IO)|I1lO0IO0lIIO0lI))|O01IlO1lIOOlI01|IIO0lI1lO0IOIl0|IO01lOIl01OOIl1|
lO10Il0IO1I01lO|OIl01IIO0lI1lO0|OI01lIlI0Ol0IO1|IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|OOIl1OlI1OOlI01|
IlO01lIO10OI01l|IO01lIO0lIIlI0O|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|lO10IOI01lO1lIO|O01IlIlO01OlI1O|
OlI01O01IlOOIl1|OI01lOOIl1OOl1I|lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOl1IOlI01OOIl1|I01lOO01IlIlO01|I1lO0OOIl1IO01l|
(~I1lO0IO0lIIO0lI&l0IO1I01lOIOIl0&(OOIl1OlI01O1lIO|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OlI01I1lO0l10IO|OOIl1IO01lOlI1O));assign I01lOOI01llO10I[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[10];assign IlO01IO0lIlO10I
=(lO10IIlO01OI01l)?10'h000:
(OI01lIIO0lOIl01&OIl01l0IO1lIO10&~O01IlIlI0OIlO01)?IIO0ll0IO1IO0lI:
(OI01lIIO0lOIl01&OIl01l0IO1lIO10&O01IlIlI0OIlO01)?l0IO1OI01lO01Il:
(lIO10l10IOOlI1O&~lO10II01lOOOIl1)?(OOl1IlIO10lIO10-10'b0000000001):
OOl1IlIO10lIO10;assign OOl1IIOIl0I01lO
=(IlI0OIO01lI1lO0&IO01lIO0lIIOIl0&O01IlO1lIOOlI01)|
(IO01lI01lOI1lO0&OOIl1OIl01IIO0l)|
(I1lO0lIO10OlI1O&OOIl1OIl01IIO0l)|
(lO10IIIO0lIlO01&OOIl1lIO10lO10I)|
(OlI01O01IlO1lIO&~IlI0OOOl1IIlO01[0])|
(O1lIOIO0lIIlO01&~l10IOI01lOOlI01&~l10IOl10IOOOIl1&~l0IO1IlO01O01Il&
~(IO01lIO0lIIOIl0&OlI01O1lIOIlI0O));dff Il0IO1I01lOO01Il
(O01IlOI01lOOl1I,OI01lIO01lIlO01,clk,hreset_b,1'b1);assign IO0lIIO01lOI01l
=(l0IO1OOIl1I1lO0[1:0]==2'b00)?IlI0OI1lO0O01Il[31:24]:
(l0IO1OOIl1I1lO0[1:0]==2'b01)?IlI0OI1lO0O01Il[23:16]:
(l0IO1OOIl1I1lO0[1:0]==2'b10)?IlI0OI1lO0O01Il[15:8]:IlI0OI1lO0O01Il[7:0];assign IOIl0IO01lOIl01[15]
=(OOIl1OOl1IIIO0l)?1'b0:csd[15];assign I1lO0IO0lIO1lIO=~IOIl0IO01lOIl01[77]&l0IO1l10IOOlI1O;assign OlI1OOlI01IIO0l
=(OIl01O1lIOOIl01&I01lOI01lOlO10I&lO10IIIO0lIO01l[0])|
(O1lIOIO01lIOIl0&~l0IO1lO10IIO01l);assign I1lO0I01lOOI01l
=O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I;assign lIO10OOIl1OlI01[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[12];assign OI01lIlI0OOIl01
=(IIO0lOIl01l10IO&(IlI0Ol0IO1IIO0l|lO10IOOIl1OI01l))|((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1&OIl01IlO01O1lIO);dff IIO0lIOlI01lIO10
(l10IOIOIl0IlI0O,lIO10I01lOIOIl0,clk,hreset_b,1'b1);assign IlI0OOOl1IIO01l
=(O01IlIIO0ll10IO&IlO01lIO10OI01l)|(~l0IO1l0IO1IlO01&OI01lOlI01IlO01);assign lO10II1lO0IlO01
=((IlI0OIlI0OOlI01==1'b0)&(O1lIOOIl01OIl01[6:0]==7'b0010001))?1'b1:
((IlI0OIlI0OOlI01==1'b1)&(O1lIOOIl01OIl01[4:0]==5'b00101))?1'b1:1'b0;assign IlI0OIlI0OlIO10
=(I01lOIOIl0OI01l&OI01lI1lO0lIO10&OIl01lO10IOIl01&O01IlO1lIOO01Il);assign I01lOO01IlI1lO0
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&
(((IO0lIOOl1IOIl01|OlI1OOIl01O01Il)&I1lO0IO0lIO1lIO)|
((I1lO0l10IOIOIl0|l10IOIOIl0IIO0l)&I01lOOI01lI1lO0));assign IIO0lOOl1IlIO10
=OOIl1IOIl0IO01l&O1lIOOOl1IIOIl0;dffe32 IOI01lO1lIOOI01l(IlI0OOOl1IIlO01,IIO0lOIl01IO01l,clk,1'b1,hreset_b,IlI0OIIO0lIOIl0);assign OI01ll0IO1IOIl0[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[14];dff32 IOlI1OI1lO0IO0lI
(I1lO0O01IlIO01l,l10IOOOIl1I01lO,clk,1'b1,1'b1);assign IOIl0OlI01l10IO=IlI0OIO01lI1lO0&(l0IO1O01IllO10I|O01IlO1lIOOlI01);dff IIlI0OlO10IIIO0l
(IIO0lIO01lOIl01,IO0lIOlI01O01Il,clk,hreset_b,1'b1);assign I01lOIOIl0OlI01=(l10IOI01lOOI01l==11'b00000000000)?1'b0:1'b1;assign OlI1OOOl1IIO0lI
=(l0IO1OOIl1lO10I&IO0lIlIO10IO01l);assign IO01lIOIl0O01Il=(~l10IOI01lOO01Il&OlI1OlIO10lIO10&~lO10Il0IO1l0IO1);assign IlO01OlI01OOl1I
=(OOIl1IO0lIl10IO==8'h0e)?1'b1:1'b0;assign IO0lIOOl1IlO10I
=(I1lO0IO0lIIO0lI)?IlO01lIO10OlI01:
(sel_mmc)?OlI1OOIl01OIl01:OOIl1OlI1OO01Il;assign OIl01l0IO1I01lO[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[5]^lIO10O1lIOIO01l[15];assign O01IlO01IlIIO0l
=(lIO10OI01lOI01l<{1'b0,OI01llO10IIOIl0})?1'b1:1'b0;assign lO10IIlO01IO0lI
=(I01lOIOIl0IlI0O&IOIl0OlI1OIlO01)|
(l0IO1OI01lIIO0l&~IOIl0OlI1OIlO01);dff IOOl1IOOl1IIOIl0
(O01Ill0IO1lIO10,OlI01IIO0llO10I,clk,hreset_b,1'b1);assign OI01lOlI01I01lO
=I1lO0OOIl1I1lO0|I01lOIO0lIO1lIO|
IO0lII1lO0OlI1O|IlI0Ol0IO1IO0lI|O01IllO10IIOIl0|OlI01O1lIOIIO0l|lIO10O1lIOl0IO1|
OOl1IOlI1OIIO0l|lIO10O01IlOI01l|IO0lIOlI01OI01l|OI01lI1lO0OIl01|
lO10IOOIl1IlI0O|O1lIOIlI0OOOIl1|OOIl1OIl01IOIl0|O1lIOOOl1IIlI0O|OlI01IO01lIO01l|
IO0lIOOl1IlIO10|OlI1OOIl01lO10I|OOl1IOI01lIlO01;assign I1lO0l10IOIO0lI[7]
=l0IO1IlO01lO10I[7]|(~lIO10lO10IlO10I[7]&IO01lIO0lIIIO0l[7]);assign OOIl1lIO10OIl01
=(~l10IOI01lOO01Il&IOIl0OOl1Il0IO1)|
(~l10IOI01lOO01Il&O1lIOOlI1OlO10I&~(~I1lO0IO0lIIO0lI|(IO0lIIIO0lOlI1O&OlI01IIO0llIO10)));assign OlI01IlO01OlI1O
=(IO01lI01lOl10IO[25:24]==2'b11)?1'b1:1'b0;assign OlI1OOOl1IOI01l=IO01lIO0lIIIO0l[23]|IO01lIO0lIIIO0l[22];assign IlI0OIlI0Ol0IO1[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[1];assign I01lOI01lOl10IO
=(IO0lIIIO0lO1lIO[9:0]==I1lO0OI01ll0IO1)?1'b1:1'b0;dff II01lOIO0lIOI01l(l0IO1OI01lIIO0l,lO10IIlO01IO0lI,clk,hreset_b,1'b1);assign IO01lOlI1OOOIl1
=(I1lO0IO0lIIO0lI)?IlI0OOOl1IIlO01[0]:OI01lIIO0lOI01l[0];dff2 Il10IOOlI1OOOl1I(IlI0OO1lIOIO0lI,IIO0ll0IO1O1lIO,clk,1'b1,1'b1);assign IO01lIO0lIIIO0l[1]
=1'b0;dff IIlI0OO1lIOIOIl0(IIO0lIIO0lOOIl1,O1lIOI1lO0OOl1I,clk,hreset_b,1'b1);assign IIO0lIIO0lIIO0l[3]
=IOIl0IlI0OlO10I[3]|(~OOl1IOlI01O1lIO[3]&IOIl0l0IO1IOIl0[3]);assign IO01lOI01lI01lO=1'b0;assign O1lIOOOl1IOIl01[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[3];assign l0IO1O01IllO10I=(l10IOIlO01lIO10==6'h00)?1'b1:1'b0;assign l10IOO1lIOIlO01[6]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[6]);assign OlI1OOIl01lO10I=O01IlOOIl1OlI1O&OI01lIlI0OI1lO0;dff Il10IOIOIl0OI01l
(IO01lIO0lIIIO0l[26],I1lO0l10IOIO0lI[26],clk,hreset_b,1'b1);dff IIlO01OIl01IlI0O
(OI01llO10IOlI1O,IlI0OO1lIOOOIl1,clk,hreset_b,1'b1);assign ecsd_r=IO01lOOl1IOOl1I;assign cmdout
=(IO0lIl0IO1OlI1O[1])?OlI1OOlI1OOlI01:O1lIOOIl01O01Il;assign IO0lIIlI0OO1lIO[7:4]
={IO0lIOlI01lO10I[12],OI01lI1lO0l10IO[12],lIO10O1lIOIO01l[12],I01lOOIl01OOIl1[12]};assign OOIl1OlI1OOlI01
=(l10IOIlO01lIO10==6'h13)?1'b1:1'b0;assign IlI0OOlI01I1lO0
=O1lIOOlI1OlO10I|IO01ll10IOOlI01|OOl1IIO0lIO01Il|
I01lOIOIl0OI01l|l0IO1OI01lIOIl0;assign I1lO0OI01lO01Il
=IOIl0IIO0lIOIl0|(~IOIl0IlI0OIlI0O&I01lOI01lOOIl01);dffe IOlI1OIO0lIIlO01
(IIO0lI1lO0IIO0l,IO01lI01lOl10IO[0],clk,hreset_b,1'b1,IO0lIIlI0OIO0lI);assign OIl01IlO01IOIl0
=
(IO0lIOIl01I01lO)?IIO0lIlI0OO01Il:
1'b0;assign l0IO1IlO01lO10I[7]
=(O01IlOOIl1OlI1O&IIO0lI1lO0IOIl0&((~l0IO1IOIl0IIO0l&OlI1OlIO10I01lO)|
(l0IO1IOIl0IIO0l&IlI0OOOIl1OOl1I)|(l10IOOOIl1IO01l&IO0lIOlI1OIO01l)|
(OOl1IIO01lOlI1O&IIO0lOIl01IlO01)|(IO01lIOIl0l0IO1&OI01lO01IlOOIl1)));dff IO01IlOI01lOlI1O
(IO0lIIO0lIIO01l,IlI0OO1lIOOOl1I,clk,hreset_b,1'b1);assign IO01llIO10OI01l[27:24]
={O01IlO1lIOIlI0O[3],l0IO1O01IlO01Il[3],IO01lI01lOlIO10[3],O1lIOIO0lII1lO0[3]};assign IlI0Ol0IO1IOIl0
=((lIO10OI01lIIO0l==1'b0)&(l10IOIlO01lIO10==6'h2a))?1'b1:1'b0;assign OOIl1l10IOl10IO[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[0];assign IO0lIOOl1IO01Il=~rdy_b&IIO0lIIO0lO1lIO;dff3 IIlI0Ol0IO1OlI01
(lO10IO1lIOl10IO,O01Ill0IO1l0IO1,clk,hreset_b,1'b1);assign l10IOlIO10OOIl1=IlI0OI1lO0lIO10|OOl1IOlI1OIlI0O|OIl01OI01lOOIl1;assign O1lIOIO01lOlI01
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&IlO01l10IOlO10I;assign OI01ll0IO1OlI01
=(IOIl0IO01lOIl01[127:126]==2'b01)?1'b1:1'b0;assign lO10Il0IO1l10IO=O1lIOIlI0OOlI1O&~I1lO0IO0lIIO0lI;assign IO01lOIl01OOIl1
=OOl1IOOl1IOlI1O&sel_mmc;assign I01lOOI01llO10I[3]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[2];assign IO01lOlI1OIIO0l
=lO10IIlO01OI01l|~I1lO0OOIl1I01lO|
(IlO01OIl01IOIl0&~(OI01lIIO0lOIl01&OIl01l0IO1lIO10))|
(lIO10l10IOOlI1O&~rdy_b&OIl01IlO01O1lIO)|
(O01IlI01lOOOl1I&OIl01IlO01O1lIO);assign OlI01IO01lI01lO[19:1]
=cid[19:1];assign l0IO1I01lOOI01l=O1lIOOOl1IO01Il|(~IOIl0OOl1IlIO10&I1lO0IOIl0OlI01);dff12 IOlI1OlIO10IlO01
(l0IO1OOIl1I1lO0,lO10IlO10Il10IO,clk,1'b1,1'b1);assign IOIl0IO01lOIl01[76]=csd[76];assign OlI1OOIl01IlI0O
=(I1lO0IOIl0IOIl0>=IO01lIOIl0OIl01)?1'b1:1'b0;assign OI01llO10IO1lIO
=(O01IlOOIl1IO0lI&~lIO10O01IlOlI01)|
(IO0lIIIO0lOOl1I&O1lIOlIO10l0IO1)|
(IO01lOI01lI1lO0&O1lIOOIl01lO10I)|
(OIl01O1lIOOIl01&IIO0lOlI1Ol10IO)|
(OI01lIIO0lOlI01&OOl1Il10IOl0IO1)|
l10IOIO0lIOOl1I;assign O1lIOOIl01l0IO1
=(~IO01lIO0lIIIO0l[25]|OI01lOlI01IO01l)&
(~lIO10OI01lIlI0O|(~IOIl0IO01lOIl01[13]&~IOIl0IO01lOIl01[12]))&
(OlI1OIO01lIIO0l|IO0lIIlI0OIOIl0|
lO10IlO10IlIO10|l0IO1OOIl1l0IO1);assign lIO10OOIl1OlI01[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[4]^IIO0lI1lO0IO0lI[2]^l0IO1O01IlO01Il[15];assign IO0lIOOl1IOI01l
=(IO01llIO10IlI0O)?{IIO0lOlI01OlI01,9'b00000000}:
{9'b000000000,IIO0lOlI01OlI01};dff II1lO0OlI1OOOIl1
(IlI0OIO01lI1lO0,IIO0lOOl1Il0IO1,clk,hreset_b,1'b1);assign O01IlIIO0ll0IO1
=(O01IlIIO0ll10IO&IO0lIIlI0OIIO0l)|(~l0IO1l0IO1IlO01&OIl01l0IO1l10IO);assign OOl1IlIO10O01Il
=(IIO0lIIO0lOlI1O[1:0]==2'b00)?2'b00:
(IIO0lIIO0lOlI1O[1:0]==2'b01)?2'b11:
(IIO0lIIO0lOlI1O[1:0]==2'b10)?2'b10:2'b01;dffe2 IOlI1OIO01lIlI0O
(dsr[9:8],IO01lI01lOl10IO[25:24],clk,hreset_b,1'b1,IlI0OOOl1II1lO0);assign OlI01O1lIOIO0lI
=(IlO01lIO10IlI0O[12]!=I1lO0IOIl0IOIl0[12])?1'b1:1'b0;dff IOOl1IOlI01IIO0l(O1lIOIO01lIOIl0,OlI1OOlI01IIO0l,clk,hreset_b,1'b1);assign OlI01lO10IO1lIO
=IOIl0IO01lOIl01[92]&OIl01OOIl1IO0lI;assign OI01ll0IO1IOIl0[7]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[6];dff IOI01llO10IOI01l
(OIl01l0IO1l0IO1,OOl1Il10IOlO10I,clk,1'b1,hreset_b);assign l0IO1O1lIOl10IO
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OIl01IIO0lI1lO0;assign l10IOOOIl1I1lO0
=(O01IlIIO0ll10IO&OOl1IOlI01OOIl1)|(~l0IO1l0IO1IlO01&I1lO0O01IlI01lO);assign IlI0OIO01lIO01l
=(OlI1OOlI01IlI0O&~lO10II01lOOOIl1&OIl01IlO01O1lIO&~O1lIOOOl1IOlI01)|
(O1lIOOOl1IOlI01&((OI01lIO01lI1lO0&I01lOI01lOl10IO)|(I01lOIOIl0OI01l&IlO01IOIl0I1lO0)));assign I1lO0IOIl0IlI0O
=(sel_mmc)?IO01lI01lOl10IO[31:16]:(IlO01IO0lIOlI01+16'h0001);assign OOl1IOOl1IIO0lI=(OI01lIIO0lO01Il==32'h00000200)?1'b1:1'b0;assign OIl01OOIl1OI01l
=(OOIl1IO0lIl10IO==8'h06)?1'b1:1'b0;dff8 IO1lIOI1lO0IIO0l(l10IOl10IOIIO0l,l0IO1IOIl0IO0lI,clk,hreset_b,1'b1);assign I1lO0OlI1OOOl1I[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[8];dff IIO01lOlI01OOIl1(IlI0OIlI0OOIl01,O01IlO1lIOOIl01,clk,1'b1,1'b1);assign IO0lIIlI0OIOIl0
=IlI0OIIO0lOI01l|IIO0lI1lO0IlI0O;dff IOIl01lO10Il0IO1(lIO10IlO01OlI01,lO10IO01IlOI01l,clk,hreset_b,1'b1);assign OIl01l0IO1lIO10
=I01lOO01IlI01lO|IO01llIO10IO0lI;assign lIO10lO10IlO10I[24]=IlO01OI01lI1lO0|OI01lIO01ll10IO;assign IOIl0IlI0OOI01l
=(~l10IOI01lOO01Il&IIO0lOIl01l10IO&OOIl1I1lO0OOl1I)|
(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&IlO01IO0lIOI01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I)|
(~l10IOI01lOO01Il&O01Ill0IO1OIl01)|
(~l10IOI01lOO01Il&lIO10lO10IlIO10&~IOIl0I1lO0IlI0O[0]);assign OlI1OOlI1OOIl01
=OIl01l0IO1I1lO0|(~O01IlOOIl1IO0lI&O1lIOOIl01lO10I);dff IlIO10lO10IIO01l(IOIl0lO10IOOl1I,IIO0lOlI1OIlO01,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[10];assign dtbuf_raddr
=((OI01lIO01lI1lO0&IO0lII1lO0O1lIO)|O1lIOOlI1OlO10I|OOl1IIO0lIO01Il|I01lOIOIl0OI01l|(IlO01I01lOI1lO0&OI01lIIO0lOI01l[2]&IO0lII1lO0O1lIO))?IIO0lOOl1II1lO0:
I1lO0IOIl0O01Il[9:0];assign IIO0lOlI01l0IO1
=(OlI01I1lO0I01lO&~cmdin)|
(IOIl0IO01ll10IO&~IOIl0OlI1OIlO01);dff32 IOlI01I1lO0IlO01
(IOIl0I1lO0IlI0O[63:32],IIO0lIlI0OIOIl0[63:32],clk,1'b1,hreset_b);assign IIO0ll0IO1IO0lI
=(lO10IIlO01OI01l)?10'h000:
(OI01lIIO0lOIl01&IO01lIlO01IO01l)?OlI1OI1lO0OlI1O[9:0]:
(OI01lIIO0lOIl01&(l10IOl10IOOlI1O|IO0lIOOl1IlIO10))?10'h004:
(OI01lIIO0lOIl01&(l0IO1IOIl0OOIl1|O01IlIIO0llO10I|lO10II01lOOOl1I))?10'h010:
(OI01lIIO0lOIl01&(I01lOO01IlI01lO|I1lO0OOIl1I1lO0|OOIl1IO01lOOl1I|OOl1IOI01lIlO01))?O01IlOOIl1IlI0O:
((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1)?(IlI0OO1lIOIIO0l-10'b0000000001):
(OI01lIIO0lOIl01&l0IO1lO10Il10IO)?10'h001:
(O1lIOIO01lIOIl0)?{4'h0,OOl1II01lOIlO01}:
IlI0OO1lIOIIO0l;assign I1lO0l10IOIO0lI[25]
=l0IO1IlO01lO10I[25]|(~lIO10lO10IlO10I[25]&IO01lIO0lIIIO0l[25]);assign OlI01l0IO1OlI01
=(~l10IOI01lOO01Il&OOl1IIO0lIO01Il&lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&I01lOIOIl0OI01l&lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&l0IO1OI01lIOIl0&lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&OIl01O01IlIO0lI&lO10Il0IO1l0IO1);assign OOl1IOlI01O1lIO[0]
=lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&~lIO10IlO01OIl01;assign O01IlOOIl1IIO0l
=(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01)?OlI01IO01lI01lO[127:96]:
(OI01lO01IlOOl1I)?OlI01IO01lI01lO[95:64]:
(OlI01IlO01OOIl1)?OlI01IO01lI01lO[63:32]:
OlI01IO01lI01lO[31:0];assign IlI0OIlI0Ol0IO1[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[12];dff IOOIl1IO0lII01lO
(OlI01I1lO0I01lO,OI01lIlI0OI1lO0,clk,hreset_b,1'b1);assign l10IOl10IOO1lIO
=OOl1IIO0lIO01Il|(I01lOIOIl0OI01l&O01IlO01IlOlI1O)|(l0IO1OI01lIOIl0&O01IlO01IlOlI1O)|
IIO0lIIO0lOOIl1|(OlI1OIOIl0IlO01&IO0lIlIO10IO01l)|(lO10IlO10IOIl01&~l0IO1OOIl1lO10I);dff IIlI0OI1lO0l10IO
(l10IOOOIl1l10IO,lIO10lO10Il0IO1,clk,hreset_b,1'b1);dff IIO0lIOOl1Il0IO1
(IO01lIO0lIIIO0l[18],I1lO0l10IOIO0lI[18],clk,hreset_b,1'b1);dff IOIl01O1lIOl10IO
(OIl01I1lO0IO01l,O01IlIlI0OI01lO,clk,hreset_b,1'b1);assign I1lO0O01IlIlO01[1]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[9]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[9])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[9])?1'b0:
IO01lOOl1IOOl1I[1];assign IO0lIOIl01I1lO0
={1'b0,OOIl1lIO10l0IO1,1'b0,IOIl0IO01lOIl01[4],IOIl0IO01lOIl01[23:22],1'b0,IlO01OlI1OIOIl0};assign O1lIOOOl1IOIl01[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[14];assign lO10Il0IO1I01lO=(l10IOIlO01lIO10==6'h0b)?1'b1:1'b0;assign dtout[5]
=I1lO0lIO10OOl1I[5];dff IO1lIOOlI01lO10I(OOIl1OOl1IIO0lI,O1lIOIO01lIOIl0,clk,hreset_b,1'b1);dff IIIO0lO1lIOOOIl1
(IO01lIO0lIIIO0l[8],OOIl1OlI1OIlI0O,clk,hreset_b,1'b1);assign lIO10IlO01OI01l=
(IO0lIOIl01I01lO)?OOl1IIO0lIl0IO1:
1'b0;dffe Il0IO1IOIl0IlI0O
(OOIl1IO0lII1lO0[0],IlO01l10IOl10IO[0],clk,hreset_b,1'b1,I1lO0I01lOlIO10);assign OlI01OOIl1OOl1I[2]
=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[1];assign OOl1IOlI1OOlI01[27:24]
={O01IlO1lIOIlI0O[7],l0IO1O01IlO01Il[7],IO01lI01lOlIO10[7],O1lIOIO0lII1lO0[7]};assign IIO0lOlI1OIO01l
=(l10IOIlO01lIO10==6'h21)?1'b1:1'b0;assign O01IlIlI0OIO01l[4]
=~l10IOI01lOO01Il&(l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO;dff II1lO0IO0lIIlI0O
(lO10II01lOOOl1I,OIl01IlI0OIlO01,clk,hreset_b,1'b1);dffe IlIO10O01IllIO10
(OlI1OOlI01IOIl0,IO01lI01lOl10IO[0],clk,1'b1,hreset_b,O1lIOIO01lIlI0O);dff IIIO0lOOl1II01lO
(OlI1OOlI01O1lIO,IIO0lIlI0OIIO0l,clk,hreset_b,1'b1);assign I01lOOI01lI01lO=1'b0;assign IIO0lOOl1IOIl01
=(IO0lIl0IO1OlI1O[1])?OlI1OOlI1OOlI01:O1lIOOIl01O01Il;assign l0IO1lO10IIlO01
=
{IOIl0I1lO0IlI0O[124],IOIl0I1lO0IlI0O[116],IOIl0I1lO0IlI0O[108],IOIl0I1lO0IlI0O[100],IOIl0I1lO0IlI0O[92],
IOIl0I1lO0IlI0O[84],IOIl0I1lO0IlI0O[76],IOIl0I1lO0IlI0O[68],IOIl0I1lO0IlI0O[60],
IOIl0I1lO0IlI0O[52],IOIl0I1lO0IlI0O[44],IOIl0I1lO0IlI0O[36],IOIl0I1lO0IlI0O[28],
IOIl0I1lO0IlI0O[20],IOIl0I1lO0IlI0O[12],IOIl0I1lO0IlI0O[4]};assign OlI01OOIl1OlI1O
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h16))?1'b1:1'b0;assign OOIl1l10IOl10IO[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[11]^IIO0lI1lO0IO0lI[0]^O1lIOIO0lII1lO0[15];assign O01Ill0IO1O01Il
=(OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~rdy_b;assign OlI1OOOl1IIOIl0[29]=(sel_mmc)?ocr_mem[29]:1'b0;assign I01lOl10IOIlI0O
=(O1lIOOIl01OIl01==15'h0003)?1'b1:1'b0;assign lIO10IOIl0O1lIO=OI01lOOIl1OOl1I|OlI01OOIl1OlI1O;assign IOIl0IO01lOIl01[119:104]
=(OOIl1OOl1IIIO0l)?16'h0e00:csd[119:104];dff32 IO1lIOOlI1OI01lO(IlO01lIO10IlI0O,OOIl1OlI1OOI01l,clk,hreset_b,1'b1);assign OlI01I1lO0l0IO1
=OlI1OOIl01OlI01&~error;assign O1lIOOlI01OlI01
=I1lO0IO0lIIO0lI&(lIO10OOIl1OIl01|OOl1IOOl1IOlI1O|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OlI01I1lO0l10IO|IIO0lOlI01lO10I|
OOIl1IO01lOlI1O|
IOIl0O1lIOOOl1I|IO0lIlIO10IlO01);assign I01lOOI01llO10I[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[13];assign IOIl0OlI01I01lO=(OOl1IlIO10lIO10==10'b0000000010)?1'b1:1'b0;assign OlI01OOIl1O1lIO
=(IO01lI01lOI1lO0&IO01lIO0lIIOIl0&(IlO01lIO10OI01l|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|lO10IOI01lO1lIO|
IlI0Ol0IO1IOIl0|(OOl1IOlI01OOIl1&~IO01lI01lOl10IO[0])))|
(OIl01IlO01IIO0l&~l10IOI01lOOlI01&~l0IO1O1lIOl10IO&~l0IO1IlO01O01Il&~OOIl1lIO10lO10I);assign OI01lOOl1IIO01l
=lO10IOOIl1O01Il|(~lO10IO1lIOOIl01&OlI01OlI01IlO01);assign O1lIOOlI01O01Il
=(l0IO1OOIl1I1lO0[1:0]==2'b11)?dtbuf_rdata[31:24]:
(l0IO1OOIl1I1lO0[1:0]==2'b10)?dtbuf_rdata[23:16]:
(l0IO1OOIl1I1lO0[1:0]==2'b01)?dtbuf_rdata[15:8]:dtbuf_rdata[7:0];assign IOIl0IO01lOIl01[9:8]
=(sel_mmc)?I01lOIO0lIIlI0O:2'b00;assign OIl01I01lOOOl1I
=(IOIl0IO01lOIl01[83:80]<=4'b1001)?1'b0:
(IOIl0IO01lOIl01[83:80]==4'b1010)?IO0lII1lO0OOIl1:
(IOIl0IO01lOIl01[83:80]==4'b1011)?O1lIOIlI0OOOl1I:
(IOIl0IO01lOIl01[83:80]==4'b1100)?OOIl1I01lOIlO01:
(IOIl0IO01lOIl01[83:80]==4'b1101)?OOl1IOI01lIO01l:IO01lIlO01I01lO;dff IlO10IOOIl1lIO10
(O01IlOOIl1IO0lI,OI01llO10IO1lIO,clk,1'b1,hreset_b);assign OI01lO1lIOOlI1O=IlI0OIIO0lIlI0O|IO0lII1lO0IO0lI|O1lIOIlI0OO1lIO;dffe16 IOI01lOOIl1IO0lI
(l0IO1O01IlO01Il,lIO10OOIl1OlI01,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign O01IlIlO01OOl1I
=(O01IlIIO0llO10I)?32'h08000000:
(IlI0Ol0IO1IO0lI)?32'h08008000:
(O01IllO10IIOIl0)?32'h08008010:
(OlI01O1lIOIIO0l)?32'h08008020:
(OOl1IOlI1OIIO0l)?32'h08008040:
(lIO10O01IlOI01l)?32'h08008050:
(IO0lIOlI01OI01l)?32'h08008060:
(IlI0OIlI0OO01Il)?32'h08008070:
(OI01lI1lO0OIl01)?32'h08008080:
(I1lO0I01lOOIl01)?32'h08008090:
(OI01lIIO0lOlI01)?32'h08008100:
(IlO01OIl01O1lIO)?32'h08008110:
(O1lIOIO01lIOIl0)?32'h08008200:
(OlI01IO01lIO01l)?32'h08008300:
(lO10II01lOOOl1I)?32'h08008400:
(IlO01l10IOlIO10)?32'h08100000:
(OlI01O1lIOIlI0O)?32'h08101000:
32'h08008030;assign OOl1IIO0lIOIl01
=(sel_mmc)?lIO10OOIl1OIl01:IOIl0O1lIOOOl1I;assign IO01lIOIl0lO10I
=(O01IlIIO0ll10IO&lIO10I01lOIO0lI)|(~l0IO1l0IO1IlO01&IlO01l10IOlIO10);assign IO01lI01lOl0IO1
=(IO0lIOIl01I01lO&I1lO0I01lOOlI01&~IOIl0I1lO0IlI0O[0])?2'b00:
(IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OOIl1l10IOI1lO0)?(OOl1IIOIl0l10IO+2'b01):
OOl1IIOIl0l10IO;dff II01lOOlI1OO1lIO
(l0IO1O01IllIO10,lIO10OOIl1lO10I,clk,hreset_b,1'b1);assign l0IO1IlO01lO10I[30]=I01lOO01IlI1lO0|I1lO0OOIl1l10IO|l0IO1lO10Il0IO1;dff8 IlIO10IO0lIOOl1I
(OOIl1IO0lIl10IO,IlO01l10IOl0IO1,clk,1'b1,1'b1);assign O01IlO1lIOOI01l=l0IO1OI01lIIO0l&IOIl0OlI1OIlO01;assign I1lO0OlI1OOOl1I[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[0];assign lO10II01lOOOIl1=rdy_b&~O01IlI01lOOOl1I;assign l10IOIO0lIOOIl1
=I1lO0lIO10OlI1O&(l0IO1O01IllO10I|OOIl1OlI01O1lIO|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|
IOIl0IO01llIO10|OOIl1IO01lOlI1O);dff IO1lIOIIO0lOlI1O
(I01lOIO0lIIIO0l,l10IOl10IOIO0lI,clk,hreset_b,1'b1);assign OOIl1OOl1IIOIl0
=(~lO10IIlO01OI01l&IIO0lIlI0OOlI01&I1lO0OOIl1I01lO)|
(~lO10IIlO01OI01l&OlI1OOlI01IlI0O&(lO10II01lOOOIl1|~OIl01IlO01O1lIO)&I1lO0OOIl1I01lO);assign lIO10lO10IlO10I[13]
=IlO01OI01lI1lO0;assign OlI01lO10IIO0lI
=(~l10IOI01lOO01Il&I1lO0I01lOOlI01&~lO10Il0IO1l0IO1&~IOIl0I1lO0IlI0O[0]&(~I1lO0IO0lIIO0lI|~OlI01lO10IIIO0l)&~l10IOIlO01I1lO0)|
(~l10IOI01lOO01Il&lIO10IlO01IlI0O&~lO10Il0IO1l0IO1&~IOIl0I1lO0IlI0O[0])|
(~l10IOI01lOO01Il&OIl01OOIl1IIO0l&~lO10Il0IO1l0IO1&(~IO0lIlIO10IO01l|OI01lOlI01IlO01));assign IlI0OIO01ll10IO
=(OlI01IlI0OI1lO0==IOIl0I1lO0IlI0O[7:0])?1'b1:1'b0;assign OI01lOOIl1OOIl1
=(~I1lO0IO0lIIO0lI|~OlI1OOOl1IOI01l)&(IlI0OIIO0lIlI0O|O01IllO10IOI01l);assign OIl01l0IO1I01lO[3]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[2];dff IlO10IlO10II01lO
(OlI01OOIl1IO0lI,IlI0OlO10IO1lIO,clk,hreset_b,1'b1);assign OlI01l0IO1OI01l
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&IO01llIO10O1lIO);dff Il10IOlIO10O1lIO
(OlI1OOOl1IIlI0O,OOl1IOIl01IOIl0,clk,hreset_b,1'b1);assign IO01lIlO01IO01l
=OI01lOlI01IlO01&l10IOO01IlI1lO0&lO10IOOIl1OIl01&I01lOOOIl1I01lO;assign I1lO0l10IOIO0lI[16]
=l0IO1IlO01lO10I[16]|(~lIO10lO10IlO10I[16]&IO01lIO0lIIIO0l[16]);assign lO10IIlO01IIO0l
=(~l10IOI01lOO01Il&I01lOIOIl0OI01l&~lO10Il0IO1l0IO1&IO0lIlIO10IO01l&~O1lIOOOl1IOlI01)|
(~l10IOI01lOO01Il&l0IO1OI01lIOIl0&~lO10Il0IO1l0IO1&~IO0lIlIO10IO01l);assign OIl01OOIl1OlI01
=(IO01lI01lOl10IO[2:0]==3'b010)?1'b1:1'b0;dff6 IOlI01IIO0ll10IO(l10IOlIO10OOl1I,l0IO1O1lIOIlO01,clk,hreset_b,1'b1);assign IlI0OIlI0Ol0IO1[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[4]^IIO0lI1lO0IO0lI[6]^OI01lI1lO0l10IO[15];assign O01IllO10IO01Il
=((OlI1OI1lO0OlI1O>=11'h004)&(OlI1OI1lO0OlI1O<=11'h00f))?1'b1:1'b0;dff IlO10II01lOIIO0l
(OOl1IIO0lIOlI01,IO01ll10IOOI01l,clk,hreset_b,1'b1);assign OlI01l0IO1lO10I[23:16]
=(OI01ll0IO1O01Il==2'b11)?IOIl0I1lO0IlI0O[15:8]:
(OI01ll0IO1O01Il==2'b10)?IOIl0I1lO0IlI0O[7:0]:8'h00;assign OI01lI1lO0l0IO1
=(IO01lOlI1OIO0lI&~IlO01OIl01IIO0l&(O1lIOOOl1IOlI01|l0IO1IOIl0O1lIO)&
(I1lO0IO0lIO1lIO|OlI1OOIl01IlI0O));dff IlO10Il10IOOOl1I
(IO01lIO0lIIIO0l[5],I1lO0l10IOIO0lI[5],clk,hreset_b,1'b1);dff IOlI1OI1lO0O1lIO
(I1lO0O01Ill10IO,l10IOOOIl1l0IO1,clk,hreset_b,1'b1);dff IIlI0OIlI0OI1lO0
(IOIl0l0IO1IOIl0[1],IIO0lIIO0lIIO0l[1],clk,hreset_b,1'b1);assign IIO0lIO01lO01Il
=IlO01lIO10O01Il|l0IO1O01Ill10IO|lIO10OOIl1l0IO1;assign O1lIOOOl1IOIl01[7]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[6];assign O01IlO1lIOOlI01=(l10IOIlO01lIO10==6'h03)?1'b1:1'b0;assign l10IOlO10II01lO
=(I01lOIOIl0OI01l&IO0lIlIO10IO01l&~O1lIOOOl1IOlI01)?12'h001:
(l0IO1OI01lIOIl0&O01IlO01IlOlI1O&~IO0lIlIO10IO01l)?(I01lOOOIl1IO01l+12'h001):
I01lOOOIl1IO01l;assign O1lIOIlI0OOOIl1
=OI01lIIO0lOlI01&~IIO0lIlI0OIlI0O;dff IO01IlIlO01IIO0l(IO01lIO0lIIIO0l[29],I1lO0l10IOIO0lI[29],clk,hreset_b,1'b1);dff Il10IOIO0lIIO0lI
(IlO01I01lOI1lO0,IO01lOI01ll10IO,clk,hreset_b,1'b1);assign OlI1OIlI0OO1lIO
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[8]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[8])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[8])?1'b0:
OlI1OIlI0OO1lIO;assign IlO01IlO01IlO01
=~clk;assign IO01lO01IlIlO01[27:24]={O01IlO1lIOIlI0O[11],l0IO1O01IlO01Il[11],IO01lI01lOlIO10[11],O1lIOIO0lII1lO0[11]};assign I1lO0l10IOIOIl0
=(l10IOIlO01lIO10==6'h18)?1'b1:1'b0;dff II1lO0l10IOO01Il(l0IO1IOIl0OOl1I,l10IOl10IOOOIl1,clk,1'b1,1'b1);assign IlI0OI1lO0OI01l
=lO10IIlO01OI01l|(lIO10l10IOOOIl1&~rdy_b);dff2 IOOl1Il10IOIO01l(OIl01IIO0lI01lO,OlI01I1lO0I1lO0,clk,hreset_b,1'b1);assign OOIl1IO01lO1lIO
=IIO0lIlI0OIIO0l&OIl01lO10IlO10I;dff16 IOIl01OI01lIIO0l(O01Ill0IO1l10IO,OlI01IIO0ll0IO1,clk,hreset_b,1'b1);dff IOI01lIlO01OOIl1
(lO10IIlO01OI01l,l10IOI01lOOlI01,clk,1'b1,hreset_b);assign IO01llIO10OI01l[15:12]
={IO0lIOlI01lO10I[1],OI01lI1lO0l10IO[1],lIO10O1lIOIO01l[1],I01lOOIl01OOIl1[1]};assign O1lIOIlI0OO1lIO
=(l10IOIlO01lIO10==6'h35)?1'b1:1'b0;assign OOIl1l10IOl10IO[4]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[3];assign l0IO1lO10IIO01l
=(~rdy_b&OIl01IlO01O1lIO);assign I01lOIOIl0O01Il=~IO01ll10IOOIl01&OOl1IIO0lIlO10I;assign OOl1IlIO10OlI01
=(I1lO0I01lOOlI01|(lIO10IlO01IlI0O&~IOIl0I1lO0IlI0O[0])|OOl1IIO0lIO01Il)?OlI1OOlI1OO01Il:
(OIl01OOIl1IIO0l&IO0lIlIO10IO01l&~I1lO0IO0lIIO0lI&~OI01lOlI01IlO01)?15'h0011:
(OIl01OOIl1IIO0l&IO0lIlIO10IO01l&~I1lO0IO0lIIO0lI&OI01lOlI01IlO01&~IOIl0IO01lOIl01[21])?OlI1OOlI1OO01Il:
((I01lOIOIl0OI01l|(OIl01OOIl1IIO0l&I1lO0IO0lIIO0lI))&IO0lIlIO10IO01l)?15'h0010:
(l10IOO01IllIO10&~I1lO0IlO01l0IO1)?15'h0007:
(lO10IlO10IOIl01&~l0IO1OOIl1lO10I)?15'h0008:
(lIO10IlO01IlI0O&IOIl0I1lO0IlI0O[0])?15'h0006:
(OI01lO1lIOO1lIO&I1lO0IO0lIIO0lI&IO0lIlIO10IO01l)?15'h0002:
(IIO0lIIO0lOOIl1|(OlI1OIOIl0IlO01&IO0lIlIO10IO01l))?15'h0005:
(O1lIOOIl01OIl01-15'h0001);assign l0IO1l10IOIO0lI
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l;dff IOIl01lO10IlIO10
(OOIl1OOl1IIIO0l,IlO01OIl01IO0lI,clk,hreset_b,1'b1);dff32 IIO0lIOIl01IO01l(IOIl0OlI01lIO10,IIO0lOOl1IlO10I,clk,hreset_b,1'b1);assign OOIl1OlI01OlI1O
=lO10IIlO01OI01l|
(OlI1OIO01lO1lIO&(IIO0lOlI01OIl01|~OlI01I1lO0l0IO1))|
(OOl1IOOl1IOOIl1&IIO0lOlI01OIl01)|
(I01lOOOIl1IlO01&IIO0lOlI01OIl01)|
(l0IO1O1lIOI01lO&IO0lIOOl1IO01Il);assign l0IO1IlO01OIl01
=I01lOI01lOlIO10&~sel_mmc;assign I01lOOI01llO10I[6]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[5];assign OlI01IlI0OIlO01
=(~lO10IIlO01OI01l&lIO10l10IOOlI1O&~OIl01IlO01O1lIO&OlI1OOOl1IOlI01&~rdy_b&I1lO0OOIl1I01lO)|
(~lO10IIlO01OI01l&O01IlI01lOOOl1I&~OIl01IlO01O1lIO&I1lO0OOIl1I01lO);assign OOIl1IOIl0IlO01[47:32]
=16'h0000;assign I01lOlIO10OOIl1=IIO0lOIl01l10IO&lO10IOOIl1OI01l;dff12 IOOIl1IO0lIIO01l
(OOIl1IlI0OOOIl1,IlO01IO01lOOl1I,clk,1'b1,1'b1);assign IOIl0IO01lOIl01[46:31]=(OOIl1OOl1IIIO0l)?16'hff00:csd[46:31];assign l10IOIOIl0OlI1O
=OI01lOlI01IlO01|OlI1OlIO10l10IO;assign IlO01I01lOI01lO
=(IO0lIIIO0lOOl1I&~O1lIOlIO10l0IO1&~lO10IIIO0lIO01l[3])|
(OOIl1IOIl0IO01l&~O1lIOOOl1IIOIl0);assign lIO10OI01lIlI0O
=I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|IOIl0OIl01IlO01|IIO0lOlI1OIO01l|lO10IOOIl1OlI01;assign lIO10OOIl1OlI01[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[7];assign OOl1IOlI01OlI1O
=IOIl0IO01ll0IO1&IOIl0I1lO0OIl01&(IO0lIOOl1IOIl01|OlI1OOIl01O01Il|
(IlO01lIO10OI01l&~l10IOO01IlI1lO0)|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l);dff IOIl01l0IO1IO01l
(I1lO0lIO10OlI1O,lIO10l10IOOOl1I,clk,hreset_b,1'b1);assign OOIl1OIl01OI01l
=(O01IlIIO0ll10IO&lO10Il0IO1I01lO)|(~l0IO1l0IO1IlO01&O1lIOOOl1IOlI01);assign OOIl1IO01lOOIl1
=~l10IOI01lOO01Il&(IlO01OOl1IOOIl1|(~IlO01OlI1OOlI1O&O1lIOIlI0OOlI1O));dffe2 IIO01lOIl01IO0lI
(dsr[1:0],IO01lI01lOl10IO[17:16],clk,hreset_b,1'b1,IlI0OOOl1II1lO0);assign IO0lII1lO0OOIl1
=(IlO01lIO10IlI0O[1]!=I1lO0IOIl0IOIl0[1])?1'b1:1'b0;assign lIO10O01IlOlI01=I1lO0I01lOOlI01&IOIl0I1lO0IlI0O[0]&OlI1OIlI0OOOIl1;assign OlI1OIOIl0IO01l
=IlI0OOOl1Il10IO|IO0lIOlI1OlIO10|OOIl1IO0lIOIl01|
IO01lIOIl0OlI01|l10IOOI01lIlI0O|lO10IO01IlIIO0l|
OlI01lO10IO1lIO|IOIl0l0IO1OOIl1|O1lIOl10IOIlO01;assign OI01ll0IO1IOIl0[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[9];dff2 IIIO0ll0IO1IOIl0
(O01IlIIO0llIO10,l10IOIOIl0O1lIO,clk,1'b1,1'b1);assign OOIl1lIO10lO10I
=(IO0lIOIl01I01lO&
((OIl01O01IlIO0lI&~lIO10IlO01OI01l)|
(IlO01OI01lI01lO&IO0lIlIO10IO01l&~lIO10IlO01OI01l)|
(I1lO0IOIl0OI01l&I1lO0O01IlI01lO)|
lO10IIlO01IOIl0));assign IOIl0IlI0OO01Il
=(O01IlIIO0ll10IO&O01IlO01IlO1lIO)|(~l0IO1l0IO1IlO01&IlI0OI1lO0OIl01);dff IOlI01lO10IO01Il
(O1lIOOlI1OI1lO0,OOIl1lIO10l10IO,clk,hreset_b,1'b1);assign IlO01OI01lI1lO0=(IlO01I01lOl10IO&IOIl0OlI1OIlO01&IIO0lOlI01lIO10);assign IO01lOIl01O1lIO
=(OI01lIIO0lO01Il==IIO0lO1lIOOOl1I)?1'b1:1'b0;assign IOIl0l0IO1IIO0l=(OOIl1IO0lIl10IO==8'h09)?1'b1:1'b0;assign I1lO0IOIl0IIO0l
=(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l)?7'b1000000:
(I01lOl10IOIOIl0-7'b0000001);assign I1lO0OlI1OOOl1I[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[11]^IIO0lI1lO0IO0lI[4]^I01lOOIl01OOIl1[15];dff10 Il10IOO01IlIlO01
(O1lIOOIl01l10IO,OlI1OOlI1Ol0IO1,clk,hreset_b,1'b1);assign l0IO1OOIl1l0IO1=I1lO0IlO01I1lO0|l10IOO01Ill10IO;dff IIlI0OIIO0lOIl01
(IIO0lIIO0lO1lIO,O1lIOI1lO0OlI1O,clk,hreset_b,1'b1);assign OlI01IlI0OIO01l
=(OIl01I1lO0IO01l)?IlO01IOIl0OIl01:
(IOIl0OOl1Il0IO1)?16'h0000:
(OlI1OOlI01IlI0O&~lO10II01lOOOIl1&OIl01IlO01O1lIO&lO10IO01IlIlI0O)?(O01IlI1lO0IlO01-16'h0001):
O01IlI1lO0IlO01;assign lIO10lO10IlO10I[28]
=IlO01OI01lI1lO0;assign I01lOlIO10OlI1O
=(~l10IOI01lOO01Il&IIO0lOIl01l10IO&I1lO0OI01lOIl01)|
(~l10IOI01lOO01Il&IIO0lIIO0lOOIl1&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I&OIl01O01IlIIO0l)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&~IO0lIlIO10IO01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I&OIl01O01IlIIO0l)|
(~l10IOI01lOO01Il&IlO01OI01lI01lO&IO0lIlIO10IO01l&(~lIO10IlO01OI01l|lO10Il0IO1l0IO1)&OIl01O01IlIIO0l)|
(~l10IOI01lOO01Il&lIO10lO10IlIO10&IOIl0I1lO0IlI0O[0]&OIl01O01IlIIO0l&~IlO01OI01lIO01l)|
(~l10IOI01lOO01Il&IO0lIIO01lIlI0O&((OIl01O01IlIIO0l&~IO01lIO0lIIIO0l[26])|(IO01lIO0lIIIO0l[26]&OI01lO1lIOIO0lI)))|
(~l10IOI01lOO01Il&OlI1OOOl1IIIO0l&((OIl01O01IlIIO0l&~IO01lIO0lIIIO0l[26])|(IO01lIO0lIIIO0l[26]&OI01lO1lIOIO0lI)))|
(~l10IOI01lOO01Il&IlO01OlI1OO1lIO&~lO10IIlO01IOIl0);assign lIO10lO10IlO10I[25]
=(I01lOIOIl0O01Il&I1lO0O01IlI1lO0)|OIl01O1lIOlIO10;assign OOIl1OlI1OO01Il
=IIO0lI1lO0IOIl0|OOIl1OlI01O1lIO|OIl01IIO0lI1lO0|OlI01I1lO0l10IO|IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|
I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO|O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|IOIl0OIl01IlO01|
IIO0lOlI1OIO01l|lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOIl1IO01lOlI1O|OOl1IOlI01OOIl1|
OIl01IlO01IO0lI|O01IlO01IlO1lIO|OlI01OOIl1OlI1O|IlI0OlO10IOOIl1|IO0lIlIO10IlO01|O1lIOIO0lIIO01l;assign OIl01l0IO1I01lO[14]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[13];assign lO10IlO10Il0IO1
=(~lIO10I01lOOlI1O|l10IOO01Ill0IO1)&
(OIl01OOIl1IIO0l&((OOIl1l10IOI1lO0|IO0lIlIO10IO01l)|
(OI01lOlI01IlO01&l10IOO01IlI1lO0&OOl1IOIl01OI01l)));assign IO01lOI01ll0IO1
=(OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&~IO01lIO0lIOI01l)|
(IlO01I01lOl10IO&~IOIl0OlI1OIlO01);assign IlO01OIl01OlI1O
=(l10IOI01lOO01Il|IlO01l10IOOIl01)?4'b0000:
((OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)&IlI0OIlI0OOlI01)?OI01lIIO0lOI01l[3:0]:
OOIl1OOl1IO1lIO;assign lIO10O1lIOlIO10
=(IlI0OO1lIOIIO0l==10'b0000000010)?1'b1:1'b0;assign I1lO0l10IOIO0lI[28]
=l0IO1IlO01lO10I[28]|(~lIO10lO10IlO10I[28]&IO01lIO0lIIIO0l[28]);dff Il0IO1OI01lOIl01
(IlO01l10IOOIl01,IO01lIOIl0O01Il,clk,hreset_b,1'b1);assign OOl1IOlI01O1lIO[3]
=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&~OlI01lO10IOI01l);assign OI01lO01IlOOl1I=(l10IOl10IOIIO0l==8'h61)?1'b1:1'b0;dffe16 IOlI1OIIO0lOOl1I
(OI01lI1lO0l10IO,IlI0OIlI0Ol0IO1,clk,1'b1,1'b1,lIO10OOIl1O01Il);dff II1lO0I01lOl0IO1
(OlI1Ol10IOI01lO,OOIl1IOIl0I1lO0,clk,hreset_b,1'b1);assign l10IOO1lIOIlO01[1]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[1]);assign OOl1IOlI1OIIO0l=IIO0lIlI0OIIO0l&O01IlIlO01OlI1O;dff IOlI1OOIl01lIO10
(IO01lIO0lIIIO0l[21],I1lO0l10IOIO0lI[21],clk,hreset_b,1'b1);dff IIOIl0I1lO0lO10I
(O1lIOOlI1OlO10I,OOIl1lIO10OIl01,clk,hreset_b,1'b1);dffe IOOIl1OIl01lO10I
(IO01lOOl1IOOl1I[0],I1lO0O01IlIlO01[0],clk,hreset_b,1'b1,lIO10lO10II01lO);assign O1lIOOlI1Ol10IO
={I01lOIOIl0OIl01,IO01lIO0lIIIO0l[27:26],IO01lIO0lIIIO0l[21:19],IO01ll10IOlO10I,IO01lIO0lIIIO0l[25]};assign IO0lIIlI0OO1lIO[27:24]
={OI01ll0IO1IOIl0[15],lIO10OOIl1OlI01[15],I01lOOI01llO10I[15],OOIl1l10IOl10IO[15]};assign OI01lIlI0Ol0IO1
=(l10IOIlO01lIO10==6'h0e)?1'b1:1'b0;assign IlI0OIO01ll0IO1[2]
=(l10IOI01lOO01Il)?1'b1:
(l10IOlIO10OOIl1&~(IIO0lIIO0lOOIl1|IlO01OI01lI01lO))?l10IOO1lIOIlO01[2]:l10IOO1lIOIlO01[6];assign OlI01IIO0lOlI01
=lIO10l10IOOOIl1&(~lO10II01lOOOIl1&(OIl01IlO01O1lIO|error));assign IOIl0OIl01I1lO0
=I1lO0OI01llIO10|(~OOl1II01lOI01lO&OI01lOOl1II01lO);assign IlI0OIIO0lOlI01=
(IO0lIOIl01I01lO)?I1lO0IOIl0OI01l:
1'b0;assign OlI1OlIO10I01lO
=(IO01lI01lOl10IO[23:16]>=8'hc0)?1'b1:1'b0;assign OlI01OOIl1OOl1I[5]=(l10IOOOIl1lIO10)?1'b0:O01IlO01IlOOIl1[4];assign OOl1IOlI1OOlI01[15:12]
={IO0lIOlI01lO10I[5],OI01lI1lO0l10IO[5],lIO10O1lIOIO01l[5],I01lOOIl01OOIl1[5]};assign I01lOI01lOlIO10
=(l10IOIlO01lIO10==6'h24)?1'b1:1'b0;assign O01IlIlI0OIO01l[7]
=~l10IOI01lOO01Il&(l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&OI01lIO01lI01lO;assign IIO0lIO01lOlI01
=IO0lII1lO0IIO0l|(~IO0lIIO01lIOIl0&IlI0OIlI0OO01Il);assign l0IO1l10IOO1lIO
=(l10IOI01lOOlI01&~OI01lIIO0lOI01l[3]&IIO0lOIl01l10IO)|I1lO0IO0lIIO0lI;assign IlO01I01lOIO01l
=(OlI01OOIl1IIO0l[1:0]==2'b10)?1'b1:1'b0;assign IO01lI01lOIO01l=1'b0;assign l0IO1IlO01lIO10
=(OlI1Ol10IOI01lO|IlO01I01lOl10IO)&l0IO1IO0lIOOl1I;assign OOIl1OIl01O01Il
=
{IOIl0I1lO0IlI0O[127],IOIl0I1lO0IlI0O[119],IOIl0I1lO0IlI0O[111],IOIl0I1lO0IlI0O[103],IOIl0I1lO0IlI0O[95],
IOIl0I1lO0IlI0O[87],IOIl0I1lO0IlI0O[79],IOIl0I1lO0IlI0O[71],IOIl0I1lO0IlI0O[63],
IOIl0I1lO0IlI0O[55],IOIl0I1lO0IlI0O[47],IOIl0I1lO0IlI0O[39],IOIl0I1lO0IlI0O[31],
IOIl0I1lO0IlI0O[23],IOIl0I1lO0IlI0O[15],IOIl0I1lO0IlI0O[7]};assign IO0lIlIO10IlO01
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h2a))?1'b1:1'b0;assign OOIl1l10IOl10IO[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[14];assign lIO10I01lOO1lIO
=(OOIl1l10IOI01lO[1:0]==2'b00)?4'b1110:
(OOIl1l10IOI01lO[1:0]==2'b01)?4'b1101:
(OOIl1l10IOI01lO[1:0]==2'b10)?4'b1011:4'b0111;assign OlI1OOOl1IIOIl0[14:8]
=7'b0000000;dff IOOl1IlIO10l0IO1(O01Ill0IO1lO10I,OlI01IIO0lOIl01,clk,hreset_b,1'b1);dff16 IIO0lIO1lIOOOl1I
(IlO01IOIl0OIl01,I01lOI01lOO01Il,clk,hreset_b,1'b1);assign IOIl0IO01lOIl01[93]=csd[93];assign OIl01OOIl1IOIl0
={1'b0,IOIl0IO01lOIl01[49:47]}+4'b0010;assign l0IO1IlO01lO10I[27]=(OlI1OOIl01OlI01|IOIl0IO01llO10I)&error;assign OOl1IIOIl0I1lO0
=
((IO0lII1lO0IO0lI|O1lIOIlI0OO1lIO)&~OIl01IIO0ll0IO1)?{15'h0000,IO01lI01lOl10IO[25:9]}:
(O01IllO10IOI01l)?{25'h0000000,IO01lI01lOl10IO[14:8]}:
(OOl1IOlI01OOIl1)?{1'b1,IO01lI01lOl10IO[31:1]}:
IO01lI01lOl10IO;assign lIO10OOIl1OlI01[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[2]^l0IO1O01IlO01Il[15];assign IO01lO01IlIO01l
=~((((OI01lIIO0lOIl01&OIl01l0IO1lIO10)|IIO0lIlI0OOlI01|OlI1OOlI01IlI0O)&(OOl1IOIl01OI01l|l0IO1IlO01lO10I[18])&~IO01lIO0lIIIO0l[18])|
OOIl1OlI01IIO0l);assign I01lOl10IOOlI01
=(O1lIOIO0lIIlO01&l0IO1IlO01O01Il)|
(IO01lI01lOI1lO0&l0IO1IlO01O01Il)|
(I1lO0lIO10OlI1O&l0IO1IlO01O01Il)|
(OIl01IlO01IIO0l&l0IO1IlO01O01Il)|
(I1lO0IOIl0OI01l&l0IO1IlO01O01Il)|
(lO10IIIO0lIlO01&l0IO1IlO01O01Il)|
(l10IOIOIl0IlI0O&l0IO1IlO01O01Il)|
(O1lIOOIl01lIO10&IO01ll10IOO01Il)|
IlO01IO0lIO01Il;assign IlI0OOlI01l0IO1
=OOl1IIO0lIO01Il|IIO0lOIl01l10IO;dff IIO01lIOIl0I1lO0(lO10IlO10IlO10I,l10IOO01Ill0IO1,clk,hreset_b,1'b1);assign O01IlOOIl1IOIl0
=(IIO0lIlI0OIIO0l&OIl01IlO01IO0lI)?IO01lI01lOl10IO[1:0]:
(lO10IIlO01OI01l)?2'b00:OIl01O01IlIlI0O;assign l0IO1O01Ill0IO1
=(IOIl0IO01lOIl01[25:22]<=4'b1001)?lIO10O01IlIlI0O:
(IOIl0IO01lOIl01[25:22]==4'b1010)?lO10IOOIl1IOIl0:
(IOIl0IO01lOIl01[25:22]==4'b1011)?O01IllO10IIIO0l:
(IOIl0IO01lOIl01[25:22]==4'b1100)?OlI01O1lIOIO0lI:
(IOIl0IO01lOIl01[25:22]==4'b1101)?IlI0Ol0IO1O1lIO:IOIl0IIO0lOlI1O;dff IIlI0Ol0IO1O01Il
(OOIl1IOIl0IO01l,IlO01I01lOI01lO,clk,hreset_b,1'b1);assign IO0lIOlI1OlIO10=IOIl0IO01lOIl01[86]&IIO0lOIl01l0IO1;assign OI01ll0IO1IOIl0[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[1];assign l0IO1I01lOIO0lI
=((IlI0OO1lIOIO0lI==2'b00)&(IO01ll10IOlIO10>=12'h004))?4'b0000:
((IlI0OO1lIOIO0lI==2'b01)&(IO01ll10IOlIO10>=12'h003))?4'b0001:
((IlI0OO1lIOIO0lI==2'b10)&(IO01ll10IOlIO10>=12'h002))?4'b0011:
((IlI0OO1lIOIO0lI==2'b11)&(IO01ll10IOlIO10>=12'h001))?4'b0111:
((IlI0OO1lIOIO0lI==2'b00)&(IO01ll10IOlIO10==12'h003))?4'b1000:
((IlI0OO1lIOIO0lI==2'b01)&(IO01ll10IOlIO10==12'h002))?4'b1001:
((IlI0OO1lIOIO0lI==2'b10)&(IO01ll10IOlIO10==12'h001))?4'b1011:
((IlI0OO1lIOIO0lI==2'b00)&(IO01ll10IOlIO10==12'h002))?4'b1100:
((IlI0OO1lIOIO0lI==2'b01)&(IO01ll10IOlIO10==12'h001))?4'b1101:
((IlI0OO1lIOIO0lI==2'b00)&(IO01ll10IOlIO10==12'h001))?4'b1110:4'b1111;assign IO01ll10IOO01Il
=OIl01O1lIOOlI01&OOl1IIO0lIOIl01&~O1lIOOlI01IlI0O&~OOl1IOIl01IIO0l;assign OlI01lO10IIOIl0
=(O01IlIIO0ll10IO&OlI01O01IlOOIl1)|(~l0IO1l0IO1IlO01&OIl01OOIl1IlI0O);assign I01lOOI01llIO10
=IO0lIOIl01I01lO&OIl01OOIl1IIO0l&OOIl1l10IOI1lO0&l10IOIlO01lO10I;dffe Il10IOlIO10OlI1O
(IO0lIl0IO1OlI1O[1],O1lIOIIO0lOOIl1,clk,hreset_b,1'b1,IOIl0O1lIOO1lIO);assign O1lIOlIO10IlO01
=(IOIl0IO01lOIl01[25:22]==4'b0000)?32'h00000001:
(IOIl0IO01lOIl01[25:22]==4'b0001)?32'h00000002:
(IOIl0IO01lOIl01[25:22]==4'b0010)?32'h00000004:
(IOIl0IO01lOIl01[25:22]==4'b0011)?32'h00000008:
(IOIl0IO01lOIl01[25:22]==4'b0100)?32'h00000010:
(IOIl0IO01lOIl01[25:22]==4'b0101)?32'h00000020:
(IOIl0IO01lOIl01[25:22]==4'b0110)?32'h00000040:
(IOIl0IO01lOIl01[25:22]==4'b0111)?32'h00000080:
(IOIl0IO01lOIl01[25:22]==4'b1000)?32'h00000100:
(IOIl0IO01lOIl01[25:22]==4'b1001)?32'h00000200:
(IOIl0IO01lOIl01[25:22]==4'b1010)?32'h00000400:
(IOIl0IO01lOIl01[25:22]==4'b1011)?32'h00000800:
(IOIl0IO01lOIl01[25:22]==4'b1100)?32'h00001000:
(IOIl0IO01lOIl01[25:22]==4'b1101)?32'h00002000:32'h00004000;assign IO01lIOIl0lIO10
=(OOIl1IO0lIl10IO==8'h01)?1'b1:1'b0;assign OOl1IlIO10OI01l
=l0IO1IlO01lO10I[31]|I01lOO01IlI1lO0|
l0IO1IlO01lO10I[29]|l0IO1IlO01lO10I[28]|
(sel_mmc&l0IO1IlO01lO10I[7]);assign I1lO0OlI1OOOl1I[4]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[3];dff10 IIlO01IO01lOlI1O(size,lIO10lO10II1lO0,clk,1'b1,1'b1);assign O01IlI1lO0IO01l
=lO10IIIO0lIlO01&(l0IO1O01IllO10I|OOIl1OlI01O1lIO|OlI01I1lO0l10IO|IOIl0IO01llIO10|OOIl1IO01lOlI1O);dff IIO01lI01lOIlO01
(OI01lOlI01IlO01,IlI0OOOl1IIO01l,clk,hreset_b,1'b1);dff IIOIl0l0IO1OI01l(OI01lIIO0lOIl01,IOIl0I1lO0O01Il,clk,1'b1,hreset_b);assign lIO10lO10IlO10I[17]
=IlO01OI01lI1lO0;assign OOl1II01lOIO01l
=(~l10IOI01lOO01Il&OI01lO1lIOO1lIO&I1lO0IO0lIIO0lI&IO0lIlIO10IO01l)|
(~l10IOI01lOO01Il&OlI1OIOIl0IlO01&~IO0lIlIO10IO01l);assign OIl01OI01lOOl1I
=l10IOIO0lIOOl1I&lO10IIIO0lIO01l[2];assign IlO01IOIl0l10IO=(~I1lO0IO0lIIO0lI|~OlI1OOOl1IOI01l)&I01lOOlI1OOOl1I;assign OIl01l0IO1I01lO[6]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[5];assign lIO10OI01lOI01l[10]
=(O01IlO01IlIOIl0==I01lOl10IOOIl01)?1'b1:1'b0;assign IlO01OIl01OOIl1
=OOl1IIO0lIOlI01|
IIO0lIlI0OIIO0l|
(OOIl1OOl1IOlI1O&~(~I1lO0IO0lIIO0lI|IlI0OI1lO0lO10I))|
(lIO10l0IO1I01lO&IIO0lOlI1OI01lO);dff23 Il0IO1IO0lIOlI1O
(l0IO1lO10II01lO,lIO10O1lIOI1lO0,clk,hreset_b,1'b1);assign IO0lIIlI0OIlI0O=lIO10l10IOOOIl1&~rdy_b&error;assign I1lO0l10IOIO0lI[19]
=1'b0;assign IO0lIIO0lIIlO01=(~l10IOI01lOO01Il&OI01llO10IOlI1O&~lO10Il0IO1l0IO1&IlI0OlO10IIO0lI[2]);assign IOIl0IlI0OlO10I[0]
=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&lIO10IlO01OIl01&ecsd_a[0]);assign IlI0OO1lIOO1lIO
=(sel_mmc)?{IlO01IO0lIOlI01,1'b1,IO01lI01lOl10IO[14:8],O1lIOOOl1IOI01l}:
32'h00000000;assign IlI0OIlI0Ol0IO1[8]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[7];assign lIO10OOIl1l0IO1=1'b0;dff IOI01lO01IlOlI1O
(IIO0lIlI0OIIO0l,O1lIOIO01lIO0lI,clk,hreset_b,1'b1);assign l0IO1OOIl1l10IO
=(IlO01l10IOlIO10|OlI1OIlI0OOOIl1)?IlO01IO0lIOIl01:OlI01l0IO1lO10I;dff IO01Ill0IO1I01lO
(IlO01OIl01IIO0l,OlI1OOlI01IlI0O,clk,hreset_b,1'b1);dff IOlI01I1lO0IO01l
(IO01lIO0lIIIO0l[13],I1lO0l10IOIO0lI[13],clk,hreset_b,1'b1);dff IIO01lOlI01OOl1I
(IlI0OI1lO0OlI01,IOIl0IlI0OOI01l,clk,hreset_b,1'b1);dff IO1lIOOOl1IlIO10
(IOIl0l0IO1IOIl0[4],IIO0lIIO0lIIO0l[4],clk,hreset_b,1'b1);dff IOlI1OOOl1IO01Il
(IO0lIOlI01OlI01,IIO0lIO01lO01Il,clk,hreset_b,1'b1);assign O1lIOOOl1IOIl01[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[9];assign IIO0lI1lO0IOIl0
=((lIO10OI01lIIO0l==1'b0)&(l10IOIlO01lIO10==6'h06))?1'b1:1'b0;assign OIl01IlO01OlI1O
=(I01lOIOIl0OI01l&IO0lIlIO10IO01l)?{IO0lIIlI0OO1lIO[31:28],IO0lIIlI0OO1lIO[23:20]}:
(I01lOOOIl1IO01l[2:0]==3'b001)?{IO0lIIlI0OO1lIO[15:12],IO0lIIlI0OO1lIO[7:4]}:
(I01lOOOIl1IO01l[2:0]==3'b010)?{IO01lO01IlIlO01[31:28],IO01lO01IlIlO01[23:20]}:
(I01lOOOIl1IO01l[2:0]==3'b011)?{IO01lO01IlIlO01[15:12],IO01lO01IlIlO01[7:4]}:
(I01lOOOIl1IO01l[2:0]==3'b100)?{OOl1IOlI1OOlI01[31:28],OOl1IOlI1OOlI01[23:20]}:
(I01lOOOIl1IO01l[2:0]==3'b101)?{OOl1IOlI1OOlI01[15:12],OOl1IOlI1OOlI01[7:4]}:
(I01lOOOIl1IO01l[2:0]==3'b110)?{IO01llIO10OI01l[31:28],IO01llIO10OI01l[23:20]}:
{IO01llIO10OI01l[15:12],IO01llIO10OI01l[7:4]};assign O01IlIIO0llO10I
=IIO0lIlI0OIIO0l&O01IlO01IlO1lIO;assign l0IO1IlO01lO10I[18]=(I01lOIOIl0OI01l&OOl1Il10IOI01lO&O1lIOOOl1IOlI01);dff IO01IlI01lOOOIl1
(OIl01O1lIOO01Il,OlI01l0IO1OlI01,clk,hreset_b,1'b1);assign ecsd_s=O1lIOI1lO0IO0lI;dff IlIO10IOIl0IO0lI
(l10IOO1lIOIO01l,IO01lOlI1OOOl1I,clk,hreset_b,1'b1);assign IO01lO01IlIlO01[15:12]
={IO0lIOlI01lO10I[9],OI01lI1lO0l10IO[9],lIO10O1lIOIO01l[9],I01lOOIl01OOIl1[9]};assign lO10IOI01lO1lIO
=(l10IOIlO01lIO10==6'h1b)?1'b1:1'b0;dff IlIO10I01lOOI01l(OI01lI1lO0O01Il,OIl01l0IO1lO10I,clk,hreset_b,1'b1);assign OlI01IO01lIO01l
=IIO0lIlI0OIIO0l&OlI1OIO01lIO0lI;dff II01lOI01lOI1lO0(OI01lIIO0lO01Il[9],IOIl0I1lO0OlI01[9],clk,1'b1,hreset_b);dff IIOIl0OlI01IO01l
(I1lO0l10IOIIO0l,l10IOIOIl0IO0lI,clk,hreset_b,1'b1);assign IO0lII1lO0IOIl0
={~IlI0Ol0IO1OI01l[15],~IlI0Ol0IO1OI01l[14],~IlI0Ol0IO1OI01l[13],~IlI0Ol0IO1OI01l[12],
~IlI0Ol0IO1OI01l[11],~IlI0Ol0IO1OI01l[10],~IlI0Ol0IO1OI01l[9],~IlI0Ol0IO1OI01l[8]};assign l0IO1OI01lOlI01
=1'b0;assign IO01llIO10OI01l[3:0]={O01IlO1lIOIlI0O[0],l0IO1O01IlO01Il[0],IO01lI01lOlIO10[0],O1lIOIO0lII1lO0[0]};assign IlO01OOl1IOOl1I
=(l10IOIlO01lIO10==6'h39)?1'b1:1'b0;assign OOIl1l10IOl10IO[7]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[6];assign OOIl1OlI01IIO0l
=OlI01I1lO0I01lO&IIO0lOlI01l0IO1;dff IIO0lII1lO0IlI0O(O1lIOOlI1Ol0IO1,IO0lIOIl01l10IO,clk,hreset_b,1'b1);assign OlI01OOIl1OOIl1
=(O1lIOOIl01OIl01[2:0]==3'b001)?1'b1:1'b0;assign I1lO0IO0lIIIO0l
=IlI0Ol0IO1IOIl0|
(~OOIl1OOl1IIIO0l&
(IO0lIOOl1IOIl01|OlI1OOIl01O01Il|(IlO01lIO10OI01l&~IOIl0IO01lOIl01[21])|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|OOl1IOlI01OOIl1));assign l10IOl10IOIOIl0
=(l10IOI01lOO01Il)?2'b0:
(I01lOlIO10OlI1O&~IlO01OlI1OO1lIO&I1lO0I01lOOIl01&~IO01lIO0lIIIO0l[16])?I1lO0O01IlIO01l[9:8]:
IOIl0IO01lOIl01[9:8];assign IO01lIlO01IlO01
=(~IOIl0IO01ll0IO1&I01lOIOIl0OI01l&O01IlO01IlOlI1O)|
(IOIl0IO01ll0IO1&I01lOIOIl0OI01l&IO0lIlIO10IO01l);assign lO10Il0IO1I1lO0
=(~lO10IIlO01OI01l&I01lOOOIl1IlO01&~IIO0lOlI01OIl01&OI01lIlI0OlIO10)|
(~lO10IIlO01OI01l&l0IO1O1lIOI01lO&~IO0lIOOl1IO01Il);assign IO01llIO10O1lIO
=~I1lO0IO0lIIO0lI&(lIO10OOIl1OIl01|OIl01lO10IO01Il|IlI0OIIO0lIlI0O|I01lOOlI1OOOl1I|IOIl0O1lIOOOl1I);assign I01lOOI01llO10I[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[8];dff IIlI0OO01IlOOIl1
(lIO10l10IOOlI1O,lO10IIOIl0OOIl1,clk,hreset_b,1'b1);assign IO0lIl0IO1OOl1I
=(O1lIOOIl01lIO10&IlO01OlI1OIO0lI)|
(IlI0OlO10IOlI1O&~l10IOI01lOOlI01&~(OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&OIl01lO10IO01Il&~IO01lIO0lIOlI01));assign IIO0lIO01llO10I
=((OI01lIO01lI1lO0|O1lIOOlI1OlO10I)&
((I1lO0IlO01lIO10&IOIl0OlI1OIlO01&IIO0lOlI01lIO10)|
(l0IO1OOIl1OIl01&IOIl0OlI1OIlO01&~IIO0lOlI01lIO10)));assign OlI01l0IO1lIO10
=(OOl1IIO0lIO01Il&IlI0OI1lO0OIl01)?{OIl01O01IlIlI0O,IlI0OOlI01I01lO[5:0]}:
(IO0lIIO01lOlI01)?IO0lIIO01lOI01l:
(OlI1OOOl1IIlI0O)?OlI1OI1lO0OOl1I:
(IIO0lIO01lOIl01)?l10IOOI01llO10I:
(OOl1IOlI1OIlI0O)?IOIl0IIO0lIlI0O:
(I1lO0IO0lIIO0lI&(l10IOlO10IIlO01|l0IO1O1lIOIO01l))?OI01lIlI0OlO10I:
O1lIOOlI01O01Il;assign IOIl0IO01lOIl01[20:17]
=4'b0000;assign OI01llO10IIIO0l=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&OIl01IlO01IO0lI&IO01lI01lOl10IO[0];assign OlI01l0IO1O01Il
=(IO0lIIIO0lOOl1I&~O1lIOlIO10l0IO1&lO10IIIO0lIO01l[3])|
(IO01lOI01lI1lO0&O1lIOIO0lII01lO&~O1lIOOIl01lO10I&~lO10IIIO0lIO01l[0])|
(l10IOO01Ill0IO1&O1lIOIO0lII01lO)|
(OIl01O1lIOOIl01&~I01lOI01lOlO10I&~IIO0lOlI1Ol10IO);assign OlI1OlIO10lO10I
=IIO0lOlI01lO10I|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO;assign lIO10OOIl1OlI01[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[10];dff Il10IOI01lOlIO10
(IO01llIO10IlI0O,I01lOIO0lIIOIl0,clk,hreset_b,1'b1);dff IIlI0OIlI0Ol10IO(lO10IIIO0lIlO01,OlI01IlI0OI01lO,clk,hreset_b,1'b1);assign lO10II01lOOlI1O
=(O01IlIIO0ll10IO&OlI1OOIl01O01Il)|(~l0IO1l0IO1IlO01&l0IO1IOIl0O1lIO);assign IO0lIOOl1IOlI01
=(IOIl0I1lO0IlI0O[47:0]!=IOIl0IO01lOIl01[63:16])?1'b1:1'b0;assign OIl01lO10IOIl01
=(((IlI0OIlI0OOlI01==1'b1)&(O1lIOOIl01OIl01==15'h0180))|
((IlI0OIlI0OOlI01==1'b0)&(O1lIOOIl01OIl01==15'h060)))?1'b1:1'b0;assign OOl1IOI01lIO01l
=(IlO01lIO10IlI0O[4]!=I1lO0IOIl0IOIl0[4])?1'b1:1'b0;assign O01IlI1lO0I01lO=IlI0OO1lIOOlI1O&O1lIOOOl1IIOIl0;assign IIO0lOIl01IO01l
={IlI0OOOl1IIlO01[30:0],cmdin};assign OI01ll0IO1IOIl0[13]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[12];assign IOIl0OOl1II1lO0
=~OOl1Il10IOlIO10&
(OI01lOlI01IlO01|IIO0lOIl01I01lO|OlI1OlIO10l10IO|IlO01l10IOlIO10|O01Ill0IO1lIO10);assign OlI1OOlI1OlO10I
=O1lIOOIl01lIO10&(l0IO1O01IllO10I|
(sel_mmc&lIO10OOIl1OIl01)|
(~sel_mmc&(OOl1IOOl1IOlI1O|OOIl1IO01lOlI1O|IOIl0O1lIOOOl1I)));dff IO01IlO01IlIlI0O
(OIl01l0IO1l10IO,O01IlIIO0ll0IO1,clk,hreset_b,1'b1);assign l0IO1OI01lIlI0O
=(l10IOI01lOO01Il|O1lIOIO01lOlI01|IO0lIIlI0OIlI0O)?11'b00000000000:
(OOl1IOlI01OOl1I&~lO10IOI01lOOIl1)?(l10IOI01lOOI01l+11'b00000000001):
(lO10IOI01lOOIl1&~OOl1IOlI01OOl1I)?(l10IOI01lOOI01l-11'b00000000001):
l10IOI01lOOI01l;assign O01IlIlI0OI1lO0
=(I1lO0IlO01lIO10&IOIl0OlI1OIlO01);assign IO0lIOlI1Ol0IO1
=l10IOI01lOO01Il|
(IIO0lOIl01l10IO&~lO10IOOIl1OI01l&~IlI0Ol0IO1IIO0l&~OlI01O1lIOIOIl0&~I1lO0OI01lOIl01&~OOIl1I1lO0OOl1I)|
(OI01lIO01lI1lO0&(lO10Il0IO1l0IO1|l10IOIlO01I1lO0))|
(OIl01O01IlIO0lI&~lIO10IlO01OI01l)|
(OI01llO10IOlI1O&lO10Il0IO1l0IO1)|
(IIO0ll0IO1OOl1I&lO10Il0IO1l0IO1)|
(OlI1Ol10IOIO01l&lO10Il0IO1l0IO1)|
(IlO01I01lOI1lO0&lO10Il0IO1l0IO1)|
(l0IO1OOIl1lO10I&IO0lIlIO10IO01l)|
OIl01O1lIOO01Il|
(I1lO0I01lOOlI01&((lO10Il0IO1l0IO1&O01Ill0IO1lO10I)|l10IOIlO01I1lO0))|
(OIl01OOIl1IIO0l&lO10Il0IO1l0IO1&O01Ill0IO1lO10I)|
(OIl01OOIl1IIO0l&~lO10Il0IO1l0IO1&IO0lIlIO10IO01l&OIl01OI01lOOIl1)|
(OI01lO1lIOO1lIO&lO10Il0IO1l0IO1&O01Ill0IO1lO10I)|
(IIO0lIIO0lOOIl1&lO10Il0IO1l0IO1&(O01Ill0IO1lO10I|(OIl01IlO01IOIl0&I01lOIlO01I01lO)))|
(IlO01OI01lI01lO&~IO0lIlIO10IO01l&lO10Il0IO1l0IO1&(O01Ill0IO1lO10I|(OIl01IlO01IOIl0&I01lOIlO01I01lO)))|
(IlO01OI01lI01lO&IO0lIlIO10IO01l&(~lIO10IlO01OI01l|lO10Il0IO1l0IO1)&(OIl01IlO01IOIl0&I01lOIlO01I01lO))|
(I1lO0O01Ill10IO&O01Ill0IO1lO10I&IO0lIlIO10IO01l)|
(lIO10lO10IlIO10&IOIl0I1lO0IlI0O[0]&(IlO01OI01lIO01l|(OIl01IlO01IOIl0&~OIl01O01IlIIO0l)))|
(IO0lIIO01lIlI0O&(OIl01IlO01IOIl0&I01lOIlO01I01lO))|
l0IO1l10IOOOl1I;assign OlI1OIlI0OOlI1O
=(OOIl1IO0lIl10IO==8'h0c)?1'b1:1'b0;assign OlI1OlIO10I1lO0
=((lIO10l0IO1I01lO&~IIO0lOlI1OI01lO)|OIl01O1lIOOlI01)?32'hffffffff:
(IIO0llIO10IlO01&~IlI0OO1lIOOOl1I)?{2'b00,l10IOlIO10OOl1I,24'hffffff}:
(IlI0OO1lIOOOl1I&IOIl0OlI1OIlO01&~IO01lIO0lIOI01l)?IO01lOIl01OlI1O:
(l0IO1IOIl0OlI1O&IO01lIO0lIOI01l)?lO10Il0IO1IO01l:
(OlI1Ol10IOI01lO&IOIl0OlI1OIlO01)?{OOIl1OlI01IO0lI,1'b1,24'hffffff}:
(l10IOO01IllO10I&~I1lO0IlO01lIO10)?IlI0OOlI01IO01l:
(I1lO0IlO01lIO10&IOIl0OlI1OIlO01&~IIO0lOlI01lIO10)?lIO10IOIl0OlI1O:
{IO0lIOlI1OI01lO[30:0],1'b1};assign I1lO0OlI1OOOl1I[15]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[14];assign I1lO0IOIl0O01Il
=(l10IOI01lOO01Il|O1lIOIO01lOlI01|lIO10O01IlOIl01)?11'b00000000000:
(l10IOO01Ill0IO1&O1lIOIO0lII01lO)?O01IlO01IlIOIl0:
(lIO10l10IOOOIl1&~lO10II01lOOOIl1&I1lO0OOIl1I01lO&~error&IOIl0OOl1II1lO0)?(I01lOl10IOOIl01+11'b00000000001):
(lIO10l10IOOOIl1&~lO10II01lOOOIl1&O1lIOIO01lIOIl0)?(I01lOl10IOOIl01-11'b00000000001):
I01lOl10IOOIl01;assign OOIl1lIO10O01Il
=(O1lIOOlI1OOIl01&(~IOIl0IIO0lIO0lI|IlO01IO0lIO01Il))|
(O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&~I1lO0IO0lIIO0lI&(~IlO01IOIl0lIO10|lO10IO1lIOlIO10))|
(OIl01O1lIOOlI01&~I01lOIO0lIOlI1O)|
(IO01lOlI1OOOl1I&IlO01IO0lIIlI0O)|
(OlI01IlI0Ol0IO1&IlO01IO0lIIlI0O)|
(IOIl0IO01ll10IO&IOIl0OlI1OIlO01)|
(I1lO0IlO01lIO10&IIO0lOlI01lIO10&IOIl0OlI1OIlO01)|
(l0IO1OOIl1OIl01&IOIl0OlI1OIlO01)|
(OlI1Ol10IOI01lO&IOIl0OlI1OIlO01&IO01lIO0lIOI01l)|
(IlO01I01lOl10IO&IOIl0OlI1OIlO01);dff IOlI1OIO01lOI01l
(I1lO0O01IlI01lO,l10IOOOIl1I1lO0,clk,hreset_b,1'b1);assign I1lO0OI01lOlI01=(IlO01IOIl0OIl01==16'h0000)?1'b1:1'b0;assign lIO10lO10IlO10I[31]
=I01lOIlO01l10IO|O01IlIlI0OI1lO0|OlI1OOOl1IIO0lI;assign IlI0OOlI01l10IO
=(~l10IOI01lOO01Il&OIl01I1lO0IO01l)|
(~l10IOI01lOO01Il&OI01lIO01lI1lO0&~lO10Il0IO1l0IO1&~l10IOIlO01I1lO0&
(O1lIOlIO10I1lO0|~IO0lII1lO0O1lIO|I01lOOI01lI01lO|
~(~I1lO0IO0lIIO0lI|(IO0lIIIO0lOlI1O&OlI01IIO0llIO10))))|
(~l10IOI01lOO01Il&OI01llO10IOlI1O&~lO10Il0IO1l0IO1&~IlI0OlO10IIO0lI[2])|
(~l10IOI01lOO01Il&IlO01I01lOI1lO0&~lO10Il0IO1l0IO1&((~IO0lII1lO0O1lIO&OI01lIIO0lOI01l[2])|I01lOOI01lI01lO));assign lO10II01lOIO0lI
=(IO01lI01lOl10IO[25:24]==2'b01)?1'b1:1'b0;assign IlO01lIO10OlI01
=l0IO1O01IllO10I|lIO10OOIl1OIl01|IIO0lI1lO0IOIl0|IO01lOIl01OOIl1|l10IOlO10IIlO01|l0IO1O1lIOIO01l|OIl01IIO0lI1lO0|
IIO0lOlI01lO10I|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|IO01lIO0lIIlI0O|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lO10IOI01lO1lIO|
O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I|
lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOIl1IO01lOlI1O|OOl1IOlI01OOIl1|I1lO0OOIl1IO01l|
OlI01OOIl1OlI1O|IlI0OlO10IOOIl1|IOIl0O1lIOOOl1I|IO0lIlIO10IlO01|O1lIOIO0lIIO01l|
OlI1OOOl1IOI01l;assign IlI0OIlI0Ol0IO1[0]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IIO0lI1lO0IO0lI[6]^OI01lI1lO0l10IO[15];assign OOl1Il10IOI01lO
=(IO0lIIIO0lO1lIO==10'b0000000000)?1'b1:1'b0;dff IOOl1IOlI1OO01Il(O1lIOOlI1OOIl01,OOIl1lIO10O01Il,clk,1'b1,hreset_b);dff7 IIO0lIOOl1Il10IO
(O1lIOIO01lIIO0l,OlI1OOlI01IO0lI,clk,1'b1,hreset_b);assign l10IOI01lOOIl01=12'h004-{10'h000,IlI0OO1lIOIO0lI};assign I1lO0l10IOIO0lI[31]
=l0IO1IlO01lO10I[31]|(~lIO10lO10IlO10I[31]&IO01lIO0lIIIO0l[31]);dff IO01IlOOIl1OI01l
(OIl01OOIl1IIO0l,OlI01lO10IIO0lI,clk,hreset_b,1'b1);assign IIO0lIIO0lIIO0l[1]
=IOIl0IlI0OlO10I[1]|(~OOl1IOlI01O1lIO[1]&IOIl0l0IO1IOIl0[1]);assign OOIl1OlI01IO0lI
=(lO10IOI01lIO0lI|(~sel_mmc&OlI01O01IlOlI1O))?7'b1111111:OlI01OOIl1OOl1I;assign O1lIOOOl1IOIl01[2]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[1];dff IlO10IO01IlOIl01
(l0IO1OOIl1OIl01,lO10IlO10IO01Il,clk,hreset_b,1'b1);assign l10IOO1lIOIlO01[4]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[4]);assign O01IllO10IIOIl0
=IO01lOlI1OOOl1I&(IIO0lOlI1OIO01l|I1lO0OI01llO10I);dff IIO01lIO0lIO01Il
(IO01lIO0lIIIO0l[24],I1lO0l10IOIO0lI[24],clk,hreset_b,1'b1);dff IOlI1OOlI01OlI01
(l0IO1OI01lIOIl0,lO10IIlO01IIO0l,clk,hreset_b,1'b1);dffe II01lOIO0lIOlI01
(IO01lOOl1IOOl1I[3],I1lO0O01IlIlO01[3],clk,hreset_b,1'b1,lIO10lO10II01lO);dff IIlO01OlI1OOI01l
(OlI1OOlI1OOlI01,OlI1OlIO10I1lO0[31],clk,1'b1,hreset_b);assign IO0lIIlI0OO1lIO[15:12]
={IO0lIOlI01lO10I[13],OI01lI1lO0l10IO[13],lIO10O1lIOIO01l[13],I01lOOIl01OOIl1[13]};assign IO0lIOOl1IOIl01
=(l10IOIlO01lIO10==6'h11)?1'b1:1'b0;dff4 IIlO01lIO10lO10I(dtout[3:0],IlI0OIO01ll0IO1[3:0],clk,1'b1,hreset_b);assign IOIl0IIO0lIOIl0
=OI01lIIO0lOIl01&O1lIOOOl1IIlI0O;assign IO01lIO0lIIIO0l[4]=1'b0;assign IlI0OOlI01I01lO
=
(IO0lIOIl01I01lO)?OlI01l0IO1lIO10:
1'b0;assign IIO0lOIl01IlO01=(IO01lI01lOl10IO[15:8]>=8'h02)?1'b1:1'b0;assign IlI0OOIl01IlO01
=(I01lOIOIl0IlI0O|l0IO1OI01lIIO0l)?IlI0OOOl1IIlO01[0]:IO0lIOlI1OI01lO[31];assign OOl1IOlI1OOlI01[3:0]
={O01IlO1lIOIlI0O[4],l0IO1O01IlO01Il[4],IO01lI01lOlIO10[4],O1lIOIO0lII1lO0[4]};assign O01IllO10IOI01l
=(l10IOIlO01lIO10==6'h27)?1'b1:1'b0;assign IIO0lI1lO0IO0lI
=(OOl1IIO0lIO01Il|I01lOIOIl0OI01l)?I1lO0lIO10OOl1I[7:0]:IOIl0I1lO0IlI0O[7:0];assign OlI1OOIl01OlI01
=~rdy_b&(IOIl0OIl01IlO01|OOl1Il10IOl10IO);assign IOIl0IlI0OOIl01=IO0lIIO01lO01Il&~OI01lIIO0lOI01l[3];dff IO1lIOOIl01I1lO0
(IlI0OIlI0OOlI01,IIO0lIO01lOI01l,clk,1'b1,1'b1);assign IlO01l10IOlO10I
=OOIl1OlI1OOlI01|IlO01lIO10OI01l|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|
lO10IOI01lO1lIO|IlI0Ol0IO1IOIl0|(OOl1IOlI01OOIl1&~IO01lI01lOl10IO[0]);dff IIOIl0OOl1IIlO01
(IO01lIO0lIOlI01,I1lO0l10IOOI01l,clk,hreset_b,1'b1);dff IIlO01IOIl0IO01l(OOIl1OlI01OOIl1,OOl1IOOl1IOOl1I,clk,hreset_b,1'b1);assign IO0lIIlI0OIIO0l
=IIO0lI1lO0IOIl0&sel_mmc;assign I01lOOI01llO10I[1]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[0];assign OlI01O01IlOOl1I
=(OOIl1l10IOI01lO[1:0]==2'b00)?drd[7:0]:
(OOIl1l10IOI01lO[1:0]==2'b01)?drd[15:8]:
(OOIl1l10IOI01lO[1:0]==2'b10)?drd[23:16]:drd[31:24];assign OlI01IO01lI01lO[127:24]
=cid[127:24];assign O1lIOOOl1IO01Il=lIO10l10IOOOIl1&~rdy_b&error;assign OOl1IIO0lIl0IO1=(IlO01IOIl0OIl01!=16'h0001)?1'b1:1'b0;assign IOIl0IO01lOIl01[79]
=(OOIl1OOl1IIIO0l)?1'b0:1'b1;assign lO10IOI01lOOl1I=(OOIl1OlI1OOI01l>=IO01lIOIl0OIl01)?1'b1:1'b0;assign l0IO1IlO01lO10I[28]
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&
((OlI1OIO01lO1lIO&(IIO0lOlI1OIO01l|I1lO0OI01llO10I|lO10IOOIl1OlI01))|
(OOl1IOOl1IOOIl1&(IOIl0OIl01IlO01|OOl1Il10IOl10IO|lO10IOOIl1OlI01))|
(I01lOOOIl1IlO01&(IOIl0OIl01IlO01|IIO0lOlI1OIO01l|OOl1Il10IOl10IO|I1lO0OI01llO10I)));assign OIl01IIO0ll0IO1
=1'b0;assign lIO10OOIl1OlI01[3]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[2];assign IIO0lOlI01OlI01
=(l10IOI01lOO01Il)?32'h00000000:
((OI01lIIO0lOIl01&(IOIl0IIO0lO1lIO|IO0lII1lO0OlI1O))|IOIl0I1lO0OIl01)?OOIl1l10IOI01lO:
(OI01lIIO0lOIl01&l0IO1IlO01OlI01)?O01IlIlO01OOl1I:
((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~lO10II01lOOOIl1&OIl01IlO01O1lIO)?IOIl0IO01lO01Il:
l0IO1lO10II1lO0;dff IIlO01OOl1IO1lIO
(O1lIOOIl01lIO10,OOl1IlIO10OIl01,clk,1'b1,hreset_b);assign O01IlIIO0ll10IO
=IIO0lOIl01l10IO&(lO10IOOIl1OI01l|OlI01O1lIOIOIl0|IlI0Ol0IO1IIO0l|I1lO0OI01lOIl01);assign OIl01O1lIOl0IO1
=(lIO10I01lOIO0lI)?13'h000f:13'h0000;dffe IIIO0lI1lO0OlI01(dsr[11],IO01lI01lOl10IO[27],clk,hreset_b,1'b1,IlI0OOOl1II1lO0);assign lO10IOOIl1IOIl0
=(IlO01lIO10IlI0O[10]!=I1lO0IOIl0IOIl0[10])?1'b1:1'b0;dff IO1lIOIlI0OIlI0O(OIl01O1lIOOIl01,OlI01l0IO1O01Il,clk,hreset_b,1'b1);assign l10IOOI01lIlI0O
=IOIl0IO01lOIl01[90]&I1lO0I01lOOI01l;assign OI01ll0IO1IOIl0[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O01IlO1lIOIlI0O[4]^IIO0lI1lO0IO0lI[3]^O01IlO1lIOIlI0O[15];dff4 IO01IlOOIl1OlI01
(be_b,OlI1OIO0lIlIO10,clk,1'b1,1'b1);assign l10IOI01lOOlI01=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&l0IO1O01IllO10I;assign OOl1IIO01lOOl1I
=(O01IlIIO0ll10IO&IlI0Ol0IO1IOIl0)|(~l0IO1l0IO1IlO01&OlI1OIlI0OOOIl1);assign l10IOlO10II1lO0
=OOl1IOIl01OI01l|(~IIO0lOIl01l10IO&I01lOOOIl1I01lO);assign OlI01OOIl1IIO0l=8'b00000000;assign OOl1IIOIl0IO01l
=(I1lO0l10IOIOIl0|l10IOIOIl0IIO0l)&
((~IOIl0IO01lOIl01[21]&(~I01lOOlI1OOlI1O|~OOl1IOOl1IIO0lI))|IO01lI01lOI01lO);assign lIO10IlO01O01Il
=(OOIl1IO0lIl10IO==8'h04)?1'b1:1'b0;assign l0IO1IlO01lO10I[23]=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&~IO0lIlIO10I01lO;assign I1lO0OlI1OOOl1I[7]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:I01lOOIl01OOIl1[6];assign IO0lIOIl01lO10I=(OI01lIIO0lOIl01&OIl01l0IO1lIO10);assign I01lOlIO10IIO0l
=lO10IIlO01OI01l|l0IO1OI01lOlI01|(~OlI1OOOl1IIOIl0[31]&IlO01OlI1OIOIl0);dff Il0IO1O01IlI1lO0
(IlO01l10IOlIO10,IO01lIOIl0lO10I,clk,hreset_b,1'b1);dff IOlI1OIlI0OIIO0l(I1lO0lIO10O1lIO,l10IOIO0lIOlI1O,clk,hreset_b,1'b1);assign lIO10lO10IlO10I[22]
=I1lO0O01Ill0IO1|O01IlIlI0OI1lO0;assign lO10IO1lIOlO10I=(~l10IOI01lOO01Il&I1lO0I01lOOlI01&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I);assign l0IO1IlO01lO10I[24]
=((IO0lIIIO0lOOl1I&O1lIOlIO10l0IO1)|O1lIOOIl01lO10I);dff II1lO0OIl01OOl1I(lO10IOI01lIO0lI,O01IlIlO01O1lIO,clk,hreset_b,1'b1);assign OIl01l0IO1I01lO[9]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[8];assign OIl01IlO01IlI0O=(lIO10OI01lOI01l==11'b00000000000)?1'b1:1'b0;assign IlI0OIO01llIO10
=(lIO10l0IO1I01lO&~IIO0lOlI1OI01lO)|
(OlI01IlI0Ol0IO1&~IIO0lIO01lO01Il&~IlO01IO0lIIlI0O);assign IIO0lIlI0OIOIl0[127:8]
=(l10IOI01lOO01Il|IlO01l10IOOIl01)?120'h000000000000000000000000000000:
((OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)&(l10IOlIO10OOIl1|OIl01OI01lOOIl1))?IOIl0I1lO0IlI0O[119:0]:
((OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)&IlI0OIlI0OOlI01)?IOIl0I1lO0IlI0O[123:4]:
((OIl01OOIl1IIO0l|OI01lO1lIOO1lIO)&~IlI0OIlI0OOlI01)?IOIl0I1lO0IlI0O[126:7]:
IOIl0I1lO0IlI0O[127:8];assign OlI1OIO0lIl10IO
=(OOIl1OOl1IIIO0l&(I01lOIO0lIIIO0l|l0IO1IOIl0O1lIO|IIO0lOIl01I01lO|OlI1OlIO10l10IO|I1lO0O01IlI01lO))|
OI01lI1lO0lIO10|OIl01l0IO1l10IO|OI01lO1lIOIIO0l|IlI0OI1lO0OIl01;assign I1lO0l10IOIO0lI[23]
=l0IO1IlO01lO10I[23]|(~lIO10lO10IlO10I[23]&IO01lIO0lIIIO0l[23]);assign l10IOO01IllIO10
=(~l10IOI01lOO01Il&OIl01O01IlIO0lI&~lO10Il0IO1l0IO1&I1lO0IO0lIIO0lI&IO01lIO0lIIIO0l[31])|
(~l10IOI01lOO01Il&I1lO0IlO01l0IO1&~lO10Il0IO1l0IO1&~IO0lIlIO10IO01l);assign IOIl0IlI0OlO10I[3]
=lO10IO1lIOI1lO0&l0IO1IOIl0IIO0l&OlI01lO10IOI01l&ecsd_a[3];assign OlI01l0IO1OIl01[1:0]=2'b01;assign IlI0OIlI0Ol0IO1[11]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[10];dff IIO0lIOlI1OIlO01
(lIO10l0IO1I01lO,lO10IIIO0lI1lO0,clk,hreset_b,1'b1);assign O01IlI1lO0I1lO0
=OIl01I1lO0IO01l|(OI01lIO01lI1lO0&~IO0lII1lO0O1lIO)|IOIl0OOl1Il0IO1|(l0IO1OI01lIOIl0&IO0lIlIO10IO01l)|(OIl01O01IlIO0lI&lIO10IlO01OI01l)|
OI01llO10IOlI1O|IIO0ll0IO1OOl1I|OlI1Ol10IOIO01l|(IlO01I01lOI1lO0&~OI01lIIO0lOI01l[2]&~IO0lII1lO0O1lIO)|(l10IOO01IllIO10&~I1lO0IlO01l0IO1)|OlI01l0IO1OlI01|IO01lIO0lIIIO0l[18]|
(IlO01OI01lI01lO&~IO0lIlIO10IO01l&lO10Il0IO1l0IO1&~O01Ill0IO1lO10I&OIl01IlO01IOIl0&I01lOIlO01I01lO)|lIO10IIO0lIlO01|OOl1IOlI1OIO0lI;assign I1lO0OOIl1IlO01
=(OlI1OOlI01IlI0O&~lO10II01lOOOIl1&OIl01IlO01O1lIO&O01IlIlI0OIlO01)|
(IlO01OIl01IIO0l&~OlI1OOlI01IlI0O&IlO01I01lOIlO01);dff IIOIl0IO01lI1lO0
(IO01lIO0lIIIO0l[16],I1lO0l10IOIO0lI[16],clk,hreset_b,1'b1);dff Il0IO1OOIl1I01lO
(IlO01OlI1OO1lIO,I01lOlIO10OlI1O,clk,hreset_b,1'b1);assign l10IOOOIl1IO01l=(IO01lI01lOl10IO[23:16]==8'hbb)?1'b1:1'b0;dff32 IOOl1IOIl01OlI01
(lIO10IOIl0OlI1O,OIl01I01lOOOIl1,clk,hreset_b,1'b1);assign O1lIOOOl1IOIl01[13]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[12];assign l10IOlO10IIlO01=(l10IOIlO01lIO10==6'h09)?1'b1:1'b0;assign dtout[7]
=I1lO0lIO10OOl1I[7];dff IIOIl0IlI0Ol0IO1(I1lO0IO0lIOOIl1,IlO01OlI1OO1lIO,clk,hreset_b,1'b1);dff4 IIOIl0lO10IOlI1O
(IO01lIO0lIIIO0l[12:9],IlO01lIO10IOIl0,clk,hreset_b,1'b1);dff IOlI01OI01lOOl1I
(lO10Il0IO1l0IO1,OIl01IIO0llIO10,clk,hreset_b,1'b1);assign IlO01l10IOl10IO[0]
=(lO10IIlO01OI01l)?1'b0:
(OlI01IlO01OlI1O)?IO01lI01lOl10IO[8]:
(lO10II01lOIO0lI&IO01lI01lOl10IO[8])?1'b1:
(OIl01OI01lO1lIO&IO01lI01lOl10IO[8])?1'b0:
OOIl1IO0lII1lO0[0];assign OlI01OOIl1OOl1I[0]
=(l10IOOOIl1lIO10)?1'b0:IlI0OOIl01IlO01^O01IlO01IlOOIl1[6];assign IO01lO01IlIlO01[3:0]
={O01IlO1lIOIlI0O[8],l0IO1O01IlO01Il[8],IO01lI01lOlIO10[8],O1lIOIO0lII1lO0[8]};assign OI01lOOIl1OOl1I
=(l10IOIlO01lIO10==6'h1e)?1'b1:1'b0;assign O01IlIlI0OIO01l[2]
=~l10IOI01lOO01Il&(IlI0OIlI0OOlI01|l10IOlIO10OOIl1|OOl1IOlI1OIlI0O)&
((~IlI0OlO10IIO0lI[2]&OI01lIO01lI01lO)|(IlI0OlO10IIO0lI[2]&IlI0OOlI01I1lO0));assign O1lIOOlI01IIO0l
=OlI1OOlI01IlI0O&OIl01IlO01O1lIO&~rdy_b;dff23 Il0IO1IlO01l0IO1(O1lIOIIO0lOOl1I,OOIl1l10IOIlO01,clk,hreset_b,1'b1);assign IlI0Ol0IO1IIO0l
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&
(OlI1OIO01lIO0lI|lO10Il0IO1I01lO|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|OI01lOOIl1OOl1I|
(O1lIOIlI0OO1lIO&~IO01lI01lOl10IO[31])|(OOl1IOlI01OOIl1&IO01lI01lOl10IO[0])|O01IlO01IlO1lIO)|
(OOl1IIOIl0IlO01&~lO10IIlO01IlI0O);assign OIl01I1lO0IlO01
=1'b0;assign OlI1OOlI1OlIO10=(OOIl1IlI0OOOl1I|IlI0OOOl1II01lO);assign OIl01lO10IOI01l
=
(l10IOlIO10OOIl1)?
{IOIl0I1lO0IlI0O[122],IOIl0I1lO0IlI0O[114],IOIl0I1lO0IlI0O[106],IOIl0I1lO0IlI0O[98],IOIl0I1lO0IlI0O[90],
IOIl0I1lO0IlI0O[82],IOIl0I1lO0IlI0O[74],IOIl0I1lO0IlI0O[66],IOIl0I1lO0IlI0O[58],
IOIl0I1lO0IlI0O[50],IOIl0I1lO0IlI0O[42],IOIl0I1lO0IlI0O[34],IOIl0I1lO0IlI0O[26],
IOIl0I1lO0IlI0O[18],IOIl0I1lO0IlI0O[10],IOIl0I1lO0IlI0O[2]}:
{IOIl0I1lO0IlI0O[62],IOIl0I1lO0IlI0O[58],IOIl0I1lO0IlI0O[54],IOIl0I1lO0IlI0O[50],IOIl0I1lO0IlI0O[46],
IOIl0I1lO0IlI0O[42],IOIl0I1lO0IlI0O[38],IOIl0I1lO0IlI0O[34],IOIl0I1lO0IlI0O[30],
IOIl0I1lO0IlI0O[26],IOIl0I1lO0IlI0O[22],IOIl0I1lO0IlI0O[18],IOIl0I1lO0IlI0O[14],
IOIl0I1lO0IlI0O[10],IOIl0I1lO0IlI0O[6],IOIl0I1lO0IlI0O[2]};assign OIl01IlO01IO0lI
=((lIO10OI01lIIO0l==1'b1)&(l10IOIlO01lIO10==6'h06))?1'b1:1'b0;assign OOIl1l10IOl10IO[10]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[9];assign IlO01lIO10O01Il
=((OlI1OOlI01IlI0O|lIO10l10IOOOIl1)&~rdy_b&O01IllO10IOI01l);dff IOOl1IOlI01IO0lI
(IO01ll10IOOIl01,OOl1IIO0lIlO10I,clk,hreset_b,1'b1);assign IO0lIlIO10IO01l=(O1lIOOIl01OIl01==15'h0001)?1'b1:1'b0;assign O01IlOI01lOOIl1
=lIO10I01lOIO0lI|lO10IOI01lO1lIO|(I1lO0IO0lIIO0lI&(l10IOlO10IIlO01|l0IO1O1lIOIO01l));assign IOIl0IO01lOIl01[125:122]
=(sel_mmc)?4'b0100:4'b0000;assign lIO10OI01lIO0lI
=(IOIl0IO01ll0IO1)?(OOIl1OlI1OOI01l+{9'h000,OI01lIIO0lO01Il[31:9]}):
(OOIl1OlI1OOI01l+OI01lIIO0lO01Il);dff Il0IO1IlO01l10IO
(I01lOOOIl1IlO01,l10IOlO10IIO01l,clk,hreset_b,1'b1);assign lO10IOI01lOlI1O=(l0IO1I01lOIOIl0&O01IllO10IOI01l)|IO0lII1lO0IO0lI;assign I01lOOI01llO10I[12]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO01lI01lOlIO10[11]^IIO0lI1lO0IO0lI[1]^IO01lI01lOlIO10[15];dff10 IIO0lIOIl01IlO01
(OOl1IlIO10lIO10,IlO01IO0lIlO10I,clk,hreset_b,1'b1);assign l10IOIlO01l0IO1
=(O1lIOIO0lIIlO01&l10IOl10IOOOIl1)|
(I1lO0lIO10OlI1O&(l0IO1O1lIOl10IO|OOIl1lIO10lO10I))|
(I1lO0IOIl0OI01l&(O01Ill0IO1lO10I|OlI1OIO01lIOIl0|OOIl1lIO10lO10I))|
(I1lO0IOIl0OI01l&lIO10I01lOOlI1O)|
(l10IOIOIl0IlI0O&IO01lIO0lIIOIl0&OI01lIlI0Ol0IO1)|
(IO01lI01lOI1lO0&~l10IOI01lOOlI01&~OOIl1OIl01IIO0l&~l0IO1IlO01O01Il&
~(IO01lIO0lIIOIl0&
(IIO0lI1lO0IOIl0|IO01lOIl01OOIl1|lO10Il0IO1I01lO|IO0lIOOl1IOIl01|OlI1OOIl01O01Il|
OOIl1OlI1OOlI01|IlO01lIO10OI01l|I1lO0l10IOIOIl0|l10IOIOIl0IIO0l|lIO10I01lOIO0lI|lO10IOI01lO1lIO|
O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|lO10IOOIl1OlI01|IlI0Ol0IO1IOIl0|OOl1IOlI01OOIl1|
O01IlO01IlO1lIO|OlI01OOIl1OlI1O|O1lIOIO0lIIO01l)));assign lO10IOOIl1O01Il
=(I1lO0IlO01lIO10&IOIl0OlI1OIlO01&IIO0lOlI01lIO10)|
(l0IO1OOIl1OIl01&IOIl0OlI1OIlO01&IO01lIO0lIOI01l)|
(l0IO1OI01lIOIl0&IO0lIlIO10IO01l);assign OlI01I1lO0lIO10
=(l10IOlO10IIlO01)?IOIl0IO01lOIl01:OlI01IO01lI01lO;assign IOIl0IO01lOIl01[14:13]=csd[14:13];assign l0IO1l10IOOlI1O
=(IOIl0IO01ll0IO1)?OIl01I01lOOOl1I:lIO10IOIl0OOIl1;assign IO01lOlI1OOlI1O
=(O1lIOIO01lIOIl0&l0IO1lO10IIO01l)|
(OIl01O1lIOOIl01&I01lOI01lOlO10I&lO10IIIO0lIO01l[1])|
(IlO01OIl01O1lIO&~lIO10O1lIOI01lO);assign lIO10IlO01IOIl0
=IIO0lOlI01lO10I|IlI0Ol0IO1IOIl0;assign lIO10OOIl1OlI01[14]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:l0IO1O01IlO01Il[13];dffe32 Il0IO1OI01llO10I
(OlI01I1lO0lO10I,IIO0lOlI01OlI01,clk,hreset_b,1'b1,OI01lIlI0OOIl01);dff IO1lIOOOl1IlO10I
(OlI01O01IlO1lIO,OI01lOOIl1OlI1O,clk,hreset_b,1'b1);assign IO0lIOlI1OI1lO0
=(O01IlIIO0ll10IO&I1lO0l10IOIOIl0)|(~l0IO1l0IO1IlO01&IIO0lOIl01I01lO);assign l0IO1IlO01lO10I[16]
=OIl01OOIl1IIO0l&I1lO0I01lOOIl01&
((OIl01IlI0OIO01l&OlI1OOIl01OI01l)|
(lO10II1lO0IlO01&IO0lIOOl1IOlI01));assign lIO10IIO0lIO01l
=OIl01O01IlIO0lI&IO0lIOlI1Ol0IO1;assign I1lO0OOIl1l10IO=OOl1IIO0lIO01Il&(O1lIOOOl1IOlI01|l0IO1IOIl0O1lIO)&I1lO0IO0lIO1lIO;dffe8 Il0IO1lIO10OOIl1
(IOIl0OlI01l0IO1,IOIl0I1lO0IlI0O[7:0],clk,hreset_b,1'b1,IIO0lOOl1IlIO10);assign OI01ll0IO1IlI0O
=I01lOIOIl0IlI0O&IOIl0OlI1OIlO01;dffe16 IIOIl0lO10IO1lIO(O01IlO1lIOIlI0O,OI01ll0IO1IOIl0,clk,1'b1,1'b1,lIO10OOIl1O01Il);assign IO01llIO10IIO0l
=IIO0lI1lO0IOIl0|O01IlIlO01OlI1O|OlI01O01IlOOIl1|OI01lOOIl1OOl1I|IOIl0OIl01IlO01|IIO0lOlI1OIO01l|
OOl1Il10IOl10IO|I1lO0OI01llO10I|IlI0OlO10IOOIl1;assign OOIl1l10IOIO01l
=O1lIOIO0lIIlO01&
((l0IO1O01IllO10I|OI01ll0IO1OI01l|OOIl1OlI01O1lIO|l10IOlO10IIlO01|l0IO1O1lIOIO01l|
OlI01I1lO0l10IO|IOIl0IO01llIO10|O01IllO10IOI01l|OOIl1IO01lOlI1O)|
(sel_mmc&(O01IllO10IOI01l|OlI01O1lIOIlI0O))|
(~sel_mmc&O01IlO1lIOOlI01));dff IIOIl0O1lIOIO0lI
(O1lIOOOl1IOlI01,OOIl1OIl01OI01l,clk,hreset_b,1'b1);assign IOIl0I1lO0O01Il
=lO10IIlO01OI01l|
(OI01lIIO0lOIl01&(~OIl01l0IO1lIO10|~I1lO0OOIl1I01lO)&~OI01lOlI01I01lO)|
(IIO0lIlI0OOlI01&~I1lO0OOIl1I01lO)|
(OlI1OOlI01IlI0O&(~I1lO0OOIl1I01lO|(~lO10II01lOOOIl1&OIl01IlO01O1lIO)))|
(lIO10l10IOOOIl1&(~I1lO0OOIl1I01lO|(~lO10II01lOOOIl1&(OIl01IlO01O1lIO|error))));assign lIO10lO10IlO10I[5]
=(IlO01I01lOl10IO|I1lO0IlO01lIO10)&IOIl0OlI1OIlO01;assign l10IOOI01lOI01l
=(~l10IOI01lOO01Il&IlO01l10IOOIl01&~lO10Il0IO1l0IO1)|
(~l10IOI01lOO01Il&I1lO0I01lOOlI01&~lO10Il0IO1l0IO1&IOIl0I1lO0IlI0O[0]&~l10IOIlO01I1lO0);assign I01lOIlO01IlO01
=(OOIl1IO0lIl10IO==8'h0f)?1'b1:1'b0;assign I1lO0l10IOIlI0O=(I1lO0IO0lIIO0lI)?lIO10I01lOIIO0l:l10IOIOIl0IOIl0;assign OIl01l0IO1I01lO[1]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:lIO10O1lIOIO01l[0];assign OOIl1OIl01OlI01
=IlO01OI01lI01lO&IO0lIlIO10IO01l&O01IlO01IlIIO0l;assign OI01llO10IOOIl1
=(l0IO1OI01lIIO0l&IOIl0OlI1OIlO01)|
(O01IlOOIl1OlI1O&~IOIl0OlI1OIlO01);dff IIO01lOIl01IIO0l
(IlI0OI1lO0OIl01,IOIl0IlI0OO01Il,clk,hreset_b,1'b1);assign I1lO0OOIl1I1lO0
=I01lOIOIl0OlI01&((OI01lOlI01IlO01&~l10IOO01IlI1lO0)|IIO0lOIl01I01lO|OlI1OlIO10l10IO);assign I1lO0l10IOIO0lI[13]
=l0IO1IlO01lO10I[13]|(~lIO10lO10IlO10I[13]&IO01lIO0lIIIO0l[13]);assign IO01ll10IOOlI01
=(~l10IOI01lOO01Il&OI01lIO01lI1lO0&~lO10Il0IO1l0IO1&~I01lOOI01lI01lO&~l10IOIlO01I1lO0&IO0lII1lO0O1lIO&~O1lIOlIO10I1lO0&
(~I1lO0IO0lIIO0lI|(IO0lIIIO0lOlI1O&OlI01IIO0llIO10)))|
(~l10IOI01lOO01Il&O1lIOOlI1OlO10I&(~I1lO0IO0lIIO0lI|(IO0lIIIO0lOlI1O&OlI01IIO0llIO10)))|
(~l10IOI01lOO01Il&IlO01I01lOI1lO0&~lO10Il0IO1l0IO1&IO0lII1lO0O1lIO&~I01lOOI01lI01lO&OI01lIIO0lOI01l[2]);assign lIO10IlO01OIl01
=(IO01lI01lOl10IO[2:0]==3'b000)?1'b1:1'b0;assign l0IO1O1lIOIlO01
=(IO01lIO0lIOI01l|lO10IOI01lIO0lI|(~sel_mmc&OlI01O01IlOlI1O))?6'b111111:l10IOIlO01lIO10;assign IlI0OIlI0Ol0IO1[3]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:OI01lI1lO0l10IO[2];assign OlI1OI1lO0OlI1O=O01IlO01IlIOIl0-I01lOl10IOOIl01;dff Il10IOl10IOIlI0O
(OIl01O01IlO1lIO,l0IO1OI01lIIO0l,clk,hreset_b,1'b1);assign OlI01l0IO1lO10I[7:0]
=(OI01ll0IO1O01Il==2'b11)?IOIl0I1lO0IlI0O[31:24]:
(OI01ll0IO1O01Il==2'b10)?IOIl0I1lO0IlI0O[23:16]:
(OI01ll0IO1O01Il==2'b01)?IOIl0I1lO0IlI0O[15:8]:IOIl0I1lO0IlI0O[7:0];assign IOIl0IlI0OOlI01
=(O1lIOIO01lOlI01)?32'h00000000:
(lIO10l10IOOOIl1&~lO10II01lOOOIl1&OIl01IlO01O1lIO&O1lIOlIO10l10IO)?(IlI0OI1lO0O01Il+32'h00000001):
IlI0OI1lO0O01Il;assign IO01lIO0lIIIO0l[2]
=1'b0;dff IIIO0ll0IO1IIO0l(OlI1OIOIl0IlO01,OOl1II01lOIO01l,clk,hreset_b,1'b1);assign IIO0lIIO0lIIO0l[4]
=IOIl0IlI0OlO10I[4]|(~OOl1IOlI01O1lIO[4]&IOIl0l0IO1IOIl0[4]);assign OOIl1OIl01IlI0O
=((IIO0lIlI0OIIO0l&O1lIOIlI0OO1lIO)|IO01lIO0lIIIO0l[4])?8'b000000:
(O01IlI1lO0l10IO&IO01lI01lOl10IO[31]&~IO01lI01lOl10IO[27])?IO01lI01lOl10IO[7:0]:
(IOIl0OlI01lO10I&IO0lIOlI01OlI01&O01IllO10IOI01l&~IO01lI01lOl10IO[15])?O01IlIlO01OOIl1:
(IOIl0OlI01lO10I&IO0lIOlI01OlI01&O01IllO10IOI01l&IO01lI01lOl10IO[15])?IO01lI01lOl10IO[7:0]:
O1lIOOOl1IOI01l;assign O1lIOOOl1IOIl01[5]
=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:IO0lIOlI01lO10I[4]^IIO0lI1lO0IO0lI[7]^IO0lIOlI01lO10I[15];assign lIO10OOIl1OIl01
=(l10IOIlO01lIO10==6'h01)?1'b1:1'b0;assign l10IOO1lIOIlO01[7]
=l10IOI01lOO01Il|O01IlI1lO0I1lO0|(~OlI01IlI0Ol10IO&lIO10l0IO1IO01l[7]);assign O1lIOOOl1IIlI0O=O1lIOIO01lIOIl0&~OOIl1OOl1IIO0lI;dff IlIO10I01lOIlI0O
(IO01lIO0lIIIO0l[27],I1lO0l10IOIO0lI[27],clk,hreset_b,1'b1);dff IIO01lOlI1OIOIl0
(IIO0ll0IO1OOl1I,IO0lIIO0lIIlO01,clk,hreset_b,1'b1);assign IlO01OlI01OOIl1=lO10IIlO01OI01l|(lO10IO1lIOI1lO0&OOl1IIO01lOlI1O);assign I1lO0IO0lIOlI1O
=~I1lO0IO0lIIO0lI&
((~sel_mmc&OI01lIIO0lIlI0O)|(l10IOO1lIOIO01l&I1lO0lO10IIlO01)|(OlI01IlI0Ol0IO1&IlI0OIO01llIO10)|
((~sel_mmc|~OlI1OIO0lIIO01l|(~OlI1OlIO10I1lO0[31]&~I1lO0l10IOOI01l))&
(IIO0llIO10IlO01|OOIl1IOIl0I1lO0|IO01lOI01ll0IO1)));assign IO0lIIlI0OO1lIO[3:0]
={O01IlO1lIOIlI0O[12],l0IO1O01IlO01Il[12],IO01lI01lOlIO10[12],O1lIOIO0lII1lO0[12]};assign IlO01lIO10OI01l
=(l10IOIlO01lIO10==6'h14)?1'b1:1'b0;assign IOIl0OOl1Il10IO
=IIO0lIIO0lOOIl1|
(IlO01OI01lI01lO&~IO0lIlIO10IO01l&(~lO10Il0IO1l0IO1|~O01Ill0IO1lO10I))|
((OOl1IOIl01IO0lI|I01lOlIO10OlI1O)&~OIl01l0IO1lO10I)|(lIO10IIO0lIlO01&~OI01lI1lO0O01Il);dff IIlO01OlI1OOlI01
(I01lOI01lOOIl01,I1lO0OI01lO01Il,clk,hreset_b,1'b1);assign OlI01I1lO0I1lO0[1]=1'b0;assign O01IllO10IIlI0O
=((IlO01I01lOl10IO|I1lO0IlO01lIO10)&lO10II01lOO1lIO&I1lO0l10IOIIO0l)|
(OOl1IIOIl0IlO01&lO10IIlO01IlI0O&~IlI0OIIO0lOlI01);assign l10IOOI01llO10I
=(l0IO1OOIl1I1lO0[11:0]==12'h007)?ecsd_a:
(l0IO1OOIl1I1lO0[11:0]==12'h128)?ecsd_b[31:24]:
(l0IO1OOIl1I1lO0[11:0]==12'h129)?ecsd_b[23:16]:
(l0IO1OOIl1I1lO0[11:0]==12'h12a)?ecsd_b[15:8]:
(l0IO1OOIl1I1lO0[11:0]==12'h12b)?ecsd_b[7:0]:
(l0IO1OOIl1I1lO0[11:0]==12'h12d)?ecsd_c:
(l0IO1OOIl1I1lO0[11:0]==12'h12e)?ecsd_d:
(l0IO1OOIl1I1lO0[11:0]==12'h12f)?ecsd_e:
(l0IO1OOIl1I1lO0[11:0]==12'h130)?ecsd_f:
(l0IO1OOIl1I1lO0[11:0]==12'h131)?ecsd_g:
(l0IO1OOIl1I1lO0[11:0]==12'h132)?ecsd_h:
(l0IO1OOIl1I1lO0[11:0]==12'h134)?ecsd_i:
(l0IO1OOIl1I1lO0[11:0]==12'h135)?ecsd_j:
(l0IO1OOIl1I1lO0[11:0]==12'h136)?ecsd_k:
(l0IO1OOIl1I1lO0[11:0]==12'h137)?ecsd_l:
(l0IO1OOIl1I1lO0[11:0]==12'h13b)?ecsd_m:
(l0IO1OOIl1I1lO0[11:0]==12'h13d)?ecsd_n:
(l0IO1OOIl1I1lO0[11:0]==12'h13f)?ecsd_o:
(l0IO1OOIl1I1lO0[11:0]==12'h140)?IOIl0l0IO1IOIl0:
(l0IO1OOIl1I1lO0[11:0]==12'h142)?ecsd_p:
(l0IO1OOIl1I1lO0[11:0]==12'h144)?IO01lOOl1IOOl1I:
(l0IO1OOIl1I1lO0[11:0]==12'h146)?O1lIOI1lO0IO0lI:
(l0IO1OOIl1I1lO0[11:0]==12'h14a)?ecsd_q:8'b00000000;assign IOIl0OlI1OIO01l
=(O01IlO01IlOOIl1==IlI0OOOl1IIlO01[6:0])?1'b1:1'b0;assign IO01llIO10OI01l[23:20]
={IO0lIOlI01lO10I[2],OI01lI1lO0l10IO[2],lIO10O1lIOIO01l[2],I01lOOIl01OOIl1[2]};assign IOIl0IIO0lIIO0l
=(l10IOIlO01lIO10==6'h32)?1'b1:1'b0;assign OOIl1l10IOl10IO[2]=(OOl1IIO0lIO01Il|I1lO0I01lOOlI01)?1'b0:O1lIOIO0lII1lO0[1];assign I01lOI01lOl0IO1
=~rdy_b&IlI0OlO10IOOIl1;assign IlI0OI1lO0lO10I=(lO10IO1lIOl10IO==3'b000)?1'b1:1'b0;assign O01IlIlO01IO0lI
=(OOIl1IO0lII1lO0==8'b00000001)?1'b1:1'b0;assign IOIl0I1lO0OIl01
=O01IlOOIl1OlI1O&IOIl0OlI1OIlO01&IlO01IOIl0lIO10&~OOl1IlIO10OI01l&OlI1OlIO10l0IO1;assign IO01lOlI1OO1lIO
=(csd[127:126]==2'b01)?1'b1:1'b0;
endmodule 
