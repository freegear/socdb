module TbSMC1000;





core_top ( 
		user_init_pc, 
		user_init_pc_en, 
		RESET_pin, 
		final_all_reset, 
        final_POR_ext_reset, 
		wdt_reset, 
		xrom_addr, 
		xrom_ce_b, 
		xrom_oe_b, 
        xrom_dout, 
		xram_addr, 
		xram_din, 
		xram_ce_b, 
		xram_oe_b, 
		xram_we_b, 
        xram_dout, 
		iram_addr, 
		iram_din, 
		iram_ce_b, 
		iram_oe_b, 
		iram_we_b, 
        iram_dout, 
		clk_cpu, 
		clk_peri, 
		clk_wdt, 
		WDT_RUN, 
		pdwn, 
		idle, 
		EA,
		ALE, 
        PSEN, 
		P0_DIN, 
		P0_DOUT, 
		P1_DIN, 
		P1_DOUT, 
		P2_DIN, 
		P2_DOUT, 
		P3_DIN, 
        P3_DOUT, 
		INT0_B, 
		INT1_B, 
		INT2, 
		INT3_B, 
		INT4, 
		INT5_B, 
		T0_PIN, 
		T1_PIN, 
        T2_PIN, 
		T2EX_PIN, 
		T2_OUT, 
		RX_PIN, 
		TX_PIN, 
		PWM1_OUT, 
		PWM2_OUT, 
        EXT_SFR_DIN, 
		EXT_SFR_DOUT, 
		EXT_SFR_ADDR, 
		EXT_SFR_WR );


endmodule
