@E8lFkRDCLmg_)ILQXwN 5LRR(W_[1P_dWR,RLMU_Pplw_,YtR6RL_$mP]Rd,R_L(Mjwts,7YRdRL_$up,LRRdp_uw
2;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0LMU_Pplw_;Yt
HRRM0bkR_L6m]P$dR;
RbHMkL0R(w_Mt7jsYR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;
bRRNlsNCs0CR6L4_Ge[lnO	ahz_BB.XRd=R.R;
RsbNN0lCCLsR4e6_[OGl	zna_Z	 z=ZRR4'Ljjj44jjjj4j44j4jj44jj44jjjjjjRjj;R

RosCR4rL6[_eG	lOn_azhXB.BRR:4RR9Lmd_)/LR*$R#MC0E#RH##_$M##sD0C$D=C"so0H#C"s#RR*/;R

RsIHCLRr4e6_[OGl	zna_.hBX:BRR9.RR_LcmQ)L;R

RINDNR$#@b@5F8#CoLCR(W_[1P_dWL2RCMoH
RRRR5HVLMU_Pplw_RYt2CRLoRHM
RRRRHRRVL5R(w_Mt7jsY
R2RRRRRRRRLmd_)=LRR6L4_Ge[lnO	a	z_ ZZz;R
RRRRRCCD#R5HVR_L6m]P$d
R2RRRRRRRRLmd_)=LRRd{L_$up,cRL_Lm)Q
};RRRRC
M8RMRC8R

R#N#HRoMLmc_)RLQ=dRL_Lm)r4RL6[_eG	lOn_azhXB.BRR:.;R9
R
RNH##oLMRdp_uwRR=Lmd_)4Lr9C;
MF8l8CkD
l

FD8kC0R[NHo_Ms0CVCNORR5
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_L(F_17d,PW
RRRRRRRRRRRRRRRR(RL_xUi_sdI,R
RRRRRRRRRRRRRRLRRnP_M_BjB,R
RRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRL_44U_ixAYJx),sL
RRRRRRRRRRRRRRRR4RLji_Uxi_sDXs0,R
RRRRRRRRRRRRRRLRR4Uj_iVx_w[V#XR,
RRRRRRRRRRRRRRRRLUg_i.x_o0sw,R
RRRRRRRRRRRRRRLRR4Mj_PI_$igvlXR,
RRRRRRRRRRRRRRRRLMg_PT_FIwVY,R
RRRRRRRRRRRRRRLRRgP_M_JOpo,mw
RRRRRRRRRRRRRRRRURL__MPZ0lBY
2;RMRHbRk0R_Ldu;pw
FRRkk0b0(RL_xUi_sdI;R
RFbk0kL0RnP_M_BjB;R
RFbk0kL0R4U4_iAx_J)xYs
L;RkRF00bkRjL4_xUi_Dsis;0X
FRRkk0b04RLji_Uxw_VVX#[;R
RFbk0kL0Rgi_Uxo_.s;w0
FRRkk0b04RLjP_M_i$IvXlg;R
RFbk0kL0RgP_M_IFTV;Yw
FRRkk0b0gRL__MPOopJm
w;RkRF00bkR_LUMZP_lYB0;R
RFbk0kL0Rdi_udR;
R0FkbRk0LF(_1d7_P
W;
IRRHRsCHM8C0$HV_	ODRR/*#0$MEHC##$R#MC_	C4b=R/R*R
;
RHRIsHCR80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88*R/RM#$0#ECH##R$	M_C=Cb4/R*R
;
RHRIsLCR(i_UxI_dsR;
RsIHCnRL__MPj;BB
IRRHRsCLUg_i.x_o0sw;R
RICHsR4L4_xUi_xAJYL)s;R
RICHsRjL4_xUi_Dsis;0X
IRRHRsCL_4jU_ixV#wV[
X;RHRIsLCRUP_M_BZl0
Y;RHRIsLCR4Mj_PI_$igvlXR;
RsIHCgRL__MPFVTIY
w;RHRIsLCRgP_M_JOpo;mw
ARRzRwtOLD	k5VR
RRRR53QRCH8MV0H$D_O	l_0b,R2
RRRR53mRCH8MV0H$D_O	2R2;R
RAq1BhQ_e)Xa c0R[Nbo_s4HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RR)  1a5RRR_L6POF1d,R2
RRRRu3z7 qaRL5RgP_M_IFTVRYw2R,
R3RR1w]Qa5RRR_LUMZP_lYB0R
2,RRRR3B7)iRRR58RHCHM0VO$_D0	_l2bR,R
RR1R3 RpRRRR5LMg_Pp_OJwomR
2,RRRR3Qa7RRRR5nRL__MPjRBB2R,
R3RRBaquzR) 54RLjP_M_i$IvXlgRR22/#*R$EM0C##HRM#$_bMFsCkM=*4R/
R;RCR8VsbNN[lR0_NoblsH4a3KqBt_]hqQR4=R;R
RAq1BhQ_e)Xa c0R[Nbo_s.HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RRzqu7a5 RRjL4_xUi_DsisR0X2R,
R3RR1w]Qa5RRR_LgU_ix.wos0,R2
RRRR)37BRiRRH5R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88,R2
RRRR 31pRRRRL5R4Uj_iVx_w[V#X,R2
RRRR73aQRRRRL5R(i_UxI_ds,R2
RRRRq3Bu)az RR5L_44U_ixAYJx)RsL2/2R*$R#MC0E#RH##_$MMsFbk=MC4/R*RR;
RV8CbNNsl0R[Nbo_s.Hl3qKat]_BqRQh=;R.
NRR#o#HMdRL_duiRH=R80CMH_V$O;D	
NRR#o#HM(RL_7F1_WdPRH=R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88
;
ClM8FD8kCl

FD8kC4RLnO_)lJH_D_Gg$l]b(5$R
RRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_Lnu_p$Q
w,RRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRgRL_wup_	aKs
[,RRRRRRRRRRRRRRRRR_L(Mjwts,7Y
RRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRnRL_l4zk,ag
RRRRRRRRRRRRRRRR6RL_$mP]
d,RRRRRRRRRRRRRRRRR.L4_Lm)QNIX Lw_8
2;RkRF00bkR:rdjL9R4Md_Pplw_.VGsTLk;R
RFbk0kr0Rj9:jR4L4_sk)Ok_gsLXA;R
RFbk0kL0Rdp_uwR;
R0FkbRk0L_4.mQ)LI XNw8_L;R
RHkMb0LRRgp_uwK_a	;s[
HRRM0bkRnRL_$up_;Qw
HRRM0bkR6RL_$mP]
d;RMRHbRk0R_L(Mjwts;7Y
HRRM0bkRnRL_#8Z0;dg
HRRM0bkRnRL_l4zk;ag
HRRM0bkRdRL_dui;R
RsRCorj6:94RLjZ_8#g0d_d w;R
RsRCorj6:9gRL_$mP]#d_N
p;RHRIsrCRc9:jRdL4_LPFwY.X __0a
 ;
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2R
RLHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRR4RLjZ_8#g0d_d wRL=RgP_m$_]d#;Np
RRRR8CM
CRRM
8
RDRNI#N$R5@@bCF#8RoCLud_iRd2LHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRRVRH5LR!(w_Mt7jsYRR2LHCoMR
RRRRRRVRH56RL_$mP]2dRRoLCHRM
RRRRRRRRR_Lgm]P$dN_#pRR={_Lnu_p$QRw,L_4dPwFL. XY_a0_ ;R}
RRRRRRRR8CM
RRRRCRRMR8
RCRRMR8
R8CM
R
RNH##oLMR4Pd_F.LwX_Y 0 _aRL=RgP_m$_]d#rNp69:4;R
RNH##oLMR4Md_Pplw_.VGsTLkRL=R48j_Zd#0gw_ d:rc4
9;R#RN#MHoR4L4_sk)Ok_gsLXAR=RRRjL4_#8Z0_dg rwdj9:j;R
RNH##oLMR4m._)ILQXwN _RL8RL=R48j_Zd#0gw_ d9r6;R
RNH##oLMRdp_uwRR=L4n_zalkgRR?Lmg_Pd$]_p#NrRj9:gRL_wup_	aKs
[;ClM8FD8kCl

FD8kCFROlLl_D	FO5R
ROlFl.OHHCH_DMH	_H_OCj
,RRHRHOOC.F_llD	HM_OHHC2_jRR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*RR;
R0FkbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
HRRM0bkR:rjjH9RH.OCOlFl_MDH	H_HOjC_;


RHRIsrCRd9:jRdL4_lMPwVp_GL.sk
T;RHRIsrCRj9:jR4L4_sk)Ok_gsLXA;R
RICHsR:rjjL9R4k4_)_sOWwYm[
Z;RHRIsrCRj9:jR_Lnu_pwQ
w;RHRIsLCRdi_udL,R(i_UxI_dsL,RnP_M_BjB,nRL_wup_,AJRcL4_wup_$i74 _Jd,dxR.L4_Lm)QNIX Lw_8L,Rgp_uwK_a	;s[
IRRHRsC0_8F#RHo/#*R$EM0C##HRM#$_C	CbR=4*;/R
IRRHRsCLMg_Pp_OJwom,gRL__MPFVTIYRw,L_4jM$P_IlivgRX,LMU_Pl_ZB;0Y
IRRHRsCL_4jU_ixV#wV[RX,L_4jU_ixssiD0RX,L_44U_ixAYJx),sLR_LgU_ix.wos0
;
`8HVC1VRQpvzqmaQhM
HHN0HDR
RfHbD10FVBDNLCHQM085HCHM0V[$_0_No0,O	RCH8MV0H$0_[N0o_lR#,HM8C0$HV_N[0o8_0HH,R80CMH_V$[o0N_F082`;
CHM8VR

R#N#HRoMLun_pQw_w9rjRH=RH.OCOlFl_MDH	H_HOjC_;R
RNH##oOMRF.llHCHO_MDH	H_HOjC_R{=RRdL4_lMPwVp_GL.skRT,L_44kO)s_sgkXrALjR9,LMn_PB_jBL,RgP_M_IFTV,YwRjL4__MP$vIil,gXR_LUMZP_lYB0,dRL_duiR
};R#RN#MHoRcL4_wup_$i74 _JdRdx=LR|np_uww_Q;R
RNH##oLMRgp_uwK_a	Rs[=LR54m._)ILQXwN _2L8?F08_o#H:cL4_wup_$i74 _Jd;dx
NRR#o#HM4RL4)_ksgO_kAsXLRR=5_LgMOP_pmJowL2?4k4_)_sOWwYm[4Z:';Lj
R
R[o0N_0HMCNsVO[CR0HNoRR5
R3RRLud_iRdRRRRRR5RRLud_i,d2
RRRR(3L_7F1_WdPRRRRR(5L_7F1_WdP2R,
R3RRLU(_idx_IRsRR5RRLU(_idx_I,s2
RRRRn3L__MPjRBBRRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRRRRRRLR5np_uwJ_A2R,
R3RRL_44U_ixAYJx)RsL54L4_xUi_xAJYL)s2R,
R3RRL_4jU_ixssiD0RXR5jL4_xUi_Dsis20X,R
RRLR34Uj_iVx_w[V#X5RRL_4jU_ixV#wV[,X2
RRRRg3L_xUi_s.owR0RRg5L_xUi_s.ow,02
RRRR43LjP_M_i$IvXlgRLR54Mj_PI_$igvlX
2,RRRR3_LgMFP_TYIVwRRR5_LgMFP_TYIVw
2,RRRR3_LgMOP_pmJowRRR5_LgMOP_pmJow
2,RRRR3_LUMZP_lYB0RRRR5_LUMZP_lYB02
2;
LRR4)n_O_lHJgDG_b$]lR($L)(_O_lHJ5DR
RRRR43LdP_Ml_wpVsG.L5kTL_4dMwPlpG_V.ksLT
2,RRRR34L4_sk)Ok_gsLXARLR54k4_)_sOWwYm[,Z2
RRRRd3L_duiRRRRRRRRRLR5(1_F7P_dW
2,RRRR3_Lnu_p$QRwRRRRRR(5L_xUi_sdI2R,
R3RRLud_pRwRRRRRRRRR5_Lnu_pwA,J2
RRRRg3L_wup_	aKsR[RRLR5gp_uwK_a	2s[,R
RRLR3(w_Mt7jsYRRRR5RRL_44U_ixAYJx)2sL,R
RRLR3nZ_8#g0dRRRRR5RRL_4jU_ixssiD0,X2
RRRRn3L_l4zkRagRRRRRLR54Uj_iVx_w[V#X
2,RRRR3_L6m]P$dRRRRRRRRg5L_xUi_s.ow,02
RRRR43L.)_mLXQIN_ wL58RL_4.mQ)LI XNw8_L2
2;
LRRg)_mLXQINR wLmg_)GL_h7$IRR5
R3RRL[(_Wd1_PRWRRRRR5_Ldu2id,R
RRLR3UP_Ml_wpY5tRL_4.mQ)LI XNw8_L2R,
R3RRLm6_Pd$]RRRR5_LUMZP_lYB02R,
R3RRLM(_wstj7RYRRLR54Mj_PI_$igvlX
2,RRRR3_LduRp$RRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRR5RR0_8F#2HoR
2;
8CMlkF8D
C
lkF8DLCR((_e4JmKxLR5d)_FA
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmd_FRA,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LcmNiK,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR.6_H,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLH._nR,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L.HRW,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.RL_,H RRR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRcY_FE
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmc_YjEjR
2;RMRHbRk0LFd_);Aj
HRRM0bkR_Ldm;FA
HRRM0bkR_LcmNiK;R
RHkMb0.RL_;H6
HRRM0bkR_L.H
n;RMRHbRk0LH._WR;
RbHMkL0R. _H;R
RFbk0kL0RcY_FE
j;RkRF00bkR_LcmjYEjR;
Rp1)B 4nR_LUm]P$do7YRR5
R3RR7RRR5_LdFj)A2R,
R3RRBR R5_Ldm2FA,R
RRBR3p5iRLmc_i2KN,R
RRqR3j5RRLH._6
2,RRRR3Rq4R.5L_2Hn,R
RRqR3.5RRLH._W
2,RRRR3RqdR.5L_2H ,R
RRTR3R5RRLFc_Y2Ej,R
RRTR3456RLmc_YjEj2;R2
M
C88lFk
DC
8lFkRDCL_44[0wKpYPYg5JELmc_i,KNRRH,F
2;RNRbsCNl0RCsLmc_)RJO=;R4
HRRM0bkR_LcmNiK;R
RHkMb0;RH
FRRkk0b0;RF
HRRMo0CC[sR;R
RsRCor_LcmO)JR4:R9nRL_s$Fj;u7
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoH
RRRR_Ln$jFsu47r9=R<R
H;RRRRV5Fs[RR=.[;RRR<=Lmc_);JOR=[RR+[RR
42RRRRRnRL_s$Fjru7[<9R=nRL_s$Fjru7[RR-4
9;RMRC8R
RNH##oFMRRL=RnF_$s7jur_LcmO)J9C;
MF8l8CkD
F
l8CkDRjL4_WMYhhagIRLp5R
RLmc_i,KN
LRR6F_P1,Od
LRR(1_u$BH_kR,
R_L6HO1WBR,
R_Lc1OY#,R
RLM(_YIWh7
Y,R(RL_$u1H#Dg,R
RL_4jMhYWaIghL;p2
R
RbNNslCC0sgRL_aMz_DoBY=vRR;4n
HRRM0bkRcRL_KmiNL,R6F_P1,OdR_L(uH1$_,BkR_L6HO1WBR;
RbHMkR0Rrj4:9cRL_#1YOR;
RbHMkR0Rr_LgM_zaoYBDvRR-4RR:jL9R(Y_MW7hIYR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRLRrgz_MaB_oDRYv-RR4:9RjRjL4_WMYhhagI;Lp
sRRCRoRR(RL_$u1H#Dg;R

RsbNN0lCCLsR($_WjdM_gRRRRRRR='RdLjjj;R
RbNNslCC0sURL_UY(s1C_DRRRR=RRRLd'j;j4
bRRNlsNCs0CRdL4_o0EMJYcB_ztA=CRRLd'j;4j
bRRNlsNCs0CR4L4_XLx_aJ1Bz(OR.=R'jLj;R
RbNNslCC0sgRL_XLx_i4#nRzRR.=R'4Lj;R
RbNNslCC0sURL_o7DY)(UBRRRR.=R'jL4;R
RbNNslCC0s4RLjI_64pnkaugTRRR=.4'L4R;
RosCR:rj.L9RnL_Mag0d,nRL_aGL0;dg
sRRCroRLMg_zoa_BvDYR4-RRj:R9(RL_EMYQ#dg;R
RsRCoLM6__.xO,cRL_6M_QR;
RosCR_LguH1$DNg#.R;
RosCRjL4_$u1H#DgG,wAR4L4_$u1H#Dgtu.X,4RL41_u$gHD#AGwaR;
RsIHCnRL_aMz_;VL
NRRD$IN#@R@5#bFCC8oR_LcmNiK2R
RRgRL_$u1H#DgN<.R=6RL_WH1O&BRR_L(uH1$_;Bk
R
RNH##oLMRnz_MaL_VR5=RLM(_YdEQg=#R=(RL_WMYhYI72
;
R#RN#MHoRjL4_WMYhhagIRLp=(RL_EMYQ#dg;R

RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:LM(_z.a_gRj
RHRRV65L_xM_O|.RR_L6POF1dR2
RRRRR_L(MQYEdRg#<'=RL
j;RRRRCCD#R5HVLMc__26Q
RRRRLRR(Y_MEgQd#=R<R_L(MQYEdRg#+;R4
CRRMR8
RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:Lmn_OV_ZLR
RRRRRLMn_Lda0g=R<R_LnG0Lad
g;RRRRRVRH5_L6POF1d
R2RRRRRRRRLMn_Lda0g=R<R_L(WM$j_;dg
CRRMR8
RINDNR$#@L@5nL_Mag0dRRFsLug_1D$Hg.#NRRFsLMn_zVa_LsRFR_L6HO1WBsRFR_Lc1OY#2R
RLHCoMRR:Lmn_On_$sR
RRnRL_aGL0Rdg<L=RnL_Mag0d;R
RR4RL41_u$gHD#Xt.u=R<R
j;RRRRL_4juH1$DGg#w<AR=;Rj
RRRR_LcMQ_6RR<=jR;
RLRR6__MxRO.<j=R;R
RRNRO#LC5nL_Mag0d2R
RR(RL_jW$Mg_dRL:RCMoH
RRRRLRR6__MxRO.<4=R;R
RRRRRHLV561_HW2OB
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RCRRMR8
RLRRU(_YU_sC1:DR
RRRRORRN5#CL1c_Y2#O
RRRRLRR4L4_xJX_1(aBO:zR
RRRRRRRR5HVLug_1D$Hg.#N2R
RRRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRRRRRL_4juH1$DGg#w<AR=;R4
RRRRRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRRMRC8DRC#RC
RRRRRRRRRLRRc__M6<QR=;R4
RRRRLRRgx_LX#_4iRnz:R
RRRRRRVRH5_LguH1$DNg#.R2
RRRRRRRRR5HVLMn_zVa_LR2
RRRRRRRRRLRR4uj_1D$Hgw#GA=R<R
4;RRRRRRRRRDRC#LCRCMoH
RRRRRRRRRRRR_LcMQ_6RR<=4R;
RRRRRRRRRLRRnL_Gag0dRR<=L_4d0MEoYBcJzAt_CR;
RRRRRRRRR8CM
RRRRLRR46j_Ik4npTaguRR:LHCoMR
RRRRRRcRL_6M_Q=R<R
4;RRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRR4RL41_u$gHD#Xt.u=R<R
4;RRRRRRRRR6RL_xM_O<.R=;R4
RRRRRRRR8CMR#CDCVRH5g!L_$u1H#DgN
.2RRRRRRRRR6RL_xM_O<.R=;R4
RRRRCRRMR8
RRRRR_LU7YDo(BU)RL:RCMoH
RRRRRRRR_LcMQ_6RR<=4R;
RRRRRHRRVn5L_aMz_2VLRoLCHRM
RRRRRRRRR4L4_$u1H#Dgtu.XRR<=4R;
RRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRCRM8CCD#R5HVLug_1D$Hg.#N2R
RRRRRRRRRLM6__.xORR<=4R;
RRRRR8CM
RRRR8RRCkVND:0R
RRRRRRRRR;
RRRRR8CMOCN#
RRRRdL4_o0EMJYcB_ztA:CRRoLCHRM
RRRRR_LcMQ_6RR<=4R;
RRRRR5HVLMn_zVa_LL2RCMoH
RRRRRRRRjL4_$u1H#DgGRwA<4=R;R
RRRRRR6RL_xM_O<.R=;R4
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RRRRR8CM
RRRR8CM
RRRRV8CN0kDRR:
RRRRRR;
RCRRMN8O#RC
R8CM
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoHRL:Rc1_u$RH
RHRRVLR56F_P1ROd|!|RLH6_1BWO2CRLo
HMRRRRR(RL_$u1H#DgRR<=jR;
RRRRR4L4_$u1H#DgGawARR<=jR;
RCRRMC8RDR#CLHCoMR
RRRRRLu(_1D$Hg<#R=4RL41_u$gHD#Xt.uR;
RRRRR4L4_$u1H#DgGawARR<=L_4juH1$DGg#w
A;RRRRRNRO#5CRL1c_Y2#ORR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRR4L4_XLx_aJ1Bz(O:RR
RRRRRLRR(1_u$gHD#=R<R4L4_$u1H#DgGawA;R
RRRRRLLg_x4X_#zin:R
RRRRRR(RL_$u1H#DgRR<=L_44uH1$DGg#w;Aa
RRRR8RRCkVND
0:RRRRRRRR;R
RRRRRCOM8N
#CRRRRC
M8RMRC8M
C88lFk
DC
8lFkRDCLmg_.V$$_.VtR,5HR;F2
HRRM0bkRRrj:9RdR
H;RkRF00bkR
F;
NRR#o#HMRRF=rRHj&9RR4Hr9RR&H9r.RH&Rr;d9
8CMlkF8D
C
lkF8DLCR4B6_)atOB_kNC_]cDLP5ci_mKRN,HF,R2R;
RbHMkL0Rci_mK
N;RMRHbRk0r:jRR9(UR
H;RkRF00bkR
F;RHRIsLCRcO_AW
h;RHRIsrCRjRR:(RU9LBg_ZI1jVlY_;R
RICHsRRrj:gR(94RL6Z_B1VjIY__lwHEV(R;
RsIHCjRrR4:RgL9RgZ_B1VjIY;_M
IRRHRsCr:jRRRc9LBg_ZI1jV8Y_;R
RICHsRRrj:9R(R6L4_1BZjYIV_w8_E(VH;R
RICHsRRrj:9R4R_LgBjZ1I_VYeR;
RsIHCjRrRd:R94RL6Z_B1VjIY__ewHEV(R;
RsIHCjRrR4:R94RLdZ_B1VjIY__ew;]g
sRRCroRjRR:4L9R4Bc_ZI1jVeY__gw]lR;
R#N#HRoMLBg_ZI1jVlY_RH=R;R
RNH##oFMRRL=RcO_AW
h;R#RN#MHoR6L4_1BZjYIV_wl_E(VHr:jRR9(URL=RgZ_B1VjIY;_l
NRR#o#HM4RL6Z_B1VjIY__lwHEV(gr(R(:Rg=9RRL4'4R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLg
R5RRRR3LH54B6_ZI1jVlY__VwEHj(rRd:R9R2,3LF5gZ_B1VjIYr_Mj292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFNL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(Rrc:9R(23,RFg5L_1BZjYIV_4Mr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_j5R
RRHR356L4_1BZjYIV_wl_E(VHr:URR94423,RFg5L_1BZjYIV_.Mr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_Q5R
RRHR356L4_1BZjYIV_wl_E(VHrR4.:6R49R2,3LF5gZ_B1VjIYr_Md292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFUL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(nr4R4:Rg,92R53FLBg_ZI1jVMY_r2c92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLO
R5RRRR3LH54B6_ZI1jVlY__VwEH.(rjRR:.2d9,FR35_LgBjZ1I_VYM9r62
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_51R
RRRR53HL_46BjZ1I_VYlE_wVrH(.:cRR9.(23,RFg5L_1BZjYIV_nMr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_45R
RRHR356L4_1BZjYIV_wl_E(VHrR.U:4Rd9R2,3LF5gZ_B1VjIYr_M(292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFwL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(.rdRd:R6,92R53FLBg_ZI1jVMY_r2U92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FL8
R5RRRR3LH54B6_ZI1jVlY__VwEHd(rnRR:d2g9,FR35_LgBjZ1I_VYM9rg2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNn5R
RRHR356L4_1BZjYIV_wl_E(VHrRcj:dRc9R2,3LF5gZ_B1VjIYr_M42j92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5(R
RRRR53HL_46BjZ1I_VYlE_wVrH(c:cRR9c(23,RFg5L_1BZjYIV_4Mr4292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_X
R5RRRR3LH54B6_ZI1jVlY__VwEHc(rURR:6249,FR35_LgBjZ1I_VYM.r49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLw_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(.r6R6:R6,92R53FLBg_ZI1jVMY_r94d2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RN65R
RRHR356L4_1BZjYIV_wl_E(VHrR6n:gR69R2,3LF5gZ_B1VjIYr_M42c92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5gR
RRRR53HL_46BjZ1I_VYlE_wVrH(n:jRR9nd23,RFg5L_1BZjYIV_4Mr6292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_u
R5RRRR3LH54B6_ZI1jVlY__VwEHn(rcRR:n2(9,FR35_LgBjZ1I_VYMnr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLY_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(UrnR(:R4,92R53FLBg_ZI1jVMY_r94(2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNB5R
RRHR356L4_1BZjYIV_wl_E(VHrR(.:6R(9R2,3LF5gZ_B1VjIYr_M42U92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5NR
RRRR53HL_46BjZ1I_VYlE_wVrH((:nRR9(g23,RFg5L_1BZjYIV_4Mrg292;R
RLmg_.V$$_.VtR4L._$m.$VV_tv._H4Tq sn__5$R
RRRR53HLBg_ZI1jVMY_r:jRR2d9,FR35_LgBjZ1I_VY89rj2
2;RgRL_$m.$VV_tL.R.m4_.V$$_.Vt_TvHqn4 _xs_RR5
R3RRHg5L_1BZjYIV_cMrR(:R9R2,3LF5gZ_B1VjIYr_84292;R
RLmg_.V$$_.VtR4L._$m.$VV_tv._H4Tq sn__5bR
RRRR53HLBg_ZI1jVMY_r:URR94423,RFg5L_1BZjYIV_.8r9;22
LRRg._m$_$VVRt.L_.4m$.$Vt_V.H_vT q4n__s(
R5RRRR3LH5gZ_B1VjIYr_M4:.RR94623,RFg5L_1BZjYIV_d8r9;22
LRRg._m$_$VVRt.L_.4m$.$Vt_V.H_vT q4n__sG
R5RRRR3LH5gZ_B1VjIYr_M4:nRR94g23,RFg5L_1BZjYIV_c8r9;22
NRR#o#HM4RL6Z_B1VjIY__8wHEV(Rrj:9RcRL=RgZ_B1VjIY;_8
NRR#o#HM4RL6Z_B1VjIY__8wHEV(Rr6:9R(Rd=R'4L44R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nEM_DG_FLg
R5RRRR3LH54B6_ZI1jV8Y__VwEHj(rRd:R9R2,3LF54Bd_ZI1jVeY__gw]r2j92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nEM_DG_FLN
R5RRRR3LH54B6_ZI1jV8Y__VwEHc(rR(:R9R2,3LF54Bd_ZI1jVeY__gw]r2492R;
RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMR
RR4RLcZ_B1VjIY__ewl]gRR<=L_4dBjZ1I_VYe]_wgR;
R8CM
NRR#o#HMgRL_1BZjYIV_=eRRcL4_1BZjYIV_we_];gl
NRR#o#HM4RL6Z_B1VjIY__ewHEV(Rrj:9R4RL=RgZ_B1VjIY;_e
NRR#o#HM4RL6Z_B1VjIY__ewHEV(Rr.:9RdR.=R'4L4;R
RLmg_.V$$_.VtR6L._$m.$VV_tv._H4Tq Zn__GDMF
L5RRRR3LH54B6_ZI1jVeY__VwEH,(2R53FLAc_O2Wh2C;
MF8l8CkD
F
l8CkDR4L4_$u1H#Dg4aV	5R
RLmc_i,KN
LRR(W_[1P_dWR,
R_L6uOidpR,
R_Ldu,p$
LRRdp_uwR,
R_L6m]P$dR,
R_Ln.0Z#d
J,R6RL_1PFO
d,R6RL_WH1O
B,R(RL_$u1H#Dg,R
RL_4jMhYWaIghL;p2
R
RHkMb0cRL_KmiNR;
RbHMkL0R(W_[1P_dWR;
RbHMkL0R6i_ud;Op
HRRM0bkR_Ldu;p$
FRRkk0b0dRL_wup;R
RHkMb06RL_$mP]
d;RMRHbRk0r:jRRn469nRL_#.Z0;dJ
HRRM0bkR_L6POF1dR;
RbHMkL0R61_HW;OB
FRRkk0b0(RL_$u1H#Dg;R
RFbk0kr0Rd:4RRRj9L_4jMhYWaIghL
p;RHRIsLCR(P_m$g]dkR;
RsIHC4RrR(:RgL9R6w_Mx;t0
IRRHRsCr:jRR9(gR_LnMtwx0
w;RCRsorRR4RR:(Rg9Lug_VIt$7L#F;R
RICHsR_L(kjzaK;Bc
sRRCRoRrRdd:9RjR_Ln$jFsu
7;RHRIsRCRrRdd:9R4R_L($jFsu;7k
IRRHRsCr:jRR9d4R_LgM$zau7w0pR;
RsIHCjRrR4:R9(RL_aMzdYuI;R
RICHsR_L(MjzaK;Bc
IRRHRsCL.g_ZQatVgcN;R
RICHsRRrj:6R4(L9R4.j_Zd#0JU	NAR;
RsIHCjRrR4:R6R(9L_4..]ZqBsJv4DX ;R
RsRCoRRrj:6R4nL9R4.4_ZAq]ggsmX
E;RHRIsrCRjRR:(RU9L.n_ZQatVR;
R#N#HRoMLm(_Pd$]g=kRR_L6m]P$dRR&Lu6_ipdO;R
RNH##oLMRnw_Mxwt0rRj9=dRL_$up;R
RNH##oLMR4.j_Zd#0JU	NARrj:6R4n=9RR_Ln.0Z#d
J;R#RN#MHoR.L4_q.Z]vBJs 4XDRrj:6R4n=9RR4L4_q.Z]sAgmEgX;R
RNH##oLMR4.j_Zd#0JU	NA6r4(RR:4R6U-R49=LR'jR;
R#N#HRoML_4..]ZqBsJv4DX r(46R4:R6-UR4=9RRj'L;R
RNNDI$@#R@F5b#oC8CcRL_KmiNR2
RLRR4.4_ZAq]ggsmX=ERR_Ln.0Z#d
J;
LRR((_e4JmKxURL_L4pO_oi)
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA9rj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD9rj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D4,92
RRRRc3L_EFYjLR5nZ_.aVtQr2j9,R
RRLR3cY_mERjj5_L6Mtwx09r42;R2
R
RLe(_(K4mJLxRUp_4LiOo_51R
RRRRd3L_AF)j5RRLMn_w0xtw9r42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r2d9,R
RRLR3cY_FE5jRL.n_ZQatV9r42R,
R3RRLmc_YjEjR65L_xMwt.0r922R;R

R_L(em(4KRJxL4U_poLOiR_Q5R
RRLR3d)_FARjR5_LnMtwx0.wr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA9r62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD9r62R,
R3RRLFc_YREj5_Ln.tZaQ.Vr9
2,RRRR3_LcmjYEjLR56w_Mxrt0dR922
;
R(RL_4e(mxKJR_LU4OpLoJi_RR5
R3RRLFd_)RAjRn5L_xMwtr0wd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Ar9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 (Dr9
2,RRRR3_LcFjYERn5L_a.ZtrQVd,92
RRRRc3L_EmYj5jRLM6_w0xtr2c9R
2;
LRR((_e4JmKxURL_L4pO_oiT5jR
RRRRd3L_AF)j5RRLMn_w0xtw9rc2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUAr9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 UDr9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r2g9,R
RRLR3cY_FE5jRL.n_ZQatV9rc2R,
R3RRLmc_YjEjR65L_xMwt60r922R;R

R_L(em(4KRJxL4U_poLOiR_z5R
RRLR3d)_FARjR5_LnMtwx06wr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA42j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r94j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9442R,
R3RRLFc_YREj5_Ln.tZaQ6Vr9
2,RRRR3_LcmjYEjLR56w_Mxrt0nR922
;
R(RL_4e(mxKJR_LU4OpLoqi_RR5
R3RRLFd_)RAjRn5L_xMwtr0wn,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr94.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr94d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr49
2,RRRR3_LcFjYERn5L_a.ZtrQVn,92
RRRRc3L_EmYj5jRLM6_w0xtr2(9R
2;
LRR((_e4JmKxURL_L4pO_oiK
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2(9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr2(9,R
RRLR3cY_mERjj5_L6Mtwx09rU2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5MR
RRRRd3L_AF)j5RRLMn_w0xtw9rU2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D42n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D42(9,R
RRLR3cY_FE5jRL.n_ZQatV9rU2R,
R3RRLmc_YjEjR65L_xMwtg0r922R;R

R_L(em(4KRJxL4U_poLOiR_e5R
RRLR3d)_FARjR5_LnMtwx0gwr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA42U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r94U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r94g2R,
R3RRLFc_YREj5_Ln.tZaQgVr9
2,RRRR3_LcmjYEjLR56w_Mxrt042j9R
2;
LRR((_e4JmKxgRL_L4pO_oi15lR
RRRRd3L_AF)j5RRLMn_w0xtwjr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9.j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9.42R,
R3RRLFc_YREj5_Ln.tZaQ4Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9442;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1M5R
RRLR3d)_FARjR5_LnMtwx04wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9..2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9.d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.9
2,RRRR3_LcFjYERn5L_a.ZtrQV4249,R
RRLR3cY_mERjj5_L6Mtwx0.r4922R;R

R_L(em(4KRJxL4g_poLOi8_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr94.2R,
R3RRLmc_YjEjR65L_xMwt40rdR922
;
R(RL_4e(mxKJR_Lg4OpLo1i_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r94d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr49
2,RRRR3_LcmjYEjLR56w_Mxrt042c9R
2;
LRR((_e4JmKxgRL_L4pO_oi15DR
RRRRd3L_AF)j5RRLMn_w0xtwcr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9.U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9.g2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9462;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1b5R
RRLR3d)_FARjR5_LnMtwx04wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9dj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9d42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rd9
2,RRRR3_LcFjYERn5L_a.ZtrQV4269,R
RRLR3cY_mERjj5_L6Mtwx0nr4922R;R

R_L(em(4KRJxL4g_poLOi6_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.rd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDr.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdrd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrd,92
RRRRc3L_EFYjLR5nZ_.aVtQr94n2R,
R3RRLmc_YjEjR65L_xMwt40r(R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r94(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd269,R
RRLR3cY_FE5jRL.n_ZQatV(r49
2,RRRR3_LcmjYEjLR56w_Mxrt042U9R
2;
LRR((_e4JmKxgRL_L4pO_oi151R
RRRRd3L_AF)j5RRLMn_w0xtwUr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9dn2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9d(2R,
R3RRLFc_YREj5_Ln.tZaQ4VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr94g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1J5R
RRLR3d)_FARjR5_LnMtwx04wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9dU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUrd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9dg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgrd9
2,RRRR3_LcFjYERn5L_a.ZtrQV42g9,R
RRLR3cY_mERjj5_L6Mtwx0jr.922R;R

R_L(em(4KRJxL4g_poLOil_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjrc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 cDrj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 cDr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.j2R,
R3RRLmc_YjEjR65L_xMwt.0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoQi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UcAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dc2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UcArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dc2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ58R
RRRRd3L_AF)j5RRLMn_w0xtw.r.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9c62R,
R3RRLFc_YREj5_Ln.tZaQ.Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9.d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQe5R
RRLR3d)_FARjR5_LnMtwx0.wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9cn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9c(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rc9
2,RRRR3_LcFjYERn5L_a.ZtrQV.2d9,R
RRLR3cY_mERjj5_L6Mtwx0cr.922R;R

R_L(em(4KRJxL4g_poLOiD_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUrc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 cDrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgrc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 cDrg,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.c2R,
R3RRLmc_YjEjR65L_xMwt.0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoQi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U6Arj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D62j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U6Ar4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6249,R
RRLR3cY_FE5jRL.n_ZQatV6r.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ56R
RRRRd3L_AF)j5RRLMn_w0xtwnr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA62.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r96.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA62d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r96d2R,
R3RRLFc_YREj5_Ln.tZaQ.Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9.(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQC5R
RRLR3d)_FARjR5_LnMtwx0.wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9662R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r69
2,RRRR3_LcFjYERn5L_a.ZtrQV.2(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur.922R;R

R_L(em(4KRJxL4g_poLOi1_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 6Drn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 6Dr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.U2R,
R3RRLmc_YjEjR65L_xMwt.0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoQi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U6ArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D62U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U6Arg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D62g9,R
RRLR3cY_FE5jRL.n_ZQatVgr.9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ5lR
RRRRd3L_AF)j5RRLMn_w0xtwjrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAn2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9nj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAn249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9n42R,
R3RRLFc_YREj5_Ln.tZaQdVrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9d42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJM5R
RRLR3d)_FARjR5_LnMtwx0dwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9n.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rn9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9nd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrn9
2,RRRR3_LcFjYERn5L_a.ZtrQVd249,R
RRLR3cY_mERjj5_L6Mtwx0.rd922R;R

R_L(em(4KRJxL4g_poLOi8_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr9d.2R,
R3RRLmc_YjEjR65L_xMwtd0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoJi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9dd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dn2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UnAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dn2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ5DR
RRRRd3L_AF)j5RRLMn_w0xtwcrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAn2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9nU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAn2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9ng2R,
R3RRLFc_YREj5_Ln.tZaQdVrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9d62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJb5R
RRLR3d)_FARjR5_LnMtwx0dwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9(j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9(42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r(9
2,RRRR3_LcFjYERn5L_a.ZtrQVd269,R
RRLR3cY_mERjj5_L6Mtwx0nrd922R;R

R_L(em(4KRJxL4g_poLOi6_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 (Dr.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 (Drd,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dn2R,
R3RRLmc_YjEjR65L_xMwtd0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(Arc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Ar6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(269,R
RRLR3cY_FE5jRL.n_ZQatV(rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ51R
RRRRd3L_AF)j5RRLMn_w0xtwUrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA(2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9(n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA(2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9((2R,
R3RRLFc_YREj5_Ln.tZaQdVrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9dg2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJJ5R
RRLR3d)_FARjR5_LnMtwx0dwrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9(U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9(g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr(9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrc922R;R

R_L(em(4KRJxL4g_poLOil_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cj2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU249,R
RRLR3cY_FE5jRL.n_ZQatVjrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c249R
2;
LRR((_e4JmKxgRL_L4pO_oiTRMj5R
RRLR3d)_FARjR5_LnMtwx0cwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9U.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9Ud2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc249,R
RRLR3cY_mERjj5_L6Mtwx0.rc922R;R

R_L(em(4KRJxL4g_poLOi8_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c.2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUAr6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU269,R
RRLR3cY_FE5jRL.n_ZQatV.rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2d9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRej5R
RRLR3d)_FARjR5_LnMtwx0cwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Un2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2d9,R
RRLR3cY_mERjj5_L6Mtwx0crc922R;R

R_L(em(4KRJxL4g_poLOiD_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cc2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2g9,R
RRLR3cY_FE5jRL.n_ZQatVcrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c269R
2;
LRR((_e4JmKxgRL_L4pO_oiTRbj5R
RRLR3d)_FARjR5_LnMtwx0cwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9g42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc269,R
RRLR3cY_mERjj5_L6Mtwx0nrc922R;R

R_L(em(4KRJxL4g_poLOi6_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg2d9,R
RRLR3cY_FE5jRL.n_ZQatVnrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2(9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRCj5R
RRLR3d)_FARjR5_LnMtwx0cwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9g62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urc922R;R

R_L(em(4KRJxL4g_poLOi1_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cU2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg2(9,R
RRLR3cY_FE5jRL.n_ZQatVUrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2g9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRJj5R
RRLR3d)_FARjR5_LnMtwx0cwrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9gg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgrg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr6922R;R

R_L(em(4KRJxL4g_poLOil_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49jj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49j42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr44,92
RRRRc3L_EFYjLR5nZ_.aVtQr96j2R,
R3RRLmc_YjEjR65L_xMwt60r4R922
;
R(RL_4e(mxKJR_Lg4OpLozi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9642R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arj2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drj2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r69
2,RRRR3_LcmjYEjLR56w_Mxrt062.9R
2;
LRR((_e4JmKxgRL_L4pO_oiz58R
RRRRd3L_AF)j5RRLMn_w0xtw.r69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49j62R,
R3RRLFc_YREj5_Ln.tZaQ6Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr96d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rze5R
RRLR3d)_FARjR5_LnMtwx06wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4j9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arj2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4j9
2,RRRR3_LcFjYERn5L_a.ZtrQV62d9,R
RRLR3cY_mERjj5_L6Mtwx0cr6922R;R

R_L(em(4KRJxL4g_poLOiD_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49jU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49jg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr96c2R,
R3RRLmc_YjEjR65L_xMwt60r6R922
;
R(RL_4e(mxKJR_Lg4OpLozi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9662R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar42j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj449
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4449
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4249,R
RRLR3cY_FE5jRL.n_ZQatV6r69
2,RRRR3_LcmjYEjLR56w_Mxrt062n9R
2;
LRR((_e4JmKxgRL_L4pO_oiz56R
RRRRd3L_AF)j5RRLMn_w0xtwnr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA494.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4r4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D494d2R,
R3RRLFc_YREj5_Ln.tZaQ6Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr96(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzC5R
RRLR3d)_FARjR5_LnMtwx06wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6449
2,RRRR3_LcFjYERn5L_a.ZtrQV62(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur6922R;R

R_L(em(4KRJxL4g_poLOi1_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4r4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D494n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA494(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr96U2R,
R3RRLmc_YjEjR65L_xMwt60rgR922
;
R(RL_4e(mxKJR_Lg4OpLozi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar42U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU449
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg449
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr42g9,R
RRLR3cY_FE5jRL.n_ZQatVgr69
2,RRRR3_LcmjYEjLR56w_Mxrt0n2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiq5lR
RRRRd3L_AF)j5RRLMn_w0xtwjrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49.j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49.42R,
R3RRLFc_YREj5_Ln.tZaQnVrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9n42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RqM5R
RRLR3d)_FARjR5_LnMtwx0nwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar.2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4.9
2,RRRR3_LcFjYERn5L_a.ZtrQVn249,R
RRLR3cY_mERjj5_L6Mtwx0.rn922R;R

R_L(em(4KRJxL4g_poLOi8_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9n.2R,
R3RRLmc_YjEjR65L_xMwtn0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoqi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9nd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr.2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiq5DR
RRRRd3L_AF)j5RRLMn_w0xtwcrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49.U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49.g2R,
R3RRLFc_YREj5_Ln.tZaQnVrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9n62;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rqb5R
RRLR3d)_FARjR5_LnMtwx0nwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj4d9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drd2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r44d9
2,RRRR3_LcFjYERn5L_a.ZtrQVn269,R
RRLR3cY_mERjj5_L6Mtwx0nrn922R;R

R_L(em(4KRJxL4g_poLOi6_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49d.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49dd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nn2R,
R3RRLmc_YjEjR65L_xMwtn0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr64d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd269,R
RRLR3cY_FE5jRL.n_ZQatV(rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiq51R
RRRRd3L_AF)j5RRLMn_w0xtwUrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49dn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49d(2R,
R3RRLFc_YREj5_Ln.tZaQnVrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9ng2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RqJ5R
RRLR3d)_FARjR5_LnMtwx0nwrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU4d9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drd2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg4d9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr(922R;R

R_L(em(4KRJxL4g_poLOil_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49cj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49c42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(j2R,
R3RRLmc_YjEjR65L_xMwt(0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoKi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9(42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arc2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4c9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4c9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drc2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiK58R
RRRRd3L_AF)j5RRLMn_w0xtw.r(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49c62R,
R3RRLFc_YREj5_Ln.tZaQ(Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9(d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKe5R
RRLR3d)_FARjR5_LnMtwx0(wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4c9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drc2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arc2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4c9
2,RRRR3_LcFjYERn5L_a.ZtrQV(2d9,R
RRLR3cY_mERjj5_L6Mtwx0cr(922R;R

R_L(em(4KRJxL4g_poLOiD_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49cU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49cg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(c2R,
R3RRLmc_YjEjR65L_xMwt(0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoKi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9(62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar62j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj469
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4469
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr6249,R
RRLR3cY_FE5jRL.n_ZQatV6r(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiK56R
RRRRd3L_AF)j5RRLMn_w0xtwnr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA496.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6r4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D496d2R,
R3RRLFc_YREj5_Ln.tZaQ(Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9((2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKC5R
RRLR3d)_FARjR5_LnMtwx0(wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar6269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6469
2,RRRR3_LcFjYERn5L_a.ZtrQV(2(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur(922R;R

R_L(em(4KRJxL4g_poLOi1_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6r4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D496n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA496(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(U2R,
R3RRLmc_YjEjR65L_xMwt(0rgR922
;
R4RL6)_BtBOakCN_]Dc_PnRL_t.ZwRTg5R
RRLR3ci_mKLN5ci_mK,N2R53HL.n_ZQatVR2,3LF5gZ_.aVtQc2Ng2R;
R#N#HRoMLk(_zKajB=cRR_Lg.tZaQNVcgR;
RINDNR$#@M@5C8oCoLCR(W_[1P_dWR2
RRRRR_Lgu$VtIF7#LRR=LM6_w0xt;R
RNH##oLMRnw_Mxwt0r:4RR9(gRL=RgV_ut7$I#;FL
R
RL_4jMhYWaIghLypR52d.R_LcMjiARR5
R3RRLmc_i5KNLmc_i2KN,R
RRLR36F_P15OdLP6_Fd1O2R,
R3RRLu(_1_$HBLk5(z_kaBjKc
2,RRRR3_L6HO1WB65L_WH1O,B2
RRRRc3L_#1YO(5L_aMzdYuI2R,
R3RRLM(_YIWh7LY5gz_Maw$u027p,R
RRLR3(1_u$gHD#(5L_aMzjcKB2R,
R3RRL_4jMhYWaIghLLp54Mj_YaWhgLhIp;22
R
RNH##oLMR(1_u$gHD#RR=LM(_zKajB
c;
NRR#o#HMgRL_aMz$0uw7=pRR_Ln$jFsud7rdRR:.
9;R#RN#MHoR_L(MdzauRIYRRR=L$n_Fusj7Rr4:9Rj;R
RNH##oLMRdp_uwRR=L$n_Fusj79rj;R
RNNDI$@#R@F5b#oC8C(RL_1[W_WdP2R
RRVRHR65L_duiO&pRR_L6m]P$dR2
RRRRR_Ln$jFsu=7RRn{L_xMwtr0w(,g9R_L($jFsu}7k;R

R#N#HRoML$(_Fusj7=kRR_Ln$jFsud7rdRR:4
9;
8CMlkF8D
C
lkF8DLCR(V_uwhxsYR5
R_LcmNiK,R
RLP6_Fd1O,R
RLH6_1BWO,R
RL1g_p_$$h7st,R
RLu(_1D$Hg
#,R(RL_1[W_WdP,R
RLu(_i_KNg
k,RdRL_$up,R
RLm6_Pd$],R
RLud_p
w,R4RLjY_MWghahpIL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L6POF1dR;
RbHMkL0R61_HW;OB
HRRM0bkR:rj496(R_Lg1$p$_ths7R;
R0FkbRk0Lu(_1D$Hg
#;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lu(_i_KNg
k;RMRHbRk0Lud_p
$;RMRHbRk0Lm6_Pd$];R
RFbk0kL0Rdp_uwR;
R0FkbRk0rRd4:9RjRjL4_WMYhhagI;Lp
IRRHRsCr:4RRR49LuU_1D$Hg;#X
IRRHRsCr:4RRR49L_44kjzaKoBcw;sY
IRRHRsCr:.RRR49LM6_w0xt;R
RICHsRRr.:9R4R_LnMtwx0
w;RHRIsrCRjRR:496nR_L(.0Z#d;Jt
IRRHRsCLH6_1BWO;R

R#N#HRoML.(_Zd#0J=tRRg{L_$1p$s_htj7r:9d4,gRL_$1p$s_htd7r.6:d9L,Rgp_1$h$_srt7ddn:gR9,L1g_p_$$h7str:cjc,j9R_Lg1$p$_ths74rc:9c4,gRL_$1p$s_htc7r.6:c9
,RRRRRRRRRRRRRR_Lg1$p$_ths7nrc:9cg,gRL_$1p$s_ht67rjj:69L,Rgp_1$h$_srt7664:4R9,L1g_p_$$h7str:6.6,.9R_Lg1$p$_ths7dr6:96d,gRL_$1p$s_ht67rcc:69
,RRRRRRRRRRRRRR_Lg1$p$_ths76r6:966,gRL_$1p$s_ht67rnn:69L,Rgp_1$h$_srt76n(:jR9,L1g_p_$$h7str:n4n,49R_Lg1$p$_ths7.rn:9n.,gRL_$1p$s_htn7rdd:n9
,RRRRRRRRRRRRRR_Lg1$p$_ths7crn:9g6,gRL_$1p$s_htg7rn.:4(R9,L1g_p_$$h7strU4.:44d9L,Rgp_1$h$_srt74:d.49d6,gRL_$1p$s_ht47rd4n:d,n9R_Lg1$p$_ths7dr4(d:4(R9,
RRRRRRRRRRRRgRL_$1p$s_ht47rd4U:d,U9R_Lg1$p$_ths7dr4gd:4gR9,L1g_p_$$h7strj4c:j4c9L,Rgp_1$h$_srt74:c449c4,gRL_$1p$s_ht47rc4.:c,.9R_Lg1$p$_ths7cr4dc:4dR9,
RRRRRRRRRRRRgRL_$1p$s_ht47rc4c:c,c9R_Lg1$p$_ths7cr46c:46R9,L1g_p_$$h7strn4c:n4c9L,Rgp_1$h$_srt74:c(49c(,gRL_$1p$s_ht47rc4U:c,U9R_Lg1$p$_ths7cr4gc:4gR9,
RRRRRRRRRRRRgRL_$1p$s_ht47r64j:6,j9R_Lg1$p$_ths76r446:44R9,L1g_p_$$h7str.46:.469L,Rgp_1$h$_srt74:6d496d,gRL_$1p$s_ht47r64c:6,c9R_Lg1$p$_ths76r466:46R9,
RRRRRRRRRRRRgRL_$1p$s_ht47r64n:6}n9;R
RNH##oLMRU1_u$gHD#4Xr9RR=L_44kjzaKoBcwrsY4
9;R#RN#MHoR_L(uH1$DRg#=URL_$u1H#DgX9r4;R

R#N#HRoMLMn_w0xtw9r4RL=Rdp_u$R;
R#N#HRoMLud_p=wRR_L6Mtwx09r4;R

R4L4_$u1H#Dg4aV	R_L(u0LaDRgt5R
RRLR3ci_mK5NRLmc_i2KN,R
RRLR3(W_[1P_dWLR5(W_[1P_dW
2,RRRR3_L6uOidpLR5(i_uKgN_k
2,RRRR3_LduRp$5_LnMtwx04wr9
2,RRRR3_LduRpw5_L6Mtwx09r42R,
R3RRLm6_Pd$]R65L_$mP],d2
RRRRn3L_#.Z0RdJ5_L(.0Z#d2Jt,R
RRLR36F_P1ROd5_L6POF1d
2,RRRR3_L6HO1WBLR561_HW2OB,R
RRLR3(1_u$gHD#LR54k4_zKajBwcos4Yr9
2,RRRR3jL4_WMYhhagIRLp5jL4_WMYhhagI2Lp2
;
ClM8FD8kCl

FD8kC(RL_AmB$BpX5cRL_KmiNL,R(1_u$gHD#L,R(W_[1P_dWL,R6P_m$,]dR_Ln80Z#dRg,Lud_pR$,LMn_VV#_wL,R44c_8paOIV_pAdu_HL,R4Mj_YdEQgw#_0L,R4P4_qdAZJ_#YXR],L_44kO)s.YXV_,X]R_L6HO1WBL,Rgw_mWgha_,NLR.L4_1PFOod_lLN#LL,R(w_Mt7jsYL,R(V_M#I_d$L,R(z_MaI_d$L,R4P._qdAZJ_#Yp,$ER.L4_sk)OV.XY$_pEL,R4M4_zdaZJ0v_	2pR;R
RbNNslCC0s(RL_aMzZYQkR4=R;R
RbNNslCC0s4RLdO_ml_jVaU	qnR Z='RcLjjjjR;
RsbNN0lCCLsR4md_OVlj_qq(UPn)Rc=R'jLjj
4;RNRbsCNl0RCsL_4dmjOlVH_]u)(nPRR=cj'Lj;4j
bRRNlsNCs0CRdL4_lmOjbV_6nAa)=PRRLc'j4j4;R
RbNNslCC0s4RL.O_ml_jVTU(AJ=tRRLc'jj4j;R
RbNNslCC0s4RLgO_ml_jV]_HuUK7wdj#_aRR=c4'Lj;j4
bRRNlsNCs0CR4L._lmOj]V_HUu_7dwK#a_j_=xRRLc'4jj4;R
RbNNslCC0s.RLjO_ml_jVba6A_F Z]_)jB=iRRLc'44j4;R
RbNNslCC0s.RL6O_ml_jVba6A_F Z]_)jBQi_PRdG='RcLj44jR;
RsbNN0lCCLsR4m(_OVlj_Ta	OLzJT6ehRc=R'4L4j
4;RNRbsCNl0RCsLhU_sgc_cRHb=;R6
R
RbNNslCC0sURL_chs_zNUb=RRRL6'jjjjjR;
RsbNN0lCCLsR(s_hcE_YURRR='R6Ljjjj
4;RNRbsCNl0RCsLhg_sYc_FT1bR6=R'jLjj;4j
bRRNlsNCs0CR_L(h_scNR[gRRR=64'L444j;R
RbNNslCC0s.RL.s_hcE_YU6_iU87Yw_h6NKPhR6=R'jLj4;jj
bRRNlsNCs0CR.L._chs_UYE_Ui67wY8h 6_iR.I='R6Ljj4j
j;RNRbsCNl0RCsL_4(h_scY_EUB ahlst_oRR=64'Ljjjj;R

RsbNN0lCCLsRgx_e.cM_XRnzRRR=6j'Ljjjj;R
RbNNslCC0sgRL_.exMn_mcRYRR6=R'jLjj;j4
bRRNlsNCs0CR4L4_.exMe_4nNTOR6=R'jLjj;4j
bRRNlsNCs0CR_LgeMx._nqaARRR='R6L4jjj
j;RNRbsCNl0RCsLeU_x_.McRUDR=RRRL6'jj4jj
;
RNRbsCNl0RCsL_4jO (j]nF]BRbR=cR4'jLjjjjjjjjjjj4j;R

RbHMkL0Rci_mK
N;RMRHbRk0Lu(_1D$Hg
#;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lm6_Pd$];R
RHkMb0nRL_#8Z0;dg
HRRM0bkR_Ldu;p$
HRRM0bkR_LnM_V#V
w;RMRHbRk0L_4c4O8appI_V_Aud
H;RMRHbRk0L_4jMQYEd_g#w
0;RMRHbRk0L_44PZqAdYJ#_;X]
HRRM0bkR4L4_sk)OV.XY]_X;R
RHkMb0(RL_tMwjYs7;R
RHkMb04RL4z_MaJZdv	_0pR;
R0FkbRk0LH6_1BWO;R
RFbk0kL0Rgw_mWgha_;NL
FRRkk0b04RL.F_P1_Odo#lNL
L;RkRF00bkR_L(M_V#d;I$
FRRkk0b0(RL_aMz_$dI;R
RFbk0kL0R4P._qdAZJ_#Yp;$E
FRRkk0b04RL.)_ksXO.VpY_$
E;
sRRCLoRgw_mWgha_;NL
sRRCroRLhU_sgc_c-Hb49:jR_LnmjOls
W;RCRso4RL.F_P1_Odo#lNL
L;RCRso6RL_WH1O
B;
sRRCroRd9:jRdL4_xMqtvVw_##pP
d;RCRsodRr:Rj9L_4jGjFz_sWv0
X;RCRsoLRrUs_hcc_gH4b-:Rj9LMd_V
#;RCRsoLRr(z_MakZQYRR-49:jR_LdM;za
sRRCLoRnz_Maw_V;R
RsRCoLMU_zaa_K,VGRdL4_aMz_VaKGu_pY
g;
sRRCroRLM(_zQaZk-YRRj4:9(RL_EMYQ#dg;R
RICHsRUrL_chs_Hgcb:-4jL9RnV_M#w_Q;R
RICHsR(rL_aMzZYQkR4-R:Rj9LMn_zQa_wR;
RsIHCURL_APqZ#dJYR;
RsIHC4RLjY_ME_QdkAl[;R
RICHsRjL4_6u1Z_VXI;[e
IRRHRsCLu(_pn$_D
h;RCRsoLRr(z_MakZQYRR+cRR+LhU_sgc_c+HbR-4RRj4:94RL.)_ksXO.VsY_L
h;R/R/RM#$F$b##sR0NDM#N_0CF
VVRMRHHN0HD4RLdq_MxwtVvp_##RPd=4RLdO_ml_jV](Hun;)P
HRRMHH0NLDRdz_MaRR=';Lj
/RR/$R#M#Fb$0#Rs#NMDCN0_
FM
NRR#o#HM4RLjY_ME_QdkAl[R5=RR_L(MQYEdRg#='=RL2jR;R
RNH##oLMR4uj_1V6ZX[_IeRR=5nRL_#MV_rQw429R;R

RINDNR$#@R@5bCF#8RoCLmc_iRKNFbsRF8#CoLCR4uj_1V6ZX[_Ie
R2RRRRHRV5L_4juZ16VIX_[2eRRoLCHRM
RRRRR_LdMRV#<L=RUs_hcU_Nz
b;RRRRRdRL_aMzRR<=jR;
RCRRMC8RDR#CLHCoMR
RRRRRLMd_V<#R=nRL_#MV_;Qw
RRRRLRRdz_Ma=R<R_LnM_zaQ
w;RMRC8R
R
NRRD$IN#@R@5FRb#oC8CcRL_KmiN
R2RRRRHRV5LMU_zaa_KRVG2R
RRRRRLM(_YdEQg<#R=dRL_aMz;R
RRDRC#HCRVL5R4Md_zaa_K_VGpguYRR2
RRRRR_L(MQYEdRg#<L=R4Oj_(]j FB]nbR;
RCRRDR#CH5V5R_LnM_zaV2wRRR&&54!LjY_ME_QdkAl[R
22RRRRR(RL_EMYQ#dgRR<=LM(_YdEQg-#RR
4;
NRRD$IN#@R@5FRb#oC8CcRL_KmiNsRFR#bFCC8oRjL4_6u1Z_VXI2[e
RRRR5HVRjL4_6u1Z_VXIR[e2R
RRRRRL_4dMtqxV_wv#Pp#d=R<RdL4_lmOjaV_	nqU 
Z;RRRRCCD#
RRRRLRR4Md_qVxtw#v_pd#PRR<=L_4jGjFz_sWv0
X;
NRRD$IN#R@@5dL4_xMqtvVw_##pPFdRsdRL_aMzRRFsLMd_VF#Rs(RL_$u1H#DgRRFsL_4jMQYEdl_k[FARsURL_APqZ#dJYL2RCMoH
RRRRjL4_zGFjv_WsR0X<L=R4Md_qVxtw#v_pd#P;R
RRnRL_aMz_RVw<4=R';Lj
RRRR_LgmhwWaNg_L=R<RL4'jR;
RLRR61_HWROB<4=R';Lj
RRRR_LUM_zaaGKVRR<=4j'L;R
RR4RLdz_MaK_aVpG_uRYg<4=R';Lj
RRRR_LnmjOls<WR=gRL_.exMn_mc
Y;RRRRL_4.POF1dl_oNL#LRR<=4j'L;R

RORRN5#CRdL4_xMqtvVw_##pP2dRRR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRRdL4_lmOjaV_	nqU RZ:LHCoMR
RRRRRR4RL.F_P1_Odo#lNL<LR='R4L
4;RRRRRRRRL_4jGjFz_sWv0<XR=4RLdO_ml_jVqU(qn;)P
RRRRRRRR_LnmjOls<WR=gRL_.exMX_cn
z;RRRRRRRRL_4dM_zaaGKV_Ypug=R<RL4'4R;
RRRRR8CM
RRRRLRR4md_OVlj_qq(UPn):CRLo
HMRRRRRRRRLmg_waWhgL_NRR<=44'L;R
RRRRRRnRL_lmOjRsW<L=Rgx_e.cM_X;nz
RRRRRRRR5HVLPU_qdAZJR#Y&RR5LMd_Vj#r9RR|LMd_V.#r9RR|LMd_Vd#r9RR|LMd_Vc#r9R22LHCoMR
RRRRRRRRRLMn_zVa_w=R<R
4;RRRRRRRRRVRH54RLjY_ME_QdkAl[RL2RCMoH
RRRRRRRRRRRR_LUM_zaaGKVRR<=4R;
RRRRRRRRRLRRnz_Maw_VRR<=jR;
RRRRRRRRRLRRgw_mWgha_RNL<j=R;R
RRRRRRRRRR4RL.F_P1_Odo#lNL<LR=;R4
RRRRRRRRRRRR#ONCL5RdV_M#RR2/#/R$bMF#R$#bNNsDDDC_#ONCR
RRRRRRRRRRRRRLh(_sYc_ERU:LHCoMR
RRRRRRRRRRRRRR4RLjF_GzWj_vXs0RR<=L_4dmjOlVH_]u)(nPR;
RRRRRRRRRRRRRLRRgw_mWgha_RNL<4=R;R
RRRRRRRRRRRRRR4RL.F_P1_Odo#lNL<LR=;Rj
R
RRRRRRRRRRRRRC
M8RRRRRRRRRRRRR4RL(s_hcE_YUa_Bht l_:so
RRRRRRRRRRRRRRRRjL4_zGFjv_WsR0X<L=R4mg_OVlj_u]H_wU7K_d#j
a;RRRRRRRRRRRRRCR8VDNk0;:R
RRRRRRRRRRRR8CMOCN#
RRRRRRRRCRRMR8
RRRRRCRRMR8
RRRRR8CM
RRRRLRR4md_OVlj_u]H(Pn):CRLo
HMRRRRRRRRLmg_waWhgL_NRR<=44'L;R
RRRRRR6RL_WH1O<BR='R4L
4;RRRRRRRRHRV5Lu(_1D$Hg=#R='R4L24RRoLCHRM
RRRRRRRRR5HVRjL4_EMYQkd_lR[A=4=R'RL42CRLo
HMRRRRRRRRRRRRL_4jGjFz_sWv0<XR=4RL.O_ml_jVTU(AJ
t;RRRRRRRRRMRC8DRC#LCRCMoH
RRRRRRRRRRRRjL4_zGFjv_WsR0X<L=R4md_OVlj_Ab6aPn);R
RRRRRRRRRC
M8RRRRRRRRCRM8CCD#R5HVR_LdMrV#cR92LHCoM/R/R_L(h_scN
[gRRRRRRRRR4RLjF_GzWj_vXs0RR<=L_4(mjOlV	_aTJOzLhTe6R;
RRRRRCRRMR8
RRRRR8CM
RRRRLRR4mg_OVlj_u]H_wU7K_d#jRa:LHCoMR
RRRRRR6RL_WH1O<BR=;R4
RRRRRRRRRHV5(RL_$u1H#DgRL2RCMoH
RRRRRRRRLRRgw_mWgha_RNL<4=R;R
RRRRRRRRRL_4jGjFz_sWv0<XR=.RLjO_ml_jVba6A_F Z]_)jB
i;RRRRRRRRCRM8CCD#RRHV5dRL_#MVrRj92/R/R_L(h_scN
[gRRRRRRRRR4RLjF_GzWj_vXs0RR<=L_4(mjOlV	_aTJOzLhTe6R;
RRRRR8CM
RRRRLRR.mj_OVlj_Ab6aZ_ Fj])_:BiRoLCHRM
RRRRRLRRnO_mlWjsRR<=Leg_x_.MqAan;R
RRRRRRgRL_Wmwh_agN<LR=;R4
RRRRRRRR_L6HO1WB=R<R
4;RRRRRRRRLMn_zVa_w=R<R
4;RRRRRRRRH5VRR_LdMrV#j29RRR//Lh(_sNc_[Rg
RRRRRRRRRjL4_zGFjv_WsR0X<L=R.m6_OVlj_Ab6aZ_ Fj])__BiQGPd;R
RRRRRRDRC#HCRVRR5Lu(_1D$Hg2#RRoLCHRM
RRRRRRRRRLRRUz_MaK_aV<GR=;R4
RRRRRRRRRRRR_LnM_zaV<wR=;Rj
RRRRRRRR8CMR#CDCVRHRL5R4Mj_YdEQ_[klA
R2RRRRRRRRRRRRL_4jGjFz_sWv0<XR=.RL4O_ml_jV]_HuUK7wdj#_a;_x
RRRRCRRMR8
RRRRR6L._lmOjbV_6_Aa ]ZF)Bj_iP_QdRG:LHCoMR
RRRRRRnRL_lmOjRsW<L=Rgx_e.qM_a;nA
RRRRRRRR_LgmhwWaNg_L=R<R
4;RRRRRRRRLMn_zVa_w=R<R
4;RRRRRRRRH5VRRjL4_EMYQkd_lR[A2R
RRRRRRRRRL_4jGjFz_sWv0<XR=4RL(O_ml_jVaO	TzTJLe;h6
RRRRCRRMR8
RRRRR4L._lmOj]V_HUu_7dwK#a_j_Rx:LHCoMR
RRRRRRnRL_lmOjRsW<L=Rgx_e.qM_a;nA
RRRRRRRR_L6HO1WB=R<R
4;RRRRRRRRH5VRR_LdMrV#j29RRR//Lh(_sNc_[Rg
RRRRRRRRRjL4_zGFjv_WsR0X<L=R4m(_OVlj_Ta	OLzJT6eh;R
RRRRRRDRC#HCRVRR5Lu(_1D$Hg2#RRoLCHRM
RRRRRRRRR_LUM_zaaGKVRR<=4R;
RRRRRRRRR_LgmhwWaNg_L=R<R
4;RRRRRRRRR4RLjF_GzWj_vXs0RR<=L_.jmjOlV6_bA a_Z)F]ji_B;R
RRRRRRMRC8R
RRRRRC
M8RRRRR4RLdO_ml_jVba6An:)PRoLCHRM
RRRRRLRRnO_mlWjsRR<=Leg_x_.MqAan;R
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLMn_zVa_w=R<RL4'4R;
RRRRRHRRVL5R4Mj_YdEQ_[klA=R=RL4'4RR2LHCoMR
RRRRRRRRRL_4jGjFz_sWv0<XR=4RL.O_ml_jVTU(AJ
t;RRRRRRRRC
M8RRRRRMRC8R
RRRRRL_4.mjOlV(_TAtUJ:CRLo
HMRRRRRRRRLmn_OsljW=R<R4L4_.exMe_4nNTO;R
RRRRRC
M8RRRRR4RL(O_ml_jVaO	TzTJLe:h6RoLCHRM
RRRRRLRRnO_mlWjsRR<=LeU_x_.Mc;UD
RRRRCRRMR8
RCRRMN8O#RC
R8CM
R
RNH##oLMR4k._).sOX_VYpR$E=4RL.)_ksXO.VsY_Ljhr9
;
R#RN#MHoR_L(u_p$nRDh=4RLc8_4aIOp_ApVuH_dRL?R4k._).sOX_VYsrLhj:9RR_Ldu;p$
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_a48O_pIpuVA_RdH|L|R4k4_).sOX_VYXR]2LHCoMR
RRRRRH5VRR_L(Mjwts27Y
RRRRRRRR.L4_sk)OV.XYL_shRR={_L(MQYEd,g#RdL4_xMqtvVw_##pPRd,LMd_VR#,LH6_1BWO}R;
RRRRR#CDCVRHR65L_$mP]
d2RRRRRRRRL_4.kO)s.YXV_hsLR{=RL_44MZzad_Jv0,	pR.L4_sk)OV.XYL_sh(rL_aMzZYQkRc+RRL+RUs_hcc_gH+bRR-4RR44:9
};RRRRC
M8RMRC8R
RLMU_)l_$JRstyc542LRR4M4_zaat_W	EJ5]R
RRRR(3L_1[W_WdPR(5L_1[W_WdP2R,
R3RRLMn_VV#_wLR5nV_M#w_V2R,
R3RRLMn_zVa_wLR54Mj_YdEQgw#_0
2,RRRR34L4_APqZ#dJY]_XR45L4q_PAJZd#XY_]
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR36P_m$R]dRLR56P_m$2]d,R
RRLR3nZ_8#g0dRLR5nZ_8#g0d2R,
R3RRLud_pR$RR5RRLu(_pn$_D,h2
RRRRn3L_lmOjRsWRn5L_lmOj2sW,R
RRLR3dV_M#RRRRLR5nV_M#w_Q2R,
R3RRLMd_zRaRR5RRLMn_zQa_w
2,RRRR3_LUPZqAdYJ#RRRRRU5L_APqZ#dJY
2,RRRR3_L(MjwtsR7YRRRR5_L(Mjwts27Y,R
RRLR3(V_M#I_d$RRRRLR5(V_M#I_d$
2,RRRR3_L(M_zadRI$RRRR5_L(M_zad2I$,R
RRLR34P._qdAZJ_#YpR$ERRRR5.L4_APqZ#dJY$_pE
2,RRRR3_LnuZ16VRXRR5RRL_4juZ16VIX_[2e2;C

MF8l8CkD
F
l8CkDR.L4_Wmwh_agI vC8L5R(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLu(_i_KNg
k,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L6m]P$dR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
$,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR(RL_#HptpVW,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRUq_[qD_iB
m,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_1PFOVd_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LUm]P$dt_YR
2;
bRRNlsNCs0CR_L6.j)#lRR=6
;
RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lu(_i_KNg
k;RMRHbRk0Lm6_Pd$];R
RHkMb0dRL_$up;R
RFbk0kL0Rdp_uwR;
RbHMkr0RL.6_)l#j:R49LH(_pV#tW
p;RMRHbRk0L[U_qiq_D;Bm
FRRkk0b04RLdF_P1_OdVsG.L;kT
FRRkk0b0URL_$mP]Yd_t
;
RCRsoLRr6)_.#:jljL9RnF_$s7ju;R
RICHsR6rL_#.)j4l:9(RL_s$Fjku7;R
RsRCoL_4dPOF1dG_V.ksLTR;
RosCR_LUm]P$dt_Y;R

R#N#HRoMLud_p=wRR_Ln$jFsuj7r9
;
RDRNI#N$R5@@Lm6_Pd$]RRFsLu(_i_KNgRk2LHCoMR
RR4RLdF_P1_OdVsG.LRkT<4=R';Lj
RRRR_LUm]P$dt_YRR<=4j'L;R
RRVRH5(RL_KuiNk_gRL2RCMoH
RRRRHRRV!5RLm6_Pd$]RR2
RRRRRLRR4Pd_Fd1O_.VGsTLkRR<=44'L;R
RRRRRCCD#
RRRRRRRR_LUm]P$dt_YRR<=44'L;R
RRMRC8R
RC
M8
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVR_L(uNiK_Rgk2CRLo
HMRRRRRVRH5LR!6P_m$R]d2CRLo
HMRRRRRRRRL$n_Fusj76rL_#.)j4l:9=R<R_L(Htp#V;Wp
RRRRRRRR_Ln$jFsuj7r9=R<R_LU[_qqimDB;R
RRRRRCRM8CCD#
RRRRRRRR_Ln$jFsu<7R=LR{dp_u$L,R(F_$s7juk
};RRRRC
M8RMRC8R

R#N#HRoML$(_Fusj7=kRR_Ln$jFsuL7r6)_.#Rjl:9R4;M
C88lFk
DC
F
l8CkDRMtCCOsH)sqvNLl_D	FORN5s8,8sR#L._	0O,NR80FN_kR0,I8N8sI,RCRM,#	OD,NR80HN_MI,RsCH0_NCMLRDC2H;
M0bkR#L._	0O;M
HbRk0rR44-:R4js9RNs88;k
F00bkRRrg-:R4j89RN_0NF;k0
bHMkI0RCRM,#	OD;M
HbRk0rR44-:R4jI9RNs88;M
HbRk0r-gRRj4:9NR80HN_MH;
M0bkRHIs0CC_MDNLCI;
HRsCsM_CNRL,IM_CN
L;
NRR#o#HM_RsCLMNR!=RRMIC;R
RNH##oIMR_NCMLRR=I0sHCM_CNCLDRI&RC
M;RqR)vnA4__1g1#gR$LM_D	FO_lsNRR5
R3RRq)77qI5RNs88RR2,
RRRRQ37qR5RR08NNM_Hr-URRR4:j29R,RR
R3RR75mq2
,RRRRR
RRRR73q75)AR8sN82sR,RR
R3RR75QARURR'RLj2
,RRRRR3A7m5RRR8NN0_0Fkr-URRR4:j29R,RR
R
RRRRRR3u7QqR5R8NN0_rHMgRR-49:URR2,
RRRRm37u2q5,RR
R3RR7AQu54RR'RLj2
,RRRRR3u7mAR5R8NN0_0Fkr-gRRU4:9,R2RR
RRRR
R3RRW5 qR'R4L24R,RR
R3RR1q1)5'R4L2jR,RR
R3RR 5hqR_RICLMNRR2,
RRRRp3BiRq5#	ODRR2,
RRRR 3WAR5R4j'LRR2,
RRRR131)RA54j'LRR2,
RRRRh3 AR5RsM_CN2LR,RR
R3RRBApi5.RL#O_0	2R2;CR
MF8l8CkD
F
l8CkDRlsN1ODHClsN_FLDO5	RR8sN8Rs,L_.#0,O	R08NNk_F0I,RNs88,CRIM#,RO,D	R08NNM_HR
2;HkMb0.RL#O_0	H;
M0bkRdr4:Rj9s8N8sF;
kk0b0URr:Rj98NN0_0Fk;M
HbRk0I,CMRD#O	H;
M0bkRdr4:Rj9I8N8sH;
M0bkR:rUj89RN_0NH
M;
sIHCURr:Rj980Fkjt;
CsMCHqO)vlsN_FLDOt	RCsMCHqO)v#QM05jRRN3s858ss8N8sjr4:2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k080Fkj
2,R3RRI8N8sN5I8r8s4jj:9
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_2HM,R
RRs3IH_0CCLMND5C5R8IN84srd4:49=R=R8d'j2R22
;
ICHsR:rUj89RF4k0;C
tMHCsOv)qs_NlLODF	CRtMHCsOv)qQ0M#4RR538sN8ss5Ns88r:4jj,92RR
RR.3L#O_0	.5L#O_0	
2,R3RRI5CMI2CM,R
RRN380FN_k805F4k02R,
RIR3Ns8858IN84srj9:j2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH,M2
RRR3HIs0CC_MDNLCR55I8N8sdr4:944RR==d4'8R222;I

HRsCrjU:9FR8k;0.
MtCCOsH)sqvNLl_D	FORMtCCOsH)QqvM.#0R35Rs8N8sN5s8r8s4jj:9R2,
RRR3#L._	0O5#L._	0O2R,
RIR3CIM5C,M2
RRR308NNk_F0F58k20.,R
RRN3I858sI8N8sjr4:2j9,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5I5RNs88r:4d4R49=d=R'R8.2;22
H
IsrCRU9:jRk8F0
d;tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0d5sR3Ns8858sN84srj9:j2
,RR3RRL_.#05O	L_.#02O	,R
RRC3IMC5IM
2,R3RR8NN0_0Fk5k8F0,d2
RRR38IN8Is5Ns88r:4jj,92
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_H2R,
RIR3sCH0_NCML5DC5NRI8r8s44d:4=9R='Rd82dR2
2;
sIHCURr:Rj980Fkct;
CsMCHqO)vlsN_FLDOt	RCsMCHqO)v#QM05cRRN3s858ss8N8sjr4:2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k080Fkc
2,R3RRI8N8sN5I8r8s4jj:9
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_2HM,R
RRs3IH_0CCLMND5C5R8IN84srd4:49=R=R8d'c2R22
;
ICHsR:rUj89RF6k0;C
tMHCsOv)qs_NlLODF	CRtMHCsOv)qQ0M#6RR538sN8ss5Ns88r:4jj,92RR
RR.3L#O_0	.5L#O_0	
2,R3RRI5CMI2CM,R
RRN380FN_k805F6k02R,
RIR3Ns8858IN84srj9:j2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH,M2
RRR3HIs0CC_MDNLCR55I8N8sdr4:944RR==d6'8R222;I

HRsCrjU:9FR8k;0n
MtCCOsH)sqvNLl_D	FORMtCCOsH)QqvMn#0R35Rs8N8sN5s8r8s4jj:9R2,
RRR3#L._	0O5#L._	0O2R,
RIR3CIM5C,M2
RRR308NNk_F0F58k20n,R
RRN3I858sI8N8sjr4:2j9,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5I5RNs88r:4d4R49=d=R'R8n2;22
H
IsrCRU9:jRk8F0
(;tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0(5sR3Ns8858sN84srj9:j2
,RR3RRL_.#05O	L_.#02O	,R
RRC3IMC5IM
2,R3RR8NN0_0Fk5k8F0,(2
RRR38IN8Is5Ns88r:4jj,92
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_H2R,
RIR3sCH0_NCML5DC5NRI8r8s44d:4=9R='Rd82(R2
2;sRCorjU:9NR80FN_k
0;RINDN@$#@RR5s8N8ssRFRk8F0FjRsFR8kR04F8sRF.k0RRFs80FkdsRFRk8F0FcRsFR8kR06F8sRFnk0RRFs80Fk(RR2LHCoMR
RR#ONCRR5s8N8sdr4:944R/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRR'Rd8:jRRNR80FN_k=0RRk8F0
j;RRRRR8d'4RR:R08NNk_F0RR=80Fk4R;
RRRRd.'8RR:R8NN0_0FkR8=RF.k0;R
RRdRR'R8d:8RRN_0NFRk0=FR8k;0d
RRRR'Rd8:cRRNR80FN_k=0RRk8F0
c;RRRRR8d'6RR:R08NNk_F0RR=80Fk6R;
RRRRdn'8RR:R8NN0_0FkR8=RFnk0;R
RRdRR'R8(:8RRN_0NFRk0=FR8k;0(
RRRCOM8N
#CR8CMRN//D$IN#M
C88lFk
DC
8lFkRDCs_NlLODF	RR5s8N8sL,R.0#_OR	,8NN0_0Fk,NRI8,8sRNIC,OR#DR	,8NN0_RHM2H;
M0bkR#L._	0O;M
HbRk0rR4d:9RjR8sN8
s;Fbk0kr0R4R6n:9RjR08NNk_F0H;
M0bkRNIC,OR#D
	;HkMb04RrdRR:jI9RNs88;M
HbRk0rn46Rj:R9NR80HN_MI;
HRsCr44n:Rj98NN0_0Fk_b0l;s

NDl1HsOCNLl_D	FORlsN1ODHC#QM05jRRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr:URR2j9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr:URR2j92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM054RRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrR4(:9Rg2R,
RIR3Ns8858IN84srcRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M(r4Rg:R9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM.#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l.brnRR:42U9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR.n:UR49;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMd#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_ldbr6RR:.2(9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRd6:(R.9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMc#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lcbrcRR:d2n9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRcc:nRd9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM6#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l6brdRR:c269,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR6d:6Rc9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMn#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lnbr.RR:62c9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRn.:cR69;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM(#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l(br4RR:n2d9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR(4:dRn9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMU#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lUbrjRR:(2.9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRUj:.R(9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMg#0R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lUbrgRR:U249,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRUg:4RU9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0jRR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlbg:URR9gj2R,
RIR3Ns8858IN84srcRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_MUrgRg:Rj292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#454RRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr(4jRg:Rg,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4Rj(:gRg9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0.RR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4R4n:jR4U,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4R4n:jR4U292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45dRRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr64.R4:R42(9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr64.R4:R42(92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R4c5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bdr4cRR:49.n2R,
RIR3Ns8858IN84srcRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_Mdr4cRR:49.n2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#604R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4brc:dRR64d9
2,R3RRI8N8sN5I8r8s4-cRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mrc:dRR64d9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0nRR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4R6.:cR4c,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4R6.:cR4c292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45(RRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr44nR4:R62d9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H5'{6LRj,8NN0_rHM4R6n:6R4d29}2R;
NH##o8MRN_0NFRk0=NR80FN_k00_l4br6:nRR;j9
8CMlkF8D
C
lkF8DLCR(w_mWgha#L5Rci_mK
N,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL[(_Wd1_P
W,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLu(_i_KNg
k,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLm6_Pd$],R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdRL_wup,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR6RL_1PFO
d,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLm(_waWhg
p,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmg_waWhgL_NR
2;
HRRM0bkR_LcmNiK;R
RHkMb0(RL_1[W_WdP;R
RHkMb0(RL_KuiNk_g;R
RHkMb06RL_$mP]
d;RkRF00bkR_Ldu;pw
HRRM0bkR_L6POF1dR;
RbHMkr0R4R6n:9RjR_L(mhwWa;gp
HRRM0bkR_LgmhwWaNg_L
;
RCRso4Rr6:nRRRj9LmU_waWhg;p)
sRRCroR4R6n:9RjR_LUmhwWa1gp;R
RsRCorn46Rj:R9URL_WmwhpagQR;
RosCR6r4nRR:jL9RUw_mWghap
J;RCRso4RrdRR:jL9Rg__Pl7xBY,X#R_Lg.x_lBX7Y#L,RUZ_wwXwpY
 ;RHRIsrCR4:dRRRj9L_4jPx_lBX7Y#
0;RHRIsrCR4R6n:9RjR_L(P_wWu;Dv
IRRHRsCL_4jmwFxIih_)
p;RHRIsLCR4Pc_Fd1O_.#s	Tw]xR;
RsIHCgRL_xmFw_IhN
L;RCRso.RL_;.F
sRRCLoR4.4_w_#tgXksA
L;RCRso4RL4w_P#gt_kAsXLR;
RosCR_LU[_qqimDB;R
RsRCor(46Rj:R9(RL_KMY_vAw;R
RICHsR6r4(RR:jL9RUY_MKw_Av
t;RCRso4Rr6:gRRRj9Lm(_.V$$_
w;RCRsodRrgRR:jL9R(._m$_$VtR;
RosCR4r4Rj:R9(RL_$m.$IV_;R
RsRCor:dRRRj9Lm(_.V$$_
C;RCRso(RL_$m.$ V_j
;
R/R/RM#$F$b##sR0NDM#N_0CF
VVRMRHHN0HDgRL_lP_xYB7X=#RRR5~'2Lj;R
RH0MHHRNDL.g__Blx7#YXR5=R~LR'j
2;R/R/RM#$F$b##sR0NDM#N_0CF
M
RDRNI#N$R5@@bCF#8RoCLmc_i2KNRoLCHRM
RLRRUw_mWghap<)R=(RL_Wmwhpag;R
RRURL_Wmwhpag1=R<R_LUmhwWa)gp;R
RRURL_WmwhpagQ=R<R_LUmhwWa1gp;R
RRURL_WmwhpagJ=R<R_LUmhwWaQgp;R
RC
M8
sRRNLl_D	FOR_Ld1RFW5R
RRLR3.0#_OR	R5_L([_W1d2PW,R
RR#R3ORD	RRRR5_LcmNiK2R,
R3RRs8N8sRRRRg5L_lP_xYB7X,#2
RRRRN3I8R8sR5RRL.g__Blx7#YX2R,
R3RR8NN0_RHMRU5L_WmwhpagJ
2,RRRR308NNk_F0LR5(w_PWD_uv
2,RRRR3NICRRRRRLR5.F_.2
2;
LRR4m._waWhgv_ICR 8yc5424RL4w_mWgha_CX4]
R5RRRR3_L([_W1dRPW5_L([_W1d2PW,R
RRLR3(i_uKgN_kLR5(i_uKgN_k
2,RRRR3_L6m]P$dLR56P_m$2]d,R
RRLR3dp_u$LR54mj_FIxwh)_ip
2,RRRR3_LduRpw5_Ldu2pw,R
RRLR3(p_H#WtVpLR5UZ_wwXwpY, 2
RRRRU3L_q[q_BiDmLR5Uq_[qD_iB,m2
RRRR43LdF_P1_OdVsG.LRkT5cL4_1PFO#d_sw.	]2Tx,R
RRLR3UP_m$_]dY5tRLmg_FIxwhL_N2;R2
R
RNNDI$@#R@g5L_Wmwh_agNRL2LHCoMR
RR4RL4w_.#gt_kAsXL=R<RL4'jR;
RLRR.F_.RR<=4j'L;R
RRVRH5gRL_Wmwh_agN2LRRoLCHRM
RRRRR_L..<FR='R4L
4;RRRRR4RL4w_.#gt_kAsXL=R<RL4'4R;
RCRRMR8
R8CM
R
RNNDI$@#R@U5L_KMY_vAwtsRFR_LgmwFxINh_LL2RCMoH
RRRR4L4_#Pwtk_gsLXARR<=4j'L;R
RRVRH5L5RgF_mxhwI_RNL2&R&RL5RUY_MKw_Av4tr6R(92R2
RRRRR4L4_#Pwtk_gsLXARR<=44'L;R
RC
M8
NRRD$IN#@R@5#bFCC8oR_LcmNiKRL2RCMoH
RRRR5HVR_L6POF1dRR2LHCoMR
RRRRRL.g__Blx7#YXRR<=';Lj
RRRRLRRUZ_wwXwpY< R=LR'jR;
RRRRR_LU[_qqimDBRR<=4j'L;R
RRMRC8DRC#HCRVL5R4.4_w_#tgXksA2LRRoLCHRM
RRRRR_LUwwZwp XYRR<=L.g__Blx7#YX;R
RRRRRHRV5L.g__Blx7#YXRR==4UnddRR2LHCoMR
RRRRRRgRL_l._xYB7X<#R=LR'jR;
RRRRRLRRUq_[qD_iB<mR='R4L
4;RRRRRMRC8DRC#RC
RRRRRLRRg__.l7xBYRX#<L=Rg__.l7xBYRX#+;R4
RRRR8CM
CRRM
8
RDRNI#N$R5@@bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5R4Pc_Fd1O_.#s	Tw]x
R2RRRRRgRL_lP_xYB7X<#R=LR'jR;
RCRRDR#CHRV5L_44Ptw#_sgkXRAL2CRLo
HMRRRRRVRH5gRL_lP_xYB7X=#R=nR4dRUd2R
RRRRRRgRL_lP_xYB7X<#R=LR'jR;
RRRRR#CDCR
RRRRRRgRL_lP_xYB7X<#R=4RLj__Pl7xBY0X#R4+R;R
RRMRC8R
RC
M8
NRR#o#HM4RLj__Pl7xBY0X#RL=Rg__Pl7xBY;X#
NRR#o#HMURL_KMY_vAwtRRR=(RL_KMY_vAw;R
RNH##oLMR4mj_FIxwh)_ipRR=Lm(_.V$$_; j
NRRD$IN#@R@5#bFCC8oR_L([_W1dRPW2CRLo
HMRRRRHRV5L_4cPOF1ds_#.]	wT2xRRoLCHRM
RRRRR_L(M_YKArwvj<9R='R4L
4;RRRRR(RL_KMY_vAwr(46R4:R9=R<Rj'L;R
RRMRC8DRC#HCRVL5RgF_mxhwI_RNL2R
RRRRRLM(_YAK_w<vR=LR{UY_MKw_Av4tr6:nRR,j9R_LUM_YKAtwvr(469
};RMRC8R

RINDNR$#@L@5(w_PWD_uvsRFR_L(M_YKA2wvRoLCHRM
RLRR(._m$_$Vw6r4nRR:j=9RR_L(P_wWuRDv&(RL_KMY_vAwr(46R4:R9R;
RLRR(._m$_$Vw6r4(=9RRL4'jR;
RLRR(._m$_$Vw6r4U=9RRL4'jR;
RLRR(._m$_$Vw6r4g=9RRL4'jR;
RLRR(._m$_$Vt9rjRL=R(._m$_$Vw9rjRR||Lm(_.V$$_4wr9|R|R_L(m$.$Vr_w.|9R|(RL_$m.$wV_r;d9
RRRR_L(m$.$Vr_t4=9RR_L(m$.$Vr_wc|9R|(RL_$m.$wV_rR69|L|R(._m$_$Vw9rnRR||Lm(_.V$$_(wr9R;
RLRR(._m$_$Vt9r.RL=R(._m$_$Vw9rURR||Lm(_.V$$_gwr9|R|R_L(m$.$Vr_w4Rj9|L|R(._m$_$Vw4r49R;
RLRR(._m$_$Vt9rdRL=R(._m$_$Vw.r49|R|R_L(m$.$Vr_w4Rd9|L|R(._m$_$Vwcr49|R|R_L(m$.$Vr_w4;69
RRRR_L(m$.$Vr_tc=9RR_L(m$.$Vr_w4Rn9|L|R(._m$_$Vw(r49|R|R_L(m$.$Vr_w4RU9|L|R(._m$_$Vwgr49R;
RLRR(._m$_$Vt9r6RL=R(._m$_$Vwjr.9|R|R_L(m$.$Vr_w.R49|L|R(._m$_$Vw.r.9|R|R_L(m$.$Vr_w.;d9
RRRR_L(m$.$Vr_tn=9RR_L(m$.$Vr_w.Rc9|L|R(._m$_$Vw6r.9|R|R_L(m$.$Vr_w.Rn9|L|R(._m$_$Vw(r.9R;
RLRR(._m$_$Vt9r(RL=R(._m$_$VwUr.9|R|R_L(m$.$Vr_w.Rg9|L|R(._m$_$Vwjrd9|R|R_L(m$.$Vr_wd;49
RRRR_L(m$.$Vr_tU=9RR_L(m$.$Vr_wdR.9|L|R(._m$_$Vwdrd9|R|R_L(m$.$Vr_wdRc9|L|R(._m$_$Vw6rd9R;
RLRR(._m$_$Vt9rgRL=R(._m$_$Vwnrd9|R|R_L(m$.$Vr_wdR(9|L|R(._m$_$VwUrd9|R|R_L(m$.$Vr_wd;g9
RRRR_L(m$.$Vr_t4Rj9=(RL_$m.$wV_r9cjRR||Lm(_.V$$_cwr4|9R|(RL_$m.$wV_r9c.RR||Lm(_.V$$_cwrd
9;RRRRLm(_.V$$_4tr4=9RR_L(m$.$Vr_wcRc9|L|R(._m$_$Vw6rc9|R|R_L(m$.$Vr_wcRn9|L|R(._m$_$Vw(rc9R;
RLRR(._m$_$Vt.r49RR=Lm(_.V$$_cwrU|9R|(RL_$m.$wV_r9cgRR||Lm(_.V$$_6wrj|9R|(RL_$m.$wV_r964;R
RR(RL_$m.$tV_r94dRL=R(._m$_$Vw.r69|R|R_L(m$.$Vr_w6Rd9|L|R(._m$_$Vwcr69|R|R_L(m$.$Vr_w6;69
RRRR_L(m$.$Vr_t4Rc9=(RL_$m.$wV_r96nRR||Lm(_.V$$_6wr(|9R|(RL_$m.$wV_r96URR||Lm(_.V$$_6wrg
9;RRRRLm(_.V$$_4tr6=9RR_L(m$.$Vr_wnRj9|L|R(._m$_$Vw4rn9|R|R_L(m$.$Vr_wnR.9|L|R(._m$_$Vwdrn9R;
RLRR(._m$_$Vtnr49RR=Lm(_.V$$_nwrc|9R|(RL_$m.$wV_r9n6RR||Lm(_.V$$_nwrn|9R|(RL_$m.$wV_r9n(;R
RR(RL_$m.$tV_r94(RL=R(._m$_$VwUrn9|R|R_L(m$.$Vr_wnRg9|L|R(._m$_$Vwjr(9|R|R_L(m$.$Vr_w(;49
RRRR_L(m$.$Vr_t4RU9=(RL_$m.$wV_r9(.RR||Lm(_.V$$_(wrd|9R|(RL_$m.$wV_r9(cRR||Lm(_.V$$_(wr6
9;RRRRLm(_.V$$_4trg=9RR_L(m$.$Vr_w(Rn9|L|R(._m$_$Vw(r(9|R|R_L(m$.$Vr_w(RU9|L|R(._m$_$Vwgr(9R;
RLRR(._m$_$Vtjr.9RR=Lm(_.V$$_Uwrj|9R|(RL_$m.$wV_r9U4RR||Lm(_.V$$_Uwr.|9R|(RL_$m.$wV_r9Ud;R
RR(RL_$m.$tV_r9.4RL=R(._m$_$VwcrU9|R|R_L(m$.$Vr_wUR69|L|R(._m$_$VwnrU9|R|R_L(m$.$Vr_wU;(9
RRRR_L(m$.$Vr_t.R.9=(RL_$m.$wV_r9UURR||Lm(_.V$$_Uwrg|9R|(RL_$m.$wV_r9gjRR||Lm(_.V$$_gwr4
9;RRRRLm(_.V$$_.trd=9RR_L(m$.$Vr_wgR.9|L|R(._m$_$Vwdrg9|R|R_L(m$.$Vr_wgRc9|L|R(._m$_$Vw6rg9R;
RLRR(._m$_$Vtcr.9RR=Lm(_.V$$_gwrn|9R|(RL_$m.$wV_r9g(RR||Lm(_.V$$_gwrU|9R|(RL_$m.$wV_r9gg;R
RR(RL_$m.$tV_r9.6RL=R(._m$_$Vwjr4j|9R|(RL_$m.$wV_r44j9|R|R_L(m$.$Vr_w49j.RR||Lm(_.V$$_4wrj;d9
RRRR_L(m$.$Vr_t.Rn9=(RL_$m.$wV_rc4j9|R|R_L(m$.$Vr_w49j6RR||Lm(_.V$$_4wrjRn9|L|R(._m$_$Vwjr4(
9;RRRRLm(_.V$$_.tr(=9RR_L(m$.$Vr_w49jURR||Lm(_.V$$_4wrjRg9|L|R(._m$_$Vw4r4j|9R|(RL_$m.$wV_r4449R;
RLRR(._m$_$VtUr.9RR=Lm(_.V$$_4wr4R.9|L|R(._m$_$Vw4r4d|9R|(RL_$m.$wV_rc449|R|R_L(m$.$Vr_w4946;R
RR(RL_$m.$tV_r9.gRL=R(._m$_$Vw4r4n|9R|(RL_$m.$wV_r(449|R|R_L(m$.$Vr_w494URR||Lm(_.V$$_4wr4;g9
RRRR_L(m$.$Vr_tdRj9=(RL_$m.$wV_rj4.9|R|R_L(m$.$Vr_w49.4RR||Lm(_.V$$_4wr.R.9|L|R(._m$_$Vw.r4d
9;RRRRLm(_.V$$_dtr4=9RR_L(m$.$Vr_w49.cRR||Lm(_.V$$_4wr.R69|L|R(._m$_$Vw.r4n|9R|(RL_$m.$wV_r(4.9R;
RLRR(._m$_$Vt.rd9RR=Lm(_.V$$_4wr.RU9|L|R(._m$_$Vw.r4g|9R|(RL_$m.$wV_rj4d9|R|R_L(m$.$Vr_w49d4;R
RR(RL_$m.$tV_r9ddRL=R(._m$_$Vwdr4.|9R|(RL_$m.$wV_rd4d9|R|R_L(m$.$Vr_w49dcRR||Lm(_.V$$_4wrd;69
RRRR_L(m$.$Vr_tdRc9=(RL_$m.$wV_rn4d9|R|R_L(m$.$Vr_w49d(RR||Lm(_.V$$_4wrdRU9|L|R(._m$_$Vwdr4g
9;RRRRLm(_.V$$_dtr6=9RR_L(m$.$Vr_w49cjRR||Lm(_.V$$_4wrcR49|L|R(._m$_$Vwcr4.|9R|(RL_$m.$wV_rd4c9R;
RLRR(._m$_$Vtnrd9RR=Lm(_.V$$_4wrcRc9|L|R(._m$_$Vwcr46|9R|(RL_$m.$wV_rn4c9|R|R_L(m$.$Vr_w49c(;R
RR(RL_$m.$tV_r9d(RL=R(._m$_$Vwcr4U|9R|(RL_$m.$wV_rg4c9|R|R_L(m$.$Vr_w496jRR||Lm(_.V$$_4wr6;49
RRRR_L(m$.$Vr_tdRU9=(RL_$m.$wV_r.469|R|R_L(m$.$Vr_w496dRR||Lm(_.V$$_4wr6Rc9|L|R(._m$_$Vw6r46
9;RRRRLm(_.V$$_dtrg=9RR_L(m$.$Vr_w496nRR||Lm(_.V$$_4wr6R(9|L|R(._m$_$Vw6r4U|9R|(RL_$m.$wV_rg469R;
RLRR(._m$_$VI9rjRL=R(._m$_$Vt9rjRR||Lm(_.V$$_4tr9|R|R_L(m$.$Vr_t.|9R|(RL_$m.$tV_r;d9
RRRR_L(m$.$Vr_I4=9RR_L(m$.$Vr_tc|9R|(RL_$m.$tV_rR69|L|R(._m$_$Vt9rnRR||Lm(_.V$$_(tr9R;
RLRR(._m$_$VI9r.RL=R(._m$_$Vt9rURR||Lm(_.V$$_gtr9|R|R_L(m$.$Vr_t4Rj9|L|R(._m$_$Vt4r49R;
RLRR(._m$_$VI9rdRL=R(._m$_$Vt.r49|R|R_L(m$.$Vr_t4Rd9|L|R(._m$_$Vtcr49|R|R_L(m$.$Vr_t4;69
RRRR_L(m$.$Vr_Ic=9RR_L(m$.$Vr_t4Rn9|L|R(._m$_$Vt(r49|R|R_L(m$.$Vr_t4RU9|L|R(._m$_$Vtgr49R;
RLRR(._m$_$VI9r6RL=R(._m$_$Vtjr.9|R|R_L(m$.$Vr_t.R49|L|R(._m$_$Vt.r.9|R|R_L(m$.$Vr_t.;d9
RRRR_L(m$.$Vr_In=9RR_L(m$.$Vr_t.Rc9|L|R(._m$_$Vt6r.9|R|R_L(m$.$Vr_t.Rn9|L|R(._m$_$Vt(r.9R;
RLRR(._m$_$VI9r(RL=R(._m$_$VtUr.9|R|R_L(m$.$Vr_t.Rg9|L|R(._m$_$Vtjrd9|R|R_L(m$.$Vr_td;49
RRRR_L(m$.$Vr_IU=9RR_L(m$.$Vr_tdR.9|L|R(._m$_$Vtdrd9|R|R_L(m$.$Vr_tdRc9|L|R(._m$_$Vt6rd9R;
RLRR(._m$_$VI9rgRL=R(._m$_$Vtnrd9|R|R_L(m$.$Vr_tdR(9|L|R(._m$_$VtUrd9|R|R_L(m$.$Vr_td;g9
RRRR_L(m$.$Vr_I4Rj9='R4L
j;RRRRLm(_.V$$_4Ir4=9RRL4'jR;
RLRR(._m$_$VC9rjRL=R(._m$_$VI9rjRR||Lm(_.V$$_4Ir9|R|R_L(m$.$Vr_I.|9R|(RL_$m.$IV_r;d9
RRRR_L(m$.$Vr_C4=9RR_L(m$.$Vr_Ic|9R|(RL_$m.$IV_rR69|L|R(._m$_$VI9rnRR||Lm(_.V$$_(Ir9R;
RLRR(._m$_$VC9r.RL=R(._m$_$VI9rURR||Lm(_.V$$_gIr9|R|R_L(m$.$Vr_I4Rj9|L|R(._m$_$VI4r49R;
RLRR(._m$_$VC9rdR4=R';Lj
RRRR_L(m$.$Vj_ RL=R(._m$_$VC9rjRR||Lm(_.V$$_4Cr9|R|R_L(m$.$Vr_C.|9R|(RL_$m.$CV_r;d9
CRRM
8
ClM8FD8kCl

FD8kC4RL.P_Ml_wpDGN4$R]5L_4dMwPlpG_V.ksLTR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4L4_sk)Ok_gsLXA,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLMg_PplwTL_N,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLMg_Pplw)L_N,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLMg_Pplw]L_N,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLMg_PplwbL_N,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLMg_PplwuL_NjR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNa_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNx_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNQ_L;R2
R
RbNNslCC0sURL__hHmgNU.RR=cR;
RsbNN0lCCLsR4md_FAKOXG_Wzin)Rc=R'jLjj
j;RNRbsCNl0RCsL_4dmOFKAWX_G)znpRR=cj'Lj;j4
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=ARRLc'jjj4;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)[='RcL4jj4R;
RsbNN0lCCLsR4md_FAKOXG_WzKn)jRR=cj'L4;jj
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=hRRLc'j44j;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)0='RcL4j4jR;
RsbNN0lCCLsR4md_FAKOXG_WzBn)Rc=R'4Lj4
4;
HRRM0bkRUrL__hHmgNU.9:4RdL4_lMPwVp_GL.sk
T;RMRHbRk0L_44kO)s_sgkX;AL
FRRkk0b0gRL_lMPw_pTN
L;RkRF00bkR_LgMwPlpN)_LR;
R0FkbRk0LMg_Pplw]L_N;R
RFbk0kL0RgP_Mlbwp_;NL
FRRkk0b0gRL_lMPw_puN;Lj
FRRkk0b0gRL_lMPw_paN
L;RkRF00bkR_LgMwPlpNx_LR;
R0FkbRk0LMg_PplwQL_N;R
RsRCoLMg_PplwTL_N;R
RsRCoLMg_Pplw)L_N;R
RsRCoLMg_Pplw]L_N;R
RsRCoLMg_PplwbL_N;R
RsRCoLMg_PplwuL_NjR;
RosCR_LgMwPlpNa_LR;
RosCR_LgMwPlpNx_LR;
RosCR_LgMwPlpNQ_L
;

NRRD$IN#@R@R45LdP_Ml_wpVsG.LRkTFLsR4k4_)_sOgXksARL2LHCoMR
RRgRL_lMPw_pTN<LR='R4L
j;RRRRLMg_Pplw)L_NRR<=4j'L;R
RRgRL_lMPw_p]N<LR='R4L
j;RRRRLMg_PplwbL_NRR<=4j'L;R
RRgRL_lMPw_puNRLj<4=R';Lj
RRRR_LgMwPlpNa_L=R<RL4'jR;
RLRRgP_Mlxwp_RNL<4=R';Lj
RRRR_LgMwPlpNQ_L=R<RL4'jR;
RHRRVLR54k4_)_sOgXksA=LR='R4LR42LHCoMR
RRRRROCN#54RLdP_Ml_wpVsG.LRkT2/R/RM#$F$b##NRbsDNDCOD_N
#CRRRRRRRRL_4dmOFKAWX_G)zniL:RgP_MlTwp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)Rp:LMg_Pplw)L_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)AR_LgMwPlpN]_L=R<RL4'4R;
RRRRRLRR4md_FAKOXG_Wz[n):gRL_lMPw_pbN<LR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)znKRj:LMg_PplwuL_Nj=R<RL4'4R;
RRRRRLRR4md_FAKOXG_Wzhn):gRL_lMPw_paN<LR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)zn0L:RgP_Mlxwp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)RB:LMg_PplwQL_NRR<=44'L;R
RRRRRCOM8N
#CRRRRC
M8RMRC8M
C88lFk
DC
8lFkRDCLu(_pnw_DRh5L_4dMwPlpG_V.ksLTR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4uj_pAw_oLV7 R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4uj_pAw_oLV7wR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4uj_pAw_oLV7PR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4uj_pAw_oLV78R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4uj_pAw_oLV77
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
],RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
M,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p2wR;R

RsbNN0lCCLsRUH_h_UmNg=.RR
c;RNRbsCNl0RCsL_4dmOFKAWX_G)zniRR=cj'Lj;jj
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=pRRLc'j4jj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)A='RcL4jjjR;
RsbNN0lCCLsR4md_FAKOXG_Wz[n)Rc=R'jLj4
4;RNRbsCNl0RCsL_4dmOFKAWX_G)znK=jRRLc'jj4j;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)h='RcLjj44R;
RsbNN0lCCLsR4md_FAKOXG_Wz0n)Rc=R'4Lj4
j;
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=BRRLc'j444;R

HkMb0LRrUH_h_UmNg4.:94RLdP_Ml_wpVsG.L;kT
MRHbRk0RjL4_wup_VAo7;L 
MRHbRk0RjL4_wup_VAo7;Lw
MRHbRk0RjL4_wup_VAo7;LP
MRHbRk0RjL4_wup_VAo7;L8
MRHbRk0RjL4_wup_VAo7jL7;H
RM0bkR4RLjp_uwo_AV]7L;H
RM0bkR4RLjp_uwo_AVM7L;F
Rkk0b0dRL_wup;s
RCLoRdp_uw
;
RDRNI#N$R5@@RdL4_lMPwVp_GL.skFTRsR
RRRRRRRRRR4RLjp_uwo_AV 7LR
FsRRRRRRRRRRRRL_4ju_pwA7oVLFwRsR
RRRRRRRRRR4RLjp_uwo_AVP7LR
FsRRRRRRRRRRRRL_4ju_pwA7oVLF8RsR
RRRRRRRRRR4RLjp_uwo_AV77LjsRF
RRRRRRRRRRRRjL4_wup_VAo7RL]FRs
RRRRRRRRRLRR4uj_pAw_oLV7MRR2LHCoMR
RRNRO#RC5L_4dMwPlpG_V.ksLTRR2/#/R$bMF#R$#bNNsDDDC_#ONCR
RRRRRL_4dmOFKAWX_G)zniL:Rdp_uw=R<RjL4_wup_VAo7;L 
RRRRLRR4md_FAKOXG_Wzpn):dRL_wupRR<=L_4ju_pwA7oVL
w;RRRRR4RLdF_mKXOA_zWGn:)AR_LduRpw<L=R4uj_pAw_oLV7PR;
RRRRRdL4_KmFO_AXWnGz)R[:Lud_p<wR=4RLjp_uwo_AV87L;R
RRRRRL_4dmOFKAWX_G)znKRj:Lud_p<wR=4RLjp_uwo_AV77LjR;
RRRRRdL4_KmFO_AXWnGz)Rh:Lud_p<wR=4RLjp_uwo_AV]7L;R
RRRRRL_4dmOFKAWX_G)zn0L:Rdp_uw=R<RjL4_wup_VAo7;LM
RRRRLRR4md_FAKOXG_WzBn):dRL_wupRR<=L_4ju_pwA7oVL
 ;RRRRRCR8VDNk0R:RRRRRRRRRRLRRdp_uw=R<RL4'jR;
RCRRMN8O#RC
R8CM
8CMlkF8D
C
lkF8DLCRdi_ks
R5RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_44kO)s_sgkX,AL
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_lMPwVp_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
$,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
w,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLu(_pu$_D
v,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.uH1$A7oVL8_L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL.1_u$XH.V_YwL
8,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4cmhwWaEg	W_J]d
H,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4duH1$A7oVLc_Z7R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4ud_1.$HXwVY_7Zc,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL6w_mWgha	JEW]g_)	R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4M._zAaToLV7_,L8
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRcL4_a48O_pIpuVA_,dH
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_aMzTVAo7ZL_c
7,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_46MQYEdIg#v8C _,vo
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRnL4_EMYQ#dgI vC8(_qUR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4P4_qdAZJ_#YX
],RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.PZqAdYJ#_Ep$,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL4)_ksXO.VXY_]R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4k._).sOX_VYp2$ERR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*R
;
RNRbsCNl0RCsLhU_HN_mURg.=;Rc
HRRM0bkR4L4_sk)Ok_gsLXA;R
RHkMb0LRrUH_h_UmNg4.:94RLdP_Ml_wpVsG.L;kT
HRRM0bkR_Ldu;p$
FRRkk0b0dRL_wup;R
RFbk0kL0R(p_u$D_uvR;
R0FkbRk0L_4.uH1$A7oVL8_L;R
RFbk0kL0R4u._1.$HXwVY_;L8
FRRkk0b04RLcw_mWgha	JEW]H_d;R
RFbk0kL0R4M._zAaToLV7_;L8
FRRkk0b04RLc8_4aIOp_ApVuH_d;R
RFbk0kL0R4M6_YdEQgv#IC_ 8v
o;RkRF00bkR4L4_APqZ#dJY]_X;R
RFbk0kL0R4k4_).sOX_VYX
];RMRHbRk0L_4duH1$A7oVLc_Z7R;
RbHMkL0R4ud_1.$HXwVY_7Zc;R
RHkMb04RL6w_mWgha	JEW]g_)	R;
RbHMkL0R4Md_zAaToLV7_7Zc;R
RHkMb04RLnY_MEgQd#CIv q8_(
U;RMRHbRk0L_4.PZqAdYJ#_Ep$;R
RHkMb04RL.)_ksXO.VpY_$
E;
IRRHRsCLu(_pQw_w
v;
IRRHRsCL_4cMjYAK_KBwN0_xRq,L_4nuH1$A7oVL8_L_lVo,4RLUw_mWgha	JEW]H_d_e4B,4RLgY_MEgQd#CIv v8_o7_xGL,R4P6_qdAZJ_#YXI]_H
$;RHRIsLCR4k6_).sOX_VYXI]_H
$;RHRIsLCR44U_8paOIV_pAdu_HB_4e
;
R4RL.P_Ml_wpDGN4$L]R4Mj_PA#O_#stp
R5RRRRRLR34k4_)_sOgXksARLRR5RRR4L4_sk)Ok_gsLXAR
2,RRRRRLR34Md_Pplw_.VGsTLkRRRRRL5R4Md_Pplw_.VGsTLkR
2,RRRRRLR3gP_MlTwp_RNL54RLcY_MAKjKB0_w_qNxR
2,RRRRRLR3gP_Ml)wp_RNL54RLn1_u$oHAV_7LLV8_o2lR,R
RRRRR3_LgMwPlpN]_LRR5L_4UmhwWaEg	W_J]d4H_B2eR,R
RRRRR3_LgMwPlpNb_LRR5L_4nuH1$.YXVw8_L_lVoR
2,RRRRRLR3gP_Mluwp_jNLRL5R4Mg_YdEQgv#IC_ 8vxo_72GR,R
RRRRR3_LgMwPlpNa_LRR5L_46PZqAdYJ#__X]IRH$2R,
RRRRRg3L_lMPw_pxN5LRR6L4_sk)OV.XY]_X_$IHR
2,RRRRRLR3gP_MlQwp_RNL54RLU8_4aIOp_ApVuH_d_e4BR;22
R
RLu(_pnw_DLhR4u._pnw_DUh_0RYP5R
RRRRR3dL4_lMPwVp_GL.skRTRRRR5L_4dMwPlpG_V.ksLT,R2
RRRR3RRL_4ju_pwA7oVL5 RRdL4_aMzTVAo7ZL_c27R,R
RRRRR3jL4_wup_VAo7RLw54RLd1_u$oHAV_7LZRc72R,
RRRRR43Ljp_uwo_AVP7LRL5R4m6_waWhgW	EJ)]_g2	R,R
RRRRR3jL4_wup_VAo7RL854RLd1_u$XH.V_YwZRc72R,
RRRRR43Ljp_uwo_AV77LjRR5L_4nMQYEdIg#v8C _Uq(R
2,RRRRRLR34uj_pAw_oLV7]RR5L_4.PZqAdYJ#_Ep$R
2,RRRRRLR34uj_pAw_oLV7MRR5L_4.kO)s.YXV_Ep$R
2,RRRRRLR3dp_uwRRRRRRRRL5R(p_uww_Qv2R2;R

R#N#HRoMLud_pRwRRRRRRRR=Lu(_pQw_w&vRR4L4_sk)Ok_gsLXA;R
RNH##oLMR(p_u$D_uvRRRRRRRRL=Rdp_u$R;
R#N#HRoML_4.uH1$A7oVL8_LR=RRRnL4_$u1HVAo7LL_8o_VlR;
R#N#HRoML_4.uH1$.YXVw8_LR=RRRnL4_$u1HV.XYLw_8o_VlR;
R#N#HRoML_4cmhwWaEg	W_J]d=HRRUL4_Wmwh	agE]WJ__dH4;Be
NRR#o#HM4RL.z_MaoTAV_7LLR8RR=RRRcL4_AMYjBKK__w0N;xq
NRR#o#HM4RL6Y_MEgQd#CIv v8_oRRRRRR=L_4gMQYEdIg#v8C __vox;7G
NRR#o#HM4RL4q_PAJZd#XY_]RRRRRR=L_46PZqAdYJ#__X]I;H$
NRR#o#HM4RL4)_ksXO.VXY_]RRRRRR=L_46kO)s.YXV__X]I;H$
NRR#o#HM4RLc8_4aIOp_ApVuH_dRRRRRL=R44U_8paOIV_pAdu_HB_4eC;
MF8l8CkD
F
l8CkDR_LUM$)_ltJs5(RL_1[W_WdP,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LnM_V#V
w,RRRRRRRRRRRRRRRRRRRRRRRRRLRRnz_Maw_V,R
RRRRRRRRRRRRRRRRRRRRRRRRRR4L4_APqZ#dJY]_X,R
RRRRRRRRRRRRRRRRRRRRRRRRRRcL4_a48O_pIpuVA_,dH
RRRRRRRRRRRRRRRRRRRRRRRRRRRLm6_Pd$],R
RRRRRRRRRRRRRRRRRRRRRRRRRR_Ln80Z#d
g,RRRRRRRRRRRRRRRRRRRRRRRRRLRRdp_u$R,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_lmOj,sW
RRRRRRRRRRRRRRRRRRRRRRRRRRRLMd_V
#,RRRRRRRRRRRRRRRRRRRRRRRRRLRRdz_MaR,
RRRRRRRRRRRRRRRRRRRRRRRRRURL_APqZ#dJYR,
RRRRRRRRRRRRRRRRRRRRRRRRR(RL_tMwjYs7,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_L(M_V#d,I$
RRRRRRRRRRRRRRRRRRRRRRRRRRRLM(_zda_I
$,RRRRRRRRRRRRRRRRRRRRRRRRRLRR4P._qdAZJ_#Yp,$E
RRRRRRRRRRRRRRRRRRRRRRRRRRRLun_1V6ZX;R2
bRRNlsNCs0CR_L(MZzaQRkY=;R4
bRRNlsNCs0CR_LUh_scgbcHR6=R;R
RbNNslCC0sURL_chs_zNUb=RRRL6'jjjjj
;
RMRHbRk0L[(_Wd1_P
W;RMRHbRk0LMn_VV#_wR;
RbHMkL0Rnz_Maw_V;R
RHkMb04RL4q_PAJZd#XY_]R;
RbHMkL0R44c_8paOIV_pAdu_HR;
RbHMkL0R6P_m$;]d
HRRM0bkR_Ln80Z#d
g;RMRHbRk0Lud_p
$;RMRHbRk0LM(_wstj7
Y;RMRHbRk0rURL_chs_Hgcb:-4jRR9Lmn_OsljWR;
RbHMkL0Rn1_u6XZV;R
RFbk0kr0RR_LUh_scgbcH-j4:RL9RdV_M#R;
R0FkbRk0r(RL_aMzZYQk-j4:RL9Rdz_MaR;
R0FkbRk0LPU_qdAZJ;#Y
FRRkk0b0(RL_#MV_$dI;R
RFbk0kL0R(z_MaI_d$R;
R0FkbRk0L_4.PZqAdYJ#_Ep$;R

RosCRUrL_chs_HgcbRR-49:jRjL4_#MV_	vgY;Vs
IRRHRsCr_LUh_scgbcHR4-R:R49L_44M_V#vYg	V;s]
sRRCroRLM(_zQaZk-YRRj4:94RLjz_Mag_v	sYV;R
RICHsR(rL_aMzZYQkR4-R:R49L_44M_zavYg	V;s]
sRRCLoR4P6_qdAZJ_#Yk)Ldl
C;RHRIsrCRLhU_sgc_c-Hb49:jR_L6M_V#aR;
RsIHCLRr(z_MakZQY:-4jL9R6z_Ma;_a
IRRHRsCL_4jPZqAdYJ#_
A;RCRsoRRrLhU_sgc_c-Hb4R:j9dRL_#MV;R
RsRCor(RL_aMzZYQk-j4:RL9Rdz_MaR;
RosCR_LUPZqAdYJ#;R

R#N#HRoMLM6_Va#_RL=R4Mj_Vv#_gV	YsUrL_chs_Hgcb:-4j
9;R#RN#MHoR_L6M_zaaRR=L_4jM_zavYg	VLsr(z_MakZQYRR-49:j;R
RNH##oLMR4Pj_qdAZJ_#YARR=L_46PZqAdYJ#_dkL);lC
NRR#o#HM(RL_#MV_$dIRL=R4Mj_Vv#_gV	Ys9rj;R
RNH##oLMR(z_MaI_d$RR=L_4jM_zavYg	Vjsr9R;
R#N#HRoML_4.PZqAdYJ#_Ep$RL=R4P6_qdAZJ_#Yk)Ldl
C;
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2CRLo
HMRRRRHRV5LMn_VV#_wRR2LHCoMR
RRRRRLMd_V<#R=6RL_#MV_
a;RRRRC
M8RMRC8R

RINDNR$#@R@5bCF#8RoCL8n_Zd#0gRR2LHCoMR
RRVRH5nRL_aMz_RVw2CRLo
HMRRRRRdRL_aMzRR<=LM6_zaa_;R
RRMRC8R
RC
M8
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0RdgFbsRF8#CoLCRn1_u6XZVRL2RCMoH
RRRR5HVR_LnuZ16V2XR
RRRRLRRUq_PAJZd#<YR='R4L
j;RRRRCCD#R5HVR4L4_APqZ#dJY]_XRL2RCMoH
RRRRLRRUq_PAJZd#<YR=4RLjq_PAJZd#AY_;R
RRMRC8R
RC
M8
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVR_LnM_V#V|wR|4RLc8_4aIOp_ApVuH_dRL2RCMoH
RRRRHRRVL5R(w_Mt7jsY
R2RRRRRRRRL_4jM_V#vYg	VLsrUs_hcc_gH-bRRj4:9=R<R_LnmjOls
W;RRRRRDRC#HCRVL5R6P_m$R]d2R
RRRRRR4RLjV_M#g_v	sYVRR<={_Ldu,p$R4L4_#MV_	vgY]Vs}R;
RCRRMR8
RHRRVL5Rnz_Maw_VRR&&Lm6_Pd$]RL2RCMoH
RRRRLRR4Mj_zva_gV	Ys=R<Rd{L_$up,4RL4z_Mag_v	sYV]
};RRRRC
M8RRRRHRV5L_44PZqAdYJ#_RX]&L&R6P_m$R]d2CRLo
HMRRRRR4RL6q_PAJZd#kY_Lld)C=R<R_Ldu;p$
RRRR8CM
CRRMR8
R#N#HRoML_44M_V#vYg	VRs]=4RLjV_M#g_v	sYVr_LUh_scgbcHR4-RR4:R9R;
R#N#HRoML_44M_zavYg	VRs]=4RLjz_Mag_v	sYVr_L(MZzaQRkY-RR4:9R4;M
C88lFk
DC
8lFkRDCL4d_.5lR
LRRci_mK
N,R(RL_1[W_WdP,R
RLu(_i_KNg
k,R6RL_$mP]
d,RdRL_$up,R
RL_4dkQp6dFB0_w[uAR,
R.L4_aMzTVAo7LL_8R,
RcL4_a48O_pIpuVA_,dH
LRR4M6_YdEQgv#IC_ 8v
o,R4RL4q_PAJZd#XY_]R,
R4L4_sk)OV.XY]_X,R
RLM(_wstj7
Y,RdRL_wup,R
RLm6_Ouax,R
RL_4dMTzaA7oVLc_Z7R,
RnL4_EMYQ#dgI vC8(_qUR,
R.L4_APqZ#dJY$_pER,
R.L4_sk)OV.XY$_pER,
R4L4_1PFONdswwNX,R
RLmg_waWhgL_N,R
RL_4jmhwWasgD0
C,RgRL_$1p$s_ht;72
R
RHkMb0cRL_KmiNR;
RbHMkL0R(W_[1P_dWR;
RbHMkL0R(i_uKgN_kR;
RbHMkL0R6P_m$;]d
HRRM0bkR_Ldu;p$
HRRM0bkRdL4_6kpQ0dBFu_[w
A;RMRHbRk0LM(_wstj7
Y;RMRHbRk0L_4.MTzaA7oVL8_L;R
RHkMb04RLc8_4aIOp_ApVuH_d;R
RHkMb04RL6Y_MEgQd#CIv v8_oR;
RbHMkL0R4P4_qdAZJ_#YX
];RMRHbRk0L_44kO)s.YXV_;X]
FRRkk0b0dRL_wup;R
RFbk0kL0R6O_ma;xu
FRRkk0b04RLdz_MaoTAV_7LZ;c7
FRRkk0b04RLnY_MEgQd#CIv q8_(
U;RkRF00bkR.L4_APqZ#dJY$_pER;
R0FkbRk0L_4.kO)s.YXV_Ep$;R
RFbk0kL0R4P4_Fd1OsNNwX
w;RkRF00bkR_LgmhwWaNg_LR;
R0FkbRk0r4j:6Rn9L_4jmhwWasgD0
C;RMRHbRk0r4j:6R(9L1g_p_$$h7st;R

RsIHC4RL6F_P1sOdNXwNwH_I$R;
RsIHC6RL_WH1O
B;RHRIsLCR4kj_zKajBwcosR;
RsIHCdRr4RR:jL9R4Mj_YaWhgLhIpR;
RosCR4rdRj:R94RLcY_MWghahpIL_1Ld;R

R#N#HRoMLm6_OuaxR4=R';Lj
R
RNH##oLMR4P4_Fd1OsNNwX=wRR6L4_1PFONdswwNX_$IH;R

R#N#HRoML_44MZzad_Jv0R	p=4RLcY_MWghahpIL_1Ldr;j9
R
RNH##oLMR4mj_waWhg0DsCRR={_Lg1$p$_ths7Rrj:4Rd9L,Rgp_1$h$_srt7d:.RR9d6,gRL_$1p$s_htd7rnRR:d,g9R_Lg1$p$_ths7jrcRc:RjR9,L1g_p_$$h7strRc4:4Rc9L,Rgp_1$h$_srt7c:.RR9c6,RR
RRRRRRRRRRRRL1g_p_$$h7strRcn:gRc9L,Rgp_1$h$_srt76:jRR96j,gRL_$1p$s_ht67r4RR:6,49R_Lg1$p$_ths7.r6R6:R.R9,L1g_p_$$h7strR6d:dR69L,Rgp_1$h$_srt76:cRR96c,RR
RRRRRRRRRRRRL1g_p_$$h7strR66:6R69L,Rgp_1$h$_srt76:nRR96n,gRL_$1p$s_ht67r(RR:n,j9R_Lg1$p$_ths74rnRn:R4R9,L1g_p_$$h7strRn.:.Rn9L,Rgp_1$h$_srt7n:dRR9nd,RR
RRRRRRRRRRRRL1g_p_$$h7strRnc:6Rg9L,Rgp_1$h$_srt7g:nRR(4.9L,Rgp_1$h$_srt74R.U:dR44R9,L1g_p_$$h7str.4dR4:Rd,69R_Lg1$p$_ths7dr4nRR:49dn,gRL_$1p$s_ht47rd:(RR(4d9
,RRRRRRRRRRRRRR_Lg1$p$_ths7dr4URR:49dU,gRL_$1p$s_ht47rd:gRRg4d9L,Rgp_1$h$_srt74Rcj:cR4jR9,L1g_p_$$h7str44cR4:Rc,49R_Lg1$p$_ths7cr4.RR:49c.,gRL_$1p$s_ht47rc:dRRd4c9
,RRRRRRRRRRRRRR_Lg1$p$_ths7cr4cRR:49cc,gRL_$1p$s_ht47rc:6RR64c9L,Rgp_1$h$_srt74Rcn:cR4nR9,L1g_p_$$h7str(4cR4:Rc,(9R_Lg1$p$_ths7cr4URR:49cU,gRL_$1p$s_ht47rc:gRRg4c9
,RRRRRRRRRRRRRR_Lg1$p$_ths76r4jRR:496j,gRL_$1p$s_ht47r6:4RR4469L,Rgp_1$h$_srt74R6.:6R4.R9,L1g_p_$$h7strd46R4:R6,d9R_Lg1$p$_ths76r4cRR:496c,gRL_$1p$s_ht47r6:6RR6469
,RRRRRRRRRRRRRR_Lg1$p$_ths76r4nRR:496n}R;
RINDNR$#@R@5bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5R44c_8paOIV_pAdu_H|R|R4L4_sk)OV.XY]_X2CRLo
HMRRRRRVRHRL5R(w_Mt7jsYR2
RRRRRLRR4Mc_YaWhgLhIpd_L1RR=L_4jMhYWaIghL
p;RRRRRDRC#HCRVLR56P_m$2]d
RRRRRRRRcL4_WMYhhagI_LpLRd1=LR{dp_u$L,R4Mc_YaWhgLhIpd_L14rd:}49;R
RRMRC8R
RC
M8R(RL_AmB$BpXR4y5cL2R6z_MaRta5R
RRLR3ci_mKLN5ci_mK,N2
RRRR(3L_$u1H#Dg5jL4_akzjcKBo2ws,R
RRLR3(W_[1P_dW(5L_1[W_WdP2R,
R3RRLm6_Pd$]5_L6m]P$d
2,RRRR3_Ln80Z#dLg54kd_pd6QB_0F[Auw2R,
R3RRLud_pL$5dp_u$
2,RRRR3_LnM_V#VLw54M._zAaToLV7_2L8,R
RRLR344c_8paOIV_pAdu_H45Lc8_4aIOp_ApVuH_d2R,
R3RRL_4jMQYEd_g#wL054M6_YdEQgv#IC_ 8v,o2
RRRR43L4q_PAJZd#XY_]45L4q_PAJZd#XY_]
2,RRRR34L4_sk)OV.XY]_X54L4_sk)OV.XY]_X2R,
R3RRLH6_1BWO5_L6HO1WB
2,RRRR3_LgmhwWaNg_Lg5L_Wmwh_agN,L2
RRRR43L.F_P1_Odo#lNLLL54P6_Fd1OsNNwXIw_H,$2
RRRR(3L_tMwjYs75_L(Mjwts27Y,R
RRLR3(V_M#I_d$45Ldz_MaoTAV_7LZ2c7,R
RRLR3(z_MaI_d$45LnY_MEgQd#CIv q8_(,U2
RRRR43L.q_PAJZd#pY_$LE54P._qdAZJ_#Yp2$E,R
RRLR34M4_zdaZJ0v_	Lp54M4_zdaZJ0v_	,p2
RRRR43L.)_ksXO.VpY_$LE54k._).sOX_VYp2$E2
;
R(RL_wuVxYshR_LcuxVwRR5
R3RRLmc_i5KNLmc_i2KN,R
RRLR36F_P15OdL_46POF1dwsNN_XwI2H$,R
RRLR361_HW5OBLH6_1BWO2R,
R3RRL1g_p_$$h7st5_Lg1$p$_ths7
2,RRRR3_L(uH1$D5g#L_4jkjzaKoBcw,s2
RRRR(3L_1[W_WdP5_L([_W1d2PW,R
RRLR3(i_uKgN_k(5L_KuiNk_g2R,
R3RRLud_pL$5dp_u$
2,RRRR3_L6m]P$d65L_$mP],d2
RRRR43LjY_MWghahpIL5jL4_WMYhhagI2Lp,R
RRLR3dp_uwd5L_wup2
2;
8CMlkF8D
C
lkF8DDCR84HO_
j5RBRuQ7_q,RR
RQuB_ BA,RR
RQuB_iBp,RR
RQuB_e7 1, pRR
Ru_BQwv)q 
,RRBRuQh_ta
,RRBRuQ7_Q1, pRR
Ru_BQQqhaL
,RRBRuQh_Qa,ALRR
Ru_BQQBhaL
,RRBRuQh_Qa,7LRR
Ru_BQQY)7,RR
RQuB_)uq,RR
RQuB_)u )
,RRBRuQ _)T
,RRBRuQ _1)R),
uRRB1Q_a,muRR
Ru_BQaY)7,RR
RHN8M
,RR8RNF,k0RR
ROHLCM,_LRR
ROFLCkL0_,RR
RP8C#HCDM,_LRR
R8#CPCkDF0,_LRR
RVlsNC_HML
,RRsRVNFlCkL0_,RR
R#H8CRD,
HRRsH8$M,_LRR
RH$s8F_k0L
,RRCRF_,N8RR
RFOC_LRC,
FRRCC_8PD#C,RR
R_FCVlsNC
,RRCRF_8Hs$
,RRCRF_sbN,RR
R_FCbsCs,RR
R_FCs,CJRR
RF#C_0,FbRR
RF0C_s,8$RR
R#b0FHLM_,RR
RF#0b0Fk_RL,
0RRsH8$M,_LRR
R0$s8F_k0L
,RRDRB	
,RRbRkD	HM_;d2
M
HbRk0r:d4ju9RBqQ_7H;
M0bkR:rdju9RBBQ_A
 ;HkMb0dRr:Rj9u_BQB;pi
bHMku0RB7Q_  e1pH;
M0bkRQuB_qw)v
 ;HkMb0cRr:R49u_BQt;ha
bHMkr0Rd9:jRQuB_1Q7 
p;HkMb0BRuQh_Qa;qL
bHMku0RBQQ_hLaA;M
HbRk0u_BQQBhaLH;
M0bkRQuB_aQh7
L;HkMb0BRuQ)_Q7
Y;HkMb0BRuQq_u)H;
M0bkRQuB_)u )H;
M0bkR:rc4u9RB)Q_ 
T;HkMb0BRuQ _1)
);HkMb0BRuQa_1m
u;HkMb0BRuQ)_a7
Y;HkMb0dRr49:jRHN8MH;
M0bkR4rd:Rj9Nk8F0H;
M0bkR:rdjO9RLMCH_
L;HkMb0dRr:Rj9OFLCkL0_;M
HbRk08#CPCMDH_
L;HkMb0CR8PD#CF_k0LH;
M0bkRNVslMCH_
L;HkMb0sRVNFlCkL0_;M
HbRk0HC8#DH;
M0bkR8Hs$_HMLH;
M0bkR8Hs$0Fk_
L;HkMb0CRF_;N8
bHMkF0RCL_OCH;
M0bkR_FC8#CPC
D;HkMb0CRF_NVsl
C;HkMb0CRF_8Hs$H;
M0bkR_FCb;Ns
bHMkF0RCC_bs
s;HkMb0CRF_JsC;M
HbRk0F#C_0;Fb
bHMkF0RCs_08
$;HkMb00R#FMbH_
L;HkMb00R#FkbF0;_L
bHMk00RsH8$M;_L
bHMk00RsF8$kL0_;M
HbRk0B;D	
0FkbRk0r4j:6R(9kHbDMd	_;R

R#N#HRoMkHbDMd	_rdj:4=9RRQuB_;q7
NRR#o#HMbRkD	HM_ddr.6:d9RR=u_BQB;A 
NRR#o#HMbRkD	HM_ddrng:d9RR=u_BQB;pi
NRR#o#HMbRkD	HM_cdrj=9RRQuB_e7 1; p
NRR#o#HMbRkD	HM_cdr4=9RRQuB_qw)v
 ;R#RN#MHoRDkbH_M	d.rc:9c6Ru=RBtQ_h
a;R#RN#MHoRDkbH_M	dnrc:9cgRu=RBQQ_7p1 ;R
RNH##okMRbMDH	r_d6Rj9=BRuQh_Qa;qL
NRR#o#HMbRkD	HM_6dr4=9RRQuB_aQhA
L;R#RN#MHoRDkbH_M	d.r69RR=u_BQQBhaLR;
R#N#HRoMkHbDMd	_r96dRu=RBQQ_hLa7;R
RNH##okMRbMDH	r_d6Rc9=BRuQ)_Q7
Y;R#RN#MHoRDkbH_M	d6r69RR=u_BQu;q)
NRR#o#HMbRkD	HM_6drn=9RRQuB_)u )R;
R#N#HRoMkHbDMd	_r:6(nRj9=BRuQ _)TR;
R#N#HRoMkHbDMd	_r9n4Ru=RB1Q_ ;))
NRR#o#HMbRkD	HM_ndr.=9RRQuB_m1auR;
R#N#HRoMkHbDMd	_r9ndRu=RBaQ_);7Y
NRR#o#HMbRkD	HM_ndrc6:g9RR=NM8H;R
RNH##okMRbMDH	r_dg4n:.R(9=8RNF;k0
NRR#o#HMbRkD	HM_4dr.4U:dR49=LROC_HMLR;
R#N#HRoMkHbDMd	_r.4d:64d9RR=OFLCkL0_;R
RNH##okMRbMDH	r_d49dnR8=RCCP#D_HMLR;
R#N#HRoMkHbDMd	_r(4d9RR=8#CPCkDF0;_L
NRR#o#HMbRkD	HM_4drdRU9=sRVNHlCM;_L
NRR#o#HMbRkD	HM_4drdRg9=sRVNFlCkL0_;R
RNH##okMRbMDH	r_d49cjRH=R8D#C;R
RNH##okMRbMDH	r_d49c4RH=RsH8$M;_L
NRR#o#HMbRkD	HM_4drcR.9=sRH8k$F0;_L
NRR#o#HMbRkD	HM_4drcRd9=CRF_;N8
NRR#o#HMbRkD	HM_4drcRc9=CRF_COL;R
RNH##okMRbMDH	r_d49c6RF=RCC_8PD#C;R
RNH##okMRbMDH	r_d49cnRF=RCs_VN;lC
NRR#o#HMbRkD	HM_4drcR(9=CRF_8Hs$R;
R#N#HRoMkHbDMd	_rU4c9RR=FbC_N
s;R#RN#MHoRDkbH_M	dcr4g=9RR_FCbsCs;R
RNH##okMRbMDH	r_d496jRF=RCC_sJR;
R#N#HRoMkHbDMd	_r4469RR=F#C_0;Fb
NRR#o#HMbRkD	HM_4dr6R.9=CRF_80s$R;
R#N#HRoMkHbDMd	_rd469RR=#b0FHLM_;R
RNH##okMRbMDH	r_d496cR#=R0FFbkL0_;R
RNH##okMRbMDH	r_d4966R0=RsH8$M;_L
NRR#o#HMbRkD	HM_4dr6Rn9=sR08k$F0;_L
NRR#o#HMbRkD	HM_4dr6R(9=DRB	C;
MF8l8CkD
F
l8CkDROHHC5_j
ORRF.llHCHO_MDH	H_HOjC_,RR
ROHHCF.OlDl_H_M	HCHO_Rj,
lRR8_HOD	HM2*R/RM#$0#ECH##R$EM_H=Cs"sEN8*"R/
R;RMRHbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
FRRkk0b0jRr:Rj9HCHO.lOFlH_DMH	_H_OCjR;
RbHMkr0Rj6:4(l9R8_HOD	HM;R

RsIHCcRL_KmiNR;
RsIHC(RL_LwYwwA_,(RL_LwYwtA_;R
RICHsR_Lcuwp$;R
RICHsR_LUuH1$AtoY,URL_$u1HY.XtL,R4mj_waWhgw	E0L,R(1_u$IHd$L,Rg1_u$XH.v;GV
IRRHRsCLmg_waWhgVvG,URL_W1FtYVWYL,RUw_mWghaY
t;RHRIsrCR4:6njL9R4mj_waWhg0DsCR;
RosCR:rj496(RHl8OH_DMs	_C/oR*$R#MC0E#RH##_$Mb#sCCCsP=*4R/
;
R#RN#MHoR_L(wwYLAR_t='R4L
4;R#RN#MHoR_L(wwYLAR_w='R4L
j;R#RN#MHoR_LcmNiKRl=R8_HOD	HMr(469R;
RINDNR$#@L@5(Y_wL_wAwsRFRHl8OH_DMR	2LHCoMRR:lO8H_MDH	C_#0
kbRRRRlO8H_MDH	C_so6r4(<9R=(RL_LwYwwA_;R
RC
M8
NRRD$IN#@R@5#bFCC8oR_LcmNiK2CRLoRHM:8RlHDO_H_M	DON0ER
RR8RlHDO_H_M	srCojRR:dR49<l=R8_HOD	HMr:jRR9d4;R
RR8RlHDO_H_M	srCod:.RR9d6RR<=lO8H_MDH	.rdRd:R6
9;RRRRlO8H_MDH	C_sonrdRd:Rg<9R=8RlHDO_HrM	d:nRR9dg;R
RR8RlHDO_H_M	srCoc:jRR9cjRR<=lO8H_MDH	jrcRc:Rj
9;RRRRlO8H_MDH	C_so4rcRc:R4<9R=8RlHDO_HrM	c:4RR9c4;R
RR8RlHDO_H_M	srCoc:.RR9c6RR<=lO8H_MDH	.rcRc:R6
9;RRRRlO8H_MDH	C_sonrcRc:Rg<9R=8RlHDO_HrM	c:nRR9cg;R
RR8RlHDO_H_M	srCo6:jRR96jRR<=lO8H_MDH	jr6R6:Rj
9;RRRRlO8H_MDH	C_so4r6R6:R4<9R=8RlHDO_HrM	6:4RR964;R
RR8RlHDO_H_M	srCo6:.RR96.RR<=lO8H_MDH	.r6R6:R.
9;RRRRlO8H_MDH	C_sodr6R6:Rd<9R=8RlHDO_HrM	6:dRR96d;R
RR8RlHDO_H_M	srCo6:cRR96cRR<=lO8H_MDH	cr6R6:Rc
9;RRRRlO8H_MDH	C_so6r6R6:R6<9R=8RlHDO_HrM	6:6RR966;R
RR8RlHDO_H_M	srCo6:nRR96nRR<=lO8H_MDH	nr6R6:Rn
9;RRRRlO8H_MDH	C_so(r6Rn:Rj<9R=8RlHDO_HrM	6:(RR9nj;R
RR8RlHDO_H_M	srCon:4RR9n4RR<=lO8H_MDH	4rnRn:R4
9;RRRRlO8H_MDH	C_so.rnRn:R.<9R=8RlHDO_HrM	n:.RR9n.;R
RR8RlHDO_H_M	srCon:dRR9ndRR<=lO8H_MDH	drnRn:Rd
9;RRRRlO8H_MDH	C_socrnRg:R6<9R=8RlHDO_HrM	n:cRR9g6;R
RR8RlHDO_H_M	srCog:nRR(4.9=R<RHl8OH_DMg	rnRR:49.(;R
RR8RlHDO_H_M	srCo4R.U:dR44<9R=8RlHDO_HrM	4R.U:dR44
9;RRRRlO8H_MDH	C_sodr4.RR:49d6RR<=lO8H_MDH	dr4.RR:49d6;R
RR8RlHDO_H_M	srCo4Rdn:dR4n<9R=8RlHDO_HrM	4Rdn:dR4n
9;RRRRlO8H_MDH	C_sodr4(RR:49d(RR<=lO8H_MDH	dr4(RR:49d(;R
RR8RlHDO_H_M	srCo4RdU:dR4U<9R=8RlHDO_HrM	4RdU:dR4U
9;RRRRlO8H_MDH	C_sodr4gRR:49dgRR<=lO8H_MDH	dr4gRR:49dg;R
RR8RlHDO_H_M	srCo4Rcj:cR4j<9R=8RlHDO_HrM	4Rcj:cR4j
9;RRRRlO8H_MDH	C_socr44RR:49c4RR<=lO8H_MDH	cr44RR:49c4;R
RR8RlHDO_H_M	srCo4Rc.:cR4.<9R=8RlHDO_HrM	4Rc.:cR4.
9;RRRRlO8H_MDH	C_socr4dRR:49cdRR<=lO8H_MDH	cr4dRR:49cd;R
RR8RlHDO_H_M	srCo4Rcc:cR4c<9R=8RlHDO_HrM	4Rcc:cR4c
9;RRRRlO8H_MDH	C_socr46RR:49c6RR<=lO8H_MDH	cr46RR:49c6;R
RR8RlHDO_H_M	srCo4Rcn:cR4n<9R=8RlHDO_HrM	4Rcn:cR4n
9;RRRRlO8H_MDH	C_socr4(RR:49c(RR<=lO8H_MDH	cr4(RR:49c(;R
RR8RlHDO_H_M	srCo4RcU:cR4U<9R=8RlHDO_HrM	4RcU:cR4U
9;RRRRlO8H_MDH	C_socr4gRR:49cgRR<=lO8H_MDH	cr4gRR:49cg;R
RR8RlHDO_H_M	srCo4R6j:6R4j<9R=8RlHDO_HrM	4R6j:6R4j
9;RRRRlO8H_MDH	C_so6r44RR:4964RR<=lO8H_MDH	6r44RR:4964;R
RR8RlHDO_H_M	srCo4R6.:6R4.<9R=8RlHDO_HrM	4R6.:6R4.
9;RRRRlO8H_MDH	C_so6r4dRR:496dRR<=lO8H_MDH	6r4dRR:496d;R
RR8RlHDO_H_M	srCo4R6c:6R4c<9R=8RlHDO_HrM	4R6c:6R4c
9;RRRRlO8H_MDH	C_so6r46RR:4966RR<=lO8H_MDH	6r46RR:4966;R
RR8RlHDO_H_M	srCo4R6n:6R4n<9R=8RlHDO_HrM	4R6n:6R4n
9;RMRC8R

R_Ld4R.lL4U_.Ql_wRpY5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR43Ldp_k6BQd0[F_uRwAROR5F.llHCHO_MDH	H_HOjC_r2n9,R
RRLR3(w_Mt7jsYRRR5lOFlH.HODC_H_M	HCHO_(jr9
2,RRRR3_L(uNiK_RgkRLR5U1_u$oHAY,t2
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pR$RRRRRRc5L_$upw
2,RRRR3_LduRpwRRRRRLR5(1_u$IHd$
2,RRRR3_L6mxOauRRRRLR5g1_u$XH.v2GV,R
RRLR34Md_zAaToLV7_7ZcR45Ldz_MaoTAV_7LZ2c7,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Mn_YdEQgv#IC_ 8qR(U5nL4_EMYQ#dgI vC8(_qU
2,RRRR36L4_EMYQ#dgI vC8o_vR45L6Y_MEgQd#CIv v8_o
2,RRRR3.L4_APqZ#dJY$_pELR54P._qdAZJ_#Yp2$E,R
RRLR34P4_qdAZJ_#YX5]RL_44PZqAdYJ#_2X],R
RRLR34k._).sOX_VYpR$E5.L4_sk)OV.XY$_pE
2,RRRR34L4_sk)OV.XY]_XR45L4)_ksXO.VXY_]
2,RRRR34L4_1PFONdswwNXRU5L_W1FtYVWY
2,RRRR3_LgmhwWaNg_LRRR5_LUmhwWatgY2R,
R3RRL_4jmhwWasgD0RCR5jL4_WmwhDags20C,R
RRLR3gp_1$h$_sRt7RlR58_HOD	HM_osC2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=R;*/
R
RLkd_iLsRUi_ksw_Qp5YR
RRRR43L4)_ksgO_kAsXL5RROlFl.OHHCH_DMH	_H_OCj9rc2R,
R3RRL_4dMwPlpG_V.ksLTOR5F.llHCHO_MDH	H_HOjC_rdj:9
2,RRRR3_LduRp$RF5OlHl.H_OCD	HM_OHHCr_j6,92
RRRRd3L_wupRHR5H.OCOlFl_MDH	H_HOjC_r2j9,R
RRLR3(p_u$D_uvLR5cp_u$,w2
RRRR43L.1_u$oHAV_7LL58RLuU_1A$Ho2Yt,R
RRLR34u._1.$HXwVY_RL85_LUuH1$.tXY2R,
R3RRL_4cmhwWaEg	W_J]d5HRL_4jmhwWaEg	w,02
RRRR43Ld1_u$oHAV_7LZRc75_L(uH1$d2I$,R
RRLR34ud_1.$HXwVY_7ZcRg5L_$u1Hv.XG,V2
RRRR43L6w_mWgha	JEW]g_)	LR5gw_mWghav2GV,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Md_zAaToLV7_7ZcRLR54Md_zAaToLV7_7Zc2R,
R3RRL_46MQYEdIg#v8C _Rvo56L4_EMYQ#dgI vC8o_v2R,
R3RRL_4nMQYEdIg#v8C _Uq(RLR54Mn_YdEQgv#IC_ 8q2(U,R
RRLR34P4_qdAZJ_#YXR]R54L4_APqZ#dJY]_X2R,
R3RRL_4.PZqAdYJ#_Ep$RLR54P._qdAZJ_#Yp2$E,R
RRLR34k4_).sOX_VYXR]R54L4_sk)OV.XY]_X2R,
R3RRL_4.kO)s.YXV_Ep$RLR54k._).sOX_VYp2$E
2RRRR/*#0$MEHC##$R#MF_MbMskCR=4*
/;R(RL_Wmwh#agR_Ld1RFW5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR(3L_KuiNk_gR5RRL_4jmhwWaEg	w,02
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pRwRRRRRRg5L_WmwhvagG,V2
RRRR63L_1PFORdRR5RRL1U_FVWtW2YY,R
RRLR3(w_mWghapRRR5jL4_WmwhDags20C,R
RRLR3gw_mWgha_RNL5_LUmhwWatgY2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=RR*/;M
C88lFk
DC
