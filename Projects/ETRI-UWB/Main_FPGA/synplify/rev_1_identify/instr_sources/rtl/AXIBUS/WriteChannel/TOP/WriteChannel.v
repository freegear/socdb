// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannel.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code

`timescale 1 ns/ 10ps
module  WriteChannel(

    SelMAP1,

    //_______________________________________________________________
    //For Master 0
    //Write address channel
//Disable_id_port
    AWADDRm02si0  ,
    AWLENm02si0   ,
    AWSIZEm02si0  ,
    AWBURSTm02si0 ,
    AWLOCKm02si0  ,
//Disable_cache_port
//Disable_protect_port

    AWVALIDm02si0 ,
    AWREADYsi02m0 ,

    //Write data channel
//Disable_id_port
    WDATAm02si0   ,
    WSTRBm02si0   ,
    WLASTm02si0   ,
    WVALIDm02si0  ,
    WREADYsi02m0  ,

    //Write response channel
//Disable_id_port
    BRESPsi02m0   ,
    BVALIDsi02m0  ,
    BREADYm02si0  ,

 
 
    //_______________________________________________________________
    //For Master 2
    //Write address channel
    AWIDm22si2    ,
    AWADDRm22si2  ,
    AWLENm22si2   ,
    AWSIZEm22si2  ,
    AWBURSTm22si2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDm22si2 ,
    AWREADYsi22m2 ,

    //Write data channel
    WIDm22si2     ,
    WDATAm22si2   ,
    WSTRBm22si2   ,
    WLASTm22si2   ,
    WVALIDm22si2  ,
    WREADYsi22m2  ,

    //Write response channel
    BIDsi22m2     ,
    BRESPsi22m2   ,
    BVALIDsi22m2  ,
    BREADYm22si2  ,

 
    //_______________________________________________________________
    //For Master 3
    //Write address channel
//Disable_id_port
    AWADDRm32si3  ,
    AWLENm32si3   ,
    AWSIZEm32si3  ,
    AWBURSTm32si3 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDm32si3 ,
    AWREADYsi32m3 ,

    //Write data channel
//Disable_id_port
    WDATAm32si3   ,
    WSTRBm32si3   ,
    WLASTm32si3   ,
    WVALIDm32si3  ,
    WREADYsi32m3  ,

    //Write response channel
//Disable_id_port
    BRESPsi32m3   ,
    BVALIDsi32m3  ,
    BREADYm32si3  ,

 
    //_______________________________________________________________
    //For Master 4
    //Write address channel
//Disable_id_port
    AWADDRm42si4  ,
    AWLENm42si4   ,
    AWSIZEm42si4  ,
    AWBURSTm42si4 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDm42si4 ,
    AWREADYsi42m4 ,

    //Write data channel
//Disable_id_port
    WDATAm42si4   ,
    WSTRBm42si4   ,
    WLASTm42si4   ,
    WVALIDm42si4  ,
    WREADYsi42m4  ,

    //Write response channel
//Disable_id_port
    BRESPsi42m4   ,
    BVALIDsi42m4  ,
    BREADYm42si4  ,

 

    
    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    AWIDmi02s0    ,
    AWADDRmi02s0  ,
    AWLENmi02s0   ,
    AWSIZEmi02s0  ,
    AWBURSTmi02s0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi02s0 ,
    AWREADYs02mi0 ,

    //Write data channel
    WIDmi02s0     ,
    WDATAmi02s0   ,
//Disable_WSTRB_port
    WLASTmi02s0   ,
    WVALIDmi02s0  ,
    WREADYs02mi0  ,

    //Write response channel
    BIDs02mi0     ,
    BRESPs02mi0   ,
    BVALIDs02mi0  ,
    BREADYmi02s0  ,
    
    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    AWIDmi12s1    ,
    AWADDRmi12s1  ,
    AWLENmi12s1   ,
    AWSIZEmi12s1  ,
    AWBURSTmi12s1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi12s1 ,
    AWREADYs12mi1 ,

    //Write data channel
    WIDmi12s1     ,
    WDATAmi12s1   ,
//Disable_WSTRB_port
    WLASTmi12s1   ,
    WVALIDmi12s1  ,
    WREADYs12mi1  ,

    //Write response channel
    BIDs12mi1     ,
    BRESPs12mi1   ,
    BVALIDs12mi1  ,
    BREADYmi12s1  ,
    
    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    AWIDmi22s2    ,
    AWADDRmi22s2  ,
    AWLENmi22s2   ,
    AWSIZEmi22s2  ,
    AWBURSTmi22s2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi22s2 ,
    AWREADYs22mi2 ,

    //Write data channel
    WIDmi22s2     ,
    WDATAmi22s2   ,
//Disable_WSTRB_port
    WLASTmi22s2   ,
    WVALIDmi22s2  ,
    WREADYs22mi2  ,

    //Write response channel
    BIDs22mi2     ,
    BRESPs22mi2   ,
    BVALIDs22mi2  ,
    BREADYmi22s2  ,
    
    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    AWIDmi32s3    ,
    AWADDRmi32s3  ,
    AWLENmi32s3   ,
    AWSIZEmi32s3  ,
    AWBURSTmi32s3 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi32s3 ,
    AWREADYs32mi3 ,

    //Write data channel
    WIDmi32s3     ,
    WDATAmi32s3   ,
    WSTRBmi32s3   ,
    WLASTmi32s3   ,
    WVALIDmi32s3  ,
    WREADYs32mi3  ,

    //Write response channel
    BIDs32mi3     ,
    BRESPs32mi3   ,
    BVALIDs32mi3  ,
    BREADYmi32s3  ,
    
    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    AWIDmi42s4    ,
    AWADDRmi42s4  ,
    AWLENmi42s4   ,
    AWSIZEmi42s4  ,
    AWBURSTmi42s4 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi42s4 ,
    AWREADYs42mi4 ,

    //Write data channel
    WIDmi42s4     ,
    WDATAmi42s4   ,
//Disable_WSTRB_port
    WLASTmi42s4   ,
    WVALIDmi42s4  ,
    WREADYs42mi4  ,

    //Write response channel
    BIDs42mi4     ,
    BRESPs42mi4   ,
    BVALIDs42mi4  ,
    BREADYmi42s4  ,
    
    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    AWIDmi52s5    ,
    AWADDRmi52s5  ,
    AWLENmi52s5   ,
    AWSIZEmi52s5  ,
    AWBURSTmi52s5 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi52s5 ,
    AWREADYs52mi5 ,

    //Write data channel
    WIDmi52s5     ,
    WDATAmi52s5   ,
//Disable_WSTRB_port
    WLASTmi52s5   ,
    WVALIDmi52s5  ,
    WREADYs52mi5  ,

    //Write response channel
    BIDs52mi5     ,
    BRESPs52mi5   ,
    BVALIDs52mi5  ,
    BREADYmi52s5  ,
    
    //_______________________________________________________________
    //For Slave 6
    //Write address channel
    AWIDmi62s6    ,
    AWADDRmi62s6  ,
    AWLENmi62s6   ,
    AWSIZEmi62s6  ,
    AWBURSTmi62s6 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi62s6 ,
    AWREADYs62mi6 ,

    //Write data channel
    WIDmi62s6     ,
    WDATAmi62s6   ,
    WSTRBmi62s6   ,
    WLASTmi62s6   ,
    WVALIDmi62s6  ,
    WREADYs62mi6  ,

    //Write response channel
    BIDs62mi6     ,
    BRESPs62mi6   ,
    BVALIDs62mi6  ,
    BREADYmi62s6  ,
    
    //_______________________________________________________________
    //For Slave 7
    //Write address channel
    AWIDmi72s7    ,
    AWADDRmi72s7  ,
    AWLENmi72s7   ,
    AWSIZEmi72s7  ,
    AWBURSTmi72s7 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi72s7 ,
    AWREADYs72mi7 ,

    //Write data channel
    WIDmi72s7     ,
    WDATAmi72s7   ,
    WSTRBmi72s7   ,
    WLASTmi72s7   ,
    WVALIDmi72s7  ,
    WREADYs72mi7  ,

    //Write response channel
    BIDs72mi7     ,
    BRESPs72mi7   ,
    BVALIDs72mi7  ,
    BREADYmi72s7  ,
    
    //_______________________________________________________________
    //For Slave 8
    //Write address channel
    AWIDmi82s8    ,
    AWADDRmi82s8  ,
    AWLENmi82s8   ,
    AWSIZEmi82s8  ,
    AWBURSTmi82s8 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi82s8 ,
    AWREADYs82mi8 ,

    //Write data channel
    WIDmi82s8     ,
    WDATAmi82s8   ,
    WSTRBmi82s8   ,
    WLASTmi82s8   ,
    WVALIDmi82s8  ,
    WREADYs82mi8  ,

    //Write response channel
    BIDs82mi8     ,
    BRESPs82mi8   ,
    BVALIDs82mi8  ,
    BREADYmi82s8  ,


    //Lock Access
    //_______________________________________________________________

    Lock2wrmi0,
    Lock2wrmi1,
    Lock2wrmi2,
    Lock2wrmi3,
    Lock2wrmi4,
    Lock2wrmi5,
    Lock2wrmi6,
    Lock2wrmi7,
    Lock2wrmi8,

    Lock2rdmi0,
    Lock2rdmi1,
    Lock2rdmi2,
    Lock2rdmi3,
    Lock2rdmi4,
    Lock2rdmi5,
    Lock2rdmi6,
    Lock2rdmi7,
    Lock2rdmi8,

    UnLock2wrmi0,
    UnLock2wrmi1,
    UnLock2wrmi2,
    UnLock2wrmi3,
    UnLock2wrmi4,
    UnLock2wrmi5,
    UnLock2wrmi6,
    UnLock2wrmi7,
    UnLock2wrmi8,

    UnLock2rdmi0,
    UnLock2rdmi1,
    UnLock2rdmi2,
    UnLock2rdmi3,
    UnLock2rdmi4,
    UnLock2rdmi5,
    UnLock2rdmi6,
    UnLock2rdmi7,
    UnLock2rdmi8,

    ARVALIDmi02s0,
    ARVALIDmi12s1,
    ARVALIDmi22s2,
    ARVALIDmi32s3,
    ARVALIDmi42s4,
    ARVALIDmi52s5,
    ARVALIDmi62s6,
    ARVALIDmi72s7,
    ARVALIDmi82s8,

    LockPort2wrmi0,
    LockPort2wrmi1,
    LockPort2wrmi2,
    LockPort2wrmi3,
    LockPort2wrmi4,
    LockPort2wrmi5,
    LockPort2wrmi6,
    LockPort2wrmi7,
    LockPort2wrmi8,

    ReadIntEmptyWrmi02Rdmi0,
    ReadIntEmptyWrmi12Rdmi1,
    ReadIntEmptyWrmi22Rdmi2,
    ReadIntEmptyWrmi32Rdmi3,
    ReadIntEmptyWrmi42Rdmi4,
    ReadIntEmptyWrmi52Rdmi5,
    ReadIntEmptyWrmi62Rdmi6,
    ReadIntEmptyWrmi72Rdmi7,
    ReadIntEmptyWrmi82Rdmi8,

    DataCntEmptyRdmi02Wrmi0,
    DataCntEmptyRdmi12Wrmi1,
    DataCntEmptyRdmi22Wrmi2,
    DataCntEmptyRdmi32Wrmi3,
    DataCntEmptyRdmi42Wrmi4,
    DataCntEmptyRdmi52Wrmi5,
    DataCntEmptyRdmi62Wrmi6,
    DataCntEmptyRdmi72Wrmi7,
    DataCntEmptyRdmi82Wrmi8,

    CtlDataWrite2Lock0,
    CtlDataWrite2Lock1,
    CtlDataWrite2Lock2,
    CtlDataWrite2Lock3,
    CtlDataWrite2Lock4,
    CtlDataWrite2Lock5,
    CtlDataWrite2Lock6,
    CtlDataWrite2Lock7,
    CtlDataWrite2Lock8,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 4;
parameter SLAVE_NUM= 9;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter MASTERID0_WID = 1 ;
parameter MASTERID1_WID = 1 ;
parameter MASTERID2_WID = 1 ;
parameter MASTERID3_WID = 1 ;
parameter MASTERID4_WID = 1 ;
parameter MAXMASTERID_WID = 1 ;
parameter BLANKMASTERID0_WID = 0 ;
parameter BLANKMASTERID1_WID = 0 ;
parameter BLANKMASTERID2_WID = 0 ;
parameter BLANKMASTERID3_WID = 0 ;
parameter BLANKMASTERID4_WID = 0 ;
parameter SLAVEID0_WID = 2 ;
parameter SLAVEID1_WID = 2 ;
parameter SLAVEID2_WID = 2 ;
parameter SLAVEID3_WID = 3 ;
parameter SLAVEID4_WID = 2 ;
parameter SLAVEID5_WID = 2 ;
parameter SLAVEID6_WID = 3 ;
parameter SLAVEID7_WID = 3 ;
parameter SLAVEID8_WID = 3 ;
parameter SELMASTER0_WID = 1 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 2 ;
parameter SELMASTER4_WID = 1 ;
parameter SELMASTER5_WID = 1 ;
parameter SELMASTER6_WID = 2 ;
parameter SELMASTER7_WID = 2 ;
parameter SELMASTER8_WID = 2 ;
parameter SLAVE_MASTERID0_WID = 1 ;
parameter SLAVE_MASTERID1_WID = 1 ;
parameter SLAVE_MASTERID2_WID = 1 ;
parameter SLAVE_MASTERID3_WID = 1 ;
parameter SLAVE_MASTERID4_WID = 1 ;
parameter SLAVE_MASTERID5_WID = 1 ;
parameter SLAVE_MASTERID6_WID = 1 ;
parameter SLAVE_MASTERID7_WID = 1 ;
parameter SLAVE_MASTERID8_WID = 1 ;
    


  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   SelMAP1;
    input   ACLK;
    input   ARESETn;  

    //Lock Access
    //_______________________________________________________________


    //Slave 0
    //_____________________________________
    input   Lock2wrmi0;
    input   UnLock2wrmi0;
    output  Lock2rdmi0;
    output  UnLock2rdmi0;
    input   ARVALIDmi02s0;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER0_WID-1:0]LockPort2wrmi0;
    input   [SELMASTER0_WID:0]LockPort2wrmi0;

    output  ReadIntEmptyWrmi02Rdmi0;
    input   DataCntEmptyRdmi02Wrmi0;
    output  [SELMASTER0_WID-1:0]CtlDataWrite2Lock0;

    //Slave 1
    //_____________________________________
    input   Lock2wrmi1;
    input   UnLock2wrmi1;
    output  Lock2rdmi1;
    output  UnLock2rdmi1;
    input   ARVALIDmi12s1;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER1_WID-1:0]LockPort2wrmi1;
    input   [SELMASTER1_WID:0]LockPort2wrmi1;

    output  ReadIntEmptyWrmi12Rdmi1;
    input   DataCntEmptyRdmi12Wrmi1;
    output  [SELMASTER1_WID-1:0]CtlDataWrite2Lock1;

    //Slave 2
    //_____________________________________
    input   Lock2wrmi2;
    input   UnLock2wrmi2;
    output  Lock2rdmi2;
    output  UnLock2rdmi2;
    input   ARVALIDmi22s2;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER2_WID-1:0]LockPort2wrmi2;
    input   [SELMASTER2_WID:0]LockPort2wrmi2;

    output  ReadIntEmptyWrmi22Rdmi2;
    input   DataCntEmptyRdmi22Wrmi2;
    output  [SELMASTER2_WID-1:0]CtlDataWrite2Lock2;

    //Slave 3
    //_____________________________________
    input   Lock2wrmi3;
    input   UnLock2wrmi3;
    output  Lock2rdmi3;
    output  UnLock2rdmi3;
    input   ARVALIDmi32s3;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER3_WID-1:0]LockPort2wrmi3;
    input   [SELMASTER3_WID:0]LockPort2wrmi3;

    output  ReadIntEmptyWrmi32Rdmi3;
    input   DataCntEmptyRdmi32Wrmi3;
    output  [SELMASTER3_WID-1:0]CtlDataWrite2Lock3;

    //Slave 4
    //_____________________________________
    input   Lock2wrmi4;
    input   UnLock2wrmi4;
    output  Lock2rdmi4;
    output  UnLock2rdmi4;
    input   ARVALIDmi42s4;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER4_WID-1:0]LockPort2wrmi4;
    input   [SELMASTER4_WID:0]LockPort2wrmi4;

    output  ReadIntEmptyWrmi42Rdmi4;
    input   DataCntEmptyRdmi42Wrmi4;
    output  [SELMASTER4_WID-1:0]CtlDataWrite2Lock4;

    //Slave 5
    //_____________________________________
    input   Lock2wrmi5;
    input   UnLock2wrmi5;
    output  Lock2rdmi5;
    output  UnLock2rdmi5;
    input   ARVALIDmi52s5;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER5_WID-1:0]LockPort2wrmi5;
    input   [SELMASTER5_WID:0]LockPort2wrmi5;

    output  ReadIntEmptyWrmi52Rdmi5;
    input   DataCntEmptyRdmi52Wrmi5;
    output  [SELMASTER5_WID-1:0]CtlDataWrite2Lock5;

    //Slave 6
    //_____________________________________
    input   Lock2wrmi6;
    input   UnLock2wrmi6;
    output  Lock2rdmi6;
    output  UnLock2rdmi6;
    input   ARVALIDmi62s6;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER6_WID-1:0]LockPort2wrmi6;
    input   [SELMASTER6_WID:0]LockPort2wrmi6;

    output  ReadIntEmptyWrmi62Rdmi6;
    input   DataCntEmptyRdmi62Wrmi6;
    output  [SELMASTER6_WID-1:0]CtlDataWrite2Lock6;

    //Slave 7
    //_____________________________________
    input   Lock2wrmi7;
    input   UnLock2wrmi7;
    output  Lock2rdmi7;
    output  UnLock2rdmi7;
    input   ARVALIDmi72s7;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER7_WID-1:0]LockPort2wrmi7;
    input   [SELMASTER7_WID:0]LockPort2wrmi7;

    output  ReadIntEmptyWrmi72Rdmi7;
    input   DataCntEmptyRdmi72Wrmi7;
    output  [SELMASTER7_WID-1:0]CtlDataWrite2Lock7;

    //Slave 8
    //_____________________________________
    input   Lock2wrmi8;
    input   UnLock2wrmi8;
    output  Lock2rdmi8;
    output  UnLock2rdmi8;
    input   ARVALIDmi82s8;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER8_WID-1:0]LockPort2wrmi8;
    input   [SELMASTER8_WID:0]LockPort2wrmi8;

    output  ReadIntEmptyWrmi82Rdmi8;
    input   DataCntEmptyRdmi82Wrmi8;
    output  [SELMASTER8_WID-1:0]CtlDataWrite2Lock8;
    //_______________________________________________________________

    //SlaveInterface
    //_______________________________________________________________

    //For Master 0
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDRm02si0;
    input   [AWLEN_WID-1:0]         AWLENm02si0;
    input   [AWSIZE_WID-1:0]        AWSIZEm02si0;  
    input   [AWBURST_WID-1:0]       AWBURSTm02si0; 
    input   [AWLOCK_WID-1:0]        AWLOCKm02si0;  
//Disable_cache_port
//Disable_protect_port

    input   AWVALIDm02si0; 
    output  AWREADYsi02m0; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATAm02si0;   
    input   [WSTRB_WID-1:0]         WSTRBm02si0;   
    input   WLASTm02si0;   
    input   WVALIDm02si0;  
    output  WREADYsi02m0;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESPsi02m0;   
    output   BVALIDsi02m0;  
    input    BREADYm02si0;  
 
 
    //For Master 2
    //Write address channel
    input   [MASTERID2_WID-1:0]    AWIDm22si2;    
    input   [ADDR_WID-1:0]          AWADDRm22si2;
    input   [AWLEN_WID-1:0]         AWLENm22si2;
    input   [AWSIZE_WID-1:0]        AWSIZEm22si2;  
    input   [AWBURST_WID-1:0]       AWBURSTm22si2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALIDm22si2; 
    output  AWREADYsi22m2; 

    //Write data channel
    input   [MASTERID2_WID-1:0]   WIDm22si2;     
    input   [BUS_WID-1:0]           WDATAm22si2;   
    input   [WSTRB_WID-1:0]         WSTRBm22si2;   
    input   WLASTm22si2;   
    input   WVALIDm22si2;  
    output  WREADYsi22m2;  

    //Write response channel
    output   [MASTERID2_WID-1:0]  BIDsi22m2;     
    output   [BRESP_WID-1:0]        BRESPsi22m2;   
    output   BVALIDsi22m2;  
    input    BREADYm22si2;  
 
    //For Master 3
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDRm32si3;
    input   [AWLEN_WID-1:0]         AWLENm32si3;
    input   [AWSIZE_WID-1:0]        AWSIZEm32si3;  
    input   [AWBURST_WID-1:0]       AWBURSTm32si3; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALIDm32si3; 
    output  AWREADYsi32m3; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATAm32si3;   
    input   [WSTRB_WID-1:0]         WSTRBm32si3;   
    input   WLASTm32si3;   
    input   WVALIDm32si3;  
    output  WREADYsi32m3;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESPsi32m3;   
    output   BVALIDsi32m3;  
    input    BREADYm32si3;  
 
    //For Master 4
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDRm42si4;
    input   [AWLEN_WID-1:0]         AWLENm42si4;
    input   [AWSIZE_WID-1:0]        AWSIZEm42si4;  
    input   [AWBURST_WID-1:0]       AWBURSTm42si4; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALIDm42si4; 
    output  AWREADYsi42m4; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATAm42si4;   
    input   [WSTRB_WID-1:0]         WSTRBm42si4;   
    input   WLASTm42si4;   
    input   WVALIDm42si4;  
    output  WREADYsi42m4;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESPsi42m4;   
    output   BVALIDsi42m4;  
    input    BREADYm42si4;  
 


    //MasterInterface
    //_______________________________________________________________

    // For slave 0
    //__________________________________________________
    //Write address channel
    output   [SLAVEID0_WID-1:0]AWIDmi02s0;    
    output   [ADDR_WID-1:0]     AWADDRmi02s0;
    output   [AWLEN_WID-1:0]    AWLENmi02s0;
    output   [AWSIZE_WID-1:0]   AWSIZEmi02s0;  
    output   [AWBURST_WID-1:0]  AWBURSTmi02s0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi02s0; 
    input    AWREADYs02mi0; 
    
    //Write data channel
    output   [SLAVEID0_WID-1:0]WIDmi02s0;     
    output   [BUS_WID-1:0]      WDATAmi02s0;   
//Disable_WSTRB_port
    output   WLASTmi02s0;   
    output   WVALIDmi02s0;  
    input    WREADYs02mi0; 

    //Write response channel
    input   [SLAVEID0_WID-1:0] BIDs02mi0;     
    input   [BRESP_WID-1:0]     BRESPs02mi0;   
    input   BVALIDs02mi0;  
    output  BREADYmi02s0;  

    // For slave 1
    //__________________________________________________
    //Write address channel
    output   [SLAVEID1_WID-1:0]AWIDmi12s1;    
    output   [ADDR_WID-1:0]     AWADDRmi12s1;
    output   [AWLEN_WID-1:0]    AWLENmi12s1;
    output   [AWSIZE_WID-1:0]   AWSIZEmi12s1;  
    output   [AWBURST_WID-1:0]  AWBURSTmi12s1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi12s1; 
    input    AWREADYs12mi1; 
    
    //Write data channel
    output   [SLAVEID1_WID-1:0]WIDmi12s1;     
    output   [BUS_WID-1:0]      WDATAmi12s1;   
//Disable_WSTRB_port
    output   WLASTmi12s1;   
    output   WVALIDmi12s1;  
    input    WREADYs12mi1; 

    //Write response channel
    input   [SLAVEID1_WID-1:0] BIDs12mi1;     
    input   [BRESP_WID-1:0]     BRESPs12mi1;   
    input   BVALIDs12mi1;  
    output  BREADYmi12s1;  

    // For slave 2
    //__________________________________________________
    //Write address channel
    output   [SLAVEID2_WID-1:0]AWIDmi22s2;    
    output   [ADDR_WID-1:0]     AWADDRmi22s2;
    output   [AWLEN_WID-1:0]    AWLENmi22s2;
    output   [AWSIZE_WID-1:0]   AWSIZEmi22s2;  
    output   [AWBURST_WID-1:0]  AWBURSTmi22s2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi22s2; 
    input    AWREADYs22mi2; 
    
    //Write data channel
    output   [SLAVEID2_WID-1:0]WIDmi22s2;     
    output   [BUS_WID-1:0]      WDATAmi22s2;   
//Disable_WSTRB_port
    output   WLASTmi22s2;   
    output   WVALIDmi22s2;  
    input    WREADYs22mi2; 

    //Write response channel
    input   [SLAVEID2_WID-1:0] BIDs22mi2;     
    input   [BRESP_WID-1:0]     BRESPs22mi2;   
    input   BVALIDs22mi2;  
    output  BREADYmi22s2;  

    // For slave 3
    //__________________________________________________
    //Write address channel
    output   [SLAVEID3_WID-1:0]AWIDmi32s3;    
    output   [ADDR_WID-1:0]     AWADDRmi32s3;
    output   [AWLEN_WID-1:0]    AWLENmi32s3;
    output   [AWSIZE_WID-1:0]   AWSIZEmi32s3;  
    output   [AWBURST_WID-1:0]  AWBURSTmi32s3; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi32s3; 
    input    AWREADYs32mi3; 
    
    //Write data channel
    output   [SLAVEID3_WID-1:0]WIDmi32s3;     
    output   [BUS_WID-1:0]      WDATAmi32s3;   
    output   [WSTRB_WID-1:0]    WSTRBmi32s3;   
    output   WLASTmi32s3;   
    output   WVALIDmi32s3;  
    input    WREADYs32mi3; 

    //Write response channel
    input   [SLAVEID3_WID-1:0] BIDs32mi3;     
    input   [BRESP_WID-1:0]     BRESPs32mi3;   
    input   BVALIDs32mi3;  
    output  BREADYmi32s3;  

    // For slave 4
    //__________________________________________________
    //Write address channel
    output   [SLAVEID4_WID-1:0]AWIDmi42s4;    
    output   [ADDR_WID-1:0]     AWADDRmi42s4;
    output   [AWLEN_WID-1:0]    AWLENmi42s4;
    output   [AWSIZE_WID-1:0]   AWSIZEmi42s4;  
    output   [AWBURST_WID-1:0]  AWBURSTmi42s4; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi42s4; 
    input    AWREADYs42mi4; 
    
    //Write data channel
    output   [SLAVEID4_WID-1:0]WIDmi42s4;     
    output   [BUS_WID-1:0]      WDATAmi42s4;   
//Disable_WSTRB_port
    output   WLASTmi42s4;   
    output   WVALIDmi42s4;  
    input    WREADYs42mi4; 

    //Write response channel
    input   [SLAVEID4_WID-1:0] BIDs42mi4;     
    input   [BRESP_WID-1:0]     BRESPs42mi4;   
    input   BVALIDs42mi4;  
    output  BREADYmi42s4;  

    // For slave 5
    //__________________________________________________
    //Write address channel
    output   [SLAVEID5_WID-1:0]AWIDmi52s5;    
    output   [ADDR_WID-1:0]     AWADDRmi52s5;
    output   [AWLEN_WID-1:0]    AWLENmi52s5;
    output   [AWSIZE_WID-1:0]   AWSIZEmi52s5;  
    output   [AWBURST_WID-1:0]  AWBURSTmi52s5; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi52s5; 
    input    AWREADYs52mi5; 
    
    //Write data channel
    output   [SLAVEID5_WID-1:0]WIDmi52s5;     
    output   [BUS_WID-1:0]      WDATAmi52s5;   
//Disable_WSTRB_port
    output   WLASTmi52s5;   
    output   WVALIDmi52s5;  
    input    WREADYs52mi5; 

    //Write response channel
    input   [SLAVEID5_WID-1:0] BIDs52mi5;     
    input   [BRESP_WID-1:0]     BRESPs52mi5;   
    input   BVALIDs52mi5;  
    output  BREADYmi52s5;  

    // For slave 6
    //__________________________________________________
    //Write address channel
    output   [SLAVEID6_WID-1:0]AWIDmi62s6;    
    output   [ADDR_WID-1:0]     AWADDRmi62s6;
    output   [AWLEN_WID-1:0]    AWLENmi62s6;
    output   [AWSIZE_WID-1:0]   AWSIZEmi62s6;  
    output   [AWBURST_WID-1:0]  AWBURSTmi62s6; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi62s6; 
    input    AWREADYs62mi6; 
    
    //Write data channel
    output   [SLAVEID6_WID-1:0]WIDmi62s6;     
    output   [BUS_WID-1:0]      WDATAmi62s6;   
    output   [WSTRB_WID-1:0]    WSTRBmi62s6;   
    output   WLASTmi62s6;   
    output   WVALIDmi62s6;  
    input    WREADYs62mi6; 

    //Write response channel
    input   [SLAVEID6_WID-1:0] BIDs62mi6;     
    input   [BRESP_WID-1:0]     BRESPs62mi6;   
    input   BVALIDs62mi6;  
    output  BREADYmi62s6;  

    // For slave 7
    //__________________________________________________
    //Write address channel
    output   [SLAVEID7_WID-1:0]AWIDmi72s7;    
    output   [ADDR_WID-1:0]     AWADDRmi72s7;
    output   [AWLEN_WID-1:0]    AWLENmi72s7;
    output   [AWSIZE_WID-1:0]   AWSIZEmi72s7;  
    output   [AWBURST_WID-1:0]  AWBURSTmi72s7; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi72s7; 
    input    AWREADYs72mi7; 
    
    //Write data channel
    output   [SLAVEID7_WID-1:0]WIDmi72s7;     
    output   [BUS_WID-1:0]      WDATAmi72s7;   
    output   [WSTRB_WID-1:0]    WSTRBmi72s7;   
    output   WLASTmi72s7;   
    output   WVALIDmi72s7;  
    input    WREADYs72mi7; 

    //Write response channel
    input   [SLAVEID7_WID-1:0] BIDs72mi7;     
    input   [BRESP_WID-1:0]     BRESPs72mi7;   
    input   BVALIDs72mi7;  
    output  BREADYmi72s7;  

    // For slave 8
    //__________________________________________________
    //Write address channel
    output   [SLAVEID8_WID-1:0]AWIDmi82s8;    
    output   [ADDR_WID-1:0]     AWADDRmi82s8;
    output   [AWLEN_WID-1:0]    AWLENmi82s8;
    output   [AWSIZE_WID-1:0]   AWSIZEmi82s8;  
    output   [AWBURST_WID-1:0]  AWBURSTmi82s8; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi82s8; 
    input    AWREADYs82mi8; 
    
    //Write data channel
    output   [SLAVEID8_WID-1:0]WIDmi82s8;     
    output   [BUS_WID-1:0]      WDATAmi82s8;   
    output   [WSTRB_WID-1:0]    WSTRBmi82s8;   
    output   WLASTmi82s8;   
    output   WVALIDmi82s8;  
    input    WREADYs82mi8; 

    //Write response channel
    input   [SLAVEID8_WID-1:0] BIDs82mi8;     
    input   [BRESP_WID-1:0]     BRESPs82mi8;   
    input   BVALIDs82mi8;  
    output  BREADYmi82s8;  



//Master module wire were generated
//Master module 0 - 0
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi0 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi0;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi0 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi0};    
    wire  [BUS_WID-1:0]         WDATAsi02mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi0;  

//Master module wire were generated
//Master module 0 - 1
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi1 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi1;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi1 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi1};    
    wire  [BUS_WID-1:0]         WDATAsi02mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi1;  

//Master module wire were generated
//Master module 0 - 2
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi2 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi2;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi2 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi2};    
    wire  [BUS_WID-1:0]         WDATAsi02mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi2;  

//Master module wire were generated
//Master module 0 - 3
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi3 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi3;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi3 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi3};    
    wire  [BUS_WID-1:0]         WDATAsi02mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi3;  

//Master module wire were generated
//Master module 0 - 4
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi4 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi4;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi4 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi4};    
    wire  [BUS_WID-1:0]         WDATAsi02mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi4;  

//Master module wire were generated
//Master module 0 - 5
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi5 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi5;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi5 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi5};    
    wire  [BUS_WID-1:0]         WDATAsi02mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi5;  

//Master module wire were generated
//Master module 0 - 6
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi6;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi6 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi6};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi6;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi6;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi6;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi6; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi6;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi6; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi6;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi6;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi6 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi6};    
    wire  [BUS_WID-1:0]         WDATAsi02mi6;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi6;  

//Master module wire were generated
//Master module 0 - 7
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi7;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi7 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi7};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi7;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi7;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi7;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi7; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi7;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi7; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi7;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi7;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi7 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi7};    
    wire  [BUS_WID-1:0]         WDATAsi02mi7;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi7;  

//Master module wire were generated
//Master module 0 - 8
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi8;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi8 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi8};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi8;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi8;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi8;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi8; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi8;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi8; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi8;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi8;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi8 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi8};    
    wire  [BUS_WID-1:0]         WDATAsi02mi8;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi8;  

//Master module wire were generated
//Master module 2 - 0
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi0 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi0;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi0 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi0};    
    wire  [BUS_WID-1:0]         WDATAsi22mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi0;  

//Master module wire were generated
//Master module 2 - 1
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi1 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi1;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi1 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi1};    
    wire  [BUS_WID-1:0]         WDATAsi22mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi1;  

//Master module wire were generated
//Master module 2 - 2
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi2 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi2;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi2 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi2};    
    wire  [BUS_WID-1:0]         WDATAsi22mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi2;  

//Master module wire were generated
//Master module 2 - 3
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi3 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi3;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi3 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi3};    
    wire  [BUS_WID-1:0]         WDATAsi22mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi3;  

//Master module wire were generated
//Master module 2 - 4
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi4 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi4;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi4 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi4};    
    wire  [BUS_WID-1:0]         WDATAsi22mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi4;  

//Master module wire were generated
//Master module 2 - 5
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi5 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi5;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi5 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi5};    
    wire  [BUS_WID-1:0]         WDATAsi22mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi5;  

//Master module wire were generated
//Master module 2 - 6
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi6;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi6 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi6};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi6;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi6;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi6;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi6; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi6;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi6; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi6;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi6;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi6 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi6};    
    wire  [BUS_WID-1:0]         WDATAsi22mi6;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi6;  

//Master module wire were generated
//Master module 2 - 7
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi7;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi7 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi7};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi7;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi7;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi7;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi7; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi7;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi7; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi7;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi7;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi7 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi7};    
    wire  [BUS_WID-1:0]         WDATAsi22mi7;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi7;  

//Master module wire were generated
//Master module 2 - 8
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi8;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi8 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi8};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi8;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi8;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi8;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi8; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi8;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi8; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi8;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi8;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi8 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi8};    
    wire  [BUS_WID-1:0]         WDATAsi22mi8;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi8;  

//Master module wire were generated
//Master module 3 - 3
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi3 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi3;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi3 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi3};    
    wire  [BUS_WID-1:0]         WDATAsi32mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi3;  

//Master module wire were generated
//Master module 3 - 6
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi6;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi6 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi6};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi6;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi6;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi6;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi6; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi6;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi6; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi6;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi6;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi6 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi6};    
    wire  [BUS_WID-1:0]         WDATAsi32mi6;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi6;  

//Master module wire were generated
//Master module 3 - 7
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi7;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi7 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi7};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi7;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi7;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi7;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi7; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi7;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi7; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi7;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi7;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi7 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi7};    
    wire  [BUS_WID-1:0]         WDATAsi32mi7;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi7;  

//Master module wire were generated
//Master module 3 - 8
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi8;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi8 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi8};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi8;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi8;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi8;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi8; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi8;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi8; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi8;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi8;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi8 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi8};    
    wire  [BUS_WID-1:0]         WDATAsi32mi8;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi8;  

//Master module wire were generated
//Master module 4 - 3
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi3 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi3;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi3 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi3};    
    wire  [BUS_WID-1:0]         WDATAsi42mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi3;  

//Master module wire were generated
//Master module 4 - 6
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi6;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi6 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi6};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi6;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi6;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi6;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi6; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi6;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi6; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi6;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi6;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi6 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi6};    
    wire  [BUS_WID-1:0]         WDATAsi42mi6;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi6;  

//Master module wire were generated
//Master module 4 - 7
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi7;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi7 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi7};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi7;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi7;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi7;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi7; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi7;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi7; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi7;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi7;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi7 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi7};    
    wire  [BUS_WID-1:0]         WDATAsi42mi7;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi7;  

//Master module wire were generated
//Master module 4 - 8
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi8;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi8 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi8};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi8;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi8;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi8;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi8; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi8;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi8; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi8;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi8;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi8 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi8};    
    wire  [BUS_WID-1:0]         WDATAsi42mi8;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi8;  



    wire    [SLAVE_NUM-1:0]     AWVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     WLASTsi02mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si0;
    wire    [SLAVE_NUM-1:0]     BREADYsi02mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi22mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si2;
    wire    [SLAVE_NUM-1:0]     WLASTsi22mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi22mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si2;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si2;
    wire    [SLAVE_NUM-1:0]     BREADYsi22mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     WLASTsi32mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si3;
    wire    [SLAVE_NUM-1:0]     BREADYsi32mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi42mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si4;
    wire    [SLAVE_NUM-1:0]     WLASTsi42mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi42mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si4;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si4;
    wire    [SLAVE_NUM-1:0]     BREADYsi42mi;
//_____________________________________________________________________

    //Slave Number 0(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si0;     
    wire   [BRESP_WID-1:0]               BRESPmi02si0; 
    //Slave Number 0(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si2;     
    wire   [BRESP_WID-1:0]               BRESPmi02si2; 
    //Slave Number 1(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si0;     
    wire   [BRESP_WID-1:0]               BRESPmi12si0; 
    //Slave Number 1(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si2;     
    wire   [BRESP_WID-1:0]               BRESPmi12si2; 
    //Slave Number 2(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si0;     
    wire   [BRESP_WID-1:0]               BRESPmi22si0; 
    //Slave Number 2(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si2;     
    wire   [BRESP_WID-1:0]               BRESPmi22si2; 
    //Slave Number 3(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si0;     
    wire   [BRESP_WID-1:0]               BRESPmi32si0; 
    //Slave Number 3(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si2;     
    wire   [BRESP_WID-1:0]               BRESPmi32si2; 
    //Slave Number 3(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si3;     
    wire   [BRESP_WID-1:0]               BRESPmi32si3; 
    //Slave Number 3(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si4;     
    wire   [BRESP_WID-1:0]               BRESPmi32si4; 
    //Slave Number 4(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si0;     
    wire   [BRESP_WID-1:0]               BRESPmi42si0; 
    //Slave Number 4(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si2;     
    wire   [BRESP_WID-1:0]               BRESPmi42si2; 
    //Slave Number 5(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si0;     
    wire   [BRESP_WID-1:0]               BRESPmi52si0; 
    //Slave Number 5(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si2;     
    wire   [BRESP_WID-1:0]               BRESPmi52si2; 
    //Slave Number 6(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID6_WID-1:0]   BIDmi62si0;     
    wire   [BRESP_WID-1:0]               BRESPmi62si0; 
    //Slave Number 6(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID6_WID-1:0]   BIDmi62si2;     
    wire   [BRESP_WID-1:0]               BRESPmi62si2; 
    //Slave Number 6(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID6_WID-1:0]   BIDmi62si3;     
    wire   [BRESP_WID-1:0]               BRESPmi62si3; 
    //Slave Number 6(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID6_WID-1:0]   BIDmi62si4;     
    wire   [BRESP_WID-1:0]               BRESPmi62si4; 
    //Slave Number 7(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID7_WID-1:0]   BIDmi72si0;     
    wire   [BRESP_WID-1:0]               BRESPmi72si0; 
    //Slave Number 7(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID7_WID-1:0]   BIDmi72si2;     
    wire   [BRESP_WID-1:0]               BRESPmi72si2; 
    //Slave Number 7(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID7_WID-1:0]   BIDmi72si3;     
    wire   [BRESP_WID-1:0]               BRESPmi72si3; 
    //Slave Number 7(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID7_WID-1:0]   BIDmi72si4;     
    wire   [BRESP_WID-1:0]               BRESPmi72si4; 
    //Slave Number 8(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID8_WID-1:0]   BIDmi82si0;     
    wire   [BRESP_WID-1:0]               BRESPmi82si0; 
    //Slave Number 8(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID8_WID-1:0]   BIDmi82si2;     
    wire   [BRESP_WID-1:0]               BRESPmi82si2; 
    //Slave Number 8(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID8_WID-1:0]   BIDmi82si3;     
    wire   [BRESP_WID-1:0]               BRESPmi82si3; 
    //Slave Number 8(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID8_WID-1:0]   BIDmi82si4;     
    wire   [BRESP_WID-1:0]               BRESPmi82si4; 

//Slave module wire were generated
//Slave module 0    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi02si;
    wire  [MASTER_NUM-1:0]    WREADYmi02si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi02si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi0;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi0;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi02si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi02si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi02si;

//Slave module wire were generated
//Slave module 1    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi12si;
    wire  [MASTER_NUM-1:0]    WREADYmi12si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi12si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi1;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi1;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi12si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi12si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi12si;

//Slave module wire were generated
//Slave module 2    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi22si;
    wire  [MASTER_NUM-1:0]    WREADYmi22si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi22si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi2;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi2;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi22si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi22si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi22si;

//Slave module wire were generated
//Slave module 3    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi32si;
    wire  [MASTER_NUM-1:0]    WREADYmi32si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi32si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi3;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi3;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi32si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi32si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi32si;

//Slave module wire were generated
//Slave module 4    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi42si;
    wire  [MASTER_NUM-1:0]    WREADYmi42si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi42si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi4;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi4;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi42si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi42si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi42si;

//Slave module wire were generated
//Slave module 5    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi52si;
    wire  [MASTER_NUM-1:0]    WREADYmi52si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi52si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi5;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi5;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi52si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi52si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi52si;

//Slave module wire were generated
//Slave module 6    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi62si;
    wire  [MASTER_NUM-1:0]    WREADYmi62si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi62si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi6;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi6;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi6;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi6;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi62si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi62si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi62si;

//Slave module wire were generated
//Slave module 7    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi72si;
    wire  [MASTER_NUM-1:0]    WREADYmi72si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi72si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi7;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi7;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi7;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi7;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi72si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi72si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi72si;

//Slave module wire were generated
//Slave module 8    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi82si;
    wire  [MASTER_NUM-1:0]    WREADYmi82si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi82si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi8;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi8;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi8;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi8;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi82si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi82si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi82si;


//MaserInterface to SlaveInterface Setting
//_____________________________________________________________________
//SlaveNum  [0]
/////////////////////////////
    assign SetAWREADYmi02si[0] = AWREADYmi02si[0]; 
    assign SetAWREADYmi02si[1] = 1'b0;
    assign SetAWREADYmi02si[2] = AWREADYmi02si[1]; 
    assign SetAWREADYmi02si[3] = 1'b0;
    assign SetAWREADYmi02si[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetAWREADYmi12si[0] = AWREADYmi12si[0]; 
    assign SetAWREADYmi12si[1] = 1'b0;
    assign SetAWREADYmi12si[2] = AWREADYmi12si[1]; 
    assign SetAWREADYmi12si[3] = 1'b0;
    assign SetAWREADYmi12si[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetAWREADYmi22si[0] = AWREADYmi22si[0]; 
    assign SetAWREADYmi22si[1] = 1'b0;
    assign SetAWREADYmi22si[2] = AWREADYmi22si[1]; 
    assign SetAWREADYmi22si[3] = 1'b0;
    assign SetAWREADYmi22si[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetAWREADYmi32si[0] = AWREADYmi32si[0]; 
    assign SetAWREADYmi32si[1] = 1'b0;
    assign SetAWREADYmi32si[2] = AWREADYmi32si[1]; 
    assign SetAWREADYmi32si[3] = AWREADYmi32si[2]; 
    assign SetAWREADYmi32si[4] = AWREADYmi32si[3]; 
//SlaveNum  [4]
/////////////////////////////
    assign SetAWREADYmi42si[0] = AWREADYmi42si[0]; 
    assign SetAWREADYmi42si[1] = 1'b0;
    assign SetAWREADYmi42si[2] = AWREADYmi42si[1]; 
    assign SetAWREADYmi42si[3] = 1'b0;
    assign SetAWREADYmi42si[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetAWREADYmi52si[0] = AWREADYmi52si[0]; 
    assign SetAWREADYmi52si[1] = 1'b0;
    assign SetAWREADYmi52si[2] = AWREADYmi52si[1]; 
    assign SetAWREADYmi52si[3] = 1'b0;
    assign SetAWREADYmi52si[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign SetAWREADYmi62si[0] = AWREADYmi62si[0]; 
    assign SetAWREADYmi62si[1] = 1'b0;
    assign SetAWREADYmi62si[2] = AWREADYmi62si[1]; 
    assign SetAWREADYmi62si[3] = AWREADYmi62si[2]; 
    assign SetAWREADYmi62si[4] = AWREADYmi62si[3]; 
//SlaveNum  [7]
/////////////////////////////
    assign SetAWREADYmi72si[0] = AWREADYmi72si[0]; 
    assign SetAWREADYmi72si[1] = 1'b0;
    assign SetAWREADYmi72si[2] = AWREADYmi72si[1]; 
    assign SetAWREADYmi72si[3] = AWREADYmi72si[2]; 
    assign SetAWREADYmi72si[4] = AWREADYmi72si[3]; 
//SlaveNum  [8]
/////////////////////////////
    assign SetAWREADYmi82si[0] = AWREADYmi82si[0]; 
    assign SetAWREADYmi82si[1] = 1'b0;
    assign SetAWREADYmi82si[2] = AWREADYmi82si[1]; 
    assign SetAWREADYmi82si[3] = AWREADYmi82si[2]; 
    assign SetAWREADYmi82si[4] = AWREADYmi82si[3]; 

//SlaveNum  [0]
/////////////////////////////
    assign  SetWREADYmi02si[0] = WREADYmi02si[0];   
    assign  SetWREADYmi02si[1] = 1'b0;
    assign  SetWREADYmi02si[2] = WREADYmi02si[1];   
    assign  SetWREADYmi02si[3] = 1'b0;
    assign  SetWREADYmi02si[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  SetWREADYmi12si[0] = WREADYmi12si[0];   
    assign  SetWREADYmi12si[1] = 1'b0;
    assign  SetWREADYmi12si[2] = WREADYmi12si[1];   
    assign  SetWREADYmi12si[3] = 1'b0;
    assign  SetWREADYmi12si[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  SetWREADYmi22si[0] = WREADYmi22si[0];   
    assign  SetWREADYmi22si[1] = 1'b0;
    assign  SetWREADYmi22si[2] = WREADYmi22si[1];   
    assign  SetWREADYmi22si[3] = 1'b0;
    assign  SetWREADYmi22si[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  SetWREADYmi32si[0] = WREADYmi32si[0];   
    assign  SetWREADYmi32si[1] = 1'b0;
    assign  SetWREADYmi32si[2] = WREADYmi32si[1];   
    assign  SetWREADYmi32si[3] = WREADYmi32si[2];   
    assign  SetWREADYmi32si[4] = WREADYmi32si[3];   
//SlaveNum  [4]
/////////////////////////////
    assign  SetWREADYmi42si[0] = WREADYmi42si[0];   
    assign  SetWREADYmi42si[1] = 1'b0;
    assign  SetWREADYmi42si[2] = WREADYmi42si[1];   
    assign  SetWREADYmi42si[3] = 1'b0;
    assign  SetWREADYmi42si[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  SetWREADYmi52si[0] = WREADYmi52si[0];   
    assign  SetWREADYmi52si[1] = 1'b0;
    assign  SetWREADYmi52si[2] = WREADYmi52si[1];   
    assign  SetWREADYmi52si[3] = 1'b0;
    assign  SetWREADYmi52si[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  SetWREADYmi62si[0] = WREADYmi62si[0];   
    assign  SetWREADYmi62si[1] = 1'b0;
    assign  SetWREADYmi62si[2] = WREADYmi62si[1];   
    assign  SetWREADYmi62si[3] = WREADYmi62si[2];   
    assign  SetWREADYmi62si[4] = WREADYmi62si[3];   
//SlaveNum  [7]
/////////////////////////////
    assign  SetWREADYmi72si[0] = WREADYmi72si[0];   
    assign  SetWREADYmi72si[1] = 1'b0;
    assign  SetWREADYmi72si[2] = WREADYmi72si[1];   
    assign  SetWREADYmi72si[3] = WREADYmi72si[2];   
    assign  SetWREADYmi72si[4] = WREADYmi72si[3];   
//SlaveNum  [8]
/////////////////////////////
    assign  SetWREADYmi82si[0] = WREADYmi82si[0];   
    assign  SetWREADYmi82si[1] = 1'b0;
    assign  SetWREADYmi82si[2] = WREADYmi82si[1];   
    assign  SetWREADYmi82si[3] = WREADYmi82si[2];   
    assign  SetWREADYmi82si[4] = WREADYmi82si[3];   

//SlaveNum  [0]
/////////////////////////////
    assign SetBVALIDmi02si[0]  = BVALIDmi02si[0];
    assign SetBVALIDmi02si[1]  = 1'b0;
    assign SetBVALIDmi02si[2]  = BVALIDmi02si[1];
    assign SetBVALIDmi02si[3]  = 1'b0;
    assign SetBVALIDmi02si[4]  = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetBVALIDmi12si[0]  = BVALIDmi12si[0];
    assign SetBVALIDmi12si[1]  = 1'b0;
    assign SetBVALIDmi12si[2]  = BVALIDmi12si[1];
    assign SetBVALIDmi12si[3]  = 1'b0;
    assign SetBVALIDmi12si[4]  = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetBVALIDmi22si[0]  = BVALIDmi22si[0];
    assign SetBVALIDmi22si[1]  = 1'b0;
    assign SetBVALIDmi22si[2]  = BVALIDmi22si[1];
    assign SetBVALIDmi22si[3]  = 1'b0;
    assign SetBVALIDmi22si[4]  = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetBVALIDmi32si[0]  = BVALIDmi32si[0];
    assign SetBVALIDmi32si[1]  = 1'b0;
    assign SetBVALIDmi32si[2]  = BVALIDmi32si[1];
    assign SetBVALIDmi32si[3]  = BVALIDmi32si[2];
    assign SetBVALIDmi32si[4]  = BVALIDmi32si[3];
//SlaveNum  [4]
/////////////////////////////
    assign SetBVALIDmi42si[0]  = BVALIDmi42si[0];
    assign SetBVALIDmi42si[1]  = 1'b0;
    assign SetBVALIDmi42si[2]  = BVALIDmi42si[1];
    assign SetBVALIDmi42si[3]  = 1'b0;
    assign SetBVALIDmi42si[4]  = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetBVALIDmi52si[0]  = BVALIDmi52si[0];
    assign SetBVALIDmi52si[1]  = 1'b0;
    assign SetBVALIDmi52si[2]  = BVALIDmi52si[1];
    assign SetBVALIDmi52si[3]  = 1'b0;
    assign SetBVALIDmi52si[4]  = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign SetBVALIDmi62si[0]  = BVALIDmi62si[0];
    assign SetBVALIDmi62si[1]  = 1'b0;
    assign SetBVALIDmi62si[2]  = BVALIDmi62si[1];
    assign SetBVALIDmi62si[3]  = BVALIDmi62si[2];
    assign SetBVALIDmi62si[4]  = BVALIDmi62si[3];
//SlaveNum  [7]
/////////////////////////////
    assign SetBVALIDmi72si[0]  = BVALIDmi72si[0];
    assign SetBVALIDmi72si[1]  = 1'b0;
    assign SetBVALIDmi72si[2]  = BVALIDmi72si[1];
    assign SetBVALIDmi72si[3]  = BVALIDmi72si[2];
    assign SetBVALIDmi72si[4]  = BVALIDmi72si[3];
//SlaveNum  [8]
/////////////////////////////
    assign SetBVALIDmi82si[0]  = BVALIDmi82si[0];
    assign SetBVALIDmi82si[1]  = 1'b0;
    assign SetBVALIDmi82si[2]  = BVALIDmi82si[1];
    assign SetBVALIDmi82si[3]  = BVALIDmi82si[2];
    assign SetBVALIDmi82si[4]  = BVALIDmi82si[3];

//AWREADYmi2si///////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  AWREADYmi2si0[0] = SetAWREADYmi02si[0];
    assign  AWREADYmi2si0[1] = SetAWREADYmi12si[0];
    assign  AWREADYmi2si0[2] = SetAWREADYmi22si[0];
    assign  AWREADYmi2si0[3] = SetAWREADYmi32si[0];
    assign  AWREADYmi2si0[4] = SetAWREADYmi42si[0];
    assign  AWREADYmi2si0[5] = SetAWREADYmi52si[0];
    assign  AWREADYmi2si0[6] = SetAWREADYmi62si[0];
    assign  AWREADYmi2si0[7] = SetAWREADYmi72si[0];
    assign  AWREADYmi2si0[8] = SetAWREADYmi82si[0];
//MasterNum  [2]
/////////////////////////////
    assign  AWREADYmi2si2[0] = SetAWREADYmi02si[2];
    assign  AWREADYmi2si2[1] = SetAWREADYmi12si[2];
    assign  AWREADYmi2si2[2] = SetAWREADYmi22si[2];
    assign  AWREADYmi2si2[3] = SetAWREADYmi32si[2];
    assign  AWREADYmi2si2[4] = SetAWREADYmi42si[2];
    assign  AWREADYmi2si2[5] = SetAWREADYmi52si[2];
    assign  AWREADYmi2si2[6] = SetAWREADYmi62si[2];
    assign  AWREADYmi2si2[7] = SetAWREADYmi72si[2];
    assign  AWREADYmi2si2[8] = SetAWREADYmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  AWREADYmi2si3[0] = SetAWREADYmi02si[3];
    assign  AWREADYmi2si3[1] = SetAWREADYmi12si[3];
    assign  AWREADYmi2si3[2] = SetAWREADYmi22si[3];
    assign  AWREADYmi2si3[3] = SetAWREADYmi32si[3];
    assign  AWREADYmi2si3[4] = SetAWREADYmi42si[3];
    assign  AWREADYmi2si3[5] = SetAWREADYmi52si[3];
    assign  AWREADYmi2si3[6] = SetAWREADYmi62si[3];
    assign  AWREADYmi2si3[7] = SetAWREADYmi72si[3];
    assign  AWREADYmi2si3[8] = SetAWREADYmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  AWREADYmi2si4[0] = SetAWREADYmi02si[4];
    assign  AWREADYmi2si4[1] = SetAWREADYmi12si[4];
    assign  AWREADYmi2si4[2] = SetAWREADYmi22si[4];
    assign  AWREADYmi2si4[3] = SetAWREADYmi32si[4];
    assign  AWREADYmi2si4[4] = SetAWREADYmi42si[4];
    assign  AWREADYmi2si4[5] = SetAWREADYmi52si[4];
    assign  AWREADYmi2si4[6] = SetAWREADYmi62si[4];
    assign  AWREADYmi2si4[7] = SetAWREADYmi72si[4];
    assign  AWREADYmi2si4[8] = SetAWREADYmi82si[4];

//BVALIDmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  BVALIDmi2si0[0] = SetBVALIDmi02si[0];
    assign  BVALIDmi2si0[1] = SetBVALIDmi12si[0];
    assign  BVALIDmi2si0[2] = SetBVALIDmi22si[0];
    assign  BVALIDmi2si0[3] = SetBVALIDmi32si[0];
    assign  BVALIDmi2si0[4] = SetBVALIDmi42si[0];
    assign  BVALIDmi2si0[5] = SetBVALIDmi52si[0];
    assign  BVALIDmi2si0[6] = SetBVALIDmi62si[0];
    assign  BVALIDmi2si0[7] = SetBVALIDmi72si[0];
    assign  BVALIDmi2si0[8] = SetBVALIDmi82si[0];
//MasterNum  [2]
/////////////////////////////
    assign  BVALIDmi2si2[0] = SetBVALIDmi02si[2];
    assign  BVALIDmi2si2[1] = SetBVALIDmi12si[2];
    assign  BVALIDmi2si2[2] = SetBVALIDmi22si[2];
    assign  BVALIDmi2si2[3] = SetBVALIDmi32si[2];
    assign  BVALIDmi2si2[4] = SetBVALIDmi42si[2];
    assign  BVALIDmi2si2[5] = SetBVALIDmi52si[2];
    assign  BVALIDmi2si2[6] = SetBVALIDmi62si[2];
    assign  BVALIDmi2si2[7] = SetBVALIDmi72si[2];
    assign  BVALIDmi2si2[8] = SetBVALIDmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  BVALIDmi2si3[0] = SetBVALIDmi02si[3];
    assign  BVALIDmi2si3[1] = SetBVALIDmi12si[3];
    assign  BVALIDmi2si3[2] = SetBVALIDmi22si[3];
    assign  BVALIDmi2si3[3] = SetBVALIDmi32si[3];
    assign  BVALIDmi2si3[4] = SetBVALIDmi42si[3];
    assign  BVALIDmi2si3[5] = SetBVALIDmi52si[3];
    assign  BVALIDmi2si3[6] = SetBVALIDmi62si[3];
    assign  BVALIDmi2si3[7] = SetBVALIDmi72si[3];
    assign  BVALIDmi2si3[8] = SetBVALIDmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  BVALIDmi2si4[0] = SetBVALIDmi02si[4];
    assign  BVALIDmi2si4[1] = SetBVALIDmi12si[4];
    assign  BVALIDmi2si4[2] = SetBVALIDmi22si[4];
    assign  BVALIDmi2si4[3] = SetBVALIDmi32si[4];
    assign  BVALIDmi2si4[4] = SetBVALIDmi42si[4];
    assign  BVALIDmi2si4[5] = SetBVALIDmi52si[4];
    assign  BVALIDmi2si4[6] = SetBVALIDmi62si[4];
    assign  BVALIDmi2si4[7] = SetBVALIDmi72si[4];
    assign  BVALIDmi2si4[8] = SetBVALIDmi82si[4];

//WREADYmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  WREADYmi2si0[0] = SetWREADYmi02si[0];
    assign  WREADYmi2si0[1] = SetWREADYmi12si[0];
    assign  WREADYmi2si0[2] = SetWREADYmi22si[0];
    assign  WREADYmi2si0[3] = SetWREADYmi32si[0];
    assign  WREADYmi2si0[4] = SetWREADYmi42si[0];
    assign  WREADYmi2si0[5] = SetWREADYmi52si[0];
    assign  WREADYmi2si0[6] = SetWREADYmi62si[0];
    assign  WREADYmi2si0[7] = SetWREADYmi72si[0];
    assign  WREADYmi2si0[8] = SetWREADYmi82si[0];
//MasterNum  [2]
/////////////////////////////
    assign  WREADYmi2si2[0] = SetWREADYmi02si[2];
    assign  WREADYmi2si2[1] = SetWREADYmi12si[2];
    assign  WREADYmi2si2[2] = SetWREADYmi22si[2];
    assign  WREADYmi2si2[3] = SetWREADYmi32si[2];
    assign  WREADYmi2si2[4] = SetWREADYmi42si[2];
    assign  WREADYmi2si2[5] = SetWREADYmi52si[2];
    assign  WREADYmi2si2[6] = SetWREADYmi62si[2];
    assign  WREADYmi2si2[7] = SetWREADYmi72si[2];
    assign  WREADYmi2si2[8] = SetWREADYmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  WREADYmi2si3[0] = SetWREADYmi02si[3];
    assign  WREADYmi2si3[1] = SetWREADYmi12si[3];
    assign  WREADYmi2si3[2] = SetWREADYmi22si[3];
    assign  WREADYmi2si3[3] = SetWREADYmi32si[3];
    assign  WREADYmi2si3[4] = SetWREADYmi42si[3];
    assign  WREADYmi2si3[5] = SetWREADYmi52si[3];
    assign  WREADYmi2si3[6] = SetWREADYmi62si[3];
    assign  WREADYmi2si3[7] = SetWREADYmi72si[3];
    assign  WREADYmi2si3[8] = SetWREADYmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  WREADYmi2si4[0] = SetWREADYmi02si[4];
    assign  WREADYmi2si4[1] = SetWREADYmi12si[4];
    assign  WREADYmi2si4[2] = SetWREADYmi22si[4];
    assign  WREADYmi2si4[3] = SetWREADYmi32si[4];
    assign  WREADYmi2si4[4] = SetWREADYmi42si[4];
    assign  WREADYmi2si4[5] = SetWREADYmi52si[4];
    assign  WREADYmi2si4[6] = SetWREADYmi62si[4];
    assign  WREADYmi2si4[7] = SetWREADYmi72si[4];
    assign  WREADYmi2si4[8] = SetWREADYmi82si[4];

//_____________________________________________________________________


//SlaveInterface to MasterInterface Setting
//_____________________________________________________________________

//AWVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  AWVALIDsi2mi0[0] = AWVALIDsi02mi[0];
    assign  AWVALIDsi2mi0[1] = AWVALIDsi22mi[0];
    assign  AWVALIDsi2mi0[2] = 1'b0;
    assign  AWVALIDsi2mi0[3] = 1'b0;
    assign  AWVALIDsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  AWVALIDsi2mi1[0] = AWVALIDsi02mi[1];
    assign  AWVALIDsi2mi1[1] = AWVALIDsi22mi[1];
    assign  AWVALIDsi2mi1[2] = 1'b0;
    assign  AWVALIDsi2mi1[3] = 1'b0;
    assign  AWVALIDsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  AWVALIDsi2mi2[0] = AWVALIDsi02mi[2];
    assign  AWVALIDsi2mi2[1] = AWVALIDsi22mi[2];
    assign  AWVALIDsi2mi2[2] = 1'b0;
    assign  AWVALIDsi2mi2[3] = 1'b0;
    assign  AWVALIDsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  AWVALIDsi2mi3[0] = AWVALIDsi02mi[3];
    assign  AWVALIDsi2mi3[1] = AWVALIDsi22mi[3];
    assign  AWVALIDsi2mi3[2] = AWVALIDsi32mi[3];
    assign  AWVALIDsi2mi3[3] = AWVALIDsi42mi[3];
    assign  AWVALIDsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  AWVALIDsi2mi4[0] = AWVALIDsi02mi[4];
    assign  AWVALIDsi2mi4[1] = AWVALIDsi22mi[4];
    assign  AWVALIDsi2mi4[2] = 1'b0;
    assign  AWVALIDsi2mi4[3] = 1'b0;
    assign  AWVALIDsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  AWVALIDsi2mi5[0] = AWVALIDsi02mi[5];
    assign  AWVALIDsi2mi5[1] = AWVALIDsi22mi[5];
    assign  AWVALIDsi2mi5[2] = 1'b0;
    assign  AWVALIDsi2mi5[3] = 1'b0;
    assign  AWVALIDsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  AWVALIDsi2mi6[0] = AWVALIDsi02mi[6];
    assign  AWVALIDsi2mi6[1] = AWVALIDsi22mi[6];
    assign  AWVALIDsi2mi6[2] = AWVALIDsi32mi[6];
    assign  AWVALIDsi2mi6[3] = AWVALIDsi42mi[6];
    assign  AWVALIDsi2mi6[4] = 1'b0;
//SlaveNum  [7]
/////////////////////////////
    assign  AWVALIDsi2mi7[0] = AWVALIDsi02mi[7];
    assign  AWVALIDsi2mi7[1] = AWVALIDsi22mi[7];
    assign  AWVALIDsi2mi7[2] = AWVALIDsi32mi[7];
    assign  AWVALIDsi2mi7[3] = AWVALIDsi42mi[7];
    assign  AWVALIDsi2mi7[4] = 1'b0;
//SlaveNum  [8]
/////////////////////////////
    assign  AWVALIDsi2mi8[0] = AWVALIDsi02mi[8];
    assign  AWVALIDsi2mi8[1] = AWVALIDsi22mi[8];
    assign  AWVALIDsi2mi8[2] = AWVALIDsi32mi[8];
    assign  AWVALIDsi2mi8[3] = AWVALIDsi42mi[8];
    assign  AWVALIDsi2mi8[4] = 1'b0;

//WVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WVALIDsi2mi0[0] = WVALIDsi02mi[0];
    assign  WVALIDsi2mi0[1] = WVALIDsi22mi[0];
    assign  WVALIDsi2mi0[2] = 1'b0;
    assign  WVALIDsi2mi0[3] = 1'b0;
    assign  WVALIDsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WVALIDsi2mi1[0] = WVALIDsi02mi[1];
    assign  WVALIDsi2mi1[1] = WVALIDsi22mi[1];
    assign  WVALIDsi2mi1[2] = 1'b0;
    assign  WVALIDsi2mi1[3] = 1'b0;
    assign  WVALIDsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WVALIDsi2mi2[0] = WVALIDsi02mi[2];
    assign  WVALIDsi2mi2[1] = WVALIDsi22mi[2];
    assign  WVALIDsi2mi2[2] = 1'b0;
    assign  WVALIDsi2mi2[3] = 1'b0;
    assign  WVALIDsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WVALIDsi2mi3[0] = WVALIDsi02mi[3];
    assign  WVALIDsi2mi3[1] = WVALIDsi22mi[3];
    assign  WVALIDsi2mi3[2] = WVALIDsi32mi[3];
    assign  WVALIDsi2mi3[3] = WVALIDsi42mi[3];
    assign  WVALIDsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WVALIDsi2mi4[0] = WVALIDsi02mi[4];
    assign  WVALIDsi2mi4[1] = WVALIDsi22mi[4];
    assign  WVALIDsi2mi4[2] = 1'b0;
    assign  WVALIDsi2mi4[3] = 1'b0;
    assign  WVALIDsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WVALIDsi2mi5[0] = WVALIDsi02mi[5];
    assign  WVALIDsi2mi5[1] = WVALIDsi22mi[5];
    assign  WVALIDsi2mi5[2] = 1'b0;
    assign  WVALIDsi2mi5[3] = 1'b0;
    assign  WVALIDsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  WVALIDsi2mi6[0] = WVALIDsi02mi[6];
    assign  WVALIDsi2mi6[1] = WVALIDsi22mi[6];
    assign  WVALIDsi2mi6[2] = WVALIDsi32mi[6];
    assign  WVALIDsi2mi6[3] = WVALIDsi42mi[6];
    assign  WVALIDsi2mi6[4] = 1'b0;
//SlaveNum  [7]
/////////////////////////////
    assign  WVALIDsi2mi7[0] = WVALIDsi02mi[7];
    assign  WVALIDsi2mi7[1] = WVALIDsi22mi[7];
    assign  WVALIDsi2mi7[2] = WVALIDsi32mi[7];
    assign  WVALIDsi2mi7[3] = WVALIDsi42mi[7];
    assign  WVALIDsi2mi7[4] = 1'b0;
//SlaveNum  [8]
/////////////////////////////
    assign  WVALIDsi2mi8[0] = WVALIDsi02mi[8];
    assign  WVALIDsi2mi8[1] = WVALIDsi22mi[8];
    assign  WVALIDsi2mi8[2] = WVALIDsi32mi[8];
    assign  WVALIDsi2mi8[3] = WVALIDsi42mi[8];
    assign  WVALIDsi2mi8[4] = 1'b0;

//WLASTsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WLASTsi2mi0[0] = WLASTsi02mi[0];
    assign  WLASTsi2mi0[1] = WLASTsi22mi[0];
    assign  WLASTsi2mi0[2] = 1'b0;
    assign  WLASTsi2mi0[3] = 1'b0;
    assign  WLASTsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WLASTsi2mi1[0] = WLASTsi02mi[1];
    assign  WLASTsi2mi1[1] = WLASTsi22mi[1];
    assign  WLASTsi2mi1[2] = 1'b0;
    assign  WLASTsi2mi1[3] = 1'b0;
    assign  WLASTsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WLASTsi2mi2[0] = WLASTsi02mi[2];
    assign  WLASTsi2mi2[1] = WLASTsi22mi[2];
    assign  WLASTsi2mi2[2] = 1'b0;
    assign  WLASTsi2mi2[3] = 1'b0;
    assign  WLASTsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WLASTsi2mi3[0] = WLASTsi02mi[3];
    assign  WLASTsi2mi3[1] = WLASTsi22mi[3];
    assign  WLASTsi2mi3[2] = WLASTsi32mi[3];
    assign  WLASTsi2mi3[3] = WLASTsi42mi[3];
    assign  WLASTsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WLASTsi2mi4[0] = WLASTsi02mi[4];
    assign  WLASTsi2mi4[1] = WLASTsi22mi[4];
    assign  WLASTsi2mi4[2] = 1'b0;
    assign  WLASTsi2mi4[3] = 1'b0;
    assign  WLASTsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WLASTsi2mi5[0] = WLASTsi02mi[5];
    assign  WLASTsi2mi5[1] = WLASTsi22mi[5];
    assign  WLASTsi2mi5[2] = 1'b0;
    assign  WLASTsi2mi5[3] = 1'b0;
    assign  WLASTsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  WLASTsi2mi6[0] = WLASTsi02mi[6];
    assign  WLASTsi2mi6[1] = WLASTsi22mi[6];
    assign  WLASTsi2mi6[2] = WLASTsi32mi[6];
    assign  WLASTsi2mi6[3] = WLASTsi42mi[6];
    assign  WLASTsi2mi6[4] = 1'b0;
//SlaveNum  [7]
/////////////////////////////
    assign  WLASTsi2mi7[0] = WLASTsi02mi[7];
    assign  WLASTsi2mi7[1] = WLASTsi22mi[7];
    assign  WLASTsi2mi7[2] = WLASTsi32mi[7];
    assign  WLASTsi2mi7[3] = WLASTsi42mi[7];
    assign  WLASTsi2mi7[4] = 1'b0;
//SlaveNum  [8]
/////////////////////////////
    assign  WLASTsi2mi8[0] = WLASTsi02mi[8];
    assign  WLASTsi2mi8[1] = WLASTsi22mi[8];
    assign  WLASTsi2mi8[2] = WLASTsi32mi[8];
    assign  WLASTsi2mi8[3] = WLASTsi42mi[8];
    assign  WLASTsi2mi8[4] = 1'b0;

//BREADYsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  BREADYsi2mi0[0] = BREADYsi02mi[0];
    assign  BREADYsi2mi0[1] = BREADYsi22mi[0];
    assign  BREADYsi2mi0[2] = 1'b0;
    assign  BREADYsi2mi0[3] = 1'b0;
    assign  BREADYsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  BREADYsi2mi1[0] = BREADYsi02mi[1];
    assign  BREADYsi2mi1[1] = BREADYsi22mi[1];
    assign  BREADYsi2mi1[2] = 1'b0;
    assign  BREADYsi2mi1[3] = 1'b0;
    assign  BREADYsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  BREADYsi2mi2[0] = BREADYsi02mi[2];
    assign  BREADYsi2mi2[1] = BREADYsi22mi[2];
    assign  BREADYsi2mi2[2] = 1'b0;
    assign  BREADYsi2mi2[3] = 1'b0;
    assign  BREADYsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  BREADYsi2mi3[0] = BREADYsi02mi[3];
    assign  BREADYsi2mi3[1] = BREADYsi22mi[3];
    assign  BREADYsi2mi3[2] = BREADYsi32mi[3];
    assign  BREADYsi2mi3[3] = BREADYsi42mi[3];
    assign  BREADYsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  BREADYsi2mi4[0] = BREADYsi02mi[4];
    assign  BREADYsi2mi4[1] = BREADYsi22mi[4];
    assign  BREADYsi2mi4[2] = 1'b0;
    assign  BREADYsi2mi4[3] = 1'b0;
    assign  BREADYsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  BREADYsi2mi5[0] = BREADYsi02mi[5];
    assign  BREADYsi2mi5[1] = BREADYsi22mi[5];
    assign  BREADYsi2mi5[2] = 1'b0;
    assign  BREADYsi2mi5[3] = 1'b0;
    assign  BREADYsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  BREADYsi2mi6[0] = BREADYsi02mi[6];
    assign  BREADYsi2mi6[1] = BREADYsi22mi[6];
    assign  BREADYsi2mi6[2] = BREADYsi32mi[6];
    assign  BREADYsi2mi6[3] = BREADYsi42mi[6];
    assign  BREADYsi2mi6[4] = 1'b0;
//SlaveNum  [7]
/////////////////////////////
    assign  BREADYsi2mi7[0] = BREADYsi02mi[7];
    assign  BREADYsi2mi7[1] = BREADYsi22mi[7];
    assign  BREADYsi2mi7[2] = BREADYsi32mi[7];
    assign  BREADYsi2mi7[3] = BREADYsi42mi[7];
    assign  BREADYsi2mi7[4] = 1'b0;
//SlaveNum  [8]
/////////////////////////////
    assign  BREADYsi2mi8[0] = BREADYsi02mi[8];
    assign  BREADYsi2mi8[1] = BREADYsi22mi[8];
    assign  BREADYsi2mi8[2] = BREADYsi32mi[8];
    assign  BREADYsi2mi8[3] = BREADYsi42mi[8];
    assign  BREADYsi2mi8[4] = 1'b0;

//_____________________________________________________________________



//Master module 0    
//________________________________________________________________________

ARMD_RS_WriteChannelsi
ARMD_RS_WriteChannelsi(
    
    .SelMAP1(SelMAP1),

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disable_id_port
    .AWADDRm2si  (AWADDRm02si0),
    .AWLENm2si   (AWLENm02si0),
    .AWSIZEm2si  (AWSIZEm02si0),
    .AWBURSTm2si (AWBURSTm02si0),
    .AWLOCKm2si  (AWLOCKm02si0),
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm2si (AWVALIDm02si0),
    .AWREADYsi2m (AWREADYsi02m0),

    //Write data channel
//Disable_id_port
    .WDATAm2si   (WDATAm02si0),
    .WSTRBm2si   (WSTRBm02si0),
    .WLASTm2si   (WLASTm02si0),
    .WVALIDm2si  (WVALIDm02si0),
    .WREADYsi2m  (WREADYsi02m0),

    //Write response channel
//Disable_id_port
    .BRESPsi2m   (BRESPsi02m0),
    .BVALIDsi2m  (BVALIDsi02m0),
    .BREADYm2si  (BREADYm02si0),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi02mi0),
    .AWADDRsi2mi0  (AWADDRsi02mi0),
    .AWLENsi2mi0   (AWLENsi02mi0),
    .AWSIZEsi2mi0  (AWSIZEsi02mi0),
    .AWBURSTsi2mi0 (AWBURSTsi02mi0),
    .AWLOCKsi2mi0  (AWLOCKsi02mi0),
    .AWCACHEsi2mi0 (AWCACHEsi02mi0),
    .AWPROTsi2mi0  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi02mi0),
    .WDATAsi2mi0   (WDATAsi02mi0),
    .WSTRBsi2mi0   (WSTRBsi02mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si0[MASTERID0_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi02mi1),
    .AWADDRsi2mi1  (AWADDRsi02mi1),
    .AWLENsi2mi1   (AWLENsi02mi1),
    .AWSIZEsi2mi1  (AWSIZEsi02mi1),
    .AWBURSTsi2mi1 (AWBURSTsi02mi1),
    .AWLOCKsi2mi1  (AWLOCKsi02mi1),
    .AWCACHEsi2mi1 (AWCACHEsi02mi1),
    .AWPROTsi2mi1  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi02mi1),
    .WDATAsi2mi1   (WDATAsi02mi1),
    .WSTRBsi2mi1   (WSTRBsi02mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si0[MASTERID0_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi02mi2),
    .AWADDRsi2mi2  (AWADDRsi02mi2),
    .AWLENsi2mi2   (AWLENsi02mi2),
    .AWSIZEsi2mi2  (AWSIZEsi02mi2),
    .AWBURSTsi2mi2 (AWBURSTsi02mi2),
    .AWLOCKsi2mi2  (AWLOCKsi02mi2),
    .AWCACHEsi2mi2 (AWCACHEsi02mi2),
    .AWPROTsi2mi2  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi02mi2),
    .WDATAsi2mi2   (WDATAsi02mi2),
    .WSTRBsi2mi2   (WSTRBsi02mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si0[MASTERID0_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi02mi3),
    .AWADDRsi2mi3  (AWADDRsi02mi3),
    .AWLENsi2mi3   (AWLENsi02mi3),
    .AWSIZEsi2mi3  (AWSIZEsi02mi3),
    .AWBURSTsi2mi3 (AWBURSTsi02mi3),
    .AWLOCKsi2mi3  (AWLOCKsi02mi3),
    .AWCACHEsi2mi3 (AWCACHEsi02mi3),
    .AWPROTsi2mi3  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi02mi3),
    .WDATAsi2mi3   (WDATAsi02mi3),
    .WSTRBsi2mi3   (WSTRBsi02mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si0[MASTERID0_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi02mi4),
    .AWADDRsi2mi4  (AWADDRsi02mi4),
    .AWLENsi2mi4   (AWLENsi02mi4),
    .AWSIZEsi2mi4  (AWSIZEsi02mi4),
    .AWBURSTsi2mi4 (AWBURSTsi02mi4),
    .AWLOCKsi2mi4  (AWLOCKsi02mi4),
    .AWCACHEsi2mi4 (AWCACHEsi02mi4),
    .AWPROTsi2mi4  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi02mi4),
    .WDATAsi2mi4   (WDATAsi02mi4),
    .WSTRBsi2mi4   (WSTRBsi02mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si0[MASTERID0_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi02mi5),
    .AWADDRsi2mi5  (AWADDRsi02mi5),
    .AWLENsi2mi5   (AWLENsi02mi5),
    .AWSIZEsi2mi5  (AWSIZEsi02mi5),
    .AWBURSTsi2mi5 (AWBURSTsi02mi5),
    .AWLOCKsi2mi5  (AWLOCKsi02mi5),
    .AWCACHEsi2mi5 (AWCACHEsi02mi5),
    .AWPROTsi2mi5  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi02mi5),
    .WDATAsi2mi5   (WDATAsi02mi5),
    .WSTRBsi2mi5   (WSTRBsi02mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si0[MASTERID0_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi6    (AWIDsi02mi6),
    .AWADDRsi2mi6  (AWADDRsi02mi6),
    .AWLENsi2mi6   (AWLENsi02mi6),
    .AWSIZEsi2mi6  (AWSIZEsi02mi6),
    .AWBURSTsi2mi6 (AWBURSTsi02mi6),
    .AWLOCKsi2mi6  (AWLOCKsi02mi6),
    .AWCACHEsi2mi6 (AWCACHEsi02mi6),
    .AWPROTsi2mi6  (AWPROTsi02mi6),

    //Write data channel
    .WIDsi2mi6     (WIDsi02mi6),
    .WDATAsi2mi6   (WDATAsi02mi6),
    .WSTRBsi2mi6   (WSTRBsi02mi6),

    //Write response channel

    //Slave Number 6
    .BIDmi62si     (BIDmi62si0[MASTERID0_WID-1:0]),
    .BRESPmi62si   (BRESPmi62si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi7    (AWIDsi02mi7),
    .AWADDRsi2mi7  (AWADDRsi02mi7),
    .AWLENsi2mi7   (AWLENsi02mi7),
    .AWSIZEsi2mi7  (AWSIZEsi02mi7),
    .AWBURSTsi2mi7 (AWBURSTsi02mi7),
    .AWLOCKsi2mi7  (AWLOCKsi02mi7),
    .AWCACHEsi2mi7 (AWCACHEsi02mi7),
    .AWPROTsi2mi7  (AWPROTsi02mi7),

    //Write data channel
    .WIDsi2mi7     (WIDsi02mi7),
    .WDATAsi2mi7   (WDATAsi02mi7),
    .WSTRBsi2mi7   (WSTRBsi02mi7),

    //Write response channel

    //Slave Number 7
    .BIDmi72si     (BIDmi72si0[MASTERID0_WID-1:0]),
    .BRESPmi72si   (BRESPmi72si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi8    (AWIDsi02mi8),
    .AWADDRsi2mi8  (AWADDRsi02mi8),
    .AWLENsi2mi8   (AWLENsi02mi8),
    .AWSIZEsi2mi8  (AWSIZEsi02mi8),
    .AWBURSTsi2mi8 (AWBURSTsi02mi8),
    .AWLOCKsi2mi8  (AWLOCKsi02mi8),
    .AWCACHEsi2mi8 (AWCACHEsi02mi8),
    .AWPROTsi2mi8  (AWPROTsi02mi8),

    //Write data channel
    .WIDsi2mi8     (WIDsi02mi8),
    .WDATAsi2mi8   (WDATAsi02mi8),
    .WSTRBsi2mi8   (WSTRBsi02mi8),

    //Write response channel

    //Slave Number 8
    .BIDmi82si     (BIDmi82si0[MASTERID0_WID-1:0]),
    .BRESPmi82si   (BRESPmi82si0),

    .AWVALIDsi2mi (AWVALIDsi02mi),
    .AWREADYmi2si (AWREADYmi2si0),

    .WLASTsi2mi   (WLASTsi02mi),
    .WVALIDsi2mi  (WVALIDsi02mi),
    .WREADYmi2si  (WREADYmi2si0),

    .BVALIDmi2si    (BVALIDmi2si0),
    .BREADYsi2mi    (BREADYsi02mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 2    
//________________________________________________________________________

DMAC_RS_WriteChannelsi
DMAC_RS_WriteChannelsi(
    
    .SelMAP1(SelMAP1),

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm22si2),
    .AWADDRm2si  (AWADDRm22si2),
    .AWLENm2si   (AWLENm22si2),
    .AWSIZEm2si  (AWSIZEm22si2),
    .AWBURSTm2si (AWBURSTm22si2),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm2si (AWVALIDm22si2),
    .AWREADYsi2m (AWREADYsi22m2),

    //Write data channel
    .WIDm2si     (WIDm22si2),
    .WDATAm2si   (WDATAm22si2),
    .WSTRBm2si   (WSTRBm22si2),
    .WLASTm2si   (WLASTm22si2),
    .WVALIDm2si  (WVALIDm22si2),
    .WREADYsi2m  (WREADYsi22m2),

    //Write response channel
    .BIDsi2m     (BIDsi22m2),
    .BRESPsi2m   (BRESPsi22m2),
    .BVALIDsi2m  (BVALIDsi22m2),
    .BREADYm2si  (BREADYm22si2),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi22mi0),
    .AWADDRsi2mi0  (AWADDRsi22mi0),
    .AWLENsi2mi0   (AWLENsi22mi0),
    .AWSIZEsi2mi0  (AWSIZEsi22mi0),
    .AWBURSTsi2mi0 (AWBURSTsi22mi0),
    .AWLOCKsi2mi0  (AWLOCKsi22mi0),
    .AWCACHEsi2mi0 (AWCACHEsi22mi0),
    .AWPROTsi2mi0  (AWPROTsi22mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi22mi0),
    .WDATAsi2mi0   (WDATAsi22mi0),
    .WSTRBsi2mi0   (WSTRBsi22mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si2[MASTERID2_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi22mi1),
    .AWADDRsi2mi1  (AWADDRsi22mi1),
    .AWLENsi2mi1   (AWLENsi22mi1),
    .AWSIZEsi2mi1  (AWSIZEsi22mi1),
    .AWBURSTsi2mi1 (AWBURSTsi22mi1),
    .AWLOCKsi2mi1  (AWLOCKsi22mi1),
    .AWCACHEsi2mi1 (AWCACHEsi22mi1),
    .AWPROTsi2mi1  (AWPROTsi22mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi22mi1),
    .WDATAsi2mi1   (WDATAsi22mi1),
    .WSTRBsi2mi1   (WSTRBsi22mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si2[MASTERID2_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi22mi2),
    .AWADDRsi2mi2  (AWADDRsi22mi2),
    .AWLENsi2mi2   (AWLENsi22mi2),
    .AWSIZEsi2mi2  (AWSIZEsi22mi2),
    .AWBURSTsi2mi2 (AWBURSTsi22mi2),
    .AWLOCKsi2mi2  (AWLOCKsi22mi2),
    .AWCACHEsi2mi2 (AWCACHEsi22mi2),
    .AWPROTsi2mi2  (AWPROTsi22mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi22mi2),
    .WDATAsi2mi2   (WDATAsi22mi2),
    .WSTRBsi2mi2   (WSTRBsi22mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si2[MASTERID2_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi22mi3),
    .AWADDRsi2mi3  (AWADDRsi22mi3),
    .AWLENsi2mi3   (AWLENsi22mi3),
    .AWSIZEsi2mi3  (AWSIZEsi22mi3),
    .AWBURSTsi2mi3 (AWBURSTsi22mi3),
    .AWLOCKsi2mi3  (AWLOCKsi22mi3),
    .AWCACHEsi2mi3 (AWCACHEsi22mi3),
    .AWPROTsi2mi3  (AWPROTsi22mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi22mi3),
    .WDATAsi2mi3   (WDATAsi22mi3),
    .WSTRBsi2mi3   (WSTRBsi22mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si2[MASTERID2_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi22mi4),
    .AWADDRsi2mi4  (AWADDRsi22mi4),
    .AWLENsi2mi4   (AWLENsi22mi4),
    .AWSIZEsi2mi4  (AWSIZEsi22mi4),
    .AWBURSTsi2mi4 (AWBURSTsi22mi4),
    .AWLOCKsi2mi4  (AWLOCKsi22mi4),
    .AWCACHEsi2mi4 (AWCACHEsi22mi4),
    .AWPROTsi2mi4  (AWPROTsi22mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi22mi4),
    .WDATAsi2mi4   (WDATAsi22mi4),
    .WSTRBsi2mi4   (WSTRBsi22mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si2[MASTERID2_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi22mi5),
    .AWADDRsi2mi5  (AWADDRsi22mi5),
    .AWLENsi2mi5   (AWLENsi22mi5),
    .AWSIZEsi2mi5  (AWSIZEsi22mi5),
    .AWBURSTsi2mi5 (AWBURSTsi22mi5),
    .AWLOCKsi2mi5  (AWLOCKsi22mi5),
    .AWCACHEsi2mi5 (AWCACHEsi22mi5),
    .AWPROTsi2mi5  (AWPROTsi22mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi22mi5),
    .WDATAsi2mi5   (WDATAsi22mi5),
    .WSTRBsi2mi5   (WSTRBsi22mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si2[MASTERID2_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi6    (AWIDsi22mi6),
    .AWADDRsi2mi6  (AWADDRsi22mi6),
    .AWLENsi2mi6   (AWLENsi22mi6),
    .AWSIZEsi2mi6  (AWSIZEsi22mi6),
    .AWBURSTsi2mi6 (AWBURSTsi22mi6),
    .AWLOCKsi2mi6  (AWLOCKsi22mi6),
    .AWCACHEsi2mi6 (AWCACHEsi22mi6),
    .AWPROTsi2mi6  (AWPROTsi22mi6),

    //Write data channel
    .WIDsi2mi6     (WIDsi22mi6),
    .WDATAsi2mi6   (WDATAsi22mi6),
    .WSTRBsi2mi6   (WSTRBsi22mi6),

    //Write response channel

    //Slave Number 6
    .BIDmi62si     (BIDmi62si2[MASTERID2_WID-1:0]),
    .BRESPmi62si   (BRESPmi62si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi7    (AWIDsi22mi7),
    .AWADDRsi2mi7  (AWADDRsi22mi7),
    .AWLENsi2mi7   (AWLENsi22mi7),
    .AWSIZEsi2mi7  (AWSIZEsi22mi7),
    .AWBURSTsi2mi7 (AWBURSTsi22mi7),
    .AWLOCKsi2mi7  (AWLOCKsi22mi7),
    .AWCACHEsi2mi7 (AWCACHEsi22mi7),
    .AWPROTsi2mi7  (AWPROTsi22mi7),

    //Write data channel
    .WIDsi2mi7     (WIDsi22mi7),
    .WDATAsi2mi7   (WDATAsi22mi7),
    .WSTRBsi2mi7   (WSTRBsi22mi7),

    //Write response channel

    //Slave Number 7
    .BIDmi72si     (BIDmi72si2[MASTERID2_WID-1:0]),
    .BRESPmi72si   (BRESPmi72si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi8    (AWIDsi22mi8),
    .AWADDRsi2mi8  (AWADDRsi22mi8),
    .AWLENsi2mi8   (AWLENsi22mi8),
    .AWSIZEsi2mi8  (AWSIZEsi22mi8),
    .AWBURSTsi2mi8 (AWBURSTsi22mi8),
    .AWLOCKsi2mi8  (AWLOCKsi22mi8),
    .AWCACHEsi2mi8 (AWCACHEsi22mi8),
    .AWPROTsi2mi8  (AWPROTsi22mi8),

    //Write data channel
    .WIDsi2mi8     (WIDsi22mi8),
    .WDATAsi2mi8   (WDATAsi22mi8),
    .WSTRBsi2mi8   (WSTRBsi22mi8),

    //Write response channel

    //Slave Number 8
    .BIDmi82si     (BIDmi82si2[MASTERID2_WID-1:0]),
    .BRESPmi82si   (BRESPmi82si2),

    .AWVALIDsi2mi (AWVALIDsi22mi),
    .AWREADYmi2si (AWREADYmi2si2),

    .WLASTsi2mi   (WLASTsi22mi),
    .WVALIDsi2mi  (WVALIDsi22mi),
    .WREADYmi2si  (WREADYmi2si2),

    .BVALIDmi2si    (BVALIDmi2si2),
    .BREADYsi2mi    (BREADYsi22mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 3    
//________________________________________________________________________

MAC_RS_WriteChannelsi
MAC_RS_WriteChannelsi(
    
    .SelMAP1(SelMAP1),

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disable_id_port
    .AWADDRm2si  (AWADDRm32si3),
    .AWLENm2si   (AWLENm32si3),
    .AWSIZEm2si  (AWSIZEm32si3),
    .AWBURSTm2si (AWBURSTm32si3),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm2si (AWVALIDm32si3),
    .AWREADYsi2m (AWREADYsi32m3),

    //Write data channel
//Disable_id_port
    .WDATAm2si   (WDATAm32si3),
    .WSTRBm2si   (WSTRBm32si3),
    .WLASTm2si   (WLASTm32si3),
    .WVALIDm2si  (WVALIDm32si3),
    .WREADYsi2m  (WREADYsi32m3),

    //Write response channel
//Disable_id_port
    .BRESPsi2m   (BRESPsi32m3),
    .BVALIDsi2m  (BVALIDsi32m3),
    .BREADYm2si  (BREADYm32si3),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi32mi3),
    .AWADDRsi2mi3  (AWADDRsi32mi3),
    .AWLENsi2mi3   (AWLENsi32mi3),
    .AWSIZEsi2mi3  (AWSIZEsi32mi3),
    .AWBURSTsi2mi3 (AWBURSTsi32mi3),
    .AWLOCKsi2mi3  (AWLOCKsi32mi3),
    .AWCACHEsi2mi3 (AWCACHEsi32mi3),
    .AWPROTsi2mi3  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi32mi3),
    .WDATAsi2mi3   (WDATAsi32mi3),
    .WSTRBsi2mi3   (WSTRBsi32mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si3[MASTERID3_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi6    (AWIDsi32mi6),
    .AWADDRsi2mi6  (AWADDRsi32mi6),
    .AWLENsi2mi6   (AWLENsi32mi6),
    .AWSIZEsi2mi6  (AWSIZEsi32mi6),
    .AWBURSTsi2mi6 (AWBURSTsi32mi6),
    .AWLOCKsi2mi6  (AWLOCKsi32mi6),
    .AWCACHEsi2mi6 (AWCACHEsi32mi6),
    .AWPROTsi2mi6  (AWPROTsi32mi6),

    //Write data channel
    .WIDsi2mi6     (WIDsi32mi6),
    .WDATAsi2mi6   (WDATAsi32mi6),
    .WSTRBsi2mi6   (WSTRBsi32mi6),

    //Write response channel

    //Slave Number 6
    .BIDmi62si     (BIDmi62si3[MASTERID3_WID-1:0]),
    .BRESPmi62si   (BRESPmi62si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi7    (AWIDsi32mi7),
    .AWADDRsi2mi7  (AWADDRsi32mi7),
    .AWLENsi2mi7   (AWLENsi32mi7),
    .AWSIZEsi2mi7  (AWSIZEsi32mi7),
    .AWBURSTsi2mi7 (AWBURSTsi32mi7),
    .AWLOCKsi2mi7  (AWLOCKsi32mi7),
    .AWCACHEsi2mi7 (AWCACHEsi32mi7),
    .AWPROTsi2mi7  (AWPROTsi32mi7),

    //Write data channel
    .WIDsi2mi7     (WIDsi32mi7),
    .WDATAsi2mi7   (WDATAsi32mi7),
    .WSTRBsi2mi7   (WSTRBsi32mi7),

    //Write response channel

    //Slave Number 7
    .BIDmi72si     (BIDmi72si3[MASTERID3_WID-1:0]),
    .BRESPmi72si   (BRESPmi72si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi8    (AWIDsi32mi8),
    .AWADDRsi2mi8  (AWADDRsi32mi8),
    .AWLENsi2mi8   (AWLENsi32mi8),
    .AWSIZEsi2mi8  (AWSIZEsi32mi8),
    .AWBURSTsi2mi8 (AWBURSTsi32mi8),
    .AWLOCKsi2mi8  (AWLOCKsi32mi8),
    .AWCACHEsi2mi8 (AWCACHEsi32mi8),
    .AWPROTsi2mi8  (AWPROTsi32mi8),

    //Write data channel
    .WIDsi2mi8     (WIDsi32mi8),
    .WDATAsi2mi8   (WDATAsi32mi8),
    .WSTRBsi2mi8   (WSTRBsi32mi8),

    //Write response channel

    //Slave Number 8
    .BIDmi82si     (BIDmi82si3[MASTERID3_WID-1:0]),
    .BRESPmi82si   (BRESPmi82si3),

    .AWVALIDsi2mi (AWVALIDsi32mi),
    .AWREADYmi2si (AWREADYmi2si3),

    .WLASTsi2mi   (WLASTsi32mi),
    .WVALIDsi2mi  (WVALIDsi32mi),
    .WREADYmi2si  (WREADYmi2si3),

    .BVALIDmi2si    (BVALIDmi2si3),
    .BREADYsi2mi    (BREADYsi32mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 4    
//________________________________________________________________________

PCI_RS_WriteChannelsi
PCI_RS_WriteChannelsi(
    
    .SelMAP1(SelMAP1),

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disable_id_port
    .AWADDRm2si  (AWADDRm42si4),
    .AWLENm2si   (AWLENm42si4),
    .AWSIZEm2si  (AWSIZEm42si4),
    .AWBURSTm2si (AWBURSTm42si4),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm2si (AWVALIDm42si4),
    .AWREADYsi2m (AWREADYsi42m4),

    //Write data channel
//Disable_id_port
    .WDATAm2si   (WDATAm42si4),
    .WSTRBm2si   (WSTRBm42si4),
    .WLASTm2si   (WLASTm42si4),
    .WVALIDm2si  (WVALIDm42si4),
    .WREADYsi2m  (WREADYsi42m4),

    //Write response channel
//Disable_id_port
    .BRESPsi2m   (BRESPsi42m4),
    .BVALIDsi2m  (BVALIDsi42m4),
    .BREADYm2si  (BREADYm42si4),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi42mi3),
    .AWADDRsi2mi3  (AWADDRsi42mi3),
    .AWLENsi2mi3   (AWLENsi42mi3),
    .AWSIZEsi2mi3  (AWSIZEsi42mi3),
    .AWBURSTsi2mi3 (AWBURSTsi42mi3),
    .AWLOCKsi2mi3  (AWLOCKsi42mi3),
    .AWCACHEsi2mi3 (AWCACHEsi42mi3),
    .AWPROTsi2mi3  (AWPROTsi42mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi42mi3),
    .WDATAsi2mi3   (WDATAsi42mi3),
    .WSTRBsi2mi3   (WSTRBsi42mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si4[MASTERID4_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi6    (AWIDsi42mi6),
    .AWADDRsi2mi6  (AWADDRsi42mi6),
    .AWLENsi2mi6   (AWLENsi42mi6),
    .AWSIZEsi2mi6  (AWSIZEsi42mi6),
    .AWBURSTsi2mi6 (AWBURSTsi42mi6),
    .AWLOCKsi2mi6  (AWLOCKsi42mi6),
    .AWCACHEsi2mi6 (AWCACHEsi42mi6),
    .AWPROTsi2mi6  (AWPROTsi42mi6),

    //Write data channel
    .WIDsi2mi6     (WIDsi42mi6),
    .WDATAsi2mi6   (WDATAsi42mi6),
    .WSTRBsi2mi6   (WSTRBsi42mi6),

    //Write response channel

    //Slave Number 6
    .BIDmi62si     (BIDmi62si4[MASTERID4_WID-1:0]),
    .BRESPmi62si   (BRESPmi62si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi7    (AWIDsi42mi7),
    .AWADDRsi2mi7  (AWADDRsi42mi7),
    .AWLENsi2mi7   (AWLENsi42mi7),
    .AWSIZEsi2mi7  (AWSIZEsi42mi7),
    .AWBURSTsi2mi7 (AWBURSTsi42mi7),
    .AWLOCKsi2mi7  (AWLOCKsi42mi7),
    .AWCACHEsi2mi7 (AWCACHEsi42mi7),
    .AWPROTsi2mi7  (AWPROTsi42mi7),

    //Write data channel
    .WIDsi2mi7     (WIDsi42mi7),
    .WDATAsi2mi7   (WDATAsi42mi7),
    .WSTRBsi2mi7   (WSTRBsi42mi7),

    //Write response channel

    //Slave Number 7
    .BIDmi72si     (BIDmi72si4[MASTERID4_WID-1:0]),
    .BRESPmi72si   (BRESPmi72si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi8    (AWIDsi42mi8),
    .AWADDRsi2mi8  (AWADDRsi42mi8),
    .AWLENsi2mi8   (AWLENsi42mi8),
    .AWSIZEsi2mi8  (AWSIZEsi42mi8),
    .AWBURSTsi2mi8 (AWBURSTsi42mi8),
    .AWLOCKsi2mi8  (AWLOCKsi42mi8),
    .AWCACHEsi2mi8 (AWCACHEsi42mi8),
    .AWPROTsi2mi8  (AWPROTsi42mi8),

    //Write data channel
    .WIDsi2mi8     (WIDsi42mi8),
    .WDATAsi2mi8   (WDATAsi42mi8),
    .WSTRBsi2mi8   (WSTRBsi42mi8),

    //Write response channel

    //Slave Number 8
    .BIDmi82si     (BIDmi82si4[MASTERID4_WID-1:0]),
    .BRESPmi82si   (BRESPmi82si4),

    .AWVALIDsi2mi (AWVALIDsi42mi),
    .AWREADYmi2si (AWREADYmi2si4),

    .WLASTsi2mi   (WLASTsi42mi),
    .WVALIDsi2mi  (WVALIDsi42mi),
    .WREADYmi2si  (WREADYmi2si4),

    .BVALIDmi2si    (BVALIDmi2si4),
    .BREADYsi2mi    (BREADYsi42mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Slave module 0    
//___________________________________________________________________________

AHB0_RS_WriteChannelmi
AHB0_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi02s0),
    .AWADDRmi2s  (AWADDRmi02s0),
    .AWLENmi2s   (AWLENmi02s0),
    .AWSIZEmi2s  (AWSIZEmi02s0),
    .AWBURSTmi2s (AWBURSTmi02s0),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi02s0),
    .AWREADYs2mi (AWREADYs02mi0),

    //Write data channel
    .WIDmi2s     (WIDmi02s0),
    .WDATAmi2s   (WDATAmi02s0),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi02s0),
    .WVALIDmi2s  (WVALIDmi02s0),
    .WREADYs2mi  (WREADYs02mi0),

    //Write response channel
    .BIDs2mi     (BIDs02mi0),
    .BRESPs2mi   (BRESPs02mi0),
    .BVALIDs2mi  (BVALIDs02mi0),
    .BREADYmi2s  (BREADYmi02s0),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi0),
    .AWLENsi02mi   (AWLENsi02mi0),
    .AWSIZEsi02mi  (AWSIZEsi02mi0),
    .AWBURSTsi02mi (AWBURSTsi02mi0),
    .AWLOCKsi02mi  (AWLOCKsi02mi0),
    .AWCACHEsi02mi (AWCACHEsi02mi0),
    .AWPROTsi02mi  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi0),   
    .WSTRBsi02mi (WSTRBsi02mi0),   

    //Write response channel
    .BIDmi2si0     (BIDmi02si0),
    .BRESPmi2si0   (BRESPmi02si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi0),
    .AWLENsi12mi   (AWLENsi22mi0),
    .AWSIZEsi12mi  (AWSIZEsi22mi0),
    .AWBURSTsi12mi (AWBURSTsi22mi0),
    .AWLOCKsi12mi  (AWLOCKsi22mi0),
    .AWCACHEsi12mi (AWCACHEsi22mi0),
    .AWPROTsi12mi  (AWPROTsi22mi0),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi0),   
    .WSTRBsi12mi (WSTRBsi22mi0),   

    //Write response channel
    .BIDmi2si1     (BIDmi02si2),
    .BRESPmi2si1   (BRESPmi02si2),

    .BVALIDmi2si  (BVALIDmi02si),
    .BREADYsi2mi   (BREADYsi2mi0),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi0),
    .AWREADYmi2si  (AWREADYmi02si),
    .WLASTsi2mi    (WLASTsi2mi0),
    .WVALIDsi2mi   (WVALIDsi2mi0),
    .WREADYmi2si   (WREADYmi02si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi0),
    .UnLock2Wrmi(UnLock2wrmi0),

    .Lock2Rdmi(Lock2rdmi0),
    .UnLock2Rdmi(UnLock2rdmi0),

    .ARVALID(ARVALIDmi02s0),
    .LockPort(LockPort2wrmi0),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi02Rdmi0),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi02Wrmi0),
    .CtlDataWrite2Lock(CtlDataWrite2Lock0)
    ////////////////////////////////////////

    );

//Slave module 1    
//___________________________________________________________________________

AHB1_RS_WriteChannelmi
AHB1_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi12s1),
    .AWADDRmi2s  (AWADDRmi12s1),
    .AWLENmi2s   (AWLENmi12s1),
    .AWSIZEmi2s  (AWSIZEmi12s1),
    .AWBURSTmi2s (AWBURSTmi12s1),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi12s1),
    .AWREADYs2mi (AWREADYs12mi1),

    //Write data channel
    .WIDmi2s     (WIDmi12s1),
    .WDATAmi2s   (WDATAmi12s1),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi12s1),
    .WVALIDmi2s  (WVALIDmi12s1),
    .WREADYs2mi  (WREADYs12mi1),

    //Write response channel
    .BIDs2mi     (BIDs12mi1),
    .BRESPs2mi   (BRESPs12mi1),
    .BVALIDs2mi  (BVALIDs12mi1),
    .BREADYmi2s  (BREADYmi12s1),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi1),
    .AWLENsi02mi   (AWLENsi02mi1),
    .AWSIZEsi02mi  (AWSIZEsi02mi1),
    .AWBURSTsi02mi (AWBURSTsi02mi1),
    .AWLOCKsi02mi  (AWLOCKsi02mi1),
    .AWCACHEsi02mi (AWCACHEsi02mi1),
    .AWPROTsi02mi  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi1),   
    .WSTRBsi02mi (WSTRBsi02mi1),   

    //Write response channel
    .BIDmi2si0     (BIDmi12si0),
    .BRESPmi2si0   (BRESPmi12si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi1),
    .AWLENsi12mi   (AWLENsi22mi1),
    .AWSIZEsi12mi  (AWSIZEsi22mi1),
    .AWBURSTsi12mi (AWBURSTsi22mi1),
    .AWLOCKsi12mi  (AWLOCKsi22mi1),
    .AWCACHEsi12mi (AWCACHEsi22mi1),
    .AWPROTsi12mi  (AWPROTsi22mi1),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi1),   
    .WSTRBsi12mi (WSTRBsi22mi1),   

    //Write response channel
    .BIDmi2si1     (BIDmi12si2),
    .BRESPmi2si1   (BRESPmi12si2),

    .BVALIDmi2si  (BVALIDmi12si),
    .BREADYsi2mi   (BREADYsi2mi1),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi1),
    .AWREADYmi2si  (AWREADYmi12si),
    .WLASTsi2mi    (WLASTsi2mi1),
    .WVALIDsi2mi   (WVALIDsi2mi1),
    .WREADYmi2si   (WREADYmi12si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi1),
    .UnLock2Wrmi(UnLock2wrmi1),

    .Lock2Rdmi(Lock2rdmi1),
    .UnLock2Rdmi(UnLock2rdmi1),

    .ARVALID(ARVALIDmi12s1),
    .LockPort(LockPort2wrmi1),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi12Rdmi1),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi12Wrmi1),
    .CtlDataWrite2Lock(CtlDataWrite2Lock1)
    ////////////////////////////////////////

    );

//Slave module 2    
//___________________________________________________________________________

AHB2_RS_WriteChannelmi
AHB2_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi22s2),
    .AWADDRmi2s  (AWADDRmi22s2),
    .AWLENmi2s   (AWLENmi22s2),
    .AWSIZEmi2s  (AWSIZEmi22s2),
    .AWBURSTmi2s (AWBURSTmi22s2),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi22s2),
    .AWREADYs2mi (AWREADYs22mi2),

    //Write data channel
    .WIDmi2s     (WIDmi22s2),
    .WDATAmi2s   (WDATAmi22s2),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi22s2),
    .WVALIDmi2s  (WVALIDmi22s2),
    .WREADYs2mi  (WREADYs22mi2),

    //Write response channel
    .BIDs2mi     (BIDs22mi2),
    .BRESPs2mi   (BRESPs22mi2),
    .BVALIDs2mi  (BVALIDs22mi2),
    .BREADYmi2s  (BREADYmi22s2),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi2),
    .AWLENsi02mi   (AWLENsi02mi2),
    .AWSIZEsi02mi  (AWSIZEsi02mi2),
    .AWBURSTsi02mi (AWBURSTsi02mi2),
    .AWLOCKsi02mi  (AWLOCKsi02mi2),
    .AWCACHEsi02mi (AWCACHEsi02mi2),
    .AWPROTsi02mi  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi2),   
    .WSTRBsi02mi (WSTRBsi02mi2),   

    //Write response channel
    .BIDmi2si0     (BIDmi22si0),
    .BRESPmi2si0   (BRESPmi22si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi2),
    .AWLENsi12mi   (AWLENsi22mi2),
    .AWSIZEsi12mi  (AWSIZEsi22mi2),
    .AWBURSTsi12mi (AWBURSTsi22mi2),
    .AWLOCKsi12mi  (AWLOCKsi22mi2),
    .AWCACHEsi12mi (AWCACHEsi22mi2),
    .AWPROTsi12mi  (AWPROTsi22mi2),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi2),   
    .WSTRBsi12mi (WSTRBsi22mi2),   

    //Write response channel
    .BIDmi2si1     (BIDmi22si2),
    .BRESPmi2si1   (BRESPmi22si2),

    .BVALIDmi2si  (BVALIDmi22si),
    .BREADYsi2mi   (BREADYsi2mi2),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi2),
    .AWREADYmi2si  (AWREADYmi22si),
    .WLASTsi2mi    (WLASTsi2mi2),
    .WVALIDsi2mi   (WVALIDsi2mi2),
    .WREADYmi2si   (WREADYmi22si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi2),
    .UnLock2Wrmi(UnLock2wrmi2),

    .Lock2Rdmi(Lock2rdmi2),
    .UnLock2Rdmi(UnLock2rdmi2),

    .ARVALID(ARVALIDmi22s2),
    .LockPort(LockPort2wrmi2),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi22Rdmi2),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi22Wrmi2),
    .CtlDataWrite2Lock(CtlDataWrite2Lock2)
    ////////////////////////////////////////

    );

//Slave module 3    
//___________________________________________________________________________

DDR_RS_WriteChannelmi
DDR_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi32s3),
    .AWADDRmi2s  (AWADDRmi32s3),
    .AWLENmi2s   (AWLENmi32s3),
    .AWSIZEmi2s  (AWSIZEmi32s3),
    .AWBURSTmi2s (AWBURSTmi32s3),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi32s3),
    .AWREADYs2mi (AWREADYs32mi3),

    //Write data channel
    .WIDmi2s     (WIDmi32s3),
    .WDATAmi2s   (WDATAmi32s3),
    .WSTRBmi2s   (WSTRBmi32s3),
    .WLASTmi2s   (WLASTmi32s3),
    .WVALIDmi2s  (WVALIDmi32s3),
    .WREADYs2mi  (WREADYs32mi3),

    //Write response channel
    .BIDs2mi     (BIDs32mi3),
    .BRESPs2mi   (BRESPs32mi3),
    .BVALIDs2mi  (BVALIDs32mi3),
    .BREADYmi2s  (BREADYmi32s3),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi3),
    .AWLENsi02mi   (AWLENsi02mi3),
    .AWSIZEsi02mi  (AWSIZEsi02mi3),
    .AWBURSTsi02mi (AWBURSTsi02mi3),
    .AWLOCKsi02mi  (AWLOCKsi02mi3),
    .AWCACHEsi02mi (AWCACHEsi02mi3),
    .AWPROTsi02mi  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi3),   
    .WSTRBsi02mi (WSTRBsi02mi3),   

    //Write response channel
    .BIDmi2si0     (BIDmi32si0),
    .BRESPmi2si0   (BRESPmi32si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi3),
    .AWLENsi12mi   (AWLENsi22mi3),
    .AWSIZEsi12mi  (AWSIZEsi22mi3),
    .AWBURSTsi12mi (AWBURSTsi22mi3),
    .AWLOCKsi12mi  (AWLOCKsi22mi3),
    .AWCACHEsi12mi (AWCACHEsi22mi3),
    .AWPROTsi12mi  (AWPROTsi22mi3),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi3),   
    .WSTRBsi12mi (WSTRBsi22mi3),   

    //Write response channel
    .BIDmi2si1     (BIDmi32si2),
    .BRESPmi2si1   (BRESPmi32si2),
    //Master Number 3
    //Write address channel
    .AWIDsi22mi    (wAWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi32mi3),
    .AWLENsi22mi   (AWLENsi32mi3),
    .AWSIZEsi22mi  (AWSIZEsi32mi3),
    .AWBURSTsi22mi (AWBURSTsi32mi3),
    .AWLOCKsi22mi  (AWLOCKsi32mi3),
    .AWCACHEsi22mi (AWCACHEsi32mi3),
    .AWPROTsi22mi  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi22mi   (wWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi22mi (WDATAsi32mi3),   
    .WSTRBsi22mi (WSTRBsi32mi3),   

    //Write response channel
    .BIDmi2si2     (BIDmi32si3),
    .BRESPmi2si2   (BRESPmi32si3),
    //Master Number 4
    //Write address channel
    .AWIDsi32mi    (wAWIDsi42mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi42mi3),
    .AWLENsi32mi   (AWLENsi42mi3),
    .AWSIZEsi32mi  (AWSIZEsi42mi3),
    .AWBURSTsi32mi (AWBURSTsi42mi3),
    .AWLOCKsi32mi  (AWLOCKsi42mi3),
    .AWCACHEsi32mi (AWCACHEsi42mi3),
    .AWPROTsi32mi  (AWPROTsi42mi3),

    //Write data channel
    .WIDsi32mi   (wWIDsi42mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi32mi (WDATAsi42mi3),   
    .WSTRBsi32mi (WSTRBsi42mi3),   

    //Write response channel
    .BIDmi2si3     (BIDmi32si4),
    .BRESPmi2si3   (BRESPmi32si4),

    .BVALIDmi2si  (BVALIDmi32si),
    .BREADYsi2mi   (BREADYsi2mi3),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi3),
    .AWREADYmi2si  (AWREADYmi32si),
    .WLASTsi2mi    (WLASTsi2mi3),
    .WVALIDsi2mi   (WVALIDsi2mi3),
    .WREADYmi2si   (WREADYmi32si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi3),
    .UnLock2Wrmi(UnLock2wrmi3),

    .Lock2Rdmi(Lock2rdmi3),
    .UnLock2Rdmi(UnLock2rdmi3),

    .ARVALID(ARVALIDmi32s3),
    .LockPort(LockPort2wrmi3),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi32Rdmi3),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi32Wrmi3),
    .CtlDataWrite2Lock(CtlDataWrite2Lock3)
    ////////////////////////////////////////

    );

//Slave module 4    
//___________________________________________________________________________

APB0_RS_WriteChannelmi
APB0_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi42s4),
    .AWADDRmi2s  (AWADDRmi42s4),
    .AWLENmi2s   (AWLENmi42s4),
    .AWSIZEmi2s  (AWSIZEmi42s4),
    .AWBURSTmi2s (AWBURSTmi42s4),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi42s4),
    .AWREADYs2mi (AWREADYs42mi4),

    //Write data channel
    .WIDmi2s     (WIDmi42s4),
    .WDATAmi2s   (WDATAmi42s4),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi42s4),
    .WVALIDmi2s  (WVALIDmi42s4),
    .WREADYs2mi  (WREADYs42mi4),

    //Write response channel
    .BIDs2mi     (BIDs42mi4),
    .BRESPs2mi   (BRESPs42mi4),
    .BVALIDs2mi  (BVALIDs42mi4),
    .BREADYmi2s  (BREADYmi42s4),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi4),
    .AWLENsi02mi   (AWLENsi02mi4),
    .AWSIZEsi02mi  (AWSIZEsi02mi4),
    .AWBURSTsi02mi (AWBURSTsi02mi4),
    .AWLOCKsi02mi  (AWLOCKsi02mi4),
    .AWCACHEsi02mi (AWCACHEsi02mi4),
    .AWPROTsi02mi  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi4),   
    .WSTRBsi02mi (WSTRBsi02mi4),   

    //Write response channel
    .BIDmi2si0     (BIDmi42si0),
    .BRESPmi2si0   (BRESPmi42si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi4),
    .AWLENsi12mi   (AWLENsi22mi4),
    .AWSIZEsi12mi  (AWSIZEsi22mi4),
    .AWBURSTsi12mi (AWBURSTsi22mi4),
    .AWLOCKsi12mi  (AWLOCKsi22mi4),
    .AWCACHEsi12mi (AWCACHEsi22mi4),
    .AWPROTsi12mi  (AWPROTsi22mi4),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi4),   
    .WSTRBsi12mi (WSTRBsi22mi4),   

    //Write response channel
    .BIDmi2si1     (BIDmi42si2),
    .BRESPmi2si1   (BRESPmi42si2),

    .BVALIDmi2si  (BVALIDmi42si),
    .BREADYsi2mi   (BREADYsi2mi4),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi4),
    .AWREADYmi2si  (AWREADYmi42si),
    .WLASTsi2mi    (WLASTsi2mi4),
    .WVALIDsi2mi   (WVALIDsi2mi4),
    .WREADYmi2si   (WREADYmi42si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi4),
    .UnLock2Wrmi(UnLock2wrmi4),

    .Lock2Rdmi(Lock2rdmi4),
    .UnLock2Rdmi(UnLock2rdmi4),

    .ARVALID(ARVALIDmi42s4),
    .LockPort(LockPort2wrmi4),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi42Rdmi4),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi42Wrmi4),
    .CtlDataWrite2Lock(CtlDataWrite2Lock4)
    ////////////////////////////////////////

    );

//Slave module 5    
//___________________________________________________________________________

APB1_RS_WriteChannelmi
APB1_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi52s5),
    .AWADDRmi2s  (AWADDRmi52s5),
    .AWLENmi2s   (AWLENmi52s5),
    .AWSIZEmi2s  (AWSIZEmi52s5),
    .AWBURSTmi2s (AWBURSTmi52s5),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi52s5),
    .AWREADYs2mi (AWREADYs52mi5),

    //Write data channel
    .WIDmi2s     (WIDmi52s5),
    .WDATAmi2s   (WDATAmi52s5),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi52s5),
    .WVALIDmi2s  (WVALIDmi52s5),
    .WREADYs2mi  (WREADYs52mi5),

    //Write response channel
    .BIDs2mi     (BIDs52mi5),
    .BRESPs2mi   (BRESPs52mi5),
    .BVALIDs2mi  (BVALIDs52mi5),
    .BREADYmi2s  (BREADYmi52s5),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi5),
    .AWLENsi02mi   (AWLENsi02mi5),
    .AWSIZEsi02mi  (AWSIZEsi02mi5),
    .AWBURSTsi02mi (AWBURSTsi02mi5),
    .AWLOCKsi02mi  (AWLOCKsi02mi5),
    .AWCACHEsi02mi (AWCACHEsi02mi5),
    .AWPROTsi02mi  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi5),   
    .WSTRBsi02mi (WSTRBsi02mi5),   

    //Write response channel
    .BIDmi2si0     (BIDmi52si0),
    .BRESPmi2si0   (BRESPmi52si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi5),
    .AWLENsi12mi   (AWLENsi22mi5),
    .AWSIZEsi12mi  (AWSIZEsi22mi5),
    .AWBURSTsi12mi (AWBURSTsi22mi5),
    .AWLOCKsi12mi  (AWLOCKsi22mi5),
    .AWCACHEsi12mi (AWCACHEsi22mi5),
    .AWPROTsi12mi  (AWPROTsi22mi5),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi5),   
    .WSTRBsi12mi (WSTRBsi22mi5),   

    //Write response channel
    .BIDmi2si1     (BIDmi52si2),
    .BRESPmi2si1   (BRESPmi52si2),

    .BVALIDmi2si  (BVALIDmi52si),
    .BREADYsi2mi   (BREADYsi2mi5),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi5),
    .AWREADYmi2si  (AWREADYmi52si),
    .WLASTsi2mi    (WLASTsi2mi5),
    .WVALIDsi2mi   (WVALIDsi2mi5),
    .WREADYmi2si   (WREADYmi52si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi5),
    .UnLock2Wrmi(UnLock2wrmi5),

    .Lock2Rdmi(Lock2rdmi5),
    .UnLock2Rdmi(UnLock2rdmi5),

    .ARVALID(ARVALIDmi52s5),
    .LockPort(LockPort2wrmi5),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi52Rdmi5),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi52Wrmi5),
    .CtlDataWrite2Lock(CtlDataWrite2Lock5)
    ////////////////////////////////////////

    );

//Slave module 6    
//___________________________________________________________________________

SMC_RS_WriteChannelmi
SMC_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi62s6),
    .AWADDRmi2s  (AWADDRmi62s6),
    .AWLENmi2s   (AWLENmi62s6),
    .AWSIZEmi2s  (AWSIZEmi62s6),
    .AWBURSTmi2s (AWBURSTmi62s6),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi62s6),
    .AWREADYs2mi (AWREADYs62mi6),

    //Write data channel
    .WIDmi2s     (WIDmi62s6),
    .WDATAmi2s   (WDATAmi62s6),
    .WSTRBmi2s   (WSTRBmi62s6),
    .WLASTmi2s   (WLASTmi62s6),
    .WVALIDmi2s  (WVALIDmi62s6),
    .WREADYs2mi  (WREADYs62mi6),

    //Write response channel
    .BIDs2mi     (BIDs62mi6),
    .BRESPs2mi   (BRESPs62mi6),
    .BVALIDs2mi  (BVALIDs62mi6),
    .BREADYmi2s  (BREADYmi62s6),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi6[SLAVE_MASTERID6_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi6),
    .AWLENsi02mi   (AWLENsi02mi6),
    .AWSIZEsi02mi  (AWSIZEsi02mi6),
    .AWBURSTsi02mi (AWBURSTsi02mi6),
    .AWLOCKsi02mi  (AWLOCKsi02mi6),
    .AWCACHEsi02mi (AWCACHEsi02mi6),
    .AWPROTsi02mi  (AWPROTsi02mi6),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi6[SLAVE_MASTERID6_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi6),   
    .WSTRBsi02mi (WSTRBsi02mi6),   

    //Write response channel
    .BIDmi2si0     (BIDmi62si0),
    .BRESPmi2si0   (BRESPmi62si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi6[SLAVE_MASTERID6_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi6),
    .AWLENsi12mi   (AWLENsi22mi6),
    .AWSIZEsi12mi  (AWSIZEsi22mi6),
    .AWBURSTsi12mi (AWBURSTsi22mi6),
    .AWLOCKsi12mi  (AWLOCKsi22mi6),
    .AWCACHEsi12mi (AWCACHEsi22mi6),
    .AWPROTsi12mi  (AWPROTsi22mi6),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi6[SLAVE_MASTERID6_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi6),   
    .WSTRBsi12mi (WSTRBsi22mi6),   

    //Write response channel
    .BIDmi2si1     (BIDmi62si2),
    .BRESPmi2si1   (BRESPmi62si2),
    //Master Number 3
    //Write address channel
    .AWIDsi22mi    (wAWIDsi32mi6[SLAVE_MASTERID6_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi32mi6),
    .AWLENsi22mi   (AWLENsi32mi6),
    .AWSIZEsi22mi  (AWSIZEsi32mi6),
    .AWBURSTsi22mi (AWBURSTsi32mi6),
    .AWLOCKsi22mi  (AWLOCKsi32mi6),
    .AWCACHEsi22mi (AWCACHEsi32mi6),
    .AWPROTsi22mi  (AWPROTsi32mi6),

    //Write data channel
    .WIDsi22mi   (wWIDsi32mi6[SLAVE_MASTERID6_WID-1:0]),     
    .WDATAsi22mi (WDATAsi32mi6),   
    .WSTRBsi22mi (WSTRBsi32mi6),   

    //Write response channel
    .BIDmi2si2     (BIDmi62si3),
    .BRESPmi2si2   (BRESPmi62si3),
    //Master Number 4
    //Write address channel
    .AWIDsi32mi    (wAWIDsi42mi6[SLAVE_MASTERID6_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi42mi6),
    .AWLENsi32mi   (AWLENsi42mi6),
    .AWSIZEsi32mi  (AWSIZEsi42mi6),
    .AWBURSTsi32mi (AWBURSTsi42mi6),
    .AWLOCKsi32mi  (AWLOCKsi42mi6),
    .AWCACHEsi32mi (AWCACHEsi42mi6),
    .AWPROTsi32mi  (AWPROTsi42mi6),

    //Write data channel
    .WIDsi32mi   (wWIDsi42mi6[SLAVE_MASTERID6_WID-1:0]),     
    .WDATAsi32mi (WDATAsi42mi6),   
    .WSTRBsi32mi (WSTRBsi42mi6),   

    //Write response channel
    .BIDmi2si3     (BIDmi62si4),
    .BRESPmi2si3   (BRESPmi62si4),

    .BVALIDmi2si  (BVALIDmi62si),
    .BREADYsi2mi   (BREADYsi2mi6),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi6),
    .AWREADYmi2si  (AWREADYmi62si),
    .WLASTsi2mi    (WLASTsi2mi6),
    .WVALIDsi2mi   (WVALIDsi2mi6),
    .WREADYmi2si   (WREADYmi62si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi6),
    .UnLock2Wrmi(UnLock2wrmi6),

    .Lock2Rdmi(Lock2rdmi6),
    .UnLock2Rdmi(UnLock2rdmi6),

    .ARVALID(ARVALIDmi62s6),
    .LockPort(LockPort2wrmi6),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi62Rdmi6),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi62Wrmi6),
    .CtlDataWrite2Lock(CtlDataWrite2Lock6)
    ////////////////////////////////////////

    );

//Slave module 7    
//___________________________________________________________________________

SSRAM_RS_WriteChannelmi
SSRAM_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi72s7),
    .AWADDRmi2s  (AWADDRmi72s7),
    .AWLENmi2s   (AWLENmi72s7),
    .AWSIZEmi2s  (AWSIZEmi72s7),
    .AWBURSTmi2s (AWBURSTmi72s7),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi72s7),
    .AWREADYs2mi (AWREADYs72mi7),

    //Write data channel
    .WIDmi2s     (WIDmi72s7),
    .WDATAmi2s   (WDATAmi72s7),
    .WSTRBmi2s   (WSTRBmi72s7),
    .WLASTmi2s   (WLASTmi72s7),
    .WVALIDmi2s  (WVALIDmi72s7),
    .WREADYs2mi  (WREADYs72mi7),

    //Write response channel
    .BIDs2mi     (BIDs72mi7),
    .BRESPs2mi   (BRESPs72mi7),
    .BVALIDs2mi  (BVALIDs72mi7),
    .BREADYmi2s  (BREADYmi72s7),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi7[SLAVE_MASTERID7_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi7),
    .AWLENsi02mi   (AWLENsi02mi7),
    .AWSIZEsi02mi  (AWSIZEsi02mi7),
    .AWBURSTsi02mi (AWBURSTsi02mi7),
    .AWLOCKsi02mi  (AWLOCKsi02mi7),
    .AWCACHEsi02mi (AWCACHEsi02mi7),
    .AWPROTsi02mi  (AWPROTsi02mi7),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi7[SLAVE_MASTERID7_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi7),   
    .WSTRBsi02mi (WSTRBsi02mi7),   

    //Write response channel
    .BIDmi2si0     (BIDmi72si0),
    .BRESPmi2si0   (BRESPmi72si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi7[SLAVE_MASTERID7_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi7),
    .AWLENsi12mi   (AWLENsi22mi7),
    .AWSIZEsi12mi  (AWSIZEsi22mi7),
    .AWBURSTsi12mi (AWBURSTsi22mi7),
    .AWLOCKsi12mi  (AWLOCKsi22mi7),
    .AWCACHEsi12mi (AWCACHEsi22mi7),
    .AWPROTsi12mi  (AWPROTsi22mi7),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi7[SLAVE_MASTERID7_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi7),   
    .WSTRBsi12mi (WSTRBsi22mi7),   

    //Write response channel
    .BIDmi2si1     (BIDmi72si2),
    .BRESPmi2si1   (BRESPmi72si2),
    //Master Number 3
    //Write address channel
    .AWIDsi22mi    (wAWIDsi32mi7[SLAVE_MASTERID7_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi32mi7),
    .AWLENsi22mi   (AWLENsi32mi7),
    .AWSIZEsi22mi  (AWSIZEsi32mi7),
    .AWBURSTsi22mi (AWBURSTsi32mi7),
    .AWLOCKsi22mi  (AWLOCKsi32mi7),
    .AWCACHEsi22mi (AWCACHEsi32mi7),
    .AWPROTsi22mi  (AWPROTsi32mi7),

    //Write data channel
    .WIDsi22mi   (wWIDsi32mi7[SLAVE_MASTERID7_WID-1:0]),     
    .WDATAsi22mi (WDATAsi32mi7),   
    .WSTRBsi22mi (WSTRBsi32mi7),   

    //Write response channel
    .BIDmi2si2     (BIDmi72si3),
    .BRESPmi2si2   (BRESPmi72si3),
    //Master Number 4
    //Write address channel
    .AWIDsi32mi    (wAWIDsi42mi7[SLAVE_MASTERID7_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi42mi7),
    .AWLENsi32mi   (AWLENsi42mi7),
    .AWSIZEsi32mi  (AWSIZEsi42mi7),
    .AWBURSTsi32mi (AWBURSTsi42mi7),
    .AWLOCKsi32mi  (AWLOCKsi42mi7),
    .AWCACHEsi32mi (AWCACHEsi42mi7),
    .AWPROTsi32mi  (AWPROTsi42mi7),

    //Write data channel
    .WIDsi32mi   (wWIDsi42mi7[SLAVE_MASTERID7_WID-1:0]),     
    .WDATAsi32mi (WDATAsi42mi7),   
    .WSTRBsi32mi (WSTRBsi42mi7),   

    //Write response channel
    .BIDmi2si3     (BIDmi72si4),
    .BRESPmi2si3   (BRESPmi72si4),

    .BVALIDmi2si  (BVALIDmi72si),
    .BREADYsi2mi   (BREADYsi2mi7),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi7),
    .AWREADYmi2si  (AWREADYmi72si),
    .WLASTsi2mi    (WLASTsi2mi7),
    .WVALIDsi2mi   (WVALIDsi2mi7),
    .WREADYmi2si   (WREADYmi72si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi7),
    .UnLock2Wrmi(UnLock2wrmi7),

    .Lock2Rdmi(Lock2rdmi7),
    .UnLock2Rdmi(UnLock2rdmi7),

    .ARVALID(ARVALIDmi72s7),
    .LockPort(LockPort2wrmi7),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi72Rdmi7),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi72Wrmi7),
    .CtlDataWrite2Lock(CtlDataWrite2Lock7)
    ////////////////////////////////////////

    );

//Slave module 8    
//___________________________________________________________________________

default_RS_WriteChannelmi
default_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi82s8),
    .AWADDRmi2s  (AWADDRmi82s8),
    .AWLENmi2s   (AWLENmi82s8),
    .AWSIZEmi2s  (AWSIZEmi82s8),
    .AWBURSTmi2s (AWBURSTmi82s8),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi82s8),
    .AWREADYs2mi (AWREADYs82mi8),

    //Write data channel
    .WIDmi2s     (WIDmi82s8),
    .WDATAmi2s   (WDATAmi82s8),
    .WSTRBmi2s   (WSTRBmi82s8),
    .WLASTmi2s   (WLASTmi82s8),
    .WVALIDmi2s  (WVALIDmi82s8),
    .WREADYs2mi  (WREADYs82mi8),

    //Write response channel
    .BIDs2mi     (BIDs82mi8),
    .BRESPs2mi   (BRESPs82mi8),
    .BVALIDs2mi  (BVALIDs82mi8),
    .BREADYmi2s  (BREADYmi82s8),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi8[SLAVE_MASTERID8_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi8),
    .AWLENsi02mi   (AWLENsi02mi8),
    .AWSIZEsi02mi  (AWSIZEsi02mi8),
    .AWBURSTsi02mi (AWBURSTsi02mi8),
    .AWLOCKsi02mi  (AWLOCKsi02mi8),
    .AWCACHEsi02mi (AWCACHEsi02mi8),
    .AWPROTsi02mi  (AWPROTsi02mi8),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi8[SLAVE_MASTERID8_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi8),   
    .WSTRBsi02mi (WSTRBsi02mi8),   

    //Write response channel
    .BIDmi2si0     (BIDmi82si0),
    .BRESPmi2si0   (BRESPmi82si0),
    //Master Number 2
    //Write address channel
    .AWIDsi12mi    (wAWIDsi22mi8[SLAVE_MASTERID8_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi22mi8),
    .AWLENsi12mi   (AWLENsi22mi8),
    .AWSIZEsi12mi  (AWSIZEsi22mi8),
    .AWBURSTsi12mi (AWBURSTsi22mi8),
    .AWLOCKsi12mi  (AWLOCKsi22mi8),
    .AWCACHEsi12mi (AWCACHEsi22mi8),
    .AWPROTsi12mi  (AWPROTsi22mi8),

    //Write data channel
    .WIDsi12mi   (wWIDsi22mi8[SLAVE_MASTERID8_WID-1:0]),     
    .WDATAsi12mi (WDATAsi22mi8),   
    .WSTRBsi12mi (WSTRBsi22mi8),   

    //Write response channel
    .BIDmi2si1     (BIDmi82si2),
    .BRESPmi2si1   (BRESPmi82si2),
    //Master Number 3
    //Write address channel
    .AWIDsi22mi    (wAWIDsi32mi8[SLAVE_MASTERID8_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi32mi8),
    .AWLENsi22mi   (AWLENsi32mi8),
    .AWSIZEsi22mi  (AWSIZEsi32mi8),
    .AWBURSTsi22mi (AWBURSTsi32mi8),
    .AWLOCKsi22mi  (AWLOCKsi32mi8),
    .AWCACHEsi22mi (AWCACHEsi32mi8),
    .AWPROTsi22mi  (AWPROTsi32mi8),

    //Write data channel
    .WIDsi22mi   (wWIDsi32mi8[SLAVE_MASTERID8_WID-1:0]),     
    .WDATAsi22mi (WDATAsi32mi8),   
    .WSTRBsi22mi (WSTRBsi32mi8),   

    //Write response channel
    .BIDmi2si2     (BIDmi82si3),
    .BRESPmi2si2   (BRESPmi82si3),
    //Master Number 4
    //Write address channel
    .AWIDsi32mi    (wAWIDsi42mi8[SLAVE_MASTERID8_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi42mi8),
    .AWLENsi32mi   (AWLENsi42mi8),
    .AWSIZEsi32mi  (AWSIZEsi42mi8),
    .AWBURSTsi32mi (AWBURSTsi42mi8),
    .AWLOCKsi32mi  (AWLOCKsi42mi8),
    .AWCACHEsi32mi (AWCACHEsi42mi8),
    .AWPROTsi32mi  (AWPROTsi42mi8),

    //Write data channel
    .WIDsi32mi   (wWIDsi42mi8[SLAVE_MASTERID8_WID-1:0]),     
    .WDATAsi32mi (WDATAsi42mi8),   
    .WSTRBsi32mi (WSTRBsi42mi8),   

    //Write response channel
    .BIDmi2si3     (BIDmi82si4),
    .BRESPmi2si3   (BRESPmi82si4),

    .BVALIDmi2si  (BVALIDmi82si),
    .BREADYsi2mi   (BREADYsi2mi8),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi8),
    .AWREADYmi2si  (AWREADYmi82si),
    .WLASTsi2mi    (WLASTsi2mi8),
    .WVALIDsi2mi   (WVALIDsi2mi8),
    .WREADYmi2si   (WREADYmi82si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi8),
    .UnLock2Wrmi(UnLock2wrmi8),

    .Lock2Rdmi(Lock2rdmi8),
    .UnLock2Rdmi(UnLock2rdmi8),

    .ARVALID(ARVALIDmi82s8),
    .LockPort(LockPort2wrmi8),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi82Rdmi8),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi82Wrmi8),
    .CtlDataWrite2Lock(CtlDataWrite2Lock8)
    ////////////////////////////////////////

    );

endmodule
