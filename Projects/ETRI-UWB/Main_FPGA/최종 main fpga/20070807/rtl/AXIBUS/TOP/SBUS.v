// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : BUSTOP.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : BUS TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
//version short name

`define  ASSERT_ON
`timescale 1 ns/ 10ps
module SBUS(

//Write channel signal
    //_______________________________________________________________
    //For Master 0 :: ARMD
    //Write address channel
//Disable_id_port
    AWADDR_ARMD  ,
    AWLEN_ARMD   ,
    AWSIZE_ARMD  ,
    AWBURST_ARMD ,
    AWLOCK_ARMD  ,
//Disable_cache_port
//Disable_protect_port

    AWVALID_ARMD ,
    AWREADY_2_ARMD ,

    
    //Write data channel
//Disable_id_port
    WDATA_ARMD   ,
    WSTRB_ARMD   ,
    WLAST_ARMD   ,
    WVALID_ARMD  ,
    WREADY_2_ARMD  ,

    //Write response channel
//Disable_id_port
    BRESP_2_ARMD   ,
    BVALID_2_ARMD  ,
    BREADY_ARMD  ,
 
 
    //_______________________________________________________________
    //For Master 2 :: DMAC
    //Write address channel
    AWID_DMAC    ,
    AWADDR_DMAC  ,
    AWLEN_DMAC   ,
    AWSIZE_DMAC  ,
    AWBURST_DMAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_DMAC ,
    AWREADY_2_DMAC ,

    
    //Write data channel
    WID_DMAC     ,
    WDATA_DMAC   ,
    WSTRB_DMAC   ,
    WLAST_DMAC   ,
    WVALID_DMAC  ,
    WREADY_2_DMAC  ,

    //Write response channel
    BID_2_DMAC     ,
    BRESP_2_DMAC   ,
    BVALID_2_DMAC  ,
    BREADY_DMAC  ,
 
    //_______________________________________________________________
    //For Master 3 :: MAC
    //Write address channel
//Disable_id_port
    AWADDR_MAC  ,
    AWLEN_MAC   ,
    AWSIZE_MAC  ,
    AWBURST_MAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_MAC ,
    AWREADY_2_MAC ,

    
    //Write data channel
//Disable_id_port
    WDATA_MAC   ,
    WSTRB_MAC   ,
    WLAST_MAC   ,
    WVALID_MAC  ,
    WREADY_2_MAC  ,

    //Write response channel
//Disable_id_port
    BRESP_2_MAC   ,
    BVALID_2_MAC  ,
    BREADY_MAC  ,
 
    //_______________________________________________________________
    //For Master 4 :: PCI
    //Write address channel
//Disable_id_port
    AWADDR_PCI  ,
    AWLEN_PCI   ,
    AWSIZE_PCI  ,
    AWBURST_PCI ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_PCI ,
    AWREADY_2_PCI ,

    
    //Write data channel
//Disable_id_port
    WDATA_PCI   ,
    WSTRB_PCI   ,
    WLAST_PCI   ,
    WVALID_PCI  ,
    WREADY_2_PCI  ,

    //Write response channel
//Disable_id_port
    BRESP_2_PCI   ,
    BVALID_2_PCI  ,
    BREADY_PCI  ,
 

    //_______________________________________________________________
    //For Slave 0 :: AHB0
    //Write address channel
    AWID_2_AHB0    ,
    AWADDR_2_AHB0  ,
    AWLEN_2_AHB0   ,
    AWSIZE_2_AHB0  ,
    AWBURST_2_AHB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_AHB0 ,
    AWREADY_AHB0 ,

    //Write data channel
    WID_2_AHB0     ,
    WDATA_2_AHB0   ,
//Disable_WSTRB_port
    WLAST_2_AHB0   ,
    WVALID_2_AHB0  ,
    WREADY_AHB0  ,

    //Write response channel
    BID_AHB0     ,
    BRESP_AHB0   ,
    BVALID_AHB0  ,
    BREADY_2_AHB0  ,
 
    //_______________________________________________________________
    //For Slave 1 :: AHB1
    //Write address channel
    AWID_2_AHB1    ,
    AWADDR_2_AHB1  ,
    AWLEN_2_AHB1   ,
    AWSIZE_2_AHB1  ,
    AWBURST_2_AHB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_AHB1 ,
    AWREADY_AHB1 ,

    //Write data channel
    WID_2_AHB1     ,
    WDATA_2_AHB1   ,
//Disable_WSTRB_port
    WLAST_2_AHB1   ,
    WVALID_2_AHB1  ,
    WREADY_AHB1  ,

    //Write response channel
    BID_AHB1     ,
    BRESP_AHB1   ,
    BVALID_AHB1  ,
    BREADY_2_AHB1  ,
 
    //_______________________________________________________________
    //For Slave 2 :: AHB2
    //Write address channel
    AWID_2_AHB2    ,
    AWADDR_2_AHB2  ,
    AWLEN_2_AHB2   ,
    AWSIZE_2_AHB2  ,
    AWBURST_2_AHB2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_AHB2 ,
    AWREADY_AHB2 ,

    //Write data channel
    WID_2_AHB2     ,
    WDATA_2_AHB2   ,
//Disable_WSTRB_port
    WLAST_2_AHB2   ,
    WVALID_2_AHB2  ,
    WREADY_AHB2  ,

    //Write response channel
    BID_AHB2     ,
    BRESP_AHB2   ,
    BVALID_AHB2  ,
    BREADY_2_AHB2  ,
 
    //_______________________________________________________________
    //For Slave 3 :: DDR
    //Write address channel
    AWID_2_DDR    ,
    AWADDR_2_DDR  ,
    AWLEN_2_DDR   ,
    AWSIZE_2_DDR  ,
    AWBURST_2_DDR ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_DDR ,
    AWREADY_DDR ,

    //Write data channel
    WID_2_DDR     ,
    WDATA_2_DDR   ,
    WSTRB_2_DDR   ,
    WLAST_2_DDR   ,
    WVALID_2_DDR  ,
    WREADY_DDR  ,

    //Write response channel
    BID_DDR     ,
    BRESP_DDR   ,
    BVALID_DDR  ,
    BREADY_2_DDR  ,
 
    //_______________________________________________________________
    //For Slave 4 :: APB0
    //Write address channel
    AWID_2_APB0    ,
    AWADDR_2_APB0  ,
    AWLEN_2_APB0   ,
    AWSIZE_2_APB0  ,
    AWBURST_2_APB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_APB0 ,
    AWREADY_APB0 ,

    //Write data channel
    WID_2_APB0     ,
    WDATA_2_APB0   ,
//Disable_WSTRB_port
    WLAST_2_APB0   ,
    WVALID_2_APB0  ,
    WREADY_APB0  ,

    //Write response channel
    BID_APB0     ,
    BRESP_APB0   ,
    BVALID_APB0  ,
    BREADY_2_APB0  ,
 
    //_______________________________________________________________
    //For Slave 5 :: APB1
    //Write address channel
    AWID_2_APB1    ,
    AWADDR_2_APB1  ,
    AWLEN_2_APB1   ,
    AWSIZE_2_APB1  ,
    AWBURST_2_APB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_APB1 ,
    AWREADY_APB1 ,

    //Write data channel
    WID_2_APB1     ,
    WDATA_2_APB1   ,
//Disable_WSTRB_port
    WLAST_2_APB1   ,
    WVALID_2_APB1  ,
    WREADY_APB1  ,

    //Write response channel
    BID_APB1     ,
    BRESP_APB1   ,
    BVALID_APB1  ,
    BREADY_2_APB1  ,
 
    //_______________________________________________________________
    //For Slave 6 :: SMC
    //Write address channel
    AWID_2_SMC    ,
    AWADDR_2_SMC  ,
    AWLEN_2_SMC   ,
    AWSIZE_2_SMC  ,
    AWBURST_2_SMC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_SMC ,
    AWREADY_SMC ,

    //Write data channel
    WID_2_SMC     ,
    WDATA_2_SMC   ,
    WSTRB_2_SMC   ,
    WLAST_2_SMC   ,
    WVALID_2_SMC  ,
    WREADY_SMC  ,

    //Write response channel
    BID_SMC     ,
    BRESP_SMC   ,
    BVALID_SMC  ,
    BREADY_2_SMC  ,
 
    //_______________________________________________________________
    //For Slave 7 :: SSRAM
    //Write address channel
    AWID_2_SSRAM    ,
    AWADDR_2_SSRAM  ,
    AWLEN_2_SSRAM   ,
    AWSIZE_2_SSRAM  ,
    AWBURST_2_SSRAM ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_SSRAM ,
    AWREADY_SSRAM ,

    //Write data channel
    WID_2_SSRAM     ,
    WDATA_2_SSRAM   ,
    WSTRB_2_SSRAM   ,
    WLAST_2_SSRAM   ,
    WVALID_2_SSRAM  ,
    WREADY_SSRAM  ,

    //Write response channel
    BID_SSRAM     ,
    BRESP_SSRAM   ,
    BVALID_SSRAM  ,
    BREADY_2_SSRAM  ,
 


//Read channel signal
    //_______________________________________________________________
    //For Master 0 :: ARMD
    //Read address channel
//Disable_id_port
    ARADDR_ARMD  ,
    ARLEN_ARMD   ,
    ARSIZE_ARMD  ,
    ARBURST_ARMD ,
    ARLOCK_ARMD  ,
//Disable_cache_port
//Disable_protect_port

    ARVALID_ARMD ,
    ARREADY_2_ARMD ,

    //Read data channel
//Disable_id_port
    RRESP_2_ARMD   ,
    RDATA_2_ARMD   ,
    RLAST_2_ARMD   ,
    RVALID_2_ARMD  ,
    RREADY_ARMD  ,
 
    //_______________________________________________________________
    //For Master 1 :: ARMI
    //Read address channel
//Disable_id_port
    ARADDR_ARMI  ,
    ARLEN_ARMI   ,
    ARSIZE_ARMI  ,
    ARBURST_ARMI ,
    ARLOCK_ARMI  ,
//Disable_cache_port
//Disable_protect_port

    ARVALID_ARMI ,
    ARREADY_2_ARMI ,

    //Read data channel
//Disable_id_port
    RRESP_2_ARMI   ,
    RDATA_2_ARMI   ,
    RLAST_2_ARMI   ,
    RVALID_2_ARMI  ,
    RREADY_ARMI  ,
 
    //_______________________________________________________________
    //For Master 2 :: DMAC
    //Read address channel
    ARID_DMAC    ,
    ARADDR_DMAC  ,
    ARLEN_DMAC   ,
    ARSIZE_DMAC  ,
    ARBURST_DMAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_DMAC ,
    ARREADY_2_DMAC ,

    //Read data channel
    RID_2_DMAC     ,
    RRESP_2_DMAC   ,
    RDATA_2_DMAC   ,
    RLAST_2_DMAC   ,
    RVALID_2_DMAC  ,
    RREADY_DMAC  ,
 
    //_______________________________________________________________
    //For Master 3 :: MAC
    //Read address channel
//Disable_id_port
    ARADDR_MAC  ,
    ARLEN_MAC   ,
    ARSIZE_MAC  ,
    ARBURST_MAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_MAC ,
    ARREADY_2_MAC ,

    //Read data channel
//Disable_id_port
    RRESP_2_MAC   ,
    RDATA_2_MAC   ,
    RLAST_2_MAC   ,
    RVALID_2_MAC  ,
    RREADY_MAC  ,
 
    //_______________________________________________________________
    //For Master 4 :: PCI
    //Read address channel
//Disable_id_port
    ARADDR_PCI  ,
    ARLEN_PCI   ,
    ARSIZE_PCI  ,
    ARBURST_PCI ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_PCI ,
    ARREADY_2_PCI ,

    //Read data channel
//Disable_id_port
    RRESP_2_PCI   ,
    RDATA_2_PCI   ,
    RLAST_2_PCI   ,
    RVALID_2_PCI  ,
    RREADY_PCI  ,
 
    
    //_______________________________________________________________
    //For Slave 0 :: AHB0
    ARID_2_AHB0    ,
    ARADDR_2_AHB0  ,
    ARLEN_2_AHB0   ,
    ARSIZE_2_AHB0  ,
    ARBURST_2_AHB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_AHB0 ,
    ARREADY_AHB0 ,

    //Read data channel
    RID_AHB0     ,
    RRESP_AHB0   ,
    RDATA_AHB0  ,
    RLAST_AHB0  ,
    RVALID_AHB0  ,
    RREADY_2_AHB0  ,
 
    //_______________________________________________________________
    //For Slave 1 :: AHB1
    ARID_2_AHB1    ,
    ARADDR_2_AHB1  ,
    ARLEN_2_AHB1   ,
    ARSIZE_2_AHB1  ,
    ARBURST_2_AHB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_AHB1 ,
    ARREADY_AHB1 ,

    //Read data channel
    RID_AHB1     ,
    RRESP_AHB1   ,
    RDATA_AHB1  ,
    RLAST_AHB1  ,
    RVALID_AHB1  ,
    RREADY_2_AHB1  ,
 
    //_______________________________________________________________
    //For Slave 2 :: AHB2
    ARID_2_AHB2    ,
    ARADDR_2_AHB2  ,
    ARLEN_2_AHB2   ,
    ARSIZE_2_AHB2  ,
    ARBURST_2_AHB2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_AHB2 ,
    ARREADY_AHB2 ,

    //Read data channel
    RID_AHB2     ,
    RRESP_AHB2   ,
    RDATA_AHB2  ,
    RLAST_AHB2  ,
    RVALID_AHB2  ,
    RREADY_2_AHB2  ,
 
    //_______________________________________________________________
    //For Slave 3 :: DDR
    ARID_2_DDR    ,
    ARADDR_2_DDR  ,
    ARLEN_2_DDR   ,
    ARSIZE_2_DDR  ,
    ARBURST_2_DDR ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_DDR ,
    ARREADY_DDR ,

    //Read data channel
    RID_DDR     ,
    RRESP_DDR   ,
    RDATA_DDR  ,
    RLAST_DDR  ,
    RVALID_DDR  ,
    RREADY_2_DDR  ,
 
    //_______________________________________________________________
    //For Slave 4 :: APB0
    ARID_2_APB0    ,
    ARADDR_2_APB0  ,
    ARLEN_2_APB0   ,
    ARSIZE_2_APB0  ,
    ARBURST_2_APB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_APB0 ,
    ARREADY_APB0 ,

    //Read data channel
    RID_APB0     ,
    RRESP_APB0   ,
    RDATA_APB0  ,
    RLAST_APB0  ,
    RVALID_APB0  ,
    RREADY_2_APB0  ,
 
    //_______________________________________________________________
    //For Slave 5 :: APB1
    ARID_2_APB1    ,
    ARADDR_2_APB1  ,
    ARLEN_2_APB1   ,
    ARSIZE_2_APB1  ,
    ARBURST_2_APB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_APB1 ,
    ARREADY_APB1 ,

    //Read data channel
    RID_APB1     ,
    RRESP_APB1   ,
    RDATA_APB1  ,
    RLAST_APB1  ,
    RVALID_APB1  ,
    RREADY_2_APB1  ,
 
    //_______________________________________________________________
    //For Slave 6 :: SMC
    ARID_2_SMC    ,
    ARADDR_2_SMC  ,
    ARLEN_2_SMC   ,
    ARSIZE_2_SMC  ,
    ARBURST_2_SMC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_SMC ,
    ARREADY_SMC ,

    //Read data channel
    RID_SMC     ,
    RRESP_SMC   ,
    RDATA_SMC  ,
    RLAST_SMC  ,
    RVALID_SMC  ,
    RREADY_2_SMC  ,
 
    //_______________________________________________________________
    //For Slave 7 :: SSRAM
    ARID_2_SSRAM    ,
    ARADDR_2_SSRAM  ,
    ARLEN_2_SSRAM   ,
    ARSIZE_2_SSRAM  ,
    ARBURST_2_SSRAM ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_SSRAM ,
    ARREADY_SSRAM ,

    //Read data channel
    RID_SSRAM     ,
    RRESP_SSRAM   ,
    RDATA_SSRAM  ,
    RLAST_SSRAM  ,
    RVALID_SSRAM  ,
    RREADY_2_SSRAM  ,
 

    ACLK    ,
    ARESETn , 
    SelMAP1
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 4;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 4;
parameter SLAVE_NUM= 9;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter WRITECHID0_WID = 1 ;
parameter WRITECHID1_WID = 1 ;
parameter WRITECHID2_WID = 1 ;
parameter WRITECHID3_WID = 1 ;
parameter WRITECHID4_WID = 1 ;
parameter READCHID0_WID = 1 ;
parameter READCHID1_WID = 1 ;
parameter READCHID2_WID = 1 ;
parameter READCHID3_WID = 1 ;
parameter READCHID4_WID = 1 ;
parameter WR_SLAVEID0_WID = 2 ;
parameter WR_SLAVEID1_WID = 2 ;
parameter WR_SLAVEID2_WID = 2 ;
parameter WR_SLAVEID3_WID = 3 ;
parameter WR_SLAVEID4_WID = 2 ;
parameter WR_SLAVEID5_WID = 2 ;
parameter WR_SLAVEID6_WID = 3 ;
parameter WR_SLAVEID7_WID = 3 ;
parameter WR_SLAVEID8_WID = 3 ;
parameter RD_SLAVEID0_WID = 2 ;
parameter RD_SLAVEID1_WID = 2 ;
parameter RD_SLAVEID2_WID = 2 ;
parameter RD_SLAVEID3_WID = 4 ;
parameter RD_SLAVEID4_WID = 2 ;
parameter RD_SLAVEID5_WID = 2 ;
parameter RD_SLAVEID6_WID = 4 ;
parameter RD_SLAVEID7_WID = 4 ;
parameter RD_SLAVEID8_WID = 4 ;
parameter SELMASTER0_WID = 1 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 3 ;
parameter SELMASTER4_WID = 1 ;
parameter SELMASTER5_WID = 1 ;
parameter SELMASTER6_WID = 3 ;
parameter SELMASTER7_WID = 3 ;
parameter SELMASTER8_WID = 3 ;
parameter SELWRITE0_WID = 1 ;
parameter SELREAD0_WID = 1 ;
parameter SELWRITE1_WID = 1 ;
parameter SELREAD1_WID = 1 ;
parameter SELWRITE2_WID = 1 ;
parameter SELREAD2_WID = 1 ;
parameter SELWRITE3_WID = 2 ;
parameter SELREAD3_WID = 3 ;
parameter SELWRITE4_WID = 1 ;
parameter SELREAD4_WID = 1 ;
parameter SELWRITE5_WID = 1 ;
parameter SELREAD5_WID = 1 ;
parameter SELWRITE6_WID = 2 ;
parameter SELREAD6_WID = 3 ;
parameter SELWRITE7_WID = 2 ;
parameter SELREAD7_WID = 3 ;
parameter SELWRITE8_WID = 2 ;
parameter SELREAD8_WID = 3 ;
parameter SLAVE_WRITEID0_WID = 1 ;
parameter SLAVE_WRITEID1_WID = 1 ;
parameter SLAVE_WRITEID2_WID = 1 ;
parameter SLAVE_WRITEID3_WID = 1 ;
parameter SLAVE_WRITEID4_WID = 1 ;
parameter SLAVE_WRITEID5_WID = 1 ;
parameter SLAVE_WRITEID6_WID = 1 ;
parameter SLAVE_WRITEID7_WID = 1 ;
parameter SLAVE_WRITEID8_WID = 1 ;
parameter SLAVE_READID0_WID = 1 ;
parameter SLAVE_READID1_WID = 1 ;
parameter SLAVE_READID2_WID = 1 ;
parameter SLAVE_READID3_WID = 1 ;
parameter SLAVE_READID4_WID = 1 ;
parameter SLAVE_READID5_WID = 1 ;
parameter SLAVE_READID6_WID = 1 ;
parameter SLAVE_READID7_WID = 1 ;
parameter SLAVE_READID8_WID = 1 ;

    input   SelMAP1;
    input   ACLK;
    input   ARESETn;

    //Write Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARMD
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_ARMD;
    input   [AWLEN_WID-1:0]         AWLEN_ARMD;
    input   [AWSIZE_WID-1:0]        AWSIZE_ARMD;  
    input   [AWBURST_WID-1:0]       AWBURST_ARMD; 
    input   [AWLOCK_WID-1:0]        AWLOCK_ARMD;  
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_ARMD; 
    output  AWREADY_2_ARMD; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_ARMD;   
    input   [WSTRB_WID-1:0]         WSTRB_ARMD;   
    input   WLAST_ARMD;   
    input   WVALID_ARMD;  
    output  WREADY_2_ARMD;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_ARMD;   
    output   BVALID_2_ARMD;  
    input    BREADY_ARMD;  
 
 
    
    //For Master 2 :: DMAC
    //Write address channel
    input   [WRITECHID2_WID-1:0]   AWID_DMAC;    
    input   [ADDR_WID-1:0]          AWADDR_DMAC;
    input   [AWLEN_WID-1:0]         AWLEN_DMAC;
    input   [AWSIZE_WID-1:0]        AWSIZE_DMAC;  
    input   [AWBURST_WID-1:0]       AWBURST_DMAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_DMAC; 
    output  AWREADY_2_DMAC; 

    //Write data channel
    input   [WRITECHID2_WID-1:0]    WID_DMAC;     
    input   [BUS_WID-1:0]           WDATA_DMAC;   
    input   [WSTRB_WID-1:0]         WSTRB_DMAC;   
    input   WLAST_DMAC;   
    input   WVALID_DMAC;  
    output  WREADY_2_DMAC;  

    //Write response channel
    output   [WRITECHID2_WID-1:0]   BID_2_DMAC;     
    output   [BRESP_WID-1:0]        BRESP_2_DMAC;   
    output   BVALID_2_DMAC;  
    input    BREADY_DMAC;  
 
    
    //For Master 3 :: MAC
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_MAC;
    input   [AWLEN_WID-1:0]         AWLEN_MAC;
    input   [AWSIZE_WID-1:0]        AWSIZE_MAC;  
    input   [AWBURST_WID-1:0]       AWBURST_MAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_MAC; 
    output  AWREADY_2_MAC; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_MAC;   
    input   [WSTRB_WID-1:0]         WSTRB_MAC;   
    input   WLAST_MAC;   
    input   WVALID_MAC;  
    output  WREADY_2_MAC;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_MAC;   
    output   BVALID_2_MAC;  
    input    BREADY_MAC;  
 
    
    //For Master 4 :: PCI
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_PCI;
    input   [AWLEN_WID-1:0]         AWLEN_PCI;
    input   [AWSIZE_WID-1:0]        AWSIZE_PCI;  
    input   [AWBURST_WID-1:0]       AWBURST_PCI; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_PCI; 
    output  AWREADY_2_PCI; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_PCI;   
    input   [WSTRB_WID-1:0]         WSTRB_PCI;   
    input   WLAST_PCI;   
    input   WVALID_PCI;  
    output  WREADY_2_PCI;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_PCI;   
    output   BVALID_2_PCI;  
    input    BREADY_PCI;  
 


    //Write Channel MasterInterface
    //_______________________________________________________________
   
    // For slave 0 :: AHB0
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID0_WID-1:0]AWID_2_AHB0;    
    output   [ADDR_WID-1:0]     AWADDR_2_AHB0;
    output   [AWLEN_WID-1:0]    AWLEN_2_AHB0;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_AHB0;  
    output   [AWBURST_WID-1:0]  AWBURST_2_AHB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_AHB0; 
    input    AWREADY_AHB0; 
    
    //Write data channel
    output   [WR_SLAVEID0_WID-1:0]WID_2_AHB0;     
    output   [BUS_WID-1:0]      WDATA_2_AHB0;   
//Disable_WSTRB_port
    output   WLAST_2_AHB0;   
    output   WVALID_2_AHB0;  
    input    WREADY_AHB0; 

    //Write response channel
    input   [WR_SLAVEID0_WID-1:0] BID_AHB0;     
    input   [BRESP_WID-1:0]     BRESP_AHB0;   
    input   BVALID_AHB0;  
    output  BREADY_2_AHB0;  
   
    // For slave 1 :: AHB1
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID1_WID-1:0]AWID_2_AHB1;    
    output   [ADDR_WID-1:0]     AWADDR_2_AHB1;
    output   [AWLEN_WID-1:0]    AWLEN_2_AHB1;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_AHB1;  
    output   [AWBURST_WID-1:0]  AWBURST_2_AHB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_AHB1; 
    input    AWREADY_AHB1; 
    
    //Write data channel
    output   [WR_SLAVEID1_WID-1:0]WID_2_AHB1;     
    output   [BUS_WID-1:0]      WDATA_2_AHB1;   
//Disable_WSTRB_port
    output   WLAST_2_AHB1;   
    output   WVALID_2_AHB1;  
    input    WREADY_AHB1; 

    //Write response channel
    input   [WR_SLAVEID1_WID-1:0] BID_AHB1;     
    input   [BRESP_WID-1:0]     BRESP_AHB1;   
    input   BVALID_AHB1;  
    output  BREADY_2_AHB1;  
   
    // For slave 2 :: AHB2
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID2_WID-1:0]AWID_2_AHB2;    
    output   [ADDR_WID-1:0]     AWADDR_2_AHB2;
    output   [AWLEN_WID-1:0]    AWLEN_2_AHB2;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_AHB2;  
    output   [AWBURST_WID-1:0]  AWBURST_2_AHB2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_AHB2; 
    input    AWREADY_AHB2; 
    
    //Write data channel
    output   [WR_SLAVEID2_WID-1:0]WID_2_AHB2;     
    output   [BUS_WID-1:0]      WDATA_2_AHB2;   
//Disable_WSTRB_port
    output   WLAST_2_AHB2;   
    output   WVALID_2_AHB2;  
    input    WREADY_AHB2; 

    //Write response channel
    input   [WR_SLAVEID2_WID-1:0] BID_AHB2;     
    input   [BRESP_WID-1:0]     BRESP_AHB2;   
    input   BVALID_AHB2;  
    output  BREADY_2_AHB2;  
   
    // For slave 3 :: DDR
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID3_WID-1:0]AWID_2_DDR;    
    output   [ADDR_WID-1:0]     AWADDR_2_DDR;
    output   [AWLEN_WID-1:0]    AWLEN_2_DDR;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_DDR;  
    output   [AWBURST_WID-1:0]  AWBURST_2_DDR; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_DDR; 
    input    AWREADY_DDR; 
    
    //Write data channel
    output   [WR_SLAVEID3_WID-1:0]WID_2_DDR;     
    output   [BUS_WID-1:0]      WDATA_2_DDR;   
    output   [WSTRB_WID-1:0]    WSTRB_2_DDR;   
    output   WLAST_2_DDR;   
    output   WVALID_2_DDR;  
    input    WREADY_DDR; 

    //Write response channel
    input   [WR_SLAVEID3_WID-1:0] BID_DDR;     
    input   [BRESP_WID-1:0]     BRESP_DDR;   
    input   BVALID_DDR;  
    output  BREADY_2_DDR;  
   
    // For slave 4 :: APB0
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID4_WID-1:0]AWID_2_APB0;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB0;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB0;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB0;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_APB0; 
    input    AWREADY_APB0; 
    
    //Write data channel
    output   [WR_SLAVEID4_WID-1:0]WID_2_APB0;     
    output   [BUS_WID-1:0]      WDATA_2_APB0;   
//Disable_WSTRB_port
    output   WLAST_2_APB0;   
    output   WVALID_2_APB0;  
    input    WREADY_APB0; 

    //Write response channel
    input   [WR_SLAVEID4_WID-1:0] BID_APB0;     
    input   [BRESP_WID-1:0]     BRESP_APB0;   
    input   BVALID_APB0;  
    output  BREADY_2_APB0;  
   
    // For slave 5 :: APB1
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID5_WID-1:0]AWID_2_APB1;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB1;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB1;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB1;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_APB1; 
    input    AWREADY_APB1; 
    
    //Write data channel
    output   [WR_SLAVEID5_WID-1:0]WID_2_APB1;     
    output   [BUS_WID-1:0]      WDATA_2_APB1;   
//Disable_WSTRB_port
    output   WLAST_2_APB1;   
    output   WVALID_2_APB1;  
    input    WREADY_APB1; 

    //Write response channel
    input   [WR_SLAVEID5_WID-1:0] BID_APB1;     
    input   [BRESP_WID-1:0]     BRESP_APB1;   
    input   BVALID_APB1;  
    output  BREADY_2_APB1;  
   
    // For slave 6 :: SMC
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID6_WID-1:0]AWID_2_SMC;    
    output   [ADDR_WID-1:0]     AWADDR_2_SMC;
    output   [AWLEN_WID-1:0]    AWLEN_2_SMC;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_SMC;  
    output   [AWBURST_WID-1:0]  AWBURST_2_SMC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_SMC; 
    input    AWREADY_SMC; 
    
    //Write data channel
    output   [WR_SLAVEID6_WID-1:0]WID_2_SMC;     
    output   [BUS_WID-1:0]      WDATA_2_SMC;   
    output   [WSTRB_WID-1:0]    WSTRB_2_SMC;   
    output   WLAST_2_SMC;   
    output   WVALID_2_SMC;  
    input    WREADY_SMC; 

    //Write response channel
    input   [WR_SLAVEID6_WID-1:0] BID_SMC;     
    input   [BRESP_WID-1:0]     BRESP_SMC;   
    input   BVALID_SMC;  
    output  BREADY_2_SMC;  
   
    // For slave 7 :: SSRAM
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID7_WID-1:0]AWID_2_SSRAM;    
    output   [ADDR_WID-1:0]     AWADDR_2_SSRAM;
    output   [AWLEN_WID-1:0]    AWLEN_2_SSRAM;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_SSRAM;  
    output   [AWBURST_WID-1:0]  AWBURST_2_SSRAM; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_SSRAM; 
    input    AWREADY_SSRAM; 
    
    //Write data channel
    output   [WR_SLAVEID7_WID-1:0]WID_2_SSRAM;     
    output   [BUS_WID-1:0]      WDATA_2_SSRAM;   
    output   [WSTRB_WID-1:0]    WSTRB_2_SSRAM;   
    output   WLAST_2_SSRAM;   
    output   WVALID_2_SSRAM;  
    input    WREADY_SSRAM; 

    //Write response channel
    input   [WR_SLAVEID7_WID-1:0] BID_SSRAM;     
    input   [BRESP_WID-1:0]     BRESP_SSRAM;   
    input   BVALID_SSRAM;  
    output  BREADY_2_SSRAM;  


    //Read Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARMD
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_ARMD;
    input   [ARLEN_WID-1:0]    ARLEN_ARMD;
    input   [ARSIZE_WID-1:0]   ARSIZE_ARMD;  
    input   [ARBURST_WID-1:0]  ARBURST_ARMD; 
    input   [ARLOCK_WID-1:0]   ARLOCK_ARMD;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_ARMD; 
    output  ARREADY_2_ARMD; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_ARMD;   
    output   [BUS_WID-1:0]     RDATA_2_ARMD;
    output   RLAST_2_ARMD;
    output   RVALID_2_ARMD;  
    input    RREADY_ARMD;  
 
    
    //For Master 1 :: ARMI
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_ARMI;
    input   [ARLEN_WID-1:0]    ARLEN_ARMI;
    input   [ARSIZE_WID-1:0]   ARSIZE_ARMI;  
    input   [ARBURST_WID-1:0]  ARBURST_ARMI; 
    input   [ARLOCK_WID-1:0]   ARLOCK_ARMI;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_ARMI; 
    output  ARREADY_2_ARMI; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_ARMI;   
    output   [BUS_WID-1:0]     RDATA_2_ARMI;
    output   RLAST_2_ARMI;
    output   RVALID_2_ARMI;  
    input    RREADY_ARMI;  
 
    
    //For Master 2 :: DMAC
    //Read address channel
    input   [READCHID2_WID-1:0]ARID_DMAC;    
    input   [ADDR_WID-1:0]     ARADDR_DMAC;
    input   [ARLEN_WID-1:0]    ARLEN_DMAC;
    input   [ARSIZE_WID-1:0]   ARSIZE_DMAC;  
    input   [ARBURST_WID-1:0]  ARBURST_DMAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_DMAC; 
    output  ARREADY_2_DMAC; 

    //Read data channel
    output   [READCHID2_WID-1:0]RID_2_DMAC;     
    output   [BRESP_WID-1:0]   RRESP_2_DMAC;   
    output   [BUS_WID-1:0]     RDATA_2_DMAC;
    output   RLAST_2_DMAC;
    output   RVALID_2_DMAC;  
    input    RREADY_DMAC;  
 
    
    //For Master 3 :: MAC
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_MAC;
    input   [ARLEN_WID-1:0]    ARLEN_MAC;
    input   [ARSIZE_WID-1:0]   ARSIZE_MAC;  
    input   [ARBURST_WID-1:0]  ARBURST_MAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_MAC; 
    output  ARREADY_2_MAC; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_MAC;   
    output   [BUS_WID-1:0]     RDATA_2_MAC;
    output   RLAST_2_MAC;
    output   RVALID_2_MAC;  
    input    RREADY_MAC;  
 
    
    //For Master 4 :: PCI
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_PCI;
    input   [ARLEN_WID-1:0]    ARLEN_PCI;
    input   [ARSIZE_WID-1:0]   ARSIZE_PCI;  
    input   [ARBURST_WID-1:0]  ARBURST_PCI; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_PCI; 
    output  ARREADY_2_PCI; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_PCI;   
    output   [BUS_WID-1:0]     RDATA_2_PCI;
    output   RLAST_2_PCI;
    output   RVALID_2_PCI;  
    input    RREADY_PCI;  
 


    //MasterInterface
    //_______________________________________________________________
    
    // For slave 0
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID0_WID-1:0]ARID_2_AHB0;    
    output   [ADDR_WID-1:0]     ARADDR_2_AHB0;
    output   [ARLEN_WID-1:0]    ARLEN_2_AHB0;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_AHB0;  
    output   [ARBURST_WID-1:0]  ARBURST_2_AHB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_AHB0; 
    input    ARREADY_AHB0; 
    

    //Read data channel
    input   [RD_SLAVEID0_WID-1:0] RID_AHB0;     
    input   [RRESP_WID-1:0]     RRESP_AHB0;   
    input   [BUS_WID-1:0]       RDATA_AHB0;  
    input   RLAST_AHB0;  
    input   RVALID_AHB0;  
    output  RREADY_2_AHB0;  

    
    // For slave 1
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID1_WID-1:0]ARID_2_AHB1;    
    output   [ADDR_WID-1:0]     ARADDR_2_AHB1;
    output   [ARLEN_WID-1:0]    ARLEN_2_AHB1;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_AHB1;  
    output   [ARBURST_WID-1:0]  ARBURST_2_AHB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_AHB1; 
    input    ARREADY_AHB1; 
    

    //Read data channel
    input   [RD_SLAVEID1_WID-1:0] RID_AHB1;     
    input   [RRESP_WID-1:0]     RRESP_AHB1;   
    input   [BUS_WID-1:0]       RDATA_AHB1;  
    input   RLAST_AHB1;  
    input   RVALID_AHB1;  
    output  RREADY_2_AHB1;  

    
    // For slave 2
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID2_WID-1:0]ARID_2_AHB2;    
    output   [ADDR_WID-1:0]     ARADDR_2_AHB2;
    output   [ARLEN_WID-1:0]    ARLEN_2_AHB2;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_AHB2;  
    output   [ARBURST_WID-1:0]  ARBURST_2_AHB2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_AHB2; 
    input    ARREADY_AHB2; 
    

    //Read data channel
    input   [RD_SLAVEID2_WID-1:0] RID_AHB2;     
    input   [RRESP_WID-1:0]     RRESP_AHB2;   
    input   [BUS_WID-1:0]       RDATA_AHB2;  
    input   RLAST_AHB2;  
    input   RVALID_AHB2;  
    output  RREADY_2_AHB2;  

    
    // For slave 3
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID3_WID-1:0]ARID_2_DDR;    
    output   [ADDR_WID-1:0]     ARADDR_2_DDR;
    output   [ARLEN_WID-1:0]    ARLEN_2_DDR;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_DDR;  
    output   [ARBURST_WID-1:0]  ARBURST_2_DDR; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_DDR; 
    input    ARREADY_DDR; 
    

    //Read data channel
    input   [RD_SLAVEID3_WID-1:0] RID_DDR;     
    input   [RRESP_WID-1:0]     RRESP_DDR;   
    input   [BUS_WID-1:0]       RDATA_DDR;  
    input   RLAST_DDR;  
    input   RVALID_DDR;  
    output  RREADY_2_DDR;  

    
    // For slave 4
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID4_WID-1:0]ARID_2_APB0;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB0;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB0;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB0;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_APB0; 
    input    ARREADY_APB0; 
    

    //Read data channel
    input   [RD_SLAVEID4_WID-1:0] RID_APB0;     
    input   [RRESP_WID-1:0]     RRESP_APB0;   
    input   [BUS_WID-1:0]       RDATA_APB0;  
    input   RLAST_APB0;  
    input   RVALID_APB0;  
    output  RREADY_2_APB0;  

    
    // For slave 5
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID5_WID-1:0]ARID_2_APB1;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB1;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB1;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB1;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_APB1; 
    input    ARREADY_APB1; 
    

    //Read data channel
    input   [RD_SLAVEID5_WID-1:0] RID_APB1;     
    input   [RRESP_WID-1:0]     RRESP_APB1;   
    input   [BUS_WID-1:0]       RDATA_APB1;  
    input   RLAST_APB1;  
    input   RVALID_APB1;  
    output  RREADY_2_APB1;  

    
    // For slave 6
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID6_WID-1:0]ARID_2_SMC;    
    output   [ADDR_WID-1:0]     ARADDR_2_SMC;
    output   [ARLEN_WID-1:0]    ARLEN_2_SMC;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_SMC;  
    output   [ARBURST_WID-1:0]  ARBURST_2_SMC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_SMC; 
    input    ARREADY_SMC; 
    

    //Read data channel
    input   [RD_SLAVEID6_WID-1:0] RID_SMC;     
    input   [RRESP_WID-1:0]     RRESP_SMC;   
    input   [BUS_WID-1:0]       RDATA_SMC;  
    input   RLAST_SMC;  
    input   RVALID_SMC;  
    output  RREADY_2_SMC;  

    
    // For slave 7
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID7_WID-1:0]ARID_2_SSRAM;    
    output   [ADDR_WID-1:0]     ARADDR_2_SSRAM;
    output   [ARLEN_WID-1:0]    ARLEN_2_SSRAM;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_SSRAM;  
    output   [ARBURST_WID-1:0]  ARBURST_2_SSRAM; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_SSRAM; 
    input    ARREADY_SSRAM; 
    

    //Read data channel
    input   [RD_SLAVEID7_WID-1:0] RID_SSRAM;     
    input   [RRESP_WID-1:0]     RRESP_SSRAM;   
    input   [BUS_WID-1:0]       RDATA_SSRAM;  
    input   RLAST_SSRAM;  
    input   RVALID_SSRAM;  
    output  RREADY_2_SSRAM;  


//______________________________________________________DEFALUT_SLAVE_START
    // default slave
    // For slave 8 :: default
    //__________________________________________________
    //Write address channel
    wire   [WR_SLAVEID8_WID-1:0]AWID_2_default;    
    wire   [ADDR_WID-1:0]     AWADDR_2_default;
    wire   [AWLEN_WID-1:0]    AWLEN_2_default;
    wire   [AWSIZE_WID-1:0]   AWSIZE_2_default;  
    wire   [AWBURST_WID-1:0]  AWBURST_2_default; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    wire   AWVALID_2_default; 
    wire    AWREADY_default; 
    
    //Write data channel
    wire   [WR_SLAVEID8_WID-1:0]WID_2_default;     
    wire   [BUS_WID-1:0]      WDATA_2_default;   
    wire   [WSTRB_WID-1:0]    WSTRB_2_default;   
    wire   WLAST_2_default;   
    wire   WVALID_2_default;  
    wire    WREADY_default; 

    //Write response channel
    wire   [WR_SLAVEID8_WID-1:0] BID_default;     
    wire   [BRESP_WID-1:0]     BRESP_default;   
    wire   BVALID_default;  
    wire  BREADY_2_default;  

    //__________________________________________________
    // Read address channel
    wire   [RD_SLAVEID8_WID-1:0]ARID_2_default;    
    wire   [ADDR_WID-1:0]     ARADDR_2_default;
    wire   [ARLEN_WID-1:0]    ARLEN_2_default;
    wire   [ARSIZE_WID-1:0]   ARSIZE_2_default;  
    wire   [ARBURST_WID-1:0]  ARBURST_2_default; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    wire   ARVALID_2_default; 
    wire   ARREADY_default; 
    
    //Read data channel
    wire   [RD_SLAVEID8_WID-1:0] RID_default;     
    wire   [RRESP_WID-1:0]     RRESP_default;   
    wire   [BUS_WID-1:0]       RDATA_default;  
    wire   RLAST_default;  
    wire   RVALID_default;  
    wire   RREADY_2_default;  

DefaultSlave #(
	.WID_WIDTH(WR_SLAVEID8_WID),
	.RID_WIDTH(RD_SLAVEID8_WID)
)
DefaultSlave
(
		.ACLK(ACLK),
		.ARESETn(ARESETn),

		.AWID(AWID_2_default),
		.AWADDR(AWADDR_2_default),
		.AWLEN(AWLEN_2_default),
		.AWSIZE(AWSIZE_2_default),
		.AWBURST(AWBURST_2_default),
		.AWVALID(AWVALID_2_default),
		.AWREADY(AWREADY_default),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

		.WID(WID_2_default),
		.WDATA(WDATA_2_default),
		.WLAST(WLAST_2_default),
		.WVALID(WVALID_2_default),
        .WSTRB  (WSTRB_2_default),
		.WREADY (WREADY_default),

		.BID(BID_default),
		.BRESP(BRESP_default),
		.BVALID(BVALID_default),
		.BREADY(BREADY_2_default),

		.ARID(ARID_2_default),
		.ARADDR(ARADDR_2_default),
		.ARLEN(ARLEN_2_default),
		.ARSIZE(ARSIZE_2_default),
		.ARBURST(ARBURST_2_default),
		.ARVALID(ARVALID_2_default),
		.ARREADY(ARREADY_default),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

		// Read Data Channel
		.RID(RID_default),
		.RDATA(RDATA_default),
		.RRESP(RRESP_default),
		.RLAST(RLAST_default),
		.RVALID(RVALID_default),
		.RREADY(RREADY_2_default)
);
//______________________________________________________DEFALUT_SLAVE_END


//version short name
//Slave Lock signals were generated
//Slave module 0  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE0_WID-1:0]CtlDataWrite2Lock0;
    wire   [SELREAD0_WID-1:0]CtlDataRead2Lock0;     
    wire   Lock2wrmi0;
    wire   UnLock2wrmi0;
    wire   UnLock2rdmi0;
    wire   Lock2rdmi0 ;
    //wire   [SELWRITE0_WID:0]LockPort2wrmi0;
    //wire   [SELREAD0_WID:0]LockPort2rdmi0;
    reg   [SELWRITE0_WID:0]LockPort2wrmi0;
    reg   [SELREAD0_WID:0]LockPort2rdmi0;

    //Syn modified
    wire   ReadIntEmptyWrmi02Rdmi0;
    wire   DataCntEmptyRdmi02Wrmi0;

//Slave Lock signals were generated
//Slave module 1  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE1_WID-1:0]CtlDataWrite2Lock1;
    wire   [SELREAD1_WID-1:0]CtlDataRead2Lock1;     
    wire   Lock2wrmi1;
    wire   UnLock2wrmi1;
    wire   UnLock2rdmi1;
    wire   Lock2rdmi1 ;
    //wire   [SELWRITE1_WID:0]LockPort2wrmi1;
    //wire   [SELREAD1_WID:0]LockPort2rdmi1;
    reg   [SELWRITE1_WID:0]LockPort2wrmi1;
    reg   [SELREAD1_WID:0]LockPort2rdmi1;

    //Syn modified
    wire   ReadIntEmptyWrmi12Rdmi1;
    wire   DataCntEmptyRdmi12Wrmi1;

//Slave Lock signals were generated
//Slave module 2  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE2_WID-1:0]CtlDataWrite2Lock2;
    wire   [SELREAD2_WID-1:0]CtlDataRead2Lock2;     
    wire   Lock2wrmi2;
    wire   UnLock2wrmi2;
    wire   UnLock2rdmi2;
    wire   Lock2rdmi2 ;
    //wire   [SELWRITE2_WID:0]LockPort2wrmi2;
    //wire   [SELREAD2_WID:0]LockPort2rdmi2;
    reg   [SELWRITE2_WID:0]LockPort2wrmi2;
    reg   [SELREAD2_WID:0]LockPort2rdmi2;

    //Syn modified
    wire   ReadIntEmptyWrmi22Rdmi2;
    wire   DataCntEmptyRdmi22Wrmi2;

//Slave Lock signals were generated
//Slave module 3  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE3_WID-1:0]CtlDataWrite2Lock3;
    wire   [SELREAD3_WID-1:0]CtlDataRead2Lock3;     
    wire   Lock2wrmi3;
    wire   UnLock2wrmi3;
    wire   UnLock2rdmi3;
    wire   Lock2rdmi3 ;
    //wire   [SELWRITE3_WID:0]LockPort2wrmi3;
    //wire   [SELREAD3_WID:0]LockPort2rdmi3;
    reg   [SELWRITE3_WID:0]LockPort2wrmi3;
    reg   [SELREAD3_WID:0]LockPort2rdmi3;

    //Syn modified
    wire   ReadIntEmptyWrmi32Rdmi3;
    wire   DataCntEmptyRdmi32Wrmi3;

//Slave Lock signals were generated
//Slave module 4  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE4_WID-1:0]CtlDataWrite2Lock4;
    wire   [SELREAD4_WID-1:0]CtlDataRead2Lock4;     
    wire   Lock2wrmi4;
    wire   UnLock2wrmi4;
    wire   UnLock2rdmi4;
    wire   Lock2rdmi4 ;
    //wire   [SELWRITE4_WID:0]LockPort2wrmi4;
    //wire   [SELREAD4_WID:0]LockPort2rdmi4;
    reg   [SELWRITE4_WID:0]LockPort2wrmi4;
    reg   [SELREAD4_WID:0]LockPort2rdmi4;

    //Syn modified
    wire   ReadIntEmptyWrmi42Rdmi4;
    wire   DataCntEmptyRdmi42Wrmi4;

//Slave Lock signals were generated
//Slave module 5  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE5_WID-1:0]CtlDataWrite2Lock5;
    wire   [SELREAD5_WID-1:0]CtlDataRead2Lock5;     
    wire   Lock2wrmi5;
    wire   UnLock2wrmi5;
    wire   UnLock2rdmi5;
    wire   Lock2rdmi5 ;
    //wire   [SELWRITE5_WID:0]LockPort2wrmi5;
    //wire   [SELREAD5_WID:0]LockPort2rdmi5;
    reg   [SELWRITE5_WID:0]LockPort2wrmi5;
    reg   [SELREAD5_WID:0]LockPort2rdmi5;

    //Syn modified
    wire   ReadIntEmptyWrmi52Rdmi5;
    wire   DataCntEmptyRdmi52Wrmi5;

//Slave Lock signals were generated
//Slave module 6  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE6_WID-1:0]CtlDataWrite2Lock6;
    wire   [SELREAD6_WID-1:0]CtlDataRead2Lock6;     
    wire   Lock2wrmi6;
    wire   UnLock2wrmi6;
    wire   UnLock2rdmi6;
    wire   Lock2rdmi6 ;
    //wire   [SELWRITE6_WID:0]LockPort2wrmi6;
    //wire   [SELREAD6_WID:0]LockPort2rdmi6;
    reg   [SELWRITE6_WID:0]LockPort2wrmi6;
    reg   [SELREAD6_WID:0]LockPort2rdmi6;

    //Syn modified
    wire   ReadIntEmptyWrmi62Rdmi6;
    wire   DataCntEmptyRdmi62Wrmi6;

//Slave Lock signals were generated
//Slave module 7  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE7_WID-1:0]CtlDataWrite2Lock7;
    wire   [SELREAD7_WID-1:0]CtlDataRead2Lock7;     
    wire   Lock2wrmi7;
    wire   UnLock2wrmi7;
    wire   UnLock2rdmi7;
    wire   Lock2rdmi7 ;
    //wire   [SELWRITE7_WID:0]LockPort2wrmi7;
    //wire   [SELREAD7_WID:0]LockPort2rdmi7;
    reg   [SELWRITE7_WID:0]LockPort2wrmi7;
    reg   [SELREAD7_WID:0]LockPort2rdmi7;

    //Syn modified
    wire   ReadIntEmptyWrmi72Rdmi7;
    wire   DataCntEmptyRdmi72Wrmi7;

//Slave Lock signals were generated
//Slave module 8  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE8_WID-1:0]CtlDataWrite2Lock8;
    wire   [SELREAD8_WID-1:0]CtlDataRead2Lock8;     
    wire   Lock2wrmi8;
    wire   UnLock2wrmi8;
    wire   UnLock2rdmi8;
    wire   Lock2rdmi8 ;
    //wire   [SELWRITE8_WID:0]LockPort2wrmi8;
    //wire   [SELREAD8_WID:0]LockPort2rdmi8;
    reg   [SELWRITE8_WID:0]LockPort2wrmi8;
    reg   [SELREAD8_WID:0]LockPort2rdmi8;

    //Syn modified
    wire   ReadIntEmptyWrmi82Rdmi8;
    wire   DataCntEmptyRdmi82Wrmi8;

//_____________________________________________________________________



  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

// Protocal Checker for master ARMD
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID0_WID ),
    .RID_WIDTH(READCHID0_WID)
 )
ARMD_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_ARMD  ),
   .AWLEN       (AWLEN_ARMD   ),
   .AWSIZE      (AWSIZE_ARMD  ),
   .AWBURST     (AWBURST_ARMD ),
   .AWLOCK      (AWLOCK_ARMD  ),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_ARMD ),
   .AWREADY     (AWREADY_2_ARMD ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_ARMD   ),
   .WDATA       (WDATA_ARMD   ),
   .WSTRB       (WSTRB_ARMD   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_ARMD  ),
   .WREADY      (WREADY_2_ARMD  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_ARMD   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_ARMD  ),
   .BREADY       (BREADY_ARMD  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_ARMD  ),
   .ARLEN        (ARLEN_ARMD   ),
   .ARSIZE       (ARSIZE_ARMD  ),
   .ARBURST      (ARBURST_ARMD ),
   .ARLOCK       (ARLOCK_ARMD  ),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_ARMD ),
   .ARREADY      (ARREADY_2_ARMD ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_ARMD   ),
   .RDATA        (RDATA_2_ARMD   ),
   .RRESP        (RRESP_2_ARMD   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_ARMD  ),
   .RREADY       (RREADY_ARMD  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master ARMI
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID1_WID ),
    .RID_WIDTH(READCHID1_WID)
 )
ARMI_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),

   // Write Address Channel
   .AWID      ({WRITECHID1_WID{1'b0}}),
   .AWADDR    ({ADDR_WID{1'b0}}  ),
   .AWLEN     ({AWLEN_WID{1'b0}}   ),
   .AWSIZE    ({AWSIZE_WID{1'b0}}  ),
   .AWBURST   ({AWBURST_WID{1'b0}} ),
   .AWLOCK    ({AWLOCK_WID{1'b0}}  ),
   .AWCACHE   ({AWCACHE_WID{1'b0}} ),
   .AWPROT    ({AWPROT_WID{1'b0}}  ),
   .AWUSER    ({32{1'b0}}),
   .AWVALID   (1'b0 ),
   .AWREADY   (1'b0 ),
   // Write Channel
   .WID       ({WRITECHID1_WID{1'b0}}),
   .WLAST       (1'b0   ),
   .WDATA       ({BUS_WID{1'b0}}   ),
   .WSTRB       ({WSTRB_WID{1'b1}}   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (1'b0  ),
   .WREADY      (1'b0  ),
   // Write Response Channel
   .BID         ({WRITECHID1_WID{1'b0}}),
   .BRESP        ({BRESP_WID{1'b0}}   ),
   .BUSER        ({32{1'b0}}),
   .BVALID       (1'b0  ),
   .BREADY       (1'b0  ),

   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_ARMI  ),
   .ARLEN        (ARLEN_ARMI   ),
   .ARSIZE       (ARSIZE_ARMI  ),
   .ARBURST      (ARBURST_ARMI ),
   .ARLOCK       (ARLOCK_ARMI  ),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_ARMI ),
   .ARREADY      (ARREADY_2_ARMI ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_ARMI   ),
   .RDATA        (RDATA_2_ARMI   ),
   .RRESP        (RRESP_2_ARMI   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_ARMI  ),
   .RREADY       (RREADY_ARMI  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DMAC
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID2_WID ),
    .RID_WIDTH(READCHID2_WID)
 )
DMAC_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID        (AWID_DMAC    ),
   .AWADDR      (AWADDR_DMAC  ),
   .AWLEN       (AWLEN_DMAC   ),
   .AWSIZE      (AWSIZE_DMAC  ),
   .AWBURST     (AWBURST_DMAC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_DMAC ),
   .AWREADY     (AWREADY_2_DMAC ),

   // Write Channel
   .WID         (WID_DMAC     ),
   .WLAST       (WLAST_DMAC   ),
   .WDATA       (WDATA_DMAC   ),
   .WSTRB       (WSTRB_DMAC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_DMAC  ),
   .WREADY      (WREADY_2_DMAC  ),

   // Write Response Channel
   .BID          (BID_2_DMAC     ),
   .BRESP        (BRESP_2_DMAC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_DMAC  ),
   .BREADY       (BREADY_DMAC  ),


   // Read Address Channel
   .ARID         (ARID_DMAC    ),
   .ARADDR       (ARADDR_DMAC  ),
   .ARLEN        (ARLEN_DMAC   ),
   .ARSIZE       (ARSIZE_DMAC  ),
   .ARBURST      (ARBURST_DMAC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DMAC ),
   .ARREADY      (ARREADY_2_DMAC ),

   // Read Channel
   .RID          (RID_2_DMAC     ),
   .RLAST        (RLAST_2_DMAC   ),
   .RDATA        (RDATA_2_DMAC   ),
   .RRESP        (RRESP_2_DMAC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DMAC  ),
   .RREADY       (RREADY_DMAC  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master MAC
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID3_WID ),
    .RID_WIDTH(READCHID3_WID)
 )
MAC_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_MAC  ),
   .AWLEN       (AWLEN_MAC   ),
   .AWSIZE      (AWSIZE_MAC  ),
   .AWBURST     (AWBURST_MAC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_MAC ),
   .AWREADY     (AWREADY_2_MAC ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_MAC   ),
   .WDATA       (WDATA_MAC   ),
   .WSTRB       (WSTRB_MAC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_MAC  ),
   .WREADY      (WREADY_2_MAC  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_MAC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_MAC  ),
   .BREADY       (BREADY_MAC  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_MAC  ),
   .ARLEN        (ARLEN_MAC   ),
   .ARSIZE       (ARSIZE_MAC  ),
   .ARBURST      (ARBURST_MAC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_MAC ),
   .ARREADY      (ARREADY_2_MAC ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_MAC   ),
   .RDATA        (RDATA_2_MAC   ),
   .RRESP        (RRESP_2_MAC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_MAC  ),
   .RREADY       (RREADY_MAC  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master PCI
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID4_WID ),
    .RID_WIDTH(READCHID4_WID)
 )
PCI_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_PCI  ),
   .AWLEN       (AWLEN_PCI   ),
   .AWSIZE      (AWSIZE_PCI  ),
   .AWBURST     (AWBURST_PCI ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_PCI ),
   .AWREADY     (AWREADY_2_PCI ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_PCI   ),
   .WDATA       (WDATA_PCI   ),
   .WSTRB       (WSTRB_PCI   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_PCI  ),
   .WREADY      (WREADY_2_PCI  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_PCI   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_PCI  ),
   .BREADY       (BREADY_PCI  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_PCI  ),
   .ARLEN        (ARLEN_PCI   ),
   .ARSIZE       (ARSIZE_PCI  ),
   .ARBURST      (ARBURST_PCI ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_PCI ),
   .ARREADY      (ARREADY_2_PCI ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_PCI   ),
   .RDATA        (RDATA_2_PCI   ),
   .RRESP        (RRESP_2_PCI   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_PCI  ),
   .RREADY       (RREADY_PCI  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

// Protocal Checker for slave AHB0
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID0_WID ),
    .RID_WIDTH(RD_SLAVEID0_WID)
 )
AHB0_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_AHB0    ),
   .AWADDR      (AWADDR_2_AHB0  ),
   .AWLEN       (AWLEN_2_AHB0   ),
   .AWSIZE      (AWSIZE_2_AHB0  ),
   .AWBURST     (AWBURST_2_AHB0 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_AHB0 ),
   .AWREADY     (AWREADY_AHB0 ),

   // Write Channel
   .WID         (WID_2_AHB0     ),
   .WLAST       (WLAST_2_AHB0   ),
   .WDATA       (WDATA_2_AHB0   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_AHB0  ),
   .WREADY      (WREADY_AHB0  ),

   // Write Response Channel
   .BID          (BID_AHB0     ),
   .BRESP        (BRESP_AHB0   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_AHB0  ),
   .BREADY       (BREADY_2_AHB0  ),

   // Read Address Channel
   .ARID         (ARID_2_AHB0    ),
   .ARADDR       (ARADDR_2_AHB0  ),
   .ARLEN        (ARLEN_2_AHB0   ),
   .ARSIZE       (ARSIZE_2_AHB0  ),
   .ARBURST      (ARBURST_2_AHB0 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_AHB0 ),
   .ARREADY      (ARREADY_AHB0 ),

   // Read Channel
   .RID          (RID_AHB0     ),
   .RLAST        (RLAST_AHB0   ),
   .RDATA        (RDATA_AHB0   ),
   .RRESP        (RRESP_AHB0   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_AHB0  ),
   .RREADY       (RREADY_2_AHB0  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave AHB1
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID1_WID ),
    .RID_WIDTH(RD_SLAVEID1_WID)
 )
AHB1_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_AHB1    ),
   .AWADDR      (AWADDR_2_AHB1  ),
   .AWLEN       (AWLEN_2_AHB1   ),
   .AWSIZE      (AWSIZE_2_AHB1  ),
   .AWBURST     (AWBURST_2_AHB1 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_AHB1 ),
   .AWREADY     (AWREADY_AHB1 ),

   // Write Channel
   .WID         (WID_2_AHB1     ),
   .WLAST       (WLAST_2_AHB1   ),
   .WDATA       (WDATA_2_AHB1   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_AHB1  ),
   .WREADY      (WREADY_AHB1  ),

   // Write Response Channel
   .BID          (BID_AHB1     ),
   .BRESP        (BRESP_AHB1   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_AHB1  ),
   .BREADY       (BREADY_2_AHB1  ),

   // Read Address Channel
   .ARID         (ARID_2_AHB1    ),
   .ARADDR       (ARADDR_2_AHB1  ),
   .ARLEN        (ARLEN_2_AHB1   ),
   .ARSIZE       (ARSIZE_2_AHB1  ),
   .ARBURST      (ARBURST_2_AHB1 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_AHB1 ),
   .ARREADY      (ARREADY_AHB1 ),

   // Read Channel
   .RID          (RID_AHB1     ),
   .RLAST        (RLAST_AHB1   ),
   .RDATA        (RDATA_AHB1   ),
   .RRESP        (RRESP_AHB1   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_AHB1  ),
   .RREADY       (RREADY_2_AHB1  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave AHB2
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID2_WID ),
    .RID_WIDTH(RD_SLAVEID2_WID)
 )
AHB2_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_AHB2    ),
   .AWADDR      (AWADDR_2_AHB2  ),
   .AWLEN       (AWLEN_2_AHB2   ),
   .AWSIZE      (AWSIZE_2_AHB2  ),
   .AWBURST     (AWBURST_2_AHB2 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_AHB2 ),
   .AWREADY     (AWREADY_AHB2 ),

   // Write Channel
   .WID         (WID_2_AHB2     ),
   .WLAST       (WLAST_2_AHB2   ),
   .WDATA       (WDATA_2_AHB2   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_AHB2  ),
   .WREADY      (WREADY_AHB2  ),

   // Write Response Channel
   .BID          (BID_AHB2     ),
   .BRESP        (BRESP_AHB2   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_AHB2  ),
   .BREADY       (BREADY_2_AHB2  ),

   // Read Address Channel
   .ARID         (ARID_2_AHB2    ),
   .ARADDR       (ARADDR_2_AHB2  ),
   .ARLEN        (ARLEN_2_AHB2   ),
   .ARSIZE       (ARSIZE_2_AHB2  ),
   .ARBURST      (ARBURST_2_AHB2 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_AHB2 ),
   .ARREADY      (ARREADY_AHB2 ),

   // Read Channel
   .RID          (RID_AHB2     ),
   .RLAST        (RLAST_AHB2   ),
   .RDATA        (RDATA_AHB2   ),
   .RRESP        (RRESP_AHB2   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_AHB2  ),
   .RREADY       (RREADY_2_AHB2  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave DDR
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID3_WID ),
    .RID_WIDTH(RD_SLAVEID3_WID)
 )
DDR_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_DDR    ),
   .AWADDR      (AWADDR_2_DDR  ),
   .AWLEN       (AWLEN_2_DDR   ),
   .AWSIZE      (AWSIZE_2_DDR  ),
   .AWBURST     (AWBURST_2_DDR ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_DDR ),
   .AWREADY     (AWREADY_DDR ),

   // Write Channel
   .WID         (WID_2_DDR     ),
   .WLAST       (WLAST_2_DDR   ),
   .WDATA       (WDATA_2_DDR   ),
   .WSTRB       (WSTRB_2_DDR   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_DDR  ),
   .WREADY      (WREADY_DDR  ),

   // Write Response Channel
   .BID          (BID_DDR     ),
   .BRESP        (BRESP_DDR   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_DDR  ),
   .BREADY       (BREADY_2_DDR  ),

   // Read Address Channel
   .ARID         (ARID_2_DDR    ),
   .ARADDR       (ARADDR_2_DDR  ),
   .ARLEN        (ARLEN_2_DDR   ),
   .ARSIZE       (ARSIZE_2_DDR  ),
   .ARBURST      (ARBURST_2_DDR ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_DDR ),
   .ARREADY      (ARREADY_DDR ),

   // Read Channel
   .RID          (RID_DDR     ),
   .RLAST        (RLAST_DDR   ),
   .RDATA        (RDATA_DDR   ),
   .RRESP        (RRESP_DDR   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_DDR  ),
   .RREADY       (RREADY_2_DDR  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB0
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID4_WID ),
    .RID_WIDTH(RD_SLAVEID4_WID)
 )
APB0_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB0    ),
   .AWADDR      (AWADDR_2_APB0  ),
   .AWLEN       (AWLEN_2_APB0   ),
   .AWSIZE      (AWSIZE_2_APB0  ),
   .AWBURST     (AWBURST_2_APB0 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB0 ),
   .AWREADY     (AWREADY_APB0 ),

   // Write Channel
   .WID         (WID_2_APB0     ),
   .WLAST       (WLAST_2_APB0   ),
   .WDATA       (WDATA_2_APB0   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB0  ),
   .WREADY      (WREADY_APB0  ),

   // Write Response Channel
   .BID          (BID_APB0     ),
   .BRESP        (BRESP_APB0   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB0  ),
   .BREADY       (BREADY_2_APB0  ),

   // Read Address Channel
   .ARID         (ARID_2_APB0    ),
   .ARADDR       (ARADDR_2_APB0  ),
   .ARLEN        (ARLEN_2_APB0   ),
   .ARSIZE       (ARSIZE_2_APB0  ),
   .ARBURST      (ARBURST_2_APB0 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB0 ),
   .ARREADY      (ARREADY_APB0 ),

   // Read Channel
   .RID          (RID_APB0     ),
   .RLAST        (RLAST_APB0   ),
   .RDATA        (RDATA_APB0   ),
   .RRESP        (RRESP_APB0   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB0  ),
   .RREADY       (RREADY_2_APB0  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB1
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID5_WID ),
    .RID_WIDTH(RD_SLAVEID5_WID)
 )
APB1_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB1    ),
   .AWADDR      (AWADDR_2_APB1  ),
   .AWLEN       (AWLEN_2_APB1   ),
   .AWSIZE      (AWSIZE_2_APB1  ),
   .AWBURST     (AWBURST_2_APB1 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB1 ),
   .AWREADY     (AWREADY_APB1 ),

   // Write Channel
   .WID         (WID_2_APB1     ),
   .WLAST       (WLAST_2_APB1   ),
   .WDATA       (WDATA_2_APB1   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB1  ),
   .WREADY      (WREADY_APB1  ),

   // Write Response Channel
   .BID          (BID_APB1     ),
   .BRESP        (BRESP_APB1   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB1  ),
   .BREADY       (BREADY_2_APB1  ),

   // Read Address Channel
   .ARID         (ARID_2_APB1    ),
   .ARADDR       (ARADDR_2_APB1  ),
   .ARLEN        (ARLEN_2_APB1   ),
   .ARSIZE       (ARSIZE_2_APB1  ),
   .ARBURST      (ARBURST_2_APB1 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB1 ),
   .ARREADY      (ARREADY_APB1 ),

   // Read Channel
   .RID          (RID_APB1     ),
   .RLAST        (RLAST_APB1   ),
   .RDATA        (RDATA_APB1   ),
   .RRESP        (RRESP_APB1   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB1  ),
   .RREADY       (RREADY_2_APB1  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave SMC
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID6_WID ),
    .RID_WIDTH(RD_SLAVEID6_WID)
 )
SMC_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_SMC    ),
   .AWADDR      (AWADDR_2_SMC  ),
   .AWLEN       (AWLEN_2_SMC   ),
   .AWSIZE      (AWSIZE_2_SMC  ),
   .AWBURST     (AWBURST_2_SMC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_SMC ),
   .AWREADY     (AWREADY_SMC ),

   // Write Channel
   .WID         (WID_2_SMC     ),
   .WLAST       (WLAST_2_SMC   ),
   .WDATA       (WDATA_2_SMC   ),
   .WSTRB       (WSTRB_2_SMC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_SMC  ),
   .WREADY      (WREADY_SMC  ),

   // Write Response Channel
   .BID          (BID_SMC     ),
   .BRESP        (BRESP_SMC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_SMC  ),
   .BREADY       (BREADY_2_SMC  ),

   // Read Address Channel
   .ARID         (ARID_2_SMC    ),
   .ARADDR       (ARADDR_2_SMC  ),
   .ARLEN        (ARLEN_2_SMC   ),
   .ARSIZE       (ARSIZE_2_SMC  ),
   .ARBURST      (ARBURST_2_SMC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_SMC ),
   .ARREADY      (ARREADY_SMC ),

   // Read Channel
   .RID          (RID_SMC     ),
   .RLAST        (RLAST_SMC   ),
   .RDATA        (RDATA_SMC   ),
   .RRESP        (RRESP_SMC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_SMC  ),
   .RREADY       (RREADY_2_SMC  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave SSRAM
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID7_WID ),
    .RID_WIDTH(RD_SLAVEID7_WID)
 )
SSRAM_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_SSRAM    ),
   .AWADDR      (AWADDR_2_SSRAM  ),
   .AWLEN       (AWLEN_2_SSRAM   ),
   .AWSIZE      (AWSIZE_2_SSRAM  ),
   .AWBURST     (AWBURST_2_SSRAM ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_SSRAM ),
   .AWREADY     (AWREADY_SSRAM ),

   // Write Channel
   .WID         (WID_2_SSRAM     ),
   .WLAST       (WLAST_2_SSRAM   ),
   .WDATA       (WDATA_2_SSRAM   ),
   .WSTRB       (WSTRB_2_SSRAM   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_SSRAM  ),
   .WREADY      (WREADY_SSRAM  ),

   // Write Response Channel
   .BID          (BID_SSRAM     ),
   .BRESP        (BRESP_SSRAM   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_SSRAM  ),
   .BREADY       (BREADY_2_SSRAM  ),

   // Read Address Channel
   .ARID         (ARID_2_SSRAM    ),
   .ARADDR       (ARADDR_2_SSRAM  ),
   .ARLEN        (ARLEN_2_SSRAM   ),
   .ARSIZE       (ARSIZE_2_SSRAM  ),
   .ARBURST      (ARBURST_2_SSRAM ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_SSRAM ),
   .ARREADY      (ARREADY_SSRAM ),

   // Read Channel
   .RID          (RID_SSRAM     ),
   .RLAST        (RLAST_SSRAM   ),
   .RDATA        (RDATA_SSRAM   ),
   .RRESP        (RRESP_SSRAM   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_SSRAM  ),
   .RREADY       (RREADY_2_SSRAM  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave default
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID8_WID ),
    .RID_WIDTH(RD_SLAVEID8_WID)
 )
default_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_default    ),
   .AWADDR      (AWADDR_2_default  ),
   .AWLEN       (AWLEN_2_default   ),
   .AWSIZE      (AWSIZE_2_default  ),
   .AWBURST     (AWBURST_2_default ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_default ),
   .AWREADY     (AWREADY_default ),

   // Write Channel
   .WID         (WID_2_default     ),
   .WLAST       (WLAST_2_default   ),
   .WDATA       (WDATA_2_default   ),
   .WSTRB       (WSTRB_2_default   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_default  ),
   .WREADY      (WREADY_default  ),

   // Write Response Channel
   .BID          (BID_default     ),
   .BRESP        (BRESP_default   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_default  ),
   .BREADY       (BREADY_2_default  ),

   // Read Address Channel
   .ARID         (ARID_2_default    ),
   .ARADDR       (ARADDR_2_default  ),
   .ARLEN        (ARLEN_2_default   ),
   .ARSIZE       (ARSIZE_2_default  ),
   .ARBURST      (ARBURST_2_default ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_default ),
   .ARREADY      (ARREADY_default ),

   // Read Channel
   .RID          (RID_default     ),
   .RLAST        (RLAST_default   ),
   .RDATA        (RDATA_default   ),
   .RRESP        (RRESP_default   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_default  ),
   .RREADY       (RREADY_2_default  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

//Write Channel 
//_____________________________________________________________________

WriteChannel 

SBUS_WriteChannel(

    //_______________________________________________________________
    //For Master 0
    //Write address channel
//Disable_id_port
    .AWADDRm02si0  (AWADDR_ARMD  ),
    .AWLENm02si0   (AWLEN_ARMD   ),
    .AWSIZEm02si0  (AWSIZE_ARMD  ),
    .AWBURSTm02si0 (AWBURST_ARMD ),
    .AWLOCKm02si0  (AWLOCK_ARMD  ),
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm02si0 (AWVALID_ARMD ),
    .AWREADYsi02m0 (AWREADY_2_ARMD ),

    //Write data channel
//Disable_id_port
    .WDATAm02si0   (WDATA_ARMD   ),
    .WSTRBm02si0   (WSTRB_ARMD   ),
    .WLASTm02si0   (WLAST_ARMD   ),
    .WVALIDm02si0  (WVALID_ARMD  ),
    .WREADYsi02m0  (WREADY_2_ARMD  ),

    //Write response channel
//Disable_id_port
    .BRESPsi02m0   (BRESP_2_ARMD   ),
    .BVALIDsi02m0  (BVALID_2_ARMD  ),
    .BREADYm02si0  (BREADY_ARMD  ),
 
 
    //_______________________________________________________________
    //For Master 2
    //Write address channel
    .AWIDm22si2    (AWID_DMAC    ),
    .AWADDRm22si2  (AWADDR_DMAC  ),
    .AWLENm22si2   (AWLEN_DMAC   ),
    .AWSIZEm22si2  (AWSIZE_DMAC  ),
    .AWBURSTm22si2 (AWBURST_DMAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm22si2 (AWVALID_DMAC ),
    .AWREADYsi22m2 (AWREADY_2_DMAC ),

    //Write data channel
    .WIDm22si2     (WID_DMAC     ),
    .WDATAm22si2   (WDATA_DMAC   ),
    .WSTRBm22si2   (WSTRB_DMAC   ),
    .WLASTm22si2   (WLAST_DMAC   ),
    .WVALIDm22si2  (WVALID_DMAC  ),
    .WREADYsi22m2  (WREADY_2_DMAC  ),

    //Write response channel
    .BIDsi22m2     (BID_2_DMAC     ),
    .BRESPsi22m2   (BRESP_2_DMAC   ),
    .BVALIDsi22m2  (BVALID_2_DMAC  ),
    .BREADYm22si2  (BREADY_DMAC  ),
 
    //_______________________________________________________________
    //For Master 3
    //Write address channel
//Disable_id_port
    .AWADDRm32si3  (AWADDR_MAC  ),
    .AWLENm32si3   (AWLEN_MAC   ),
    .AWSIZEm32si3  (AWSIZE_MAC  ),
    .AWBURSTm32si3 (AWBURST_MAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm32si3 (AWVALID_MAC ),
    .AWREADYsi32m3 (AWREADY_2_MAC ),

    //Write data channel
//Disable_id_port
    .WDATAm32si3   (WDATA_MAC   ),
    .WSTRBm32si3   (WSTRB_MAC   ),
    .WLASTm32si3   (WLAST_MAC   ),
    .WVALIDm32si3  (WVALID_MAC  ),
    .WREADYsi32m3  (WREADY_2_MAC  ),

    //Write response channel
//Disable_id_port
    .BRESPsi32m3   (BRESP_2_MAC   ),
    .BVALIDsi32m3  (BVALID_2_MAC  ),
    .BREADYm32si3  (BREADY_MAC  ),
 
    //_______________________________________________________________
    //For Master 4
    //Write address channel
//Disable_id_port
    .AWADDRm42si4  (AWADDR_PCI  ),
    .AWLENm42si4   (AWLEN_PCI   ),
    .AWSIZEm42si4  (AWSIZE_PCI  ),
    .AWBURSTm42si4 (AWBURST_PCI ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm42si4 (AWVALID_PCI ),
    .AWREADYsi42m4 (AWREADY_2_PCI ),

    //Write data channel
//Disable_id_port
    .WDATAm42si4   (WDATA_PCI   ),
    .WSTRBm42si4   (WSTRB_PCI   ),
    .WLASTm42si4   (WLAST_PCI   ),
    .WVALIDm42si4  (WVALID_PCI  ),
    .WREADYsi42m4  (WREADY_2_PCI  ),

    //Write response channel
//Disable_id_port
    .BRESPsi42m4   (BRESP_2_PCI   ),
    .BVALIDsi42m4  (BVALID_2_PCI  ),
    .BREADYm42si4  (BREADY_PCI  ),
 

    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    .AWIDmi02s0    (AWID_2_AHB0    ),
    .AWADDRmi02s0  (AWADDR_2_AHB0  ),
    .AWLENmi02s0   (AWLEN_2_AHB0   ),
    .AWSIZEmi02s0  (AWSIZE_2_AHB0  ),
    .AWBURSTmi02s0 (AWBURST_2_AHB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi02s0 (AWVALID_2_AHB0 ),
    .AWREADYs02mi0 (AWREADY_AHB0 ),

    //Write data channel
    .WIDmi02s0     (WID_2_AHB0     ),
    .WDATAmi02s0   (WDATA_2_AHB0   ),
//Disable_WSTRB_port
    .WLASTmi02s0   (WLAST_2_AHB0   ),
    .WVALIDmi02s0  (WVALID_2_AHB0  ),
    .WREADYs02mi0  (WREADY_AHB0  ),

    //Write response channel
    .BIDs02mi0     (BID_AHB0     ),
    .BRESPs02mi0   (BRESP_AHB0   ),
    .BVALIDs02mi0  (BVALID_AHB0  ),
    .BREADYmi02s0  (BREADY_2_AHB0  ),
 
    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    .AWIDmi12s1    (AWID_2_AHB1    ),
    .AWADDRmi12s1  (AWADDR_2_AHB1  ),
    .AWLENmi12s1   (AWLEN_2_AHB1   ),
    .AWSIZEmi12s1  (AWSIZE_2_AHB1  ),
    .AWBURSTmi12s1 (AWBURST_2_AHB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi12s1 (AWVALID_2_AHB1 ),
    .AWREADYs12mi1 (AWREADY_AHB1 ),

    //Write data channel
    .WIDmi12s1     (WID_2_AHB1     ),
    .WDATAmi12s1   (WDATA_2_AHB1   ),
//Disable_WSTRB_port
    .WLASTmi12s1   (WLAST_2_AHB1   ),
    .WVALIDmi12s1  (WVALID_2_AHB1  ),
    .WREADYs12mi1  (WREADY_AHB1  ),

    //Write response channel
    .BIDs12mi1     (BID_AHB1     ),
    .BRESPs12mi1   (BRESP_AHB1   ),
    .BVALIDs12mi1  (BVALID_AHB1  ),
    .BREADYmi12s1  (BREADY_2_AHB1  ),
 
    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    .AWIDmi22s2    (AWID_2_AHB2    ),
    .AWADDRmi22s2  (AWADDR_2_AHB2  ),
    .AWLENmi22s2   (AWLEN_2_AHB2   ),
    .AWSIZEmi22s2  (AWSIZE_2_AHB2  ),
    .AWBURSTmi22s2 (AWBURST_2_AHB2 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi22s2 (AWVALID_2_AHB2 ),
    .AWREADYs22mi2 (AWREADY_AHB2 ),

    //Write data channel
    .WIDmi22s2     (WID_2_AHB2     ),
    .WDATAmi22s2   (WDATA_2_AHB2   ),
//Disable_WSTRB_port
    .WLASTmi22s2   (WLAST_2_AHB2   ),
    .WVALIDmi22s2  (WVALID_2_AHB2  ),
    .WREADYs22mi2  (WREADY_AHB2  ),

    //Write response channel
    .BIDs22mi2     (BID_AHB2     ),
    .BRESPs22mi2   (BRESP_AHB2   ),
    .BVALIDs22mi2  (BVALID_AHB2  ),
    .BREADYmi22s2  (BREADY_2_AHB2  ),
 
    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    .AWIDmi32s3    (AWID_2_DDR    ),
    .AWADDRmi32s3  (AWADDR_2_DDR  ),
    .AWLENmi32s3   (AWLEN_2_DDR   ),
    .AWSIZEmi32s3  (AWSIZE_2_DDR  ),
    .AWBURSTmi32s3 (AWBURST_2_DDR ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi32s3 (AWVALID_2_DDR ),
    .AWREADYs32mi3 (AWREADY_DDR ),

    //Write data channel
    .WIDmi32s3     (WID_2_DDR     ),
    .WDATAmi32s3   (WDATA_2_DDR   ),
    .WSTRBmi32s3   (WSTRB_2_DDR   ),
    .WLASTmi32s3   (WLAST_2_DDR   ),
    .WVALIDmi32s3  (WVALID_2_DDR  ),
    .WREADYs32mi3  (WREADY_DDR  ),

    //Write response channel
    .BIDs32mi3     (BID_DDR     ),
    .BRESPs32mi3   (BRESP_DDR   ),
    .BVALIDs32mi3  (BVALID_DDR  ),
    .BREADYmi32s3  (BREADY_2_DDR  ),
 
    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    .AWIDmi42s4    (AWID_2_APB0    ),
    .AWADDRmi42s4  (AWADDR_2_APB0  ),
    .AWLENmi42s4   (AWLEN_2_APB0   ),
    .AWSIZEmi42s4  (AWSIZE_2_APB0  ),
    .AWBURSTmi42s4 (AWBURST_2_APB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi42s4 (AWVALID_2_APB0 ),
    .AWREADYs42mi4 (AWREADY_APB0 ),

    //Write data channel
    .WIDmi42s4     (WID_2_APB0     ),
    .WDATAmi42s4   (WDATA_2_APB0   ),
//Disable_WSTRB_port
    .WLASTmi42s4   (WLAST_2_APB0   ),
    .WVALIDmi42s4  (WVALID_2_APB0  ),
    .WREADYs42mi4  (WREADY_APB0  ),

    //Write response channel
    .BIDs42mi4     (BID_APB0     ),
    .BRESPs42mi4   (BRESP_APB0   ),
    .BVALIDs42mi4  (BVALID_APB0  ),
    .BREADYmi42s4  (BREADY_2_APB0  ),
 
    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    .AWIDmi52s5    (AWID_2_APB1    ),
    .AWADDRmi52s5  (AWADDR_2_APB1  ),
    .AWLENmi52s5   (AWLEN_2_APB1   ),
    .AWSIZEmi52s5  (AWSIZE_2_APB1  ),
    .AWBURSTmi52s5 (AWBURST_2_APB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi52s5 (AWVALID_2_APB1 ),
    .AWREADYs52mi5 (AWREADY_APB1 ),

    //Write data channel
    .WIDmi52s5     (WID_2_APB1     ),
    .WDATAmi52s5   (WDATA_2_APB1   ),
//Disable_WSTRB_port
    .WLASTmi52s5   (WLAST_2_APB1   ),
    .WVALIDmi52s5  (WVALID_2_APB1  ),
    .WREADYs52mi5  (WREADY_APB1  ),

    //Write response channel
    .BIDs52mi5     (BID_APB1     ),
    .BRESPs52mi5   (BRESP_APB1   ),
    .BVALIDs52mi5  (BVALID_APB1  ),
    .BREADYmi52s5  (BREADY_2_APB1  ),
 
    //_______________________________________________________________
    //For Slave 6
    //Write address channel
    .AWIDmi62s6    (AWID_2_SMC    ),
    .AWADDRmi62s6  (AWADDR_2_SMC  ),
    .AWLENmi62s6   (AWLEN_2_SMC   ),
    .AWSIZEmi62s6  (AWSIZE_2_SMC  ),
    .AWBURSTmi62s6 (AWBURST_2_SMC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi62s6 (AWVALID_2_SMC ),
    .AWREADYs62mi6 (AWREADY_SMC ),

    //Write data channel
    .WIDmi62s6     (WID_2_SMC     ),
    .WDATAmi62s6   (WDATA_2_SMC   ),
    .WSTRBmi62s6   (WSTRB_2_SMC   ),
    .WLASTmi62s6   (WLAST_2_SMC   ),
    .WVALIDmi62s6  (WVALID_2_SMC  ),
    .WREADYs62mi6  (WREADY_SMC  ),

    //Write response channel
    .BIDs62mi6     (BID_SMC     ),
    .BRESPs62mi6   (BRESP_SMC   ),
    .BVALIDs62mi6  (BVALID_SMC  ),
    .BREADYmi62s6  (BREADY_2_SMC  ),
 
    //_______________________________________________________________
    //For Slave 7
    //Write address channel
    .AWIDmi72s7    (AWID_2_SSRAM    ),
    .AWADDRmi72s7  (AWADDR_2_SSRAM  ),
    .AWLENmi72s7   (AWLEN_2_SSRAM   ),
    .AWSIZEmi72s7  (AWSIZE_2_SSRAM  ),
    .AWBURSTmi72s7 (AWBURST_2_SSRAM ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi72s7 (AWVALID_2_SSRAM ),
    .AWREADYs72mi7 (AWREADY_SSRAM ),

    //Write data channel
    .WIDmi72s7     (WID_2_SSRAM     ),
    .WDATAmi72s7   (WDATA_2_SSRAM   ),
    .WSTRBmi72s7   (WSTRB_2_SSRAM   ),
    .WLASTmi72s7   (WLAST_2_SSRAM   ),
    .WVALIDmi72s7  (WVALID_2_SSRAM  ),
    .WREADYs72mi7  (WREADY_SSRAM  ),

    //Write response channel
    .BIDs72mi7     (BID_SSRAM     ),
    .BRESPs72mi7   (BRESP_SSRAM   ),
    .BVALIDs72mi7  (BVALID_SSRAM  ),
    .BREADYmi72s7  (BREADY_2_SSRAM  ),
 
    //_______________________________________________________________
    //For Slave 8
    //Write address channel
    .AWIDmi82s8    (AWID_2_default    ),
    .AWADDRmi82s8  (AWADDR_2_default  ),
    .AWLENmi82s8   (AWLEN_2_default   ),
    .AWSIZEmi82s8  (AWSIZE_2_default  ),
    .AWBURSTmi82s8 (AWBURST_2_default ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi82s8 (AWVALID_2_default ),
    .AWREADYs82mi8 (AWREADY_default ),

    //Write data channel
    .WIDmi82s8     (WID_2_default     ),
    .WDATAmi82s8   (WDATA_2_default   ),
    .WSTRBmi82s8   (WSTRB_2_default   ),
    .WLASTmi82s8   (WLAST_2_default   ),
    .WVALIDmi82s8  (WVALID_2_default  ),
    .WREADYs82mi8  (WREADY_default  ),

    //Write response channel
    .BIDs82mi8     (BID_default     ),
    .BRESPs82mi8   (BRESP_default   ),
    .BVALIDs82mi8  (BVALID_default  ),
    .BREADYmi82s8  (BREADY_2_default  ),
 

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2wrmi0          (Lock2wrmi0      ),
    .Lock2rdmi0          (Lock2rdmi0      ),
    .UnLock2wrmi0        (UnLock2wrmi0    ),
    .UnLock2rdmi0        (UnLock2rdmi0    ),
    .ARVALIDmi02s0      (ARVALID_2_AHB0   ),
    .LockPort2wrmi0      (LockPort2wrmi0  ),
    .ReadIntEmptyWrmi02Rdmi0     (ReadIntEmptyWrmi02Rdmi0     ),
    .DataCntEmptyRdmi02Wrmi0     (DataCntEmptyRdmi02Wrmi0     ),    
    .CtlDataWrite2Lock0          (CtlDataWrite2Lock0          ),
    
    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2wrmi1          (Lock2wrmi1      ),
    .Lock2rdmi1          (Lock2rdmi1      ),
    .UnLock2wrmi1        (UnLock2wrmi1    ),
    .UnLock2rdmi1        (UnLock2rdmi1    ),
    .ARVALIDmi12s1      (ARVALID_2_AHB1   ),
    .LockPort2wrmi1      (LockPort2wrmi1  ),
    .ReadIntEmptyWrmi12Rdmi1     (ReadIntEmptyWrmi12Rdmi1     ),
    .DataCntEmptyRdmi12Wrmi1     (DataCntEmptyRdmi12Wrmi1     ),    
    .CtlDataWrite2Lock1          (CtlDataWrite2Lock1          ),
    
    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2wrmi2          (Lock2wrmi2      ),
    .Lock2rdmi2          (Lock2rdmi2      ),
    .UnLock2wrmi2        (UnLock2wrmi2    ),
    .UnLock2rdmi2        (UnLock2rdmi2    ),
    .ARVALIDmi22s2      (ARVALID_2_AHB2   ),
    .LockPort2wrmi2      (LockPort2wrmi2  ),
    .ReadIntEmptyWrmi22Rdmi2     (ReadIntEmptyWrmi22Rdmi2     ),
    .DataCntEmptyRdmi22Wrmi2     (DataCntEmptyRdmi22Wrmi2     ),    
    .CtlDataWrite2Lock2          (CtlDataWrite2Lock2          ),
    
    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2wrmi3          (Lock2wrmi3      ),
    .Lock2rdmi3          (Lock2rdmi3      ),
    .UnLock2wrmi3        (UnLock2wrmi3    ),
    .UnLock2rdmi3        (UnLock2rdmi3    ),
    .ARVALIDmi32s3      (ARVALID_2_DDR   ),
    .LockPort2wrmi3      (LockPort2wrmi3  ),
    .ReadIntEmptyWrmi32Rdmi3     (ReadIntEmptyWrmi32Rdmi3     ),
    .DataCntEmptyRdmi32Wrmi3     (DataCntEmptyRdmi32Wrmi3     ),    
    .CtlDataWrite2Lock3          (CtlDataWrite2Lock3          ),
    
    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2wrmi4          (Lock2wrmi4      ),
    .Lock2rdmi4          (Lock2rdmi4      ),
    .UnLock2wrmi4        (UnLock2wrmi4    ),
    .UnLock2rdmi4        (UnLock2rdmi4    ),
    .ARVALIDmi42s4      (ARVALID_2_APB0   ),
    .LockPort2wrmi4      (LockPort2wrmi4  ),
    .ReadIntEmptyWrmi42Rdmi4     (ReadIntEmptyWrmi42Rdmi4     ),
    .DataCntEmptyRdmi42Wrmi4     (DataCntEmptyRdmi42Wrmi4     ),    
    .CtlDataWrite2Lock4          (CtlDataWrite2Lock4          ),
    
    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2wrmi5          (Lock2wrmi5      ),
    .Lock2rdmi5          (Lock2rdmi5      ),
    .UnLock2wrmi5        (UnLock2wrmi5    ),
    .UnLock2rdmi5        (UnLock2rdmi5    ),
    .ARVALIDmi52s5      (ARVALID_2_APB1   ),
    .LockPort2wrmi5      (LockPort2wrmi5  ),
    .ReadIntEmptyWrmi52Rdmi5     (ReadIntEmptyWrmi52Rdmi5     ),
    .DataCntEmptyRdmi52Wrmi5     (DataCntEmptyRdmi52Wrmi5     ),    
    .CtlDataWrite2Lock5          (CtlDataWrite2Lock5          ),
    
    //_______________________________________________________________
    //For Slave 6 (lock control signal)

    .Lock2wrmi6          (Lock2wrmi6      ),
    .Lock2rdmi6          (Lock2rdmi6      ),
    .UnLock2wrmi6        (UnLock2wrmi6    ),
    .UnLock2rdmi6        (UnLock2rdmi6    ),
    .ARVALIDmi62s6      (ARVALID_2_SMC   ),
    .LockPort2wrmi6      (LockPort2wrmi6  ),
    .ReadIntEmptyWrmi62Rdmi6     (ReadIntEmptyWrmi62Rdmi6     ),
    .DataCntEmptyRdmi62Wrmi6     (DataCntEmptyRdmi62Wrmi6     ),    
    .CtlDataWrite2Lock6          (CtlDataWrite2Lock6          ),
    
    //_______________________________________________________________
    //For Slave 7 (lock control signal)

    .Lock2wrmi7          (Lock2wrmi7      ),
    .Lock2rdmi7          (Lock2rdmi7      ),
    .UnLock2wrmi7        (UnLock2wrmi7    ),
    .UnLock2rdmi7        (UnLock2rdmi7    ),
    .ARVALIDmi72s7      (ARVALID_2_SSRAM   ),
    .LockPort2wrmi7      (LockPort2wrmi7  ),
    .ReadIntEmptyWrmi72Rdmi7     (ReadIntEmptyWrmi72Rdmi7     ),
    .DataCntEmptyRdmi72Wrmi7     (DataCntEmptyRdmi72Wrmi7     ),    
    .CtlDataWrite2Lock7          (CtlDataWrite2Lock7          ),
    
    //_______________________________________________________________
    //For Slave 8 (lock control signal)

    .Lock2wrmi8          (Lock2wrmi8      ),
    .Lock2rdmi8          (Lock2rdmi8      ),
    .UnLock2wrmi8        (UnLock2wrmi8    ),
    .UnLock2rdmi8        (UnLock2rdmi8    ),
    .ARVALIDmi82s8      (ARVALID_2_default   ),
    .LockPort2wrmi8      (LockPort2wrmi8  ),
    .ReadIntEmptyWrmi82Rdmi8     (ReadIntEmptyWrmi82Rdmi8     ),
    .DataCntEmptyRdmi82Wrmi8     (DataCntEmptyRdmi82Wrmi8     ),    
    .CtlDataWrite2Lock8          (CtlDataWrite2Lock8          ),
    
    
    .SelMAP1 (SelMAP1),
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);


//Read Channel 
//_____________________________________________________________________

ReadChannel 
SBUS_ReadChannel (

    //_______________________________________________________________
    //For Master 0
    //Read address channel
//Disable_id_port
    .ARADDRm02si0  (ARADDR_ARMD  ),
    .ARLENm02si0   (ARLEN_ARMD   ),
    .ARSIZEm02si0  (ARSIZE_ARMD  ),
    .ARBURSTm02si0 (ARBURST_ARMD ),
    .ARLOCKm02si0  (ARLOCK_ARMD  ),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm02si0 (ARVALID_ARMD ),
    .ARREADYsi02m0 (ARREADY_2_ARMD ),

    //Read data channel
//Disable_id_port
    .RRESPsi02m0   (RRESP_2_ARMD   ),
    .RDATAsi02m0   (RDATA_2_ARMD   ),
    .RLASTsi02m0   (RLAST_2_ARMD   ),
    .RVALIDsi02m0  (RVALID_2_ARMD  ),
    .RREADYm02si0  (RREADY_ARMD  ),
 
    //_______________________________________________________________
    //For Master 1
    //Read address channel
//Disable_id_port
    .ARADDRm12si1  (ARADDR_ARMI  ),
    .ARLENm12si1   (ARLEN_ARMI   ),
    .ARSIZEm12si1  (ARSIZE_ARMI  ),
    .ARBURSTm12si1 (ARBURST_ARMI ),
    .ARLOCKm12si1  (ARLOCK_ARMI  ),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm12si1 (ARVALID_ARMI ),
    .ARREADYsi12m1 (ARREADY_2_ARMI ),

    //Read data channel
//Disable_id_port
    .RRESPsi12m1   (RRESP_2_ARMI   ),
    .RDATAsi12m1   (RDATA_2_ARMI   ),
    .RLASTsi12m1   (RLAST_2_ARMI   ),
    .RVALIDsi12m1  (RVALID_2_ARMI  ),
    .RREADYm12si1  (RREADY_ARMI  ),
 
    //_______________________________________________________________
    //For Master 2
    //Read address channel
    .ARIDm22si2    (ARID_DMAC    ),
    .ARADDRm22si2  (ARADDR_DMAC  ),
    .ARLENm22si2   (ARLEN_DMAC   ),
    .ARSIZEm22si2  (ARSIZE_DMAC  ),
    .ARBURSTm22si2 (ARBURST_DMAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm22si2 (ARVALID_DMAC ),
    .ARREADYsi22m2 (ARREADY_2_DMAC ),

    //Read data channel
    .RIDsi22m2     (RID_2_DMAC     ),
    .RRESPsi22m2   (RRESP_2_DMAC   ),
    .RDATAsi22m2   (RDATA_2_DMAC   ),
    .RLASTsi22m2   (RLAST_2_DMAC   ),
    .RVALIDsi22m2  (RVALID_2_DMAC  ),
    .RREADYm22si2  (RREADY_DMAC  ),
 
    //_______________________________________________________________
    //For Master 3
    //Read address channel
//Disable_id_port
    .ARADDRm32si3  (ARADDR_MAC  ),
    .ARLENm32si3   (ARLEN_MAC   ),
    .ARSIZEm32si3  (ARSIZE_MAC  ),
    .ARBURSTm32si3 (ARBURST_MAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm32si3 (ARVALID_MAC ),
    .ARREADYsi32m3 (ARREADY_2_MAC ),

    //Read data channel
//Disable_id_port
    .RRESPsi32m3   (RRESP_2_MAC   ),
    .RDATAsi32m3   (RDATA_2_MAC   ),
    .RLASTsi32m3   (RLAST_2_MAC   ),
    .RVALIDsi32m3  (RVALID_2_MAC  ),
    .RREADYm32si3  (RREADY_MAC  ),
 
    //_______________________________________________________________
    //For Master 4
    //Read address channel
//Disable_id_port
    .ARADDRm42si4  (ARADDR_PCI  ),
    .ARLENm42si4   (ARLEN_PCI   ),
    .ARSIZEm42si4  (ARSIZE_PCI  ),
    .ARBURSTm42si4 (ARBURST_PCI ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm42si4 (ARVALID_PCI ),
    .ARREADYsi42m4 (ARREADY_2_PCI ),

    //Read data channel
//Disable_id_port
    .RRESPsi42m4   (RRESP_2_PCI   ),
    .RDATAsi42m4   (RDATA_2_PCI   ),
    .RLASTsi42m4   (RLAST_2_PCI   ),
    .RVALIDsi42m4  (RVALID_2_PCI  ),
    .RREADYm42si4  (RREADY_PCI  ),
 

    //_______________________________________________________________
    //For Slave 0
    //Read address channel
    .ARIDmi02s0    (ARID_2_AHB0    ),
    .ARADDRmi02s0  (ARADDR_2_AHB0  ),
    .ARLENmi02s0   (ARLEN_2_AHB0   ),
    .ARSIZEmi02s0  (ARSIZE_2_AHB0  ),
    .ARBURSTmi02s0 (ARBURST_2_AHB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi02s0 (ARVALID_2_AHB0 ),
    .ARREADYs02mi0 (ARREADY_AHB0 ),

    //Read data channel
    .RIDs02mi0     (RID_AHB0     ),
    .RRESPs02mi0   (RRESP_AHB0   ),
    .RDATAs02mi0   (RDATA_AHB0   ),
    .RLASTs02mi0   (RLAST_AHB0   ),
    .RVALIDs02mi0  (RVALID_AHB0  ),
    .RREADYmi02s0  (RREADY_2_AHB0  ),
 
    //_______________________________________________________________
    //For Slave 1
    //Read address channel
    .ARIDmi12s1    (ARID_2_AHB1    ),
    .ARADDRmi12s1  (ARADDR_2_AHB1  ),
    .ARLENmi12s1   (ARLEN_2_AHB1   ),
    .ARSIZEmi12s1  (ARSIZE_2_AHB1  ),
    .ARBURSTmi12s1 (ARBURST_2_AHB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi12s1 (ARVALID_2_AHB1 ),
    .ARREADYs12mi1 (ARREADY_AHB1 ),

    //Read data channel
    .RIDs12mi1     (RID_AHB1     ),
    .RRESPs12mi1   (RRESP_AHB1   ),
    .RDATAs12mi1   (RDATA_AHB1   ),
    .RLASTs12mi1   (RLAST_AHB1   ),
    .RVALIDs12mi1  (RVALID_AHB1  ),
    .RREADYmi12s1  (RREADY_2_AHB1  ),
 
    //_______________________________________________________________
    //For Slave 2
    //Read address channel
    .ARIDmi22s2    (ARID_2_AHB2    ),
    .ARADDRmi22s2  (ARADDR_2_AHB2  ),
    .ARLENmi22s2   (ARLEN_2_AHB2   ),
    .ARSIZEmi22s2  (ARSIZE_2_AHB2  ),
    .ARBURSTmi22s2 (ARBURST_2_AHB2 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi22s2 (ARVALID_2_AHB2 ),
    .ARREADYs22mi2 (ARREADY_AHB2 ),

    //Read data channel
    .RIDs22mi2     (RID_AHB2     ),
    .RRESPs22mi2   (RRESP_AHB2   ),
    .RDATAs22mi2   (RDATA_AHB2   ),
    .RLASTs22mi2   (RLAST_AHB2   ),
    .RVALIDs22mi2  (RVALID_AHB2  ),
    .RREADYmi22s2  (RREADY_2_AHB2  ),
 
    //_______________________________________________________________
    //For Slave 3
    //Read address channel
    .ARIDmi32s3    (ARID_2_DDR    ),
    .ARADDRmi32s3  (ARADDR_2_DDR  ),
    .ARLENmi32s3   (ARLEN_2_DDR   ),
    .ARSIZEmi32s3  (ARSIZE_2_DDR  ),
    .ARBURSTmi32s3 (ARBURST_2_DDR ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi32s3 (ARVALID_2_DDR ),
    .ARREADYs32mi3 (ARREADY_DDR ),

    //Read data channel
    .RIDs32mi3     (RID_DDR     ),
    .RRESPs32mi3   (RRESP_DDR   ),
    .RDATAs32mi3   (RDATA_DDR   ),
    .RLASTs32mi3   (RLAST_DDR   ),
    .RVALIDs32mi3  (RVALID_DDR  ),
    .RREADYmi32s3  (RREADY_2_DDR  ),
 
    //_______________________________________________________________
    //For Slave 4
    //Read address channel
    .ARIDmi42s4    (ARID_2_APB0    ),
    .ARADDRmi42s4  (ARADDR_2_APB0  ),
    .ARLENmi42s4   (ARLEN_2_APB0   ),
    .ARSIZEmi42s4  (ARSIZE_2_APB0  ),
    .ARBURSTmi42s4 (ARBURST_2_APB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi42s4 (ARVALID_2_APB0 ),
    .ARREADYs42mi4 (ARREADY_APB0 ),

    //Read data channel
    .RIDs42mi4     (RID_APB0     ),
    .RRESPs42mi4   (RRESP_APB0   ),
    .RDATAs42mi4   (RDATA_APB0   ),
    .RLASTs42mi4   (RLAST_APB0   ),
    .RVALIDs42mi4  (RVALID_APB0  ),
    .RREADYmi42s4  (RREADY_2_APB0  ),
 
    //_______________________________________________________________
    //For Slave 5
    //Read address channel
    .ARIDmi52s5    (ARID_2_APB1    ),
    .ARADDRmi52s5  (ARADDR_2_APB1  ),
    .ARLENmi52s5   (ARLEN_2_APB1   ),
    .ARSIZEmi52s5  (ARSIZE_2_APB1  ),
    .ARBURSTmi52s5 (ARBURST_2_APB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi52s5 (ARVALID_2_APB1 ),
    .ARREADYs52mi5 (ARREADY_APB1 ),

    //Read data channel
    .RIDs52mi5     (RID_APB1     ),
    .RRESPs52mi5   (RRESP_APB1   ),
    .RDATAs52mi5   (RDATA_APB1   ),
    .RLASTs52mi5   (RLAST_APB1   ),
    .RVALIDs52mi5  (RVALID_APB1  ),
    .RREADYmi52s5  (RREADY_2_APB1  ),
 
    //_______________________________________________________________
    //For Slave 6
    //Read address channel
    .ARIDmi62s6    (ARID_2_SMC    ),
    .ARADDRmi62s6  (ARADDR_2_SMC  ),
    .ARLENmi62s6   (ARLEN_2_SMC   ),
    .ARSIZEmi62s6  (ARSIZE_2_SMC  ),
    .ARBURSTmi62s6 (ARBURST_2_SMC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi62s6 (ARVALID_2_SMC ),
    .ARREADYs62mi6 (ARREADY_SMC ),

    //Read data channel
    .RIDs62mi6     (RID_SMC     ),
    .RRESPs62mi6   (RRESP_SMC   ),
    .RDATAs62mi6   (RDATA_SMC   ),
    .RLASTs62mi6   (RLAST_SMC   ),
    .RVALIDs62mi6  (RVALID_SMC  ),
    .RREADYmi62s6  (RREADY_2_SMC  ),
 
    //_______________________________________________________________
    //For Slave 7
    //Read address channel
    .ARIDmi72s7    (ARID_2_SSRAM    ),
    .ARADDRmi72s7  (ARADDR_2_SSRAM  ),
    .ARLENmi72s7   (ARLEN_2_SSRAM   ),
    .ARSIZEmi72s7  (ARSIZE_2_SSRAM  ),
    .ARBURSTmi72s7 (ARBURST_2_SSRAM ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi72s7 (ARVALID_2_SSRAM ),
    .ARREADYs72mi7 (ARREADY_SSRAM ),

    //Read data channel
    .RIDs72mi7     (RID_SSRAM     ),
    .RRESPs72mi7   (RRESP_SSRAM   ),
    .RDATAs72mi7   (RDATA_SSRAM   ),
    .RLASTs72mi7   (RLAST_SSRAM   ),
    .RVALIDs72mi7  (RVALID_SSRAM  ),
    .RREADYmi72s7  (RREADY_2_SSRAM  ),
 
    //_______________________________________________________________
    //For Slave 8
    //Read address channel
    .ARIDmi82s8    (ARID_2_default    ),
    .ARADDRmi82s8  (ARADDR_2_default  ),
    .ARLENmi82s8   (ARLEN_2_default   ),
    .ARSIZEmi82s8  (ARSIZE_2_default  ),
    .ARBURSTmi82s8 (ARBURST_2_default ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi82s8 (ARVALID_2_default ),
    .ARREADYs82mi8 (ARREADY_default ),

    //Read data channel
    .RIDs82mi8     (RID_default     ),
    .RRESPs82mi8   (RRESP_default   ),
    .RDATAs82mi8   (RDATA_default   ),
    .RLASTs82mi8   (RLAST_default   ),
    .RVALIDs82mi8  (RVALID_default  ),
    .RREADYmi82s8  (RREADY_2_default  ),
 

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2rdmi0          (Lock2rdmi0          ),
    .Lock2wrmi0          (Lock2wrmi0          ),
    .UnLock2rdmi0        (UnLock2rdmi0        ),
    .UnLock2wrmi0        (UnLock2wrmi0        ),
    .AWVALIDmi02s0      (AWVALID_2_AHB0  ),
    .LockPort2rdmi0      (LockPort2rdmi0      ),
    .ReadIntEmptyWrmi02Rdmi0    (ReadIntEmptyWrmi02Rdmi0    ),
    .DataCntEmptyRdmi02Wrmi0    (DataCntEmptyRdmi02Wrmi0    ),
    .CtlDataRead2Lock0           (CtlDataRead2Lock0           ),

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2rdmi1          (Lock2rdmi1          ),
    .Lock2wrmi1          (Lock2wrmi1          ),
    .UnLock2rdmi1        (UnLock2rdmi1        ),
    .UnLock2wrmi1        (UnLock2wrmi1        ),
    .AWVALIDmi12s1      (AWVALID_2_AHB1  ),
    .LockPort2rdmi1      (LockPort2rdmi1      ),
    .ReadIntEmptyWrmi12Rdmi1    (ReadIntEmptyWrmi12Rdmi1    ),
    .DataCntEmptyRdmi12Wrmi1    (DataCntEmptyRdmi12Wrmi1    ),
    .CtlDataRead2Lock1           (CtlDataRead2Lock1           ),

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2rdmi2          (Lock2rdmi2          ),
    .Lock2wrmi2          (Lock2wrmi2          ),
    .UnLock2rdmi2        (UnLock2rdmi2        ),
    .UnLock2wrmi2        (UnLock2wrmi2        ),
    .AWVALIDmi22s2      (AWVALID_2_AHB2  ),
    .LockPort2rdmi2      (LockPort2rdmi2      ),
    .ReadIntEmptyWrmi22Rdmi2    (ReadIntEmptyWrmi22Rdmi2    ),
    .DataCntEmptyRdmi22Wrmi2    (DataCntEmptyRdmi22Wrmi2    ),
    .CtlDataRead2Lock2           (CtlDataRead2Lock2           ),

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2rdmi3          (Lock2rdmi3          ),
    .Lock2wrmi3          (Lock2wrmi3          ),
    .UnLock2rdmi3        (UnLock2rdmi3        ),
    .UnLock2wrmi3        (UnLock2wrmi3        ),
    .AWVALIDmi32s3      (AWVALID_2_DDR  ),
    .LockPort2rdmi3      (LockPort2rdmi3      ),
    .ReadIntEmptyWrmi32Rdmi3    (ReadIntEmptyWrmi32Rdmi3    ),
    .DataCntEmptyRdmi32Wrmi3    (DataCntEmptyRdmi32Wrmi3    ),
    .CtlDataRead2Lock3           (CtlDataRead2Lock3           ),

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2rdmi4          (Lock2rdmi4          ),
    .Lock2wrmi4          (Lock2wrmi4          ),
    .UnLock2rdmi4        (UnLock2rdmi4        ),
    .UnLock2wrmi4        (UnLock2wrmi4        ),
    .AWVALIDmi42s4      (AWVALID_2_APB0  ),
    .LockPort2rdmi4      (LockPort2rdmi4      ),
    .ReadIntEmptyWrmi42Rdmi4    (ReadIntEmptyWrmi42Rdmi4    ),
    .DataCntEmptyRdmi42Wrmi4    (DataCntEmptyRdmi42Wrmi4    ),
    .CtlDataRead2Lock4           (CtlDataRead2Lock4           ),

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2rdmi5          (Lock2rdmi5          ),
    .Lock2wrmi5          (Lock2wrmi5          ),
    .UnLock2rdmi5        (UnLock2rdmi5        ),
    .UnLock2wrmi5        (UnLock2wrmi5        ),
    .AWVALIDmi52s5      (AWVALID_2_APB1  ),
    .LockPort2rdmi5      (LockPort2rdmi5      ),
    .ReadIntEmptyWrmi52Rdmi5    (ReadIntEmptyWrmi52Rdmi5    ),
    .DataCntEmptyRdmi52Wrmi5    (DataCntEmptyRdmi52Wrmi5    ),
    .CtlDataRead2Lock5           (CtlDataRead2Lock5           ),

    //_______________________________________________________________
    //For Slave 6 (lock control signal)

    .Lock2rdmi6          (Lock2rdmi6          ),
    .Lock2wrmi6          (Lock2wrmi6          ),
    .UnLock2rdmi6        (UnLock2rdmi6        ),
    .UnLock2wrmi6        (UnLock2wrmi6        ),
    .AWVALIDmi62s6      (AWVALID_2_SMC  ),
    .LockPort2rdmi6      (LockPort2rdmi6      ),
    .ReadIntEmptyWrmi62Rdmi6    (ReadIntEmptyWrmi62Rdmi6    ),
    .DataCntEmptyRdmi62Wrmi6    (DataCntEmptyRdmi62Wrmi6    ),
    .CtlDataRead2Lock6           (CtlDataRead2Lock6           ),

    //_______________________________________________________________
    //For Slave 7 (lock control signal)

    .Lock2rdmi7          (Lock2rdmi7          ),
    .Lock2wrmi7          (Lock2wrmi7          ),
    .UnLock2rdmi7        (UnLock2rdmi7        ),
    .UnLock2wrmi7        (UnLock2wrmi7        ),
    .AWVALIDmi72s7      (AWVALID_2_SSRAM  ),
    .LockPort2rdmi7      (LockPort2rdmi7      ),
    .ReadIntEmptyWrmi72Rdmi7    (ReadIntEmptyWrmi72Rdmi7    ),
    .DataCntEmptyRdmi72Wrmi7    (DataCntEmptyRdmi72Wrmi7    ),
    .CtlDataRead2Lock7           (CtlDataRead2Lock7           ),

    //_______________________________________________________________
    //For Slave 8 (lock control signal)

    .Lock2rdmi8          (Lock2rdmi8          ),
    .Lock2wrmi8          (Lock2wrmi8          ),
    .UnLock2rdmi8        (UnLock2rdmi8        ),
    .UnLock2wrmi8        (UnLock2wrmi8        ),
    .AWVALIDmi82s8      (AWVALID_2_default  ),
    .LockPort2rdmi8      (LockPort2rdmi8      ),
    .ReadIntEmptyWrmi82Rdmi8    (ReadIntEmptyWrmi82Rdmi8    ),
    .DataCntEmptyRdmi82Wrmi8    (DataCntEmptyRdmi82Wrmi8    ),
    .CtlDataRead2Lock8           (CtlDataRead2Lock8           ),


    .SelMAP1 (SelMAP1),
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

//assign  LockPort2wrmi0 = CtlDataRead2Lock0; 
//assign  LockPort2rdmi0 = CtlDataWrite2Lock0;

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

//assign  LockPort2wrmi1 = CtlDataRead2Lock1; 
//assign  LockPort2rdmi1 = CtlDataWrite2Lock1;

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

//assign  LockPort2wrmi2 = CtlDataRead2Lock2; 
//assign  LockPort2rdmi2 = CtlDataWrite2Lock2;

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

//assign  LockPort2wrmi3 = CtlDataRead2Lock3; 
//assign  LockPort2rdmi3 = CtlDataWrite2Lock3;

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

//assign  LockPort2wrmi4 = CtlDataRead2Lock4; 
//assign  LockPort2rdmi4 = CtlDataWrite2Lock4;

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

//assign  LockPort2wrmi5 = CtlDataRead2Lock5; 
//assign  LockPort2rdmi5 = CtlDataWrite2Lock5;

    //_______________________________________________________________
    //For Slave 6 (lock control signal)

//assign  LockPort2wrmi6 = CtlDataRead2Lock6; 
//assign  LockPort2rdmi6 = CtlDataWrite2Lock6;

    //_______________________________________________________________
    //For Slave 7 (lock control signal)

//assign  LockPort2wrmi7 = CtlDataRead2Lock7; 
//assign  LockPort2rdmi7 = CtlDataWrite2Lock7;

    //_______________________________________________________________
    //For Slave 8 (lock control signal)

//assign  LockPort2wrmi8 = CtlDataRead2Lock8; 
//assign  LockPort2rdmi8 = CtlDataWrite2Lock8;


//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataRead2Lock0 or
         LockPort2wrmi0
        )
begin
    case(CtlDataRead2Lock0)
        1'd0:  LockPort2wrmi0 = 2'd0;
        1'd1:  LockPort2wrmi0 = 2'd1;
        default:  LockPort2wrmi0 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataRead2Lock1 or
         LockPort2wrmi1
        )
begin
    case(CtlDataRead2Lock1)
        1'd0:  LockPort2wrmi1 = 2'd0;
        1'd1:  LockPort2wrmi1 = 2'd1;
        default:  LockPort2wrmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataRead2Lock2 or
         LockPort2wrmi2
        )
begin
    case(CtlDataRead2Lock2)
        1'd0:  LockPort2wrmi2 = 2'd0;
        1'd1:  LockPort2wrmi2 = 2'd1;
        default:  LockPort2wrmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataRead2Lock3 or
         LockPort2wrmi3
        )
begin
    case(CtlDataRead2Lock3)
        3'd0:  LockPort2wrmi3 = 3'd0;
        3'd1:  LockPort2wrmi3 = {1'b1, {2{1'b0}}};
        3'd2:  LockPort2wrmi3 = 3'd1;
        3'd3:  LockPort2wrmi3 = 3'd2;
        3'd4:  LockPort2wrmi3 = 3'd3;
        default:  LockPort2wrmi3 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataRead2Lock4 or
         LockPort2wrmi4
        )
begin
    case(CtlDataRead2Lock4)
        1'd0:  LockPort2wrmi4 = 2'd0;
        1'd1:  LockPort2wrmi4 = 2'd1;
        default:  LockPort2wrmi4 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataRead2Lock5 or
         LockPort2wrmi5
        )
begin
    case(CtlDataRead2Lock5)
        1'd0:  LockPort2wrmi5 = 2'd0;
        1'd1:  LockPort2wrmi5 = 2'd1;
        default:  LockPort2wrmi5 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 6 (lock control signal)
always @(CtlDataRead2Lock6 or
         LockPort2wrmi6
        )
begin
    case(CtlDataRead2Lock6)
        3'd0:  LockPort2wrmi6 = 3'd0;
        3'd1:  LockPort2wrmi6 = {1'b1, {2{1'b0}}};
        3'd2:  LockPort2wrmi6 = 3'd1;
        3'd3:  LockPort2wrmi6 = 3'd2;
        3'd4:  LockPort2wrmi6 = 3'd3;
        default:  LockPort2wrmi6 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 7 (lock control signal)
always @(CtlDataRead2Lock7 or
         LockPort2wrmi7
        )
begin
    case(CtlDataRead2Lock7)
        3'd0:  LockPort2wrmi7 = 3'd0;
        3'd1:  LockPort2wrmi7 = {1'b1, {2{1'b0}}};
        3'd2:  LockPort2wrmi7 = 3'd1;
        3'd3:  LockPort2wrmi7 = 3'd2;
        3'd4:  LockPort2wrmi7 = 3'd3;
        default:  LockPort2wrmi7 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 8 (lock control signal)
always @(CtlDataRead2Lock8 or
         LockPort2wrmi8
        )
begin
    case(CtlDataRead2Lock8)
        3'd0:  LockPort2wrmi8 = 3'd0;
        3'd1:  LockPort2wrmi8 = {1'b1, {2{1'b0}}};
        3'd2:  LockPort2wrmi8 = 3'd1;
        3'd3:  LockPort2wrmi8 = 3'd2;
        3'd4:  LockPort2wrmi8 = 3'd3;
        default:  LockPort2wrmi8 = {1'b1, {2{1'b0}}};
    endcase
end

//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataWrite2Lock0 or 
         LockPort2rdmi0
        )
begin
    case(CtlDataWrite2Lock0)
        1'd0:  LockPort2rdmi0 = 2'd0;
        1'd1:  LockPort2rdmi0 = 2'd1;
        default:  LockPort2rdmi0 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataWrite2Lock1 or 
         LockPort2rdmi1
        )
begin
    case(CtlDataWrite2Lock1)
        1'd0:  LockPort2rdmi1 = 2'd0;
        1'd1:  LockPort2rdmi1 = 2'd1;
        default:  LockPort2rdmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataWrite2Lock2 or 
         LockPort2rdmi2
        )
begin
    case(CtlDataWrite2Lock2)
        1'd0:  LockPort2rdmi2 = 2'd0;
        1'd1:  LockPort2rdmi2 = 2'd1;
        default:  LockPort2rdmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataWrite2Lock3 or 
         LockPort2rdmi3
        )
begin
    case(CtlDataWrite2Lock3)
        2'd0:  LockPort2rdmi3 = 4'd0;
        2'd1:  LockPort2rdmi3 = 4'd2;
        2'd2:  LockPort2rdmi3 = 4'd3;
        2'd3:  LockPort2rdmi3 = 4'd4;
        default:  LockPort2rdmi3 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataWrite2Lock4 or 
         LockPort2rdmi4
        )
begin
    case(CtlDataWrite2Lock4)
        1'd0:  LockPort2rdmi4 = 2'd0;
        1'd1:  LockPort2rdmi4 = 2'd1;
        default:  LockPort2rdmi4 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataWrite2Lock5 or 
         LockPort2rdmi5
        )
begin
    case(CtlDataWrite2Lock5)
        1'd0:  LockPort2rdmi5 = 2'd0;
        1'd1:  LockPort2rdmi5 = 2'd1;
        default:  LockPort2rdmi5 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 6 (lock control signal)
always @(CtlDataWrite2Lock6 or 
         LockPort2rdmi6
        )
begin
    case(CtlDataWrite2Lock6)
        2'd0:  LockPort2rdmi6 = 4'd0;
        2'd1:  LockPort2rdmi6 = 4'd2;
        2'd2:  LockPort2rdmi6 = 4'd3;
        2'd3:  LockPort2rdmi6 = 4'd4;
        default:  LockPort2rdmi6 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 7 (lock control signal)
always @(CtlDataWrite2Lock7 or 
         LockPort2rdmi7
        )
begin
    case(CtlDataWrite2Lock7)
        2'd0:  LockPort2rdmi7 = 4'd0;
        2'd1:  LockPort2rdmi7 = 4'd2;
        2'd2:  LockPort2rdmi7 = 4'd3;
        2'd3:  LockPort2rdmi7 = 4'd4;
        default:  LockPort2rdmi7 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 8 (lock control signal)
always @(CtlDataWrite2Lock8 or 
         LockPort2rdmi8
        )
begin
    case(CtlDataWrite2Lock8)
        2'd0:  LockPort2rdmi8 = 4'd0;
        2'd1:  LockPort2rdmi8 = 4'd2;
        2'd2:  LockPort2rdmi8 = 4'd3;
        2'd3:  LockPort2rdmi8 = 4'd4;
        default:  LockPort2rdmi8 = {1'b1, {3{1'b0}}};
    endcase
end

endmodule
