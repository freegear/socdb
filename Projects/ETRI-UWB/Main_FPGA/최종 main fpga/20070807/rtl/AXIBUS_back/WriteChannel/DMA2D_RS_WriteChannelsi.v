// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannelmi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel Master Interface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  DMA2D_RS_WriteChannelsi(

    SelMAP1,

    //Global signal
    ACLK    ,
    ARESETn ,

    //For Master
    //Write address channel
    AWADDRm2si  ,
    AWLENm2si   ,
    AWSIZEm2si  ,
    AWBURSTm2si ,
    AWVALIDm2si ,
    AWREADYsi2m ,

    //Write data channel
    WDATAm2si   ,
    WSTRBm2si   ,
    WLASTm2si   ,
    WVALIDm2si  ,
    WREADYsi2m  ,

    //Write response channel
    BRESPsi2m   ,
    BVALIDsi2m  ,
    BREADYm2si  ,

    //For Master interface slave Number = 0
    //Write address channel
    AWIDsi2mi0    ,
    AWADDRsi2mi0  ,
    AWLENsi2mi0   ,
    AWSIZEsi2mi0  ,
    AWBURSTsi2mi0 ,
    AWLOCKsi2mi0  ,
    AWCACHEsi2mi0 ,
    AWPROTsi2mi0  ,

    //Write data channel
    WIDsi2mi0     ,
    WDATAsi2mi0   ,
    WSTRBsi2mi0   ,
    //For Master interface slave Number = 3
    //Write address channel
    AWIDsi2mi3    ,
    AWADDRsi2mi3  ,
    AWLENsi2mi3   ,
    AWSIZEsi2mi3  ,
    AWBURSTsi2mi3 ,
    AWLOCKsi2mi3  ,
    AWCACHEsi2mi3 ,
    AWPROTsi2mi3  ,

    //Write data channel
    WIDsi2mi3     ,
    WDATAsi2mi3   ,
    WSTRBsi2mi3   ,
    //For Master interface slave Number = 4
    //Write address channel
    AWIDsi2mi4    ,
    AWADDRsi2mi4  ,
    AWLENsi2mi4   ,
    AWSIZEsi2mi4  ,
    AWBURSTsi2mi4 ,
    AWLOCKsi2mi4  ,
    AWCACHEsi2mi4 ,
    AWPROTsi2mi4  ,

    //Write data channel
    WIDsi2mi4     ,
    WDATAsi2mi4   ,
    WSTRBsi2mi4   ,

//Default Slave Number = 5    //For Master interface slave Number = 5
    //Write address channel
    AWIDsi2mi5    ,
    AWADDRsi2mi5  ,
    AWLENsi2mi5   ,
    AWSIZEsi2mi5  ,
    AWBURSTsi2mi5 ,
    AWLOCKsi2mi5  ,
    AWCACHEsi2mi5 ,
    AWPROTsi2mi5  ,

    //Write data channel
    WIDsi2mi5     ,
    WDATAsi2mi5   ,
    WSTRBsi2mi5   ,
////////////////////////////

    //VALID & READY signal
    AWVALIDsi2mi ,
    AWREADYmi2si ,

    WLASTsi2mi   ,
    WVALIDsi2mi  ,
    WREADYmi2si  ,
    //Write response channel

    
    //Slave Number 0
    BIDmi02si     ,
    BRESPmi02si   ,
    
    //Slave Number 3
    BIDmi32si     ,
    BRESPmi32si   ,
    
    //Slave Number 4
    BIDmi42si     ,
    BRESPmi42si   ,

//Default Slave Number = 5    
    //Slave Number 5
    BIDmi52si     ,
    BRESPmi52si   ,
////////////////////////////

    BVALIDmi2si  ,
    BREADYsi2mi
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 4;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 7;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   SelMAP1;

    input   ACLK;
    input   ARESETn;

    //For Master
    //Write address channel
    input   [ADDR_WID-1:0]     AWADDRm2si;
    input   [AWLEN_WID-1:0]    AWLENm2si;
    input   [AWSIZE_WID-1:0]   AWSIZEm2si;  
    input   [AWBURST_WID-1:0]  AWBURSTm2si; 
    wire   [MASTERID_WID-1:0] AWIDm2si = {MASTERID_WID{1'b0}};
    input   AWVALIDm2si; 
    output  AWREADYsi2m; 

    //Write data channel
     wire    [MASTERID_WID-1:0] WIDm2si = 1'b0;
    input   [BUS_WID-1:0]      WDATAm2si;   
    input   [WSTRB_WID-1:0]    WSTRBm2si;   
    input   WLASTm2si;   
    input   WVALIDm2si;  
    output  WREADYsi2m;  

    //Write response channel
    wire    [MASTERID_WID-1:0]      BIDsi2m;
    output   [BRESP_WID-1:0]   BRESPsi2m;   
    output   BVALIDsi2m;  
    input    BREADYm2si;  

    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi0;    
    output  [ADDR_WID-1:0] AWADDRsi2mi0;  
    output  [AWLEN_WID-1:0] AWLENsi2mi0;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi0;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi0; 
//Disable_LockPortWriteChannel(master)
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi0;  
    assign  AWLOCKsi2mi0 = {AWLOCK_WID{1'b0}};  
//Disable_CachePortWriteChannel(master)
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi0; 
    assign  AWCACHEsi2mi0 = {AWCACHE_WID{1'b0}};  
//Disable_ProtectPortWriteChannel(master)
    output  [AWPROT_WID-1:0] AWPROTsi2mi0;  
    assign  AWPROTsi2mi0 = {AWPROT_WID{1'b0}};  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi0;     
    output  [WSTRB_WID-1:0]WSTRBsi2mi0;   
    output  [BUS_WID-1:0] WDATAsi2mi0;   
    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi3;    
    output  [ADDR_WID-1:0] AWADDRsi2mi3;  
    output  [AWLEN_WID-1:0] AWLENsi2mi3;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi3;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi3; 
//Disable_LockPortWriteChannel(master)
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi3;  
    assign  AWLOCKsi2mi3 = {AWLOCK_WID{1'b0}};  
//Disable_CachePortWriteChannel(master)
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi3; 
    assign  AWCACHEsi2mi3 = {AWCACHE_WID{1'b0}};  
//Disable_ProtectPortWriteChannel(master)
    output  [AWPROT_WID-1:0] AWPROTsi2mi3;  
    assign  AWPROTsi2mi3 = {AWPROT_WID{1'b0}};  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi3;     
    output  [WSTRB_WID-1:0]WSTRBsi2mi3;   
    output  [BUS_WID-1:0] WDATAsi2mi3;   
    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi4;    
    output  [ADDR_WID-1:0] AWADDRsi2mi4;  
    output  [AWLEN_WID-1:0] AWLENsi2mi4;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi4;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi4; 
//Disable_LockPortWriteChannel(master)
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi4;  
    assign  AWLOCKsi2mi4 = {AWLOCK_WID{1'b0}};  
//Disable_CachePortWriteChannel(master)
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi4; 
    assign  AWCACHEsi2mi4 = {AWCACHE_WID{1'b0}};  
//Disable_ProtectPortWriteChannel(master)
    output  [AWPROT_WID-1:0] AWPROTsi2mi4;  
    assign  AWPROTsi2mi4 = {AWPROT_WID{1'b0}};  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi4;     
    output  [WSTRB_WID-1:0]WSTRBsi2mi4;   
    output  [BUS_WID-1:0] WDATAsi2mi4;   

//Default Slave Number = 5    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi5;    
    output  [ADDR_WID-1:0] AWADDRsi2mi5;  
    output  [AWLEN_WID-1:0] AWLENsi2mi5;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi5;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi5; 
//ENABLE_LOCK_WriteOutput
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi5;  
//ENABLE_CACHE_WriteOutput
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi5; 
//ENABLE_PROT_WriteOutput
    output  [AWPROT_WID-1:0] AWPROTsi2mi5;  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi5;     
//ENABLE_WSTRB_WriteOutput
    output  [WSTRB_WID-1:0]WSTRBsi2mi5;   
    output  [BUS_WID-1:0] WDATAsi2mi5;   
////////////////////////////

    //Write response channel

    //Slave Number 0
    input   [MASTERID_WID-1:0] BIDmi02si;     
    input   [BRESP_WID-1:0] BRESPmi02si;   

    //Slave Number 3
    input   [MASTERID_WID-1:0] BIDmi32si;     
    input   [BRESP_WID-1:0] BRESPmi32si;   

    //Slave Number 4
    input   [MASTERID_WID-1:0] BIDmi42si;     
    input   [BRESP_WID-1:0] BRESPmi42si;   

//Default Slave Number = 5
    //Slave Number 5
    input   [MASTERID_WID-1:0] BIDmi52si;     
    input   [BRESP_WID-1:0] BRESPmi52si;   
////////////////////////////
    
    output  [SLAVE_NUM-1:0]AWVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]AWREADYmi2si; 

    output  [SLAVE_NUM-1:0]WLASTsi2mi;   
    output  [SLAVE_NUM-1:0]WVALIDsi2mi;  
    input   [SLAVE_NUM-1:0]WREADYmi2si;  

    input   [SLAVE_NUM-1:0]BVALIDmi2si;  
    output  [SLAVE_NUM-1:0]BREADYsi2mi;

    

//_______________________________________RS Number = 0
//
    //for register slice
    wire   [MASTERID_WID-1:0] w0AWIDm2si;    
    wire   [ADDR_WID-1:0]     w0AWADDRm2si;
    wire   [AWLEN_WID-1:0]    w0AWLENm2si;
    wire   [AWSIZE_WID-1:0]   w0AWSIZEm2si;  
    wire   [AWBURST_WID-1:0]  w0AWBURSTm2si; 
    wire   [AWLOCK_WID-1:0]   w0AWLOCKm2si;  
    wire   [AWCACHE_WID-1:0]  w0AWCACHEm2si; 
    wire   [AWPROT_WID-1:0]   w0AWPROTm2si;  
    wire   w0AWVALIDm2si; 
    wire   w0AWREADYsi2m; 

    //for register slice
    wire   [MASTERID_WID-1:0] w0WIDm2si;     
    wire   [BUS_WID-1:0]      w0WDATAm2si;   
    wire   [WSTRB_WID-1:0]    w0WSTRBm2si;   
    wire   w0WLASTm2si;   
    wire   w0WVALIDm2si;  
    wire   w0WREADYsi2m;  

    //for register slice
    wire   [MASTERID_WID-1:0]w0BIDsi2m;     
    wire   [BRESP_WID-1:0]   w0BRESPsi2m;   
    wire   w0BVALIDsi2m;  
    wire   w0BREADYm2si;  




//Mater to Slave interface register slice 
//Number == 0
//_________________________________________
DMA2D_AWSIm2si_registered
DMA2D_0_AWSIm2si_registered
(
	.ACLK         (ACLK         ), 
    .ARESETn      (ARESETn      ), 

    .INFORMATION_S({ AWIDm2si, 
                     AWLENm2si, 
                     AWSIZEm2si, 
                     AWBURSTm2si, 
                     AWADDRm2si 
                    }),

    .VALID_S      ( AWVALIDm2si  ),
    .READY_S      ( AWREADYsi2m  ),

    .INFORMATION_R({w0AWIDm2si, 
                    w0AWLENm2si ,
                    w0AWSIZEm2si, 
                    w0AWBURSTm2si, 
                    w0AWADDRm2si 
                    }),

    .VALID_R      (w0AWVALIDm2si ),
    .READY_R      (w0AWREADYsi2m )
);


DMA2D_WDSIm2si_registered
DMA2D_0_WDSIm2si_registered
(
	.ACLK         (ACLK         ), 
	.ARESETn      (ARESETn      ), 
	.INFORMATION_S({ WIDm2si, 
                     WDATAm2si, 
                     WSTRBm2si, 
                     WLASTm2si
                    }), 

	.VALID_S      ( WVALIDm2si  ),
	.READY_S      ( WREADYsi2m  ),

	.INFORMATION_R({w0WIDm2si, 
                    w0WDATAm2si, 
                    w0WSTRBm2si, 
                    w0WLASTm2si}),

	.VALID_R      (w0WVALIDm2si ),
	.READY_R      (w0WREADYsi2m )
);

DMA2D_WRSIm2si_registered
DMA2D_0_WRSIm2si_registered
(
	.ACLK         (ACLK         ), 
    .ARESETn      (ARESETn      ), 
    .INFORMATION_S({w0BIDsi2m, w0BRESPsi2m}), 

	.VALID_S      (w0BVALIDsi2m),
	.READY_S      (w0BREADYm2si),
        
	.INFORMATION_R({ BIDsi2m,  BRESPsi2m}),

	.VALID_R      ( BVALIDsi2m),
	.READY_R      ( BREADYm2si)
);



//////////////////////////////////////////////////



//////////////////////////////////////////////////





//Master module     
//__________________________________________________

DMA2D_WriteChannelsi
DMA2D_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (1'b0),
    .AWADDRm2si  (w0AWADDRm2si),
    .AWLENm2si   (w0AWLENm2si),
    .AWSIZEm2si  (w0AWSIZEm2si),
    .AWBURSTm2si (w0AWBURSTm2si),
    .AWLOCKm2si  ({AWLOCK_WID{1'b0}}),
    .AWCACHEm2si ({AWCACHE_WID{1'b0}}),
    .AWPROTm2si  ({AWPROT_WID{1'b0}}),

    .AWVALIDm2si (w0AWVALIDm2si),
    .AWREADYsi2m (w0AWREADYsi2m),

    //Write data channel
    .WIDm2si     (w0WIDm2si),
    .WDATAm2si   (w0WDATAm2si),
    .WSTRBm2si   (w0WSTRBm2si),
    .WLASTm2si   (w0WLASTm2si),
    .WVALIDm2si  (w0WVALIDm2si),
    .WREADYsi2m  (w0WREADYsi2m),

    //Write response channel
    .BIDsi2m     (w0BIDsi2m),
    .BRESPsi2m   (w0BRESPsi2m),
    .BVALIDsi2m  (w0BVALIDsi2m),
    .BREADYm2si  (w0BREADYm2si),


    .AWVALIDsi2mi ( AWVALIDsi2mi),
    .AWREADYmi2si ( AWREADYmi2si),

    .WLASTsi2mi   ( WLASTsi2mi),
    .WVALIDsi2mi  ( WVALIDsi2mi),
    .WREADYmi2si  ( WREADYmi2si),

    .BVALIDmi2si    ( BVALIDmi2si),
    .BREADYsi2mi    ( BREADYsi2mi),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  slave Number = 0
    //Write address channel
    .AWIDsi2mi0    ( AWIDsi2mi0),
    .AWADDRsi2mi0  ( AWADDRsi2mi0),
    .AWLENsi2mi0   ( AWLENsi2mi0),
    .AWSIZEsi2mi0  ( AWSIZEsi2mi0),
    .AWBURSTsi2mi0 ( AWBURSTsi2mi0),
//Disable_LockPortWriteChannel(master)
    .AWLOCKsi2mi0  ( ),
//Disable_CachePortWriteChannel(master)
    .AWCACHEsi2mi0 ( ),
//Disable_ProtectPortWriteChannel(master)
    .AWPROTsi2mi0  ( ),

    //Write data channel
    .WIDsi2mi0     ( WIDsi2mi0),
    .WDATAsi2mi0   ( WDATAsi2mi0),
    .WSTRBsi2mi0   ( WSTRBsi2mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     ( BIDmi02si),
    .BRESPmi02si   ( BRESPmi02si),
//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  slave Number = 3
    //Write address channel
    .AWIDsi2mi3    ( AWIDsi2mi3),
    .AWADDRsi2mi3  ( AWADDRsi2mi3),
    .AWLENsi2mi3   ( AWLENsi2mi3),
    .AWSIZEsi2mi3  ( AWSIZEsi2mi3),
    .AWBURSTsi2mi3 ( AWBURSTsi2mi3),
//Disable_LockPortWriteChannel(master)
    .AWLOCKsi2mi3  ( ),
//Disable_CachePortWriteChannel(master)
    .AWCACHEsi2mi3 ( ),
//Disable_ProtectPortWriteChannel(master)
    .AWPROTsi2mi3  ( ),

    //Write data channel
    .WIDsi2mi3     ( WIDsi2mi3),
    .WDATAsi2mi3   ( WDATAsi2mi3),
    .WSTRBsi2mi3   ( WSTRBsi2mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     ( BIDmi32si),
    .BRESPmi32si   ( BRESPmi32si),
//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  slave Number = 4
    //Write address channel
    .AWIDsi2mi4    ( AWIDsi2mi4),
    .AWADDRsi2mi4  ( AWADDRsi2mi4),
    .AWLENsi2mi4   ( AWLENsi2mi4),
    .AWSIZEsi2mi4  ( AWSIZEsi2mi4),
    .AWBURSTsi2mi4 ( AWBURSTsi2mi4),
//Disable_LockPortWriteChannel(master)
    .AWLOCKsi2mi4  ( ),
//Disable_CachePortWriteChannel(master)
    .AWCACHEsi2mi4 ( ),
//Disable_ProtectPortWriteChannel(master)
    .AWPROTsi2mi4  ( ),

    //Write data channel
    .WIDsi2mi4     ( WIDsi2mi4),
    .WDATAsi2mi4   ( WDATAsi2mi4),
    .WSTRBsi2mi4   ( WSTRBsi2mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     ( BIDmi42si),
    .BRESPmi42si   ( BRESPmi42si),

//Default Slave Number = 5//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  slave Number = 5
    //Write address channel
    .AWIDsi2mi5    ( AWIDsi2mi5),
    .AWADDRsi2mi5  ( AWADDRsi2mi5),
    .AWLENsi2mi5   ( AWLENsi2mi5),
    .AWSIZEsi2mi5  ( AWSIZEsi2mi5),
    .AWBURSTsi2mi5 ( AWBURSTsi2mi5),
//Disable_LockPortWriteChannel(master)
    .AWLOCKsi2mi5  ( ),
//Disable_CachePortWriteChannel(master)
    .AWCACHEsi2mi5 ( ),
//Disable_ProtectPortWriteChannel(master)
    .AWPROTsi2mi5  ( ),

    //Write data channel
    .WIDsi2mi5     ( WIDsi2mi5),
    .WDATAsi2mi5   ( WDATAsi2mi5),
    .WSTRBsi2mi5   ( WSTRBsi2mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     ( BIDmi52si),
    .BRESPmi52si   ( BRESPmi52si),
////////////////////////////

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
    .SelMAP1 (SelMAP1)
);
endmodule
//STATE_END
