@E8lFkRDCLmg_)ILQXwN 5LRR(W_[1P_dWR,RLMU_Pplw_,YtR6RL_$mP]Rd,R_L(Mjwts,7YRdRL_$up,LRRdp_uw
2;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0LMU_Pplw_;Yt
HRRM0bkR_L6m]P$dR;
RbHMkL0R(w_Mt7jsYR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;
bRRNlsNCs0CR6L4_Ge[lnO	ahz_BB.XRd=R.R;
RsbNN0lCCLsR4e6_[OGl	zna_Z	 z=ZRR4'Ljjj444jj4jj4j4j4j4jj4jjj4j4j4R44;R

RosCR4rL6[_eG	lOn_azhXB.BRR:4RR9Lmd_)/LR*$R#MC0E#RH##_$M##sD0C$D=C"so0H#C"s#RR*/;R

RsIHCLRr4e6_[OGl	zna_.hBX:BRR9.RR_LcmQ)L;R

RINDNR$#@b@5F8#CoLCR(W_[1P_dWL2RCMoH
RRRR5HVLMU_Pplw_RYt2CRLoRHM
RRRRHRRVL5R(w_Mt7jsY
R2RRRRRRRRLmd_)=LRR6L4_Ge[lnO	a	z_ ZZz;R
RRRRRCCD#R5HVR_L6m]P$d
R2RRRRRRRRLmd_)=LRRd{L_$up,cRL_Lm)Q
};RRRRC
M8RMRC8R

R#N#HRoMLmc_)RLQ=dRL_Lm)r4RL6[_eG	lOn_azhXB.BRR:.;R9
R
RNH##oLMRdp_uwRR=Lmd_)4Lr9C;
MF8l8CkD
l

FD8kC0R[NHo_Ms0CVCNORR5
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_L(F_17d,PW
RRRRRRRRRRRRRRRR(RL_xUi_sdI,R
RRRRRRRRRRRRRRLRRnP_M_BjB,R
RRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRL_44U_ixAYJx),sL
RRRRRRRRRRRRRRRR4RLji_Uxi_sDXs0,R
RRRRRRRRRRRRRRLRR4Uj_iVx_w[V#XR,
RRRRRRRRRRRRRRRRLUg_i.x_o0sw,R
RRRRRRRRRRRRRRLRR4Mj_PI_$igvlXR,
RRRRRRRRRRRRRRRRLMg_PT_FIwVY,R
RRRRRRRRRRRRRRLRRgP_M_JOpo,mw
RRRRRRRRRRRRRRRRURL__MPZ0lBY
2;RMRHbRk0R_Ldu;pw
FRRkk0b0(RL_xUi_sdI;R
RFbk0kL0RnP_M_BjB;R
RFbk0kL0R4U4_iAx_J)xYs
L;RkRF00bkRjL4_xUi_Dsis;0X
FRRkk0b04RLji_Uxw_VVX#[;R
RFbk0kL0Rgi_Uxo_.s;w0
FRRkk0b04RLjP_M_i$IvXlg;R
RFbk0kL0RgP_M_IFTV;Yw
FRRkk0b0gRL__MPOopJm
w;RkRF00bkR_LUMZP_lYB0;R
RFbk0kL0Rdi_udR;
R0FkbRk0LF(_1d7_P
W;
IRRHRsCHM8C0$HV_	ODRR/*#0$MEHC##$R#MC_	C4b=R/R*R
;
RHRIsHCR80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88*R/RM#$0#ECH##R$	M_C=Cb4/R*R
;
RHRIsLCR(i_UxI_dsR;
RsIHCnRL__MPj;BB
IRRHRsCLUg_i.x_o0sw;R
RICHsR4L4_xUi_xAJYL)s;R
RICHsRjL4_xUi_Dsis;0X
IRRHRsCL_4jU_ixV#wV[
X;RHRIsLCRUP_M_BZl0
Y;RHRIsLCR4Mj_PI_$igvlXR;
RsIHCgRL__MPFVTIY
w;RHRIsLCRgP_M_JOpo;mw
ARRzRwtOLD	k5VR
RRRR53QRCH8MV0H$D_O	l_0b,R2
RRRR53mRCH8MV0H$D_O	2R2;R
RAq1BhQ_e)Xa c0R[Nbo_s4HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RR)  1a5RRR_L6POF1d,R2
RRRRu3z7 qaRL5RgP_M_IFTVRYw2R,
R3RR1w]Qa5RRR_LUMZP_lYB0R
2,RRRR3B7)iRRR58RHCHM0VO$_D0	_l2bR,R
RR1R3 RpRRRR5LMg_Pp_OJwomR
2,RRRR3Qa7RRRR5nRL__MPjRBB2R,
R3RRBaquzR) 54RLjP_M_i$IvXlgRR22/#*R$EM0C##HRM#$_bMFsCkM=*4R/
R;RCR8VsbNN[lR0_NoblsH4a3KqBt_]hqQR4=R;R
RAq1BhQ_e)Xa c0R[Nbo_s.HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RRzqu7a5 RRjL4_xUi_DsisR0X2R,
R3RR1w]Qa5RRR_LgU_ix.wos0,R2
RRRR)37BRiRRH5R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88,R2
RRRR 31pRRRRL5R4Uj_iVx_w[V#X,R2
RRRR73aQRRRRL5R(i_UxI_ds,R2
RRRRq3Bu)az RR5L_44U_ixAYJx)RsL2/2R*$R#MC0E#RH##_$MMsFbk=MC4/R*RR;
RV8CbNNsl0R[Nbo_s.Hl3qKat]_BqRQh=;R.
NRR#o#HMdRL_duiRH=R80CMH_V$O;D	
NRR#o#HM(RL_7F1_WdPRH=R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88
;
ClM8FD8kCl

FD8kC4RLnO_)lJH_D_Gg$l]b(5$R
RRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_Lnu_p$Q
w,RRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRgRL_wup_	aKs
[,RRRRRRRRRRRRRRRRR_L(Mjwts,7Y
RRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRnRL_l4zk,ag
RRRRRRRRRRRRRRRR6RL_$mP]
d,RRRRRRRRRRRRRRRRR.L4_Lm)QNIX Lw_8
2;RkRF00bkR:rdjL9R4Md_Pplw_.VGsTLk;R
RFbk0kr0Rj9:jR4L4_sk)Ok_gsLXA;R
RFbk0kL0Rdp_uwR;
R0FkbRk0L_4.mQ)LI XNw8_L;R
RHkMb0LRRgp_uwK_a	;s[
HRRM0bkRnRL_$up_;Qw
HRRM0bkR6RL_$mP]
d;RMRHbRk0R_L(Mjwts;7Y
HRRM0bkRnRL_#8Z0;dg
HRRM0bkRnRL_l4zk;ag
HRRM0bkRdRL_dui;R
RsRCorj6:94RLjZ_8#g0d_d w;R
RsRCorj6:9gRL_$mP]#d_N
p;RHRIsrCRc9:jRdL4_LPFwY.X __0a
 ;
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2R
RLHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRR4RLjZ_8#g0d_d wRL=RgP_m$_]d#;Np
RRRR8CM
CRRM
8
RDRNI#N$R5@@bCF#8RoCLud_iRd2LHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRRVRH5LR!(w_Mt7jsYRR2LHCoMR
RRRRRRVRH56RL_$mP]2dRRoLCHRM
RRRRRRRRR_Lgm]P$dN_#pRR={_Lnu_p$QRw,L_4dPwFL. XY_a0_ ;R}
RRRRRRRR8CM
RRRRCRRMR8
RCRRMR8
R8CM
R
RNH##oLMR4Pd_F.LwX_Y 0 _aRL=RgP_m$_]d#rNp69:4;R
RNH##oLMR4Md_Pplw_.VGsTLkRL=R48j_Zd#0gw_ d:rc4
9;R#RN#MHoR4L4_sk)Ok_gsLXAR=RRRjL4_#8Z0_dg rwdj9:j;R
RNH##oLMR4m._)ILQXwN _RL8RL=R48j_Zd#0gw_ d9r6;R
RNH##oLMRdp_uwRR=L4n_zalkgRR?Lmg_Pd$]_p#NrRj9:gRL_wup_	aKs
[;ClM8FD8kCl

FD8kCFROlLl_D	FO5R
ROlFl.OHHCH_DMH	_H_OCj
,RRHRHOOC.F_llD	HM_OHHC2_jRR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*RR;
R0FkbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
HRRM0bkR:rjjH9RH.OCOlFl_MDH	H_HOjC_;


RHRIsrCRd9:jRdL4_lMPwVp_GL.sk
T;RHRIsrCRj9:jR4L4_sk)Ok_gsLXA;R
RICHsR:rjjL9R4k4_)_sOWwYm[
Z;RHRIsrCRj9:jR_Lnu_pwQ
w;RHRIsLCRdi_udL,R(i_UxI_dsL,RnP_M_BjB,nRL_wup_,AJRcL4_wup_$i74 _Jd,dxR.L4_Lm)QNIX Lw_8L,Rgp_uwK_a	;s[
IRRHRsC0_8F#RHo/#*R$EM0C##HRM#$_C	CbR=4*;/R
IRRHRsCLMg_Pp_OJwom,gRL__MPFVTIYRw,L_4jM$P_IlivgRX,LMU_Pl_ZB;0Y
IRRHRsCL_4jU_ixV#wV[RX,L_4jU_ixssiD0RX,L_44U_ixAYJx),sLR_LgU_ix.wos0
;
`8HVC1VRQpvzqmaQhM
HHN0HDR
RfHbD10FVBDNLCHQM085HCHM0V[$_0_No0,O	RCH8MV0H$0_[N0o_lR#,HM8C0$HV_N[0o8_0HH,R80CMH_V$[o0N_F082`;
CHM8VR

R#N#HRoMLun_pQw_w9rjRH=RH.OCOlFl_MDH	H_HOjC_;R
RNH##oOMRF.llHCHO_MDH	H_HOjC_R{=RRdL4_lMPwVp_GL.skRT,L_44kO)s_sgkXrALjR9,LMn_PB_jBL,RgP_M_IFTV,YwRjL4__MP$vIil,gXR_LUMZP_lYB0,dRL_duiR
};R#RN#MHoRcL4_wup_$i74 _JdRdx=LR|np_uww_Q;R
RNH##oLMRgp_uwK_a	Rs[=LR54m._)ILQXwN _2L8?F08_o#H:cL4_wup_$i74 _Jd;dx
NRR#o#HM4RL4)_ksgO_kAsXLRR=5_LgMOP_pmJowL2?4k4_)_sOWwYm[4Z:';Lj
R
R[o0N_0HMCNsVO[CR0HNoRR5
R3RRLud_iRdRRRRRR5RRLud_i,d2
RRRR(3L_7F1_WdPRRRRR(5L_7F1_WdP2R,
R3RRLU(_idx_IRsRR5RRLU(_idx_I,s2
RRRRn3L__MPjRBBRRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRRRRRRLR5np_uwJ_A2R,
R3RRL_44U_ixAYJx)RsL54L4_xUi_xAJYL)s2R,
R3RRL_4jU_ixssiD0RXR5jL4_xUi_Dsis20X,R
RRLR34Uj_iVx_w[V#X5RRL_4jU_ixV#wV[,X2
RRRRg3L_xUi_s.owR0RRg5L_xUi_s.ow,02
RRRR43LjP_M_i$IvXlgRLR54Mj_PI_$igvlX
2,RRRR3_LgMFP_TYIVwRRR5_LgMFP_TYIVw
2,RRRR3_LgMOP_pmJowRRR5_LgMOP_pmJow
2,RRRR3_LUMZP_lYB0RRRR5_LUMZP_lYB02
2;
LRR4)n_O_lHJgDG_b$]lR($L)(_O_lHJ5DR
RRRR43LdP_Ml_wpVsG.L5kTL_4dMwPlpG_V.ksLT
2,RRRR34L4_sk)Ok_gsLXARLR54k4_)_sOWwYm[,Z2
RRRRd3L_duiRRRRRRRRRLR5(1_F7P_dW
2,RRRR3_Lnu_p$QRwRRRRRR(5L_xUi_sdI2R,
R3RRLud_pRwRRRRRRRRR5_Lnu_pwA,J2
RRRRg3L_wup_	aKsR[RRLR5gp_uwK_a	2s[,R
RRLR3(w_Mt7jsYRRRR5RRL_44U_ixAYJx)2sL,R
RRLR3nZ_8#g0dRRRRR5RRL_4jU_ixssiD0,X2
RRRRn3L_l4zkRagRRRRRLR54Uj_iVx_w[V#X
2,RRRR3_L6m]P$dRRRRRRRRg5L_xUi_s.ow,02
RRRR43L.)_mLXQIN_ wL58RL_4.mQ)LI XNw8_L2
2;
LRRg)_mLXQINR wLmg_)GL_h7$IRR5
R3RRL[(_Wd1_PRWRRRRR5_Ldu2id,R
RRLR3UP_Ml_wpY5tRL_4.mQ)LI XNw8_L2R,
R3RRLm6_Pd$]RRRR5_LUMZP_lYB02R,
R3RRLM(_wstj7RYRRLR54Mj_PI_$igvlX
2,RRRR3_LduRp$RRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRR5RR0_8F#2HoR
2;
8CMlkF8D
C
lkF8DLCR((_e4JmKxLR5d)_FA
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmd_FRA,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LcmNiK,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR.6_H,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLH._nR,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L.HRW,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.RL_,H RRR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRcY_FE
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmc_YjEjR
2;RMRHbRk0LFd_);Aj
HRRM0bkR_Ldm;FA
HRRM0bkR_LcmNiK;R
RHkMb0.RL_;H6
HRRM0bkR_L.H
n;RMRHbRk0LH._WR;
RbHMkL0R. _H;R
RFbk0kL0RcY_FE
j;RkRF00bkR_LcmjYEjR;
Rp1)B 4nR_LUm]P$do7YRR5
R3RR7RRR5_LdFj)A2R,
R3RRBR R5_Ldm2FA,R
RRBR3p5iRLmc_i2KN,R
RRqR3j5RRLH._6
2,RRRR3Rq4R.5L_2Hn,R
RRqR3.5RRLH._W
2,RRRR3RqdR.5L_2H ,R
RRTR3R5RRLFc_Y2Ej,R
RRTR3456RLmc_YjEj2;R2
M
C88lFk
DC
8lFkRDCL_44[0wKpYPYg5JELmc_i,KNRRH,F
2;RNRbsCNl0RCsLmc_)RJO=;R4
HRRM0bkR_LcmNiK;R
RHkMb0;RH
FRRkk0b0;RF
HRRMo0CC[sR;R
RsRCor_LcmO)JR4:R9nRL_s$Fj;u7
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoH
RRRR_Ln$jFsu47r9=R<R
H;RRRRV5Fs[RR=.[;RRR<=Lmc_);JOR=[RR+[RR
42RRRRRnRL_s$Fjru7[<9R=nRL_s$Fjru7[RR-4
9;RMRC8R
RNH##oFMRRL=RnF_$s7jur_LcmO)J9C;
MF8l8CkD
F
l8CkDRjL4_WMYhhagIRLp5R
RLmc_i,KN
LRR6F_P1,Od
LRR(1_u$BH_kR,
R_L6HO1WBR,
R_Lc1OY#,R
RLM(_YIWh7
Y,R(RL_$u1H#Dg,R
RL_4jMhYWaIghL;p2
R
RbNNslCC0sgRL_aMz_DoBY=vRR;4n
HRRM0bkRcRL_KmiNL,R6F_P1,OdR_L(uH1$_,BkR_L6HO1WBR;
RbHMkR0Rrj4:9cRL_#1YOR;
RbHMkR0Rr_LgM_zaoYBDvRR-4RR:jL9R(Y_MW7hIYR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRLRrgz_MaB_oDRYv-RR4:9RjRjL4_WMYhhagI;Lp
sRRCRoRR(RL_$u1H#Dg;R

RsbNN0lCCLsR($_WjdM_gRRRRRRR='RdLjjj;R
RbNNslCC0sURL_UY(s1C_DRRRR=RRRLd'j;j4
bRRNlsNCs0CRdL4_o0EMJYcB_ztA=CRRLd'j;4j
bRRNlsNCs0CR4L4_XLx_aJ1Bz(OR.=R'jLj;R
RbNNslCC0sgRL_XLx_i4#nRzRR.=R'4Lj;R
RbNNslCC0sURL_o7DY)(UBRRRR.=R'jL4;R
RbNNslCC0s4RLjI_64pnkaugTRRR=.4'L4R;
RosCR:rj.L9RnL_Mag0d,nRL_aGL0;dg
sRRCroRLMg_zoa_BvDYR4-RRj:R9(RL_EMYQ#dg;R
RsRCoLM6__.xO,cRL_6M_QR;
RosCR_LguH1$DNg#.R;
RosCRjL4_$u1H#DgG,wAR4L4_$u1H#Dgtu.X,4RL41_u$gHD#AGwaR;
RsIHCnRL_aMz_;VL
NRRD$IN#@R@5#bFCC8oR_LcmNiK2R
RRgRL_$u1H#DgN<.R=6RL_WH1O&BRR_L(uH1$_;Bk
R
RNH##oLMRnz_MaL_VR5=RLM(_YdEQg=#R=(RL_WMYhYI72
;
R#RN#MHoRjL4_WMYhhagIRLp=(RL_EMYQ#dg;R

RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:LM(_z.a_gRj
RHRRV65L_xM_O|.RR_L6POF1dR2
RRRRR_L(MQYEdRg#<'=RL
j;RRRRCCD#R5HVLMc__26Q
RRRRLRR(Y_MEgQd#=R<R_L(MQYEdRg#+;R4
CRRMR8
RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:Lmn_OV_ZLR
RRRRRLMn_Lda0g=R<R_LnG0Lad
g;RRRRRVRH5_L6POF1d
R2RRRRRRRRLMn_Lda0g=R<R_L(WM$j_;dg
CRRMR8
RINDNR$#@L@5nL_Mag0dRRFsLug_1D$Hg.#NRRFsLMn_zVa_LsRFR_L6HO1WBsRFR_Lc1OY#2R
RLHCoMRR:Lmn_On_$sR
RRnRL_aGL0Rdg<L=RnL_Mag0d;R
RR4RL41_u$gHD#Xt.u=R<R
j;RRRRL_4juH1$DGg#w<AR=;Rj
RRRR_LcMQ_6RR<=jR;
RLRR6__MxRO.<j=R;R
RRNRO#LC5nL_Mag0d2R
RR(RL_jW$Mg_dRL:RCMoH
RRRRLRR6__MxRO.<4=R;R
RRRRRHLV561_HW2OB
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RCRRMR8
RLRRU(_YU_sC1:DR
RRRRORRN5#CL1c_Y2#O
RRRRLRR4L4_xJX_1(aBO:zR
RRRRRRRR5HVLug_1D$Hg.#N2R
RRRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRRRRRL_4juH1$DGg#w<AR=;R4
RRRRRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRRMRC8DRC#RC
RRRRRRRRRLRRc__M6<QR=;R4
RRRRLRRgx_LX#_4iRnz:R
RRRRRRVRH5_LguH1$DNg#.R2
RRRRRRRRR5HVLMn_zVa_LR2
RRRRRRRRRLRR4uj_1D$Hgw#GA=R<R
4;RRRRRRRRRDRC#LCRCMoH
RRRRRRRRRRRR_LcMQ_6RR<=4R;
RRRRRRRRRLRRnL_Gag0dRR<=L_4d0MEoYBcJzAt_CR;
RRRRRRRRR8CM
RRRRLRR46j_Ik4npTaguRR:LHCoMR
RRRRRRcRL_6M_Q=R<R
4;RRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRR4RL41_u$gHD#Xt.u=R<R
4;RRRRRRRRR6RL_xM_O<.R=;R4
RRRRRRRR8CMR#CDCVRH5g!L_$u1H#DgN
.2RRRRRRRRR6RL_xM_O<.R=;R4
RRRRCRRMR8
RRRRR_LU7YDo(BU)RL:RCMoH
RRRRRRRR_LcMQ_6RR<=4R;
RRRRRHRRVn5L_aMz_2VLRoLCHRM
RRRRRRRRR4L4_$u1H#Dgtu.XRR<=4R;
RRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRCRM8CCD#R5HVLug_1D$Hg.#N2R
RRRRRRRRRLM6__.xORR<=4R;
RRRRR8CM
RRRR8RRCkVND:0R
RRRRRRRRR;
RRRRR8CMOCN#
RRRRdL4_o0EMJYcB_ztA:CRRoLCHRM
RRRRR_LcMQ_6RR<=4R;
RRRRR5HVLMn_zVa_LL2RCMoH
RRRRRRRRjL4_$u1H#DgGRwA<4=R;R
RRRRRR6RL_xM_O<.R=;R4
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RRRRR8CM
RRRR8CM
RRRRV8CN0kDRR:
RRRRRR;
RCRRMN8O#RC
R8CM
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoHRL:Rc1_u$RH
RHRRVLR56F_P1ROd|!|RLH6_1BWO2CRLo
HMRRRRR(RL_$u1H#DgRR<=jR;
RRRRR4L4_$u1H#DgGawARR<=jR;
RCRRMC8RDR#CLHCoMR
RRRRRLu(_1D$Hg<#R=4RL41_u$gHD#Xt.uR;
RRRRR4L4_$u1H#DgGawARR<=L_4juH1$DGg#w
A;RRRRRNRO#5CRL1c_Y2#ORR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRR4L4_XLx_aJ1Bz(O:RR
RRRRRLRR(1_u$gHD#=R<R4L4_$u1H#DgGawA;R
RRRRRLLg_x4X_#zin:R
RRRRRR(RL_$u1H#DgRR<=L_44uH1$DGg#w;Aa
RRRR8RRCkVND
0:RRRRRRRR;R
RRRRRCOM8N
#CRRRRC
M8RMRC8M
C88lFk
DC
8lFkRDCLmg_.V$$_.VtR,5HR;F2
HRRM0bkRRrj:9RdR
H;RkRF00bkR
F;
NRR#o#HMRRF=rRHj&9RR4Hr9RR&H9r.RH&Rr;d9
8CMlkF8D
C
lkF8DLCR4Bn_)atOB_kNC_]ck5HoLmc_i,KNRRH,F
2;RMRHbRk0Lmc_i;KN
HRRM0bkRRrj:.R4jH9R;R
RFbk0kF0R;R
RICHsR_LcAhOW;R
RICHsRRrj:.R4jL9RgZ_B1VjIY;_l
IRRHRsCr:jRRd4.94RL6Z_B1VjIY__lwHEV(R;
RsIHCjRrRd:RjL9RgZ_B1VjIY;_M
IRRHRsCr:jRR9d4R6L4_1BZjYIV_wM_E(VH;R
RICHsRRrj:9R(R_LgBjZ1I_VY8R;
RsIHCjRrR4:R9gRL_1BZjYIV_
e;RHRIsrCRjRR:dL9R4B6_ZI1jVeY__VwEH
(;RHRIsrCRjRR:4L9R4Bd_ZI1jVeY__gw];R
RsRCor:jRRR49L_4cBjZ1I_VYe]_wg
l;R#RN#MHoR_LgBjZ1I_VYlRR=HR;
R#N#HRoMFRR=LAc_O;Wh
NRR#o#HM4RL6Z_B1VjIY__lwHEV(Rrj:.R4j=9RR_LgBjZ1I_VYlR;
R#N#HRoML_46BjZ1I_VYlE_wVrH(4R.4:.R4d=9RRLd'4;44
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_g5R
RRHR356L4_1BZjYIV_wl_E(VHr:jRR2d9,FR35_LgBjZ1I_VYM9rj2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5NR
RRRR53HL_46BjZ1I_VYlE_wVrH(cRR:(,92R53FLBg_ZI1jVMY_r2492R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLj
R5RRRR3LH54B6_ZI1jVlY__VwEHU(rR4:R4,92R53FLBg_ZI1jVMY_r2.92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLQ
R5RRRR3LH54B6_ZI1jVlY__VwEH4(r.RR:4269,FR35_LgBjZ1I_VYM9rd2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5UR
RRRR53HL_46BjZ1I_VYlE_wVrH(4:nRR94g23,RFg5L_1BZjYIV_cMr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_O5R
RRHR356L4_1BZjYIV_wl_E(VHrR.j:dR.9R2,3LF5gZ_B1VjIYr_M6292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMF1L_RR5
R3RRH45L6Z_B1VjIY__lwHEV(cr.R.:R(,92R53FLBg_ZI1jVMY_r2n92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FL4
R5RRRR3LH54B6_ZI1jVlY__VwEH.(rURR:d249,FR35_LgBjZ1I_VYM9r(2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5wR
RRRR53HL_46BjZ1I_VYlE_wVrH(d:.RR9d623,RFg5L_1BZjYIV_UMr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_85R
RRHR356L4_1BZjYIV_wl_E(VHrRdn:gRd9R2,3LF5gZ_B1VjIYr_Mg292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_n
R5RRRR3LH54B6_ZI1jVlY__VwEHc(rjRR:c2d9,FR35_LgBjZ1I_VYMjr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGL(_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(crcRc:R(,92R53FLBg_ZI1jVMY_r9442
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNX5R
RRHR356L4_1BZjYIV_wl_E(VHrRcU:4R69R2,3LF5gZ_B1VjIYr_M42.92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5wR
RRRR53HL_46BjZ1I_VYlE_wVrH(6:.RR96623,RFg5L_1BZjYIV_4Mrd292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_6
R5RRRR3LH54B6_ZI1jVlY__VwEH6(rnRR:62g9,FR35_LgBjZ1I_VYMcr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLg_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(jrnRn:Rd,92R53FLBg_ZI1jVMY_r9462
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNu5R
RRHR356L4_1BZjYIV_wl_E(VHrRnc:(Rn9R2,3LF5gZ_B1VjIYr_M42n92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5YR
RRRR53HL_46BjZ1I_VYlE_wVrH(n:URR9(423,RFg5L_1BZjYIV_4Mr(292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_B
R5RRRR3LH54B6_ZI1jVlY__VwEH((r.RR:(269,FR35_LgBjZ1I_VYMUr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLN_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(nr(R(:Rg,92R53FLBg_ZI1jVMY_r94g2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rjn5R
RRHR356L4_1BZjYIV_wl_E(VHrRUj:dRU9R2,3LF5gZ_B1VjIYr_M.2j92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5(R
RRRR53HL_46BjZ1I_VYlE_wVrH(U:cRR9U(23,RFg5L_1BZjYIV_.Mr4292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFjL_X
R5RRRR3LH54B6_ZI1jVlY__VwEHU(rURR:g249,FR35_LgBjZ1I_VYM.r.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLw_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(.rgRg:R6,92R53FLBg_ZI1jVMY_r9.d2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rj65R
RRHR356L4_1BZjYIV_wl_E(VHrRgn:gRg9R2,3LF5gZ_B1VjIYr_M.2c92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5gR
RRRR53HL_46BjZ1I_VYlE_wVrH(4Rjj:jR4d,92R53FLBg_ZI1jVMY_r9.62
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rju5R
RRHR356L4_1BZjYIV_wl_E(VHrc4jR4:Rj2(9,FR35_LgBjZ1I_VYMnr.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLY_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(jr4URR:494423,RFg5L_1BZjYIV_.Mr(292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFjL_B
R5RRRR3LH54B6_ZI1jVlY__VwEH4(r4:.RR6449R2,3LF5gZ_B1VjIYr_M.2U92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5NR
RRRR53HL_46BjZ1I_VYlE_wVrH(4R4n:4R4g,92R53FLBg_ZI1jVMY_r9.g2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RQn5R
RRHR356L4_1BZjYIV_wl_E(VHrj4.R4:R.2d9,FR35_LgBjZ1I_VYMjrd9;22
NRR#o#HM4RL6Z_B1VjIY__MwHEV(Rrj:jRd9RR=LBg_ZI1jVMY_;R
RNH##oLMR4B6_ZI1jVMY__VwEHd(r4RR:dR49='R4L
4;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_5gR
RRRR53HL_46BjZ1I_VYME_wVrH(jRR:d,92R53FLBg_ZI1jV8Y_r2j92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLN
R5RRRR3LH54B6_ZI1jVMY__VwEHc(rR(:R9R2,3LF5gZ_B1VjIYr_84292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMFjL_RR5
R3RRH45L6Z_B1VjIY__MwHEV(RrU:4R49R2,3LF5gZ_B1VjIYr_8.292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMFQL_RR5
R3RRH45L6Z_B1VjIY__MwHEV(.r4R4:R6,92R53FLBg_ZI1jV8Y_r2d92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLU
R5RRRR3LH54B6_ZI1jVMY__VwEH4(rnRR:42g9,FR35_LgBjZ1I_VY89rc2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_5OR
RRRR53HL_46BjZ1I_VYME_wVrH(.:jRR9.d23,RFg5L_1BZjYIV_68r9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_15R
RRHR356L4_1BZjYIV_wM_E(VHrR.c:(R.9R2,3LF5gZ_B1VjIYr_8n292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMF4L_RR5
R3RRH45L6Z_B1VjIY__MwHEV(Ur.Rd:R4,92R53FLBg_ZI1jV8Y_r2(92R;
R_Lgm$.$Vt_V..RL4._m$_$VV_t.vqHT4_ nER_$5R
RRHR35_LgBjZ1I_VY8Rrj:9Rd23,RF45LdZ_B1VjIY__ewr]gj292;R
RLmg_.V$$_.VtR4L._$m.$VV_tv._H4Tq En__5xR
RRRR53HLBg_ZI1jV8Y_r:cRR2(9,FR35dL4_1BZjYIV_we_]4gr9;22
NRRD$IN#@R@5#bFCC8oR_LcmNiK2CRLo
HMRRRRL_4cBjZ1I_VYe]_wg<lR=4RLdZ_B1VjIY__ew;]g
CRRMR8
R#N#HRoMLBg_ZI1jVeY_RL=R4Bc_ZI1jVeY__gw]lR;
R#N#HRoML_46BjZ1I_VYeE_wVrH(jRR:4=9RR_LgBjZ1I_VYeR;
R#N#HRoML_46BjZ1I_VYeE_wVrH(.RR:d=9RRL.'4
4;RgRL_$m.$VV_tL.R.m6_.V$$_.Vt_TvHqn4 _DZ_MLGF5R
RRHR356L4_1BZjYIV_we_E(VH23,RFc5L_WAOh;22
8CMlkF8D
C
lkF8DLCR4u4_1D$HgV#4	
a5RcRL_KmiNR,
R_L([_W1d,PW
LRR6i_ud,Op
LRRdp_u$R,
R_Ldu,pw
LRR6P_m$,]d
LRRnZ_.#J0d,R
RLP6_Fd1O,R
RLH6_1BWO,R
RLu(_1D$Hg
#,R4RLjY_MWghahpIL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L6uOidpR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;RMRHbRk0Lm6_Pd$];R
RHkMb0jRrR.:RcRj9L.n_Zd#0JR;
RbHMkL0R6F_P1;Od
HRRM0bkR_L6HO1WBR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRgr4Rj:R94RLjY_MWghahpIL;R
RICHsR_L(m]P$d;gk
IRRHRsCr:4RR44.96RL_xMwt
0;RHRIsrCRjRR:49.4R_LnMtwx0
w;RCRsorRR4RR:49.4R_Lgu$VtIF7#LR;
RsIHC(RL_akzjcKB;R
RsRCoR4r.Rj:R9nRL_s$Fj;u7
IRRHRsCR4r.R4:R9(RL_s$Fjku7;R
RICHsRRrj:gR49gRL_aMz$0uw7
p;RHRIsrCRjRR:4L9R(z_MaIduYR;
RsIHC(RL_aMzjcKB;R
RICHsR_Lg.tZaQNVcgR;
RsIHCjRrR.:RcR49L_4j.0Z#dNJ	U
A;RHRIsrCRjRR:.9c4R.L4_q.Z]vBJs 4XDR;
RosCRjRrR.:RcRj9L_44.]ZqAmgsg;XE
IRRHRsCr:jRRj4.9nRL_a.Zt;QV
NRR#o#HM(RL_$mP]kdgRL=R6P_m$R]d&6RL_duiO
p;R#RN#MHoR_LnMtwx0jwr9RR=Lud_p
$;R#RN#MHoRjL4_#.Z0	dJNrUAjRR:.9cjRL=RnZ_.#J0d;R
RNH##oLMR4.._ZBq]J4vsXr DjRR:.9cjRL=R4.4_ZAq]ggsmX
E;R#RN#MHoRjL4_#.Z0	dJNrUA.Rc4:cR..4R-9RR=';Lj
NRR#o#HM4RL.Z_.qJ]BvXs4 .Drc:4RR..cR9-4R'=RL
j;RDRNI#N$R5@@bCF#8RoCLmc_i2KN
RRRR4L4_q.Z]sAgmEgXRL=RnZ_.#J0d;R

R_L(em(4KRJxL4U_poLOiR_)5R
RRLR3d)_FARjR5_LnMtwx0jwr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA9r42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD9r42R,
R3RRLFc_YREj5_Ln.tZaQjVr9
2,RRRR3_LcmjYEjLR56w_Mxrt04R922
;
R(RL_4e(mxKJR_LU4OpLo1i_RR5
R3RRLFd_)RAjRn5L_xMwtr0w4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr9
2,RRRR3_LcFjYERn5L_a.ZtrQV4,92
RRRRc3L_EmYj5jRLM6_w0xtr2.9R
2;
LRR((_e4JmKxURL_L4pO_oiQ
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA9rc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD9rc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6,92
RRRRc3L_EFYjLR5nZ_.aVtQr2.9,R
RRLR3cY_mERjj5_L6Mtwx09rd2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5JR
RRRRd3L_AF)j5RRLMn_w0xtw9rd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDr9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r2(9,R
RRLR3cY_FE5jRL.n_ZQatV9rd2R,
R3RRLmc_YjEjR65L_xMwtc0r922R;R

R_L(em(4KRJxL4U_poLOij_TRR5
R3RRLFd_)RAjRn5L_xMwtr0wc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 gDr9
2,RRRR3_LcFjYERn5L_a.ZtrQVc,92
RRRRc3L_EmYj5jRLM6_w0xtr269R
2;
LRR((_e4JmKxURL_L4pO_oiz
R5RRRR3_LdFj)ARLR5nw_Mxwt0r269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr269,R
RRLR3cY_mERjj5_L6Mtwx09rn2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5qR
RRRRd3L_AF)j5RRLMn_w0xtw9rn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D42.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D42d9,R
RRLR3cY_FE5jRL.n_ZQatV9rn2R,
R3RRLmc_YjEjR65L_xMwt(0r922R;R

R_L(em(4KRJxL4U_poLOiR_K5R
RRLR3d)_FARjR5_LnMtwx0(wr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r94c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9462R,
R3RRLFc_YREj5_Ln.tZaQ(Vr9
2,RRRR3_LcmjYEjLR56w_Mxrt0UR922
;
R(RL_4e(mxKJR_LU4OpLoMi_RR5
R3RRLFd_)RAjRn5L_xMwtr0wU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr94n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr94(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r49
2,RRRR3_LcFjYERn5L_a.ZtrQVU,92
RRRRc3L_EmYj5jRLM6_w0xtr2g9R
2;
LRR((_e4JmKxURL_L4pO_oie
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr4922R;R

R_L(em(4KRJxL4g_poLOil_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr94j2R,
R3RRLmc_YjEjR65L_xMwt40r4R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9442R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r49
2,RRRR3_LcmjYEjLR56w_Mxrt042.9R
2;
LRR((_e4JmKxgRL_L4pO_oi158R
RRRRd3L_AF)j5RRLMn_w0xtw.r49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9.c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9.62R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr94d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1e5R
RRLR3d)_FARjR5_LnMtwx04wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9.n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9.(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r.9
2,RRRR3_LcFjYERn5L_a.ZtrQV42d9,R
RRLR3cY_mERjj5_L6Mtwx0cr4922R;R

R_L(em(4KRJxL4g_poLOiD_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr94c2R,
R3RRLmc_YjEjR65L_xMwt40r6R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9462R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd249,R
RRLR3cY_FE5jRL.n_ZQatV6r49
2,RRRR3_LcmjYEjLR56w_Mxrt042n9R
2;
LRR((_e4JmKxgRL_L4pO_oi156R
RRRRd3L_AF)j5RRLMn_w0xtwnr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9d.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9dd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr94(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1C5R
RRLR3d)_FARjR5_LnMtwx04wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9dc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9d62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rd9
2,RRRR3_LcFjYERn5L_a.ZtrQV42(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur4922R;R

R_L(em(4KRJxL4g_poLOi1_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnrd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(rd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr94U2R,
R3RRLmc_YjEjR65L_xMwt40rgR922
;
R(RL_4e(mxKJR_Lg4OpLo1i_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r94g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgr49
2,RRRR3_LcmjYEjLR56w_Mxrt0.2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9c42R,
R3RRLFc_YREj5_Ln.tZaQ.Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9.42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQM5R
RRLR3d)_FARjR5_LnMtwx0.wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9c.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9cd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrc9
2,RRRR3_LcFjYERn5L_a.ZtrQV.249,R
RRLR3cY_mERjj5_L6Mtwx0.r.922R;R

R_L(em(4KRJxL4g_poLOi8_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcrc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 cDrc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 cDr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr9..2R,
R3RRLmc_YjEjR65L_xMwt.0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoQi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UcArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dc2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UcAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9cg2R,
R3RRLFc_YREj5_Ln.tZaQ.Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9.62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQb5R
RRLR3d)_FARjR5_LnMtwx0.wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9642R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r69
2,RRRR3_LcFjYERn5L_a.ZtrQV.269,R
RRLR3cY_mERjj5_L6Mtwx0nr.922R;R

R_L(em(4KRJxL4g_poLOi6_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 6Dr.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 6Drd,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.n2R,
R3RRLmc_YjEjR65L_xMwt.0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoQi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U6Arc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D62c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U6Ar6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6269,R
RRLR3cY_FE5jRL.n_ZQatV(r.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ51R
RRRRd3L_AF)j5RRLMn_w0xtwUr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA62n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r96n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA62(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r96(2R,
R3RRLFc_YREj5_Ln.tZaQ.VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9.g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQJ5R
RRLR3d)_FARjR5_LnMtwx0.wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr96g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr69
2,RRRR3_LcFjYERn5L_a.ZtrQV.2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrd922R;R

R_L(em(4KRJxL4g_poLOil_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dj2R,
R3RRLmc_YjEjR65L_xMwtd0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dn2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UnArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ58R
RRRRd3L_AF)j5RRLMn_w0xtw.rd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAn2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9nc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAn269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9n62R,
R3RRLFc_YREj5_Ln.tZaQdVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9dd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJe5R
RRLR3d)_FARjR5_LnMtwx0dwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9nn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrn9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9n(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rn9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2d9,R
RRLR3cY_mERjj5_L6Mtwx0crd922R;R

R_L(em(4KRJxL4g_poLOiD_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgrn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDrg,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dc2R,
R3RRLmc_YjEjR65L_xMwtd0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(Arj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Ar4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(249,R
RRLR3cY_FE5jRL.n_ZQatV6rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ56R
RRRRd3L_AF)j5RRLMn_w0xtwnrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA(2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9(.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA(2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9(d2R,
R3RRLFc_YREj5_Ln.tZaQdVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9d(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJC5R
RRLR3d)_FARjR5_LnMtwx0dwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9(c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9(62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r(9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urd922R;R

R_L(em(4KRJxL4g_poLOi1_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 (Drn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 (Dr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dU2R,
R3RRLmc_YjEjR65L_xMwtd0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoJi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9dg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(ArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Arg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrd9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRlj5R
RRLR3d)_FARjR5_LnMtwx0cwrj,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2j9,R
RRLR3cY_mERjj5_L6Mtwx04rc922R;R

R_L(em(4KRJxL4g_poLOiM_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR8j5R
RRLR3d)_FARjR5_LnMtwx0cwr.,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2.9,R
RRLR3cY_mERjj5_L6Mtwx0drc922R;R

R_L(em(4KRJxL4g_poLOie_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRDj5R
RRLR3d)_FARjR5_LnMtwx0cwrc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9Ug2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgrU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2c9,R
RRLR3cY_mERjj5_L6Mtwx06rc922R;R

R_L(em(4KRJxL4g_poLOib_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg249,R
RRLR3cY_FE5jRL.n_ZQatV6rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR6j5R
RRLR3d)_FARjR5_LnMtwx0cwrn,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9g.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2n9,R
RRLR3cY_mERjj5_L6Mtwx0(rc922R;R

R_L(em(4KRJxL4g_poLOiC_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg269,R
RRLR3cY_FE5jRL.n_ZQatV(rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR1j5R
RRLR3d)_FARjR5_LnMtwx0cwrU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9g(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2U9,R
RRLR3cY_mERjj5_L6Mtwx0grc922R;R

R_L(em(4KRJxL4g_poLOiJ_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrc9
2,RRRR3_LcmjYEjLR56w_Mxrt062j9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49j42R,
R3RRLFc_YREj5_Ln.tZaQ6Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9642;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzM5R
RRLR3d)_FARjR5_LnMtwx06wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4j9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arj2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4j9
2,RRRR3_LcFjYERn5L_a.ZtrQV6249,R
RRLR3cY_mERjj5_L6Mtwx0.r6922R;R

R_L(em(4KRJxL4g_poLOi8_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49jc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49j62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr96.2R,
R3RRLmc_YjEjR65L_xMwt60rdR922
;
R(RL_4e(mxKJR_Lg4OpLozi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arj2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drj2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr69
2,RRRR3_LcmjYEjLR56w_Mxrt062c9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49jg2R,
R3RRLFc_YREj5_Ln.tZaQ6Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9662;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rzb5R
RRLR3d)_FARjR5_LnMtwx06wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4449
2,RRRR3_LcFjYERn5L_a.ZtrQV6269,R
RRLR3cY_mERjj5_L6Mtwx0nr6922R;R

R_L(em(4KRJxL4g_poLOi6_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D494.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA494d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr96n2R,
R3RRLmc_YjEjR65L_xMwt60r(R922
;
R(RL_4e(mxKJR_Lg4OpLozi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc449
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6449
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4269,R
RRLR3cY_FE5jRL.n_ZQatV(r69
2,RRRR3_LcmjYEjLR56w_Mxrt062U9R
2;
LRR((_e4JmKxgRL_L4pO_oiz51R
RRRRd3L_AF)j5RRLMn_w0xtwUr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA494n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D494(2R,
R3RRLFc_YREj5_Ln.tZaQ6VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr96g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzJ5R
RRLR3d)_FARjR5_LnMtwx06wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg449
2,RRRR3_LcFjYERn5L_a.ZtrQV62g9,R
RRLR3cY_mERjj5_L6Mtwx0jrn922R;R

R_L(em(4KRJxL4g_poLOil_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nj2R,
R3RRLmc_YjEjR65L_xMwtn0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiq58R
RRRRd3L_AF)j5RRLMn_w0xtw.rn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49.c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49.62R,
R3RRLFc_YREj5_Ln.tZaQnVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9nd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rqe5R
RRLR3d)_FARjR5_LnMtwx0nwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar.2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4.9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2d9,R
RRLR3cY_mERjj5_L6Mtwx0crn922R;R

R_L(em(4KRJxL4g_poLOiD_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nc2R,
R3RRLmc_YjEjR65L_xMwtn0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd249,R
RRLR3cY_FE5jRL.n_ZQatV6rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiq56R
RRRRd3L_AF)j5RRLMn_w0xtwnrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49d.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49dd2R,
R3RRLFc_YREj5_Ln.tZaQnVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9n(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RqC5R
RRLR3d)_FARjR5_LnMtwx0nwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4d9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drd2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64d9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urn922R;R

R_L(em(4KRJxL4g_poLOi1_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49dn2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49d(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nU2R,
R3RRLmc_YjEjR65L_xMwtn0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoqi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9ng2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrn9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49c42R,
R3RRLFc_YREj5_Ln.tZaQ(Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9(42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKM5R
RRLR3d)_FARjR5_LnMtwx0(wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4c9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drc2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arc2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4c9
2,RRRR3_LcFjYERn5L_a.ZtrQV(249,R
RRLR3cY_mERjj5_L6Mtwx0.r(922R;R

R_L(em(4KRJxL4g_poLOi8_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49cc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49c62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(.2R,
R3RRLmc_YjEjR65L_xMwt(0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoKi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9(d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arc2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4c9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4c9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49cg2R,
R3RRLFc_YREj5_Ln.tZaQ(Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9(62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKb5R
RRLR3d)_FARjR5_LnMtwx0(wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar6249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4469
2,RRRR3_LcFjYERn5L_a.ZtrQV(269,R
RRLR3cY_mERjj5_L6Mtwx0nr(922R;R

R_L(em(4KRJxL4g_poLOi6_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D496.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA496d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(n2R,
R3RRLmc_YjEjR65L_xMwt(0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoKi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9((2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar62c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc469
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6469
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr6269,R
RRLR3cY_FE5jRL.n_ZQatV(r(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiK51R
RRRRd3L_AF)j5RRLMn_w0xtwUr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA496n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D496(2R,
R3RRLFc_YREj5_Ln.tZaQ(VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9(g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKJ5R
RRLR3d)_FARjR5_LnMtwx0(wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar62g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg469
2,RRRR3_LcFjYERn5L_a.ZtrQV(2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrU922R;R

R_L(em(4KRJxL4g_poLOil_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49n42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uj2R,
R3RRLmc_YjEjR65L_xMwtU0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arn2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4n9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4n9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiM58R
RRRRd3L_AF)j5RRLMn_w0xtw.rU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49nc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAnr46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49n62R,
R3RRLFc_YREj5_Ln.tZaQUVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9Ud2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMe5R
RRLR3d)_FARjR5_LnMtwx0Uwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4n9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drn2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arn2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4n9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2d9,R
RRLR3cY_mERjj5_L6Mtwx0crU922R;R

R_L(em(4KRJxL4g_poLOiD_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49ng2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uc2R,
R3RRLmc_YjEjR65L_xMwtU0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(249,R
RRLR3cY_FE5jRL.n_ZQatV6rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiM56R
RRRRd3L_AF)j5RRLMn_w0xtwnrU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49(.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49(d2R,
R3RRLFc_YREj5_Ln.tZaQUVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9U(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMC5R
RRLR3d)_FARjR5_LnMtwx0Uwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr(2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar(269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64(9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2(9,R
RRLR3cY_mERjj5_L6Mtwx0UrU922R;R

R_L(em(4KRJxL4g_poLOi1_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA(r4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49(n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49((2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9UU2R,
R3RRLmc_YjEjR65L_xMwtU0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoMi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9Ug2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrU9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2j9R
2;
LRR((_e4JmKxgRL_L4pO_oie5lR
RRRRd3L_AF)j5RRLMn_w0xtwjrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49U42R,
R3RRLFc_YREj5_Ln.tZaQgVrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9g42;R2
R
RLe(_(K4mJLxRgp_4LiOo_ReM5R
RRLR3d)_FARjR5_LnMtwx0gwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4U9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4ArU2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4U9
2,RRRR3_LcFjYERn5L_a.ZtrQVg249,R
RRLR3cY_mERjj5_L6Mtwx0.rg922R;R

R_L(em(4KRJxL4g_poLOi8_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49Uc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDUr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9g.2R,
R3RRLmc_YjEjR65L_xMwtg0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoei_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9gd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4ArU2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4U9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4U9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4DrU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2c9R
2;
LRR((_e4JmKxgRL_L4pO_oie5DR
RRRRd3L_AF)j5RRLMn_w0xtwcrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49Ug2R,
R3RRLFc_YREj5_Ln.tZaQgVrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9g62;R2
R
RLe(_(K4mJLxRgp_4LiOo_Reb5R
RRLR3d)_FARjR5_LnMtwx0gwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj4g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arg249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r44g9
2,RRRR3_LcFjYERn5L_a.ZtrQVg269,R
RRLR3cY_mERjj5_L6Mtwx0nrg922R;R

R_L(em(4KRJxL4g_poLOi6_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAgr4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49g.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9gn2R,
R3RRLmc_YjEjR65L_xMwtg0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoei_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9g(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arg2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc4g9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr64g9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg269,R
RRLR3cY_FE5jRL.n_ZQatV(rg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2U9R
2;
LRR((_e4JmKxgRL_L4pO_oie51R
RRRRd3L_AF)j5RRLMn_w0xtwUrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDgr4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49g(2R,
R3RRLFc_YREj5_Ln.tZaQgVrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9gg2;R2
R
RLe(_(K4mJLxRgp_4LiOo_ReJ5R
RRLR3d)_FARjR5_LnMtwx0gwrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU4g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arg2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg4g9
2,RRRR3_LcFjYERn5L_a.ZtrQVg2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr4jR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1Rl 5R
RRLR3d)_FARjR5_LnMtwx04wrj2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9jj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9j42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr.4,92
RRRRc3L_EFYjLR5nZ_.aVtQrj4j9
2,RRRR3_LcmjYEjLR56w_Mxrt049j42;R2
R
RLe(_(K4mJLxR44j_poLOil_1w
R5RRRR3_LdFj)ARLR5nw_Mxwt0r44j9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9j.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr..,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr.d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9jd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrj249,R
RRLR3cY_mERjj5_L6Mtwx0jr4.R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RlP5R
RRLR3d)_FARjR5_LnMtwx04wrj2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9jc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9j62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr.6,92
RRRRc3L_EFYjLR5nZ_.aVtQr.4j9
2,RRRR3_LcmjYEjLR56w_Mxrt049jd2;R2
R
RLe(_(K4mJLxR44j_poLOil_18
R5RRRR3_LdFj)ARLR5nw_Mxwt0rd4j9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9jn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr.n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr.(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9j(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrj2d9,R
RRLR3cY_mERjj5_L6Mtwx0jr4cR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1jl7RR5
R3RRLFd_)RAjRn5L_xMwtr0w49jc2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arj2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU.j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg.j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drj2g9,R
RRLR3cY_FE5jRL.n_ZQatVjr4c,92
RRRRc3L_EmYj5jRLM6_w0xtr64j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5]R
RRRRd3L_AF)j5RRLMn_w0xtwjr46,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49j62R,
R3RRLmc_YjEjR65L_xMwt40rj2n9R
2;
LRR((_e4JmKx4RLjp_4LiOo_M1lRR5
R3RRLFd_)RAjRn5L_xMwtr0w49jn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar42.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r..49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd.49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr42d9,R
RRLR3cY_FE5jRL.n_ZQatVjr4n,92
RRRRc3L_EmYj5jRLM6_w0xtr(4j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5IR
RRRRd3L_AF)j5RRLMn_w0xtwjr4(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49j(2R,
R3RRLmc_YjEjR65L_xMwt40rj2U9R
2;
LRR((_e4JmKx4RLjp_4LiOo_N1lRR5
R3RRLFd_)RAjRn5L_xMwtr0w49jU2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar42n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn.49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(.49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr42(9,R
RRLR3cY_FE5jRL.n_ZQatVjr4U,92
RRRRc3L_EmYj5jRLM6_w0xtrg4j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5QR
RRRRd3L_AF)j5RRLMn_w0xtwjr4g,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49jg2R,
R3RRLmc_YjEjR65L_xMwt40r42j9R
2;
LRR((_e4JmKx4RLjp_4LiOo_ 1MRR5
R3RRLFd_)RAjRn5L_xMwtr0w494j2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj..9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4..9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr.249,R
RRLR3cY_FE5jRL.n_ZQatV4r4j,92
RRRRc3L_EmYj5jRLM6_w0xtr444922R;R

R_L(em(4KRJxL_4j4OpLo1i_M5wR
RRRRd3L_AF)j5RRLMn_w0xtw4r44,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr...9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar.2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd..9
2,RRRR3_LcFjYERn5L_a.ZtrQV49442R,
R3RRLmc_YjEjR65L_xMwt40r42.9R
2;
LRR((_e4JmKx4RLjp_4LiOo_P1MRR5
R3RRLFd_)RAjRn5L_xMwtr0w494.2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc..9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6..9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr.269,R
RRLR3cY_FE5jRL.n_ZQatV4r4.,92
RRRRc3L_EmYj5jRLM6_w0xtrd44922R;R

R_L(em(4KRJxL_4j4OpLo1i_M58R
RRRRd3L_AF)j5RRLMn_w0xtw4r4d,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn..9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar.2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(..9
2,RRRR3_LcFjYERn5L_a.ZtrQV494d2R,
R3RRLmc_YjEjR65L_xMwt40r42c9R
2;
LRR((_e4JmKx4RLjp_4LiOo_71Mj
R5RRRR3_LdFj)ARLR5nw_Mxwt0rc449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9.U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r.U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r.g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9.g2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42c9,R
RRLR3cY_mERjj5_L6Mtwx04r46R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RM]5R
RRLR3d)_FARjR5_LnMtwx04wr4269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9d42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.4,92
RRRRc3L_EFYjLR5nZ_.aVtQr6449
2,RRRR3_LcmjYEjLR56w_Mxrt0494n2;R2
R
RLe(_(K4mJLxR44j_poLOiM_1M
R5RRRR3_LdFj)ARLR5nw_Mxwt0rn449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9d.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr..,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr.d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9dd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42n9,R
RRLR3cY_mERjj5_L6Mtwx04r4(R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RMI5R
RRLR3d)_FARjR5_LnMtwx04wr42(9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9d62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.6,92
RRRRc3L_EFYjLR5nZ_.aVtQr(449
2,RRRR3_LcmjYEjLR56w_Mxrt0494U2;R2
R
RLe(_(K4mJLxR44j_poLOiM_1N
R5RRRR3_LdFj)ARLR5nw_Mxwt0rU449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9dn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr.n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr.(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9d(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42U9,R
RRLR3cY_mERjj5_L6Mtwx04r4gR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RMQ5R
RRLR3d)_FARjR5_LnMtwx04wr42g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9dg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.g,92
RRRRc3L_EFYjLR5nZ_.aVtQrg449
2,RRRR3_LcmjYEjLR56w_Mxrt049.j2;R2
R
RLe(_(K4mJLxR44j_poLOi8_1 
R5RRRR3_LdFj)ARLR5nw_Mxwt0rj4.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9cj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr.j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr.4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9c42R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.2j9,R
RRLR3cY_mERjj5_L6Mtwx0.r44R922
;
R4RLn)_BtBOakCN_]kc_HLoRnZ_.tgwTRR5
R3RRLmc_i5KNLmc_i2KN,HR35_Ln.tZaQ,V2R53FL.g_ZQatVgcN2
2;R#RN#MHoR_L(kjzaKRBc=gRL_a.ZtcQVN
g;RDRNI#N$R5@@MCCo8RoCL[(_Wd1_P
W2RRRRRgRL_tuV$#I7F=LRR_L6Mtwx0R;
R#N#HRoMLMn_w0xtwRr4:.R44=9RR_Lgu$VtIF7#L
;
R4RLjY_MWghahpILR.y5jL2Rci_MA5jR
RRRRc3L_KmiNc5L_KmiN
2,RRRR3_L6POF1d65L_1PFO,d2
RRRR(3L_$u1Hk_B5_L(kjzaK2Bc,R
RRLR361_HW5OBLH6_1BWO2R,
R3RRL1c_Y5#OLM(_zuadI,Y2
RRRR(3L_WMYhYI75_LgM$zau7w0p
2,RRRR3_L(uH1$D5g#LM(_zKajB,c2
RRRR43LjY_MWghahpIL5jL4_WMYhhagI2Lp2
;
R#RN#MHoR_L(uH1$DRg#=(RL_aMzjcKB;R

R#N#HRoMLMg_zua$wp07RL=RnF_$s7jurR.4:9R.;R
RNH##oLMR(z_MaIduYRRR=nRL_s$Fjru74RR:j
9;R#RN#MHoR_LduRpw=nRL_s$Fjru7j
9;RDRNI#N$R5@@bCF#8RoCL[(_Wd1_P
W2RRRRH5VRLu6_ipdORL&R6P_m$2]d
RRRRLRRnF_$s7juR{=RLMn_w0xtw.r44R9,L$(_Fusj7;k}
R
RNH##oLMR(F_$s7jukRR=L$n_Fusj74r.R4:R9
;
ClM8FD8kCl

FD8kC(RL_wuVxYsh5R
RLmc_i,KN
LRR6F_P1,Od
LRR61_HW,OB
LRRgp_1$h$_s,t7
LRR(1_u$gHD#R,
R_L([_W1d,PW
LRR(i_uKgN_kR,
R_Ldu,p$
LRR6P_m$,]d
LRRdp_uwR,
RjL4_WMYhhagI2Lp;R

RbHMkL0Rci_mK
N;RMRHbRk0LP6_Fd1O;R
RHkMb06RL_WH1O
B;RMRHbRk0r.j:cR49L1g_p_$$h7st;R
RFbk0kL0R(1_u$gHD#R;
RbHMkL0R(W_[1P_dWR;
RbHMkL0R(i_uKgN_kR;
RbHMkL0Rdp_u$R;
RbHMkL0R6P_m$;]d
FRRkk0b0dRL_wup;R
RFbk0kr0R4:gRRRj9L_4jMhYWaIghL
p;RHRIsrCR4RR:4L9RU1_u$gHD#
X;RHRIsrCR4RR:4L9R4k4_zKajBwcos
Y;RHRIsrCR.RR:4L9R6w_Mx;t0
IRRHRsCr:.RRR49LMn_w0xtwR;
RsIHCjRrR.:RcRj9L.(_Zd#0J
t;RHRIsLCR61_HW;OB
R
RNH##oLMR(Z_.#J0dtRR={_Lg1$p$_ths7:rjd,49R_Lg1$p$_ths7.rd:9nd,gRL_$1p$s_htn7rc(:n9L,Rgp_1$h$_srt7n(U:4R9,L1g_p_$$h7str:(.(,69R_Lg1$p$_ths7nr(:9(g,RR
RRRRRRRRRRRRL1g_p_$$h7str:UjU,j9R_Lg1$p$_ths74rU:9U4,gRL_$1p$s_htU7r..:U9L,Rgp_1$h$_srt7UUd:dR9,L1g_p_$$h7str:UcU,c9R_Lg1$p$_ths76rU:9U6,RR
RRRRRRRRRRRRL1g_p_$$h7str:Un494(,gRL_$1p$s_ht47r44U:.,j9R_Lg1$p$_ths7.r446:4.R9,L1g_p_$$h7strd46:d469L,Rgp_1$h$_srt74:6c496c,gRL_$1p$s_ht47r646:6,n9RR
RRRRRRRRRRLRRgp_1$h$_srt74:6(49nj,gRL_$1p$s_ht47rn44:n,d9R_Lg1$p$_ths7nr4cn:46R9,L1g_p_$$h7strn4n:(4g9L,Rgp_1$h$_srt74:gU49gU,gRL_$1p$s_ht47rg.g:j,(9RR
RRRRRRRRRRLRRgp_1$h$_srt7.:jU.94n,gRL_$1p$s_ht.7r4.(:4,(9R_Lg1$p$_ths74r.U4:.UR9,L1g_p_$$h7strg.4:g.49L,Rgp_1$h$_srt7.:.j.9.j,gRL_$1p$s_ht.7r..4:.,49RR
RRRRRRRRRRLRRgp_1$h$_srt7.:...9..,gRL_$1p$s_ht.7r..d:.,d9R_Lg1$p$_ths7.r.c.:.cR9,L1g_p_$$h7str6..:6..9L,Rgp_1$h$_srt7.:.n.9.n,gRL_$1p$s_ht.7r..(:.,(9RR
RRRRRRRRRRLRRgp_1$h$_srt7.:.U.9.U,gRL_$1p$s_ht.7r..g:.,g9R_Lg1$p$_ths7dr.jd:.jR9,L1g_p_$$h7str4.d:4.d9L,Rgp_1$h$_srt7.:d..9d.,gRL_$1p$s_ht.7rd.d:d,d9RR
RRRRRRRRRRLRRgp_1$h$_srt7.:dc.9dc,gRL_$1p$s_ht.7rd.6:d,69R_Lg1$p$_ths7dr.nd:.nR9,L1g_p_$$h7str(.d:(.d9L,Rgp_1$h$_srt7.:dU.9dU,gRL_$1p$s_ht.7rd.g:d,g9RR
RRRRRRRRRRLRRgp_1$h$_srt7.:cj.9cj}R;
R#N#HRoMLuU_1D$Hgr#X4=9RR4L4_akzjcKBoYwsr;49
NRR#o#HM(RL_$u1H#DgRL=RU1_u$gHD#4Xr9
;
R#RN#MHoR_LnMtwx04wr9RR=Lud_p
$;R#RN#MHoR_LduRpw=6RL_xMwt40r9
;
R4RL41_u$gHD#	4Va(RL_auL0tDgRR5
R3RRLmc_iRKN5_LcmNiK2R,
R3RRL[(_Wd1_P5WRL[(_Wd1_P,W2
RRRR63L_duiO5pRLu(_i_KNg,k2
RRRRd3L_$upRn5L_xMwtr0w4,92
RRRRd3L_wupR65L_xMwt40r9
2,RRRR3_L6m]P$dLR56P_m$2]d,R
RRLR3nZ_.#J0dR(5L_#.Z0tdJ2R,
R3RRLP6_Fd1OR65L_1PFO,d2
RRRR63L_WH1O5BRLH6_1BWO2R,
R3RRLu(_1D$Hg5#RL_44kjzaKoBcwrsY4,92
RRRR43LjY_MWghahpILR45LjY_MWghahpIL2
2;
8CMlkF8D
C
lkF8DLCR(B_mAX$pBL5Rci_mKRN,Lu(_1D$HgR#,L[(_Wd1_PRW,Lm6_Pd$],nRL_#8Z0,dgR_Ldu,p$R_LnM_V#VRw,L_4c4O8appI_V_AudRH,L_4jMQYEd_g#wR0,L_44PZqAdYJ#_,X]R4L4_sk)OV.XY]_X,6RL_WH1ORB,Lmg_waWhgL_N,4RL.F_P1_Odo#lNLRL,LM(_wstj7RY,LM(_Vd#_IR$,LM(_zda_IR$,L_4.PZqAdYJ#_Ep$,4RL.)_ksXO.VpY_$RE,L_44MZzad_Jv0R	p2R;
RsbNN0lCCLsR(z_MakZQYRR=4R;
RsbNN0lCCLsR4md_OVlj_qa	UZn Rc=R'jLjj
j;RNRbsCNl0RCsL_4dmjOlV(_qq)UnPRR=cj'Lj;j4
bRRNlsNCs0CRdL4_lmOj]V_Hnu()=PRRLc'jjj4;R
RbNNslCC0s4RLdO_ml_jVba6AnR)P='RcL4jj4R;
RsbNN0lCCLsR4m._OVlj_AT(URJt='RcLjj4jR;
RsbNN0lCCLsR4m(_OVlj_Ta	OLzJT6ehRc=R'4L4j
4;RNRbsCNl0RCsLhU_sgc_cRHb=;R6
R
RbNNslCC0sURL_chs_zNUb=RRRL6'jjjjjR;
RsbNN0lCCLsR(s_hcE_YURRR='R6Ljjjj
4;RNRbsCNl0RCsLhg_sYc_FT1bR6=R'jLjj;4j
bRRNlsNCs0CR_L(h_scNR[gRRR=64'L444j;R
RbNNslCC0s.RL.s_hcE_YU6_iU87Yw_h6NKPhR6=R'jLj4;jj
bRRNlsNCs0CR.L._chs_UYE_Ui67wY8h 6_iR.I='R6Ljj4j
j;RNRbsCNl0RCsL_4(h_scY_EUB ahlst_oRR=64'Ljjjj;R

RsbNN0lCCLsRgx_e.cM_XRnzRRR=6j'Ljjjj;R
RbNNslCC0sgRL_.exMn_mcRYRR6=R'jLjj;j4
bRRNlsNCs0CR4L4_.exMe_4nNTOR6=R'jLjj;4j
bRRNlsNCs0CR_LgeMx._nqaARRR='R6L4jjj
j;RNRbsCNl0RCsLeU_x_.McRUDR=RRRL6'jj4jj
;
RNRbsCNl0RCsL_4jO (j]nF]BRbR=dR4'jLjjjjjjjjj4;jj
R
RHkMb0cRL_KmiNR;
RbHMkL0R(1_u$gHD#R;
RbHMkL0R(W_[1P_dWR;
RbHMkL0R6P_m$;]d
HRRM0bkR_Ln80Z#d
g;RMRHbRk0Lud_p
$;RMRHbRk0LMn_VV#_wR;
RbHMkL0R44c_8paOIV_pAdu_HR;
RbHMkL0R4Mj_YdEQgw#_0R;
RbHMkL0R4P4_qdAZJ_#YX
];RMRHbRk0L_44kO)s.YXV_;X]
HRRM0bkR_L(Mjwts;7Y
HRRM0bkR4L4_aMzZvdJ_p0	;R
RFbk0kL0R61_HW;OB
FRRkk0b0gRL_Wmwh_agN
L;RkRF00bkR.L4_1PFOod_lLN#LR;
R0FkbRk0LM(_Vd#_I
$;RkRF00bkR_L(M_zad;I$
FRRkk0b04RL.q_PAJZd#pY_$
E;RkRF00bkR.L4_sk)OV.XY$_pE
;
RCRsogRL_Wmwh_agN
L;RCRsoLRrUs_hcc_gH4b-:Rj9Lmn_OsljWR;
RosCR.L4_1PFOod_lLN#LR;
RosCR_L6HO1WB
;
RCRsodRr:Rj9L_4dMtqxV_wv#Pp#dR;
RosCR:rdjL9R4Gj_F_zjW0vsXR;
RosCRUrL_chs_Hgcb:-4jL9RdV_M#R;
RosCR(rL_aMzZYQkR4-R:Rj9LMd_z
a;RCRsonRL_aMz_;Vw
sRRCLoRUz_MaK_aVRG,L_4dM_zaaGKV_Ypug
;
RCRsoLRr(z_MakZQYRR-49:jR_L(MQYEd;g#
IRRHRsCr_LUh_scgbcH-j4:9nRL_#MV_;Qw
IRRHRsCr_L(MZzaQRkY-:R4jL9Rnz_Maw_Q;R
RICHsR_LUPZqAdYJ#;R
RICHsRjL4_EMYQkd_l;[A
IRRHRsCL_4juZ16VIX_[
e;RHRIsLCR(p_u$D_nhR;
RosCR(rL_aMzZYQkRc+RRL+RUs_hcc_gHRb+4RR-49:jR.L4_sk)OV.XYL_shR;
RR//#F$Mb##$RN0sMN#D0FC_VRV
RHHM0DHNRdL4_xMqtvVw_##pP=dRRdL4_lmOj]V_Hnu()
P;RMRHHN0HDdRL_aMzR'=RL
j;R/R/RM#$F$b##sR0NDM#N_0CF
M
R#RN#MHoRjL4_EMYQkd_lR[A=RR5LM(_YdEQg=#R=LR'j;R2
NRR#o#HM4RLj1_u6XZV_eI[R5=RR_LnM_V#Q4wr9;R2
R
RNNDI$@#R@b5RF8#CoLCRci_mKFNRsFRb#oC8C4RLj1_u6XZV_eI[RR2
RHRRVL5R4uj_1V6ZX[_IeRR2LHCoMR
RRRRRLMd_V<#R=URL_chs_zNUbR;
RRRRR_LdMRza<j=R;R
RRMRC8DRC#LCRCMoH
RRRRLRRdV_M#=R<R_LnM_V#Q
w;RRRRRdRL_aMzRR<=LMn_zQa_wR;
R8CM

RRRDRNI#N$R5@@R#bFCC8oR_LcmNiKRR2
RHRRVL5RUz_MaK_aV2GR
RRRRLRR(Y_MEgQd#=R<R_LdM;za
RRRR#CDCVRH54RLdz_MaK_aVpG_uRYg2R
RRRRRLM(_YdEQg<#R=4RLj(_OjF ]]bnB;R
RRDRC#HCRVR55LMn_zVa_wRR2&5&R!jL4_EMYQkd_lR[A2R2
RRRRR_L(MQYEdRg#<L=R(Y_MEgQd#RR-4
;
RDRNI#N$R5@@R#bFCC8oR_LcmNiKRRFsbCF#8RoCL_4juZ16VIX_[
e2RRRRHRV5L_4juZ16VIX_[2eR
RRRRLRR4Md_qVxtw#v_pd#PRR<=L_4dmjOlV	_aq UnZR;
RCRRD
#CRRRRR4RLdq_MxwtVvp_##RPd<L=R4Gj_F_zjW0vsX
;
RDRNI#N$@5@RL_4dMtqxV_wv#Pp#dsRFR_LdMRzaFLsRdV_M#sRFR_L(uH1$DRg#FLsR4Mj_YdEQ_[klAsRFR_LUPZqAdYJ#2CRLo
HMRRRRL_4jGjFz_sWv0<XR=4RLdq_MxwtVvp_##;Pd
RRRR_LnM_zaV<wR='R4L
j;RRRRLmg_waWhgL_NRR<=4j'L;R
RR6RL_WH1O<BR='R4L
j;RRRRLMU_zaa_KRVG<4=R';Lj
RRRRdL4_aMz_VaKGu_pY<gR='R4L
j;RRRRLmn_OsljW=R<R_LgeMx._cmnYR;
RLRR4P._Fd1O_Nol#RLL<4=R';Lj
R
RRNRO#RC5L_4dMtqxV_wv#Pp#dRR2/#/R$bMF#R$#bNNsDDDC_#ONCR
RRRRRL_4dmjOlV	_aq UnZL:RCMoH
RRRRRRRR.L4_1PFOod_lLN#L=R<RL4'4R;
RRRRRLRR4Gj_F_zjW0vsX=R<RdL4_lmOjqV_(nqU)
P;RRRRRRRRLmn_OsljW=R<R_LgeMx._ncXzR;
RRRRRLRR4Md_zaa_K_VGpguYRR<=44'L;R
RRRRRC
M8RRRRR4RLdO_ml_jVqU(qn:)PRoLCHRM
RRRRRLRRgw_mWgha_RNL<4=R';L4
RRRRRRRR_LnmjOls<WR=gRL_.exMX_cn
z;RRRRRRRRHLV5Uq_PAJZd#&YRRL5RdV_M#9rjRL|RdV_M#9r.RL|RdV_M#9rdRL|RdV_M#9rc2L2RCMoH
RRRRRRRRLRRnz_Maw_VRR<=4R;
RRRRRRRRR5HVRjL4_EMYQkd_lR[A2CRLo
HMRRRRRRRRRRRRLMU_zaa_KRVG<4=R;R
RRRRRRRRRRnRL_aMz_RVw<j=R;R
RRRRRRRRRRgRL_Wmwh_agN<LR=;Rj
RRRRRRRRRRRR.L4_1PFOod_lLN#L=R<R
4;RRRRRRRRRRRROCN#5dRL_#MVR/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRRRRRRRRRRLRR(s_hcE_YUL:RCMoH
RRRRRRRRRRRRRRRRjL4_zGFjv_WsR0X<L=R4md_OVlj_u]H(Pn);R
RRRRRRRRRRRRRRgRL_Wmwh_agN<LR=;R4
RRRRRRRRRRRRRRRR.L4_1PFOod_lLN#L=R<R
j;
RRRRRRRRRRRRCRRMR8
RRRRRRRRRRRRRV8CN0kD:
R;RRRRRRRRRRRRCOM8N
#CRRRRRRRRRMRC8R
RRRRRRMRC8R
RRRRRC
M8RRRRR4RLdO_ml_jV](Hun:)PRoLCHRM
RRRRRLRRgw_mWgha_RNL<4=R';L4
RRRRRRRR_L6HO1WB=R<RL4'4R;
RRRRRHRRVL5R(1_u$gHD#=R=RL4'4RR2LHCoMR
RRRRRRRRRHRV5L_4jMQYEdl_k[=AR='R4L24RRoLCHRM
RRRRRRRRRLRR4Gj_F_zjW0vsX=R<R.L4_lmOjTV_(JAUtR;
RRRRRRRRR8CMR#CDCCRLo
HMRRRRRRRRRRRRL_4jGjFz_sWv0<XR=4RLdO_ml_jVba6An;)P
RRRRRRRRCRRMR8
RRRRRCRRMC8RDR#CHRV5LMd_Vc#r9L2RCMoHRR//Lh(_sNc_[Rg
RRRRRRRRRjL4_zGFjv_WsR0X<L=R4m(_OVlj_Ta	OLzJT6eh;R
RRRRRRMRC8R
RRRRRC
M8RRRRR4RLdO_ml_jVba6An:)PRoLCHRM
RRRRRLRRnO_mlWjsRR<=Leg_x_.MqAan;R
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLMn_zVa_w=R<RL4'4R;
RRRRRHRRVL5R4Mj_YdEQ_[klA=R=RL4'4RR2LHCoMR
RRRRRRRRRL_4jGjFz_sWv0<XR=4RL.O_ml_jVTU(AJ
t;RRRRRRRRC
M8RRRRRMRC8R
RRRRRL_4.mjOlV(_TAtUJ:CRLo
HMRRRRRRRRLmn_OsljW=R<R4L4_.exMe_4nNTO;R
RRRRRC
M8RRRRR4RL(O_ml_jVaO	TzTJLe:h6RoLCHRM
RRRRRLRRnO_mlWjsRR<=LeU_x_.Mc;UD
RRRRCRRMR8
RCRRMN8O#RC
R8CM
R
RNH##oLMR4k._).sOX_VYpR$E=4RL.)_ksXO.VsY_Ljhr9
;
R#RN#MHoR_L(u_p$nRDh=4RLc8_4aIOp_ApVuH_dRL?R4k._).sOX_VYsrLhj:9RR_Ldu;p$
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_a48O_pIpuVA_RdH|L|R4k4_).sOX_VYXR]2LHCoMR
RRRRRH5VRR_L(Mjwts27Y
RRRRRRRR.L4_sk)OV.XYL_shRR={_L(MQYEd,g#RdL4_xMqtvVw_##pPRd,LMd_VR#,LH6_1BWO}R;
RRRRR#CDCVRHR65L_$mP]
d2RRRRRRRRL_4.kO)s.YXV_hsLR{=RL_44MZzad_Jv0,	pR.L4_sk)OV.XYL_sh(rL_aMzZYQkRc+RRL+RUs_hcc_gH+bRR-4RR44:9
};RRRRC
M8RMRC8R
RLMU_)l_$JRstyd542LRR4M4_zaat_W	EJ5]R
RRRR(3L_1[W_WdPR(5L_1[W_WdP2R,
R3RRLMn_VV#_wLR5nV_M#w_V2R,
R3RRLMn_zVa_wLR54Mj_YdEQgw#_0
2,RRRR34L4_APqZ#dJY]_XR45L4q_PAJZd#XY_]
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR36P_m$R]dRLR56P_m$2]d,R
RRLR3nZ_8#g0dRLR5nZ_8#g0d2R,
R3RRLud_pR$RR5RRLu(_pn$_D,h2
RRRRn3L_lmOjRsWRn5L_lmOj2sW,R
RRLR3dV_M#RRRRLR5nV_M#w_Q2R,
R3RRLMd_zRaRR5RRLMn_zQa_w
2,RRRR3_LUPZqAdYJ#RRRRRU5L_APqZ#dJY
2,RRRR3_L(MjwtsR7YRRRR5_L(Mjwts27Y,R
RRLR3(V_M#I_d$RRRRLR5(V_M#I_d$
2,RRRR3_L(M_zadRI$RRRR5_L(M_zad2I$,R
RRLR34P._qdAZJ_#YpR$ERRRR5.L4_APqZ#dJY$_pE
2,RRRR3_LnuZ16VRXRR5RRL_4juZ16VIX_[2e2;C

MF8l8CkD
F
l8CkDR.L4_Wmwh_agI vC8L5R(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLu(_i_KNg
k,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L6m]P$dR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
$,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR(RL_#HptpVW,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRUq_[qD_iB
m,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_1PFOVd_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LUm]P$dt_YR
2;
bRRNlsNCs0CR_L6.j)#lRR=6
;
RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lu(_i_KNg
k;RMRHbRk0Lm6_Pd$];R
RHkMb0dRL_$up;R
RFbk0kL0Rdp_uwR;
RbHMkr0RL.6_)l#j:R49LH(_pV#tW
p;RMRHbRk0L[U_qiq_D;Bm
FRRkk0b04RLdF_P1_OdVsG.L;kT
FRRkk0b0URL_$mP]Yd_t
;
RCRsoLRr6)_.#:jljL9RnF_$s7ju;R
RICHsR6rL_#.)j4l:9(RL_s$Fjku7;R
RsRCoL_4dPOF1dG_V.ksLTR;
RosCR_LUm]P$dt_Y;R

R#N#HRoMLud_p=wRR_Ln$jFsuj7r9
;
RDRNI#N$R5@@Lm6_Pd$]RRFsLu(_i_KNgRk2LHCoMR
RR4RLdF_P1_OdVsG.LRkT<4=R';Lj
RRRR_LUm]P$dt_YRR<=4j'L;R
RRVRH5(RL_KuiNk_gRL2RCMoH
RRRRHRRV!5RLm6_Pd$]RR2
RRRRRLRR4Pd_Fd1O_.VGsTLkRR<=44'L;R
RRRRRCCD#
RRRRRRRR_LUm]P$dt_YRR<=44'L;R
RRMRC8R
RC
M8
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVR_L(uNiK_Rgk2CRLo
HMRRRRRVRH5LR!6P_m$R]d2CRLo
HMRRRRRRRRL$n_Fusj76rL_#.)j4l:9=R<R_L(Htp#V;Wp
RRRRRRRR_Ln$jFsuj7r9=R<R_LU[_qqimDB;R
RRRRRCRM8CCD#
RRRRRRRR_Ln$jFsu<7R=LR{dp_u$L,R(F_$s7juk
};RRRRC
M8RMRC8R

R#N#HRoML$(_Fusj7=kRR_Ln$jFsuL7r6)_.#Rjl:9R4;M
C88lFk
DC
F
l8CkDRMtCCOsH)sqvNLl_D	FORN5s8,8sR#L._	0O,NR80FN_kR0,I8N8sI,RCRM,#	OD,NR80HN_MI,RsCH0_NCMLRDC2H;
M0bkR#L._	0O;M
HbRk0rR44-:R4js9RNs88;k
F00bkRRrg-:R4j89RN_0NF;k0
bHMkI0RCRM,#	OD;M
HbRk0rR44-:R4jI9RNs88;M
HbRk0r-gRRj4:9NR80HN_MH;
M0bkRHIs0CC_MDNLCI;
HRsCsM_CNRL,IM_CN
L;
NRR#o#HM_RsCLMNR!=RRMIC;R
RNH##oIMR_NCMLRR=I0sHCM_CNCLDRI&RC
M;RqR)vnA4__1g1#gR$LM_D	FO_lsNRR5
R3RRq)77qI5RNs88RR2,
RRRRQ37qR5RR08NNM_Hr-URRR4:j29R,RR
R3RR75mq2
,RRRRR
RRRR73q75)AR8sN82sR,RR
R3RR75QARURR'RLj2
,RRRRR3A7m5RRR8NN0_0Fkr-URRR4:j29R,RR
R
RRRRRR3u7QqR5R8NN0_rHMgRR-49:URR2,
RRRRm37u2q5,RR
R3RR7AQu54RR'RLj2
,RRRRR3u7mAR5R8NN0_0Fkr-gRRU4:9,R2RR
RRRR
R3RRW5 qR'R4L24R,RR
R3RR1q1)5'R4L2jR,RR
R3RR 5hqR_RICLMNRR2,
RRRRp3BiRq5#	ODRR2,
RRRR 3WAR5R4j'LRR2,
RRRR131)RA54j'LRR2,
RRRRh3 AR5RsM_CN2LR,RR
R3RRBApi5.RL#O_0	2R2;CR
MF8l8CkD
F
l8CkDRlsN1ODHClsN_FLDO5	RR8sN8Rs,L_.#0,O	R08NNk_F0I,RNs88,CRIM#,RO,D	R08NNM_HR
2;HkMb0.RL#O_0	H;
M0bkR.r4:Rj9s8N8sF;
kk0b0URr:Rj98NN0_0Fk;M
HbRk0I,CMRD#O	H;
M0bkR.r4:Rj9I8N8sH;
M0bkR:rUj89RN_0NH
M;
sIHCURr:Rj980Fkjt;
CsMCHqO)vlsN_FLDOt	RCsMCHqO)v#QM05jRRN3s858ss8N8sjr4:2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k080Fkj
2,R3RRI8N8sN5I8r8s4jj:9
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_2HM,R
RRs3IH_0CCLMND5C5R8IN84sr.4:49=R=R8.'j2R22
;
ICHsR:rUj89RF4k0;C
tMHCsOv)qs_NlLODF	CRtMHCsOv)qQ0M#4RR538sN8ss5Ns88r:4jj,92RR
RR.3L#O_0	.5L#O_0	
2,R3RRI5CMI2CM,R
RRN380FN_k805F4k02R,
RIR3Ns8858IN84srj9:j2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH,M2
RRR3HIs0CC_MDNLCR55I8N8s.r4:944RR==.4'8R222;I

HRsCrjU:9FR8k;0.
MtCCOsH)sqvNLl_D	FORMtCCOsH)QqvM.#0R35Rs8N8sN5s8r8s4jj:9R2,
RRR3#L._	0O5#L._	0O2R,
RIR3CIM5C,M2
RRR308NNk_F0F58k20.,R
RRN3I858sI8N8sjr4:2j9,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5I5RNs88r:4.4R49=.=R'R8.2;22
H
IsrCRU9:jRk8F0
d;tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0d5sR3Ns8858sN84srj9:j2
,RR3RRL_.#05O	L_.#02O	,R
RRC3IMC5IM
2,R3RR8NN0_0Fk5k8F0,d2
RRR38IN8Is5Ns88r:4jj,92
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_H2R,
RIR3sCH0_NCML5DC5NRI8r8s44.:4=9R='R.82dR2
2;sRCorjU:9NR80FN_k
0;RINDN@$#@RR5s8N8ssRFRk8F0FjRsFR8kR04F8sRF.k0RRFs80FkdRR2LHCoMR
RR#ONCRR5s8N8s.r4:944R/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRR'R.8:jRRNR80FN_k=0RRk8F0
j;RRRRR8.'4RR:R08NNk_F0RR=80Fk4R;
RRRR..'8RR:R8NN0_0FkR8=RF.k0;R
RR.RR'R8d:8RRN_0NFRk0=FR8k;0d
RRRCOM8N
#CR8CMRN//D$IN#M
C88lFk
DC
8lFkRDCs_NlLODF	RR5s8N8sL,R.0#_OR	,8NN0_0Fk,NRI8,8sRNIC,OR#DR	,8NN0_RHM2H;
M0bkR#L._	0O;M
HbRk0rR4.:9RjR8sN8
s;Fbk0kr0R.Rcj:9RjR08NNk_F0H;
M0bkRNIC,OR#D
	;HkMb04Rr.RR:jI9RNs88;M
HbRk0rj.cRj:R9NR80HN_MI;
HRsCr..c:Rj98NN0_0Fk_b0l;s

NDl1HsOCNLl_D	FORlsN1ODHC#QM05jRRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr:URR2j9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr:URR2j92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM054RRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrR4(:9Rg2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M(r4Rg:R9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM.#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l.brnRR:42U9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR.n:UR49;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMd#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_ldbr6RR:.2(9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRd6:(R.9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMc#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lcbrcRR:d2n9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRcc:nRd9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM6#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l6brdRR:c269,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR6d:6Rc9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMn#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lnbr.RR:62c9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRn.:cR69;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM(#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l(br4RR:n2d9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR(4:dRn9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMU#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lUbrjRR:(2.9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRUj:.R(9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCMg#0R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lUbrgRR:U249,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRUg:4RU9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0jRR538sN8ss5Ns88rR4.:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlbg:URR9gj2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_MUrgRg:Rj292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#454RRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr(4jRg:Rg,92
RRR38IN8Is5Ns88rR4d-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4Rj(:gRg9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0.RR538sN8ss5Ns88rR4.:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4R4n:jR4U,92
RRR38IN8Is5Ns88rR4d-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4R4n:jR4U292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45dRRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr64.R4:R42(9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr64.R4:R42(92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R4c5sR3Ns8858sN84sr.RR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bdr4cRR:49.n2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_Mdr4cRR:49.n2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#604R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4brc:dRR64d9
2,R3RRI8N8sN5I8r8s4-dRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mrc:dRR64d9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0nRR538sN8ss5Ns88rR4.:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4R6.:cR4c,92
RRR38IN8Is5Ns88rR4d-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4R6.:cR4c292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45(RRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr44nR4:R62d9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr44nR4:R62d92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R4U5sR3Ns8858sN84sr.RR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0b(r4jRR:49n.2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M(r4jRR:49n.2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#g04R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4br(:gRR44(9
2,R3RRI8N8sN5I8r8s4-dRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mr(:gRR44(9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM.#0jRR538sN8ss5Ns88rR4.:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4RUU:UR4j,92
RRR38IN8Is5Ns88rR4d-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4RUU:UR4j292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#.54RRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr(4gR4:RU2g9,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hr(4gR4:RU2g92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R..5sR3Ns8858sN84sr.RR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bjr.nRR:49gU2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_Mjr.nRR:49gU2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#d0.R35Rs8N8sN5s8r8s4:.RR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l.br4:6RR(.j9
2,R3RRI8N8sN5I8r8s4-dRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH.Mr4:6RR(.j9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM.#0cRR538sN8ss5Ns88rR4.:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb.R.c:4R.n,92
RRR38IN8Is5Ns88rR4d-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM.R.c:4R.n292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#.56RRN3s858ss8N8s.r4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrd.dR.:R.269,R
RRN3I858sI8N8sdr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hrd.dR.:R.2692s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R.n5sR3Ns8858sN84sr.RR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bcr..RR:.9dc2R,
RIR3Ns8858IN84srdRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_M.5{',LjR08NNM_Hrj.cR.:Rd}c92
2;R#N#HRoM8NN0_0FkR8=RN_0NF_k00rlb.Rcj:9Rj;M
C88lFk
DC
8lFkRDCLm(_waWhgR#5Lmc_i,KN
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L([_W1d,PW
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L(uNiK_,gk
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L6m]P$dR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR6F_P1,Od
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L(mhwWa,gp
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgmhwWaNg_L;R2
R
RHkMb0cRL_KmiNR;
RbHMkL0R(W_[1P_dWR;
RbHMkL0R(i_uKgN_kR;
RbHMkL0R6P_m$;]d
FRRkk0b0dRL_wup;R
RHkMb06RL_1PFO
d;RMRHbRk0rj.cRj:R9(RL_Wmwhpag;R
RHkMb0gRL_Wmwh_agN
L;
sRRCroR4:.RRRj9LPg__Blx7#YX,gRL_l._xYB7XR#,LwU_ZpwwX;Y 
IRRHRsCrR4.:9RjRjL4_lP_xYB7X;#0
IRRHRsCrj.cRj:R9(RL_WPw_vuD;R
RICHsRjL4_xmFw_Ihi;)p
IRRHRsCL_4cPOF1ds_#.]	wT
x;RHRIsLCRgF_mxhwI_;NL
sRRCLoR.F_.;R
RsRCoL_44.tw#_sgkX;AL
sRRCLoR4P4_w_#tgXksA
L;RCRsoURL_q[q_BiDmR;
RosCRcr.4RR:jL9R(Y_MKw_AvR;
RsIHC.Rrc:4RRRj9LMU_YAK_w;vt
sRRCroR.Rcd:9RjR_L(m$.$V;_w
sRRCroRn:dRRRj9Lm(_.V$$_
t;RCRso4Rr6RR:jL9R(._m$_$VIR;
RosCRRrd:9RjR_L(m$.$V;_C
sRRCLoR(._m$_$V 
j;
/RR/$R#M#Fb$0#Rs#NMDCN0_VFV
HRRMHH0NLDRg__Pl7xBYRX#=~R5Rj'L2R;
RHHM0DHNR_Lg.x_lBX7Y#RR=5'~RL;j2
/RR/$R#M#Fb$0#Rs#NMDCN0_
FM
sRRNLl_D	FOR_Ld1RFW5R
RRLR3.0#_OR	R5_L([_W1d2PW,R
RR#R3ORD	RRRR5_LcmNiK2R,
R3RRs8N8sRRRRg5L_lP_xYB7X,#2
RRRRN3I8R8sR5RRL.g__Blx7#YX2R,
R3RR8NN0_RHMR(5L_Wmwhpag2R,
R3RR8NN0_0FkR(5L_WPw_vuD2R,
R3RRIRCNRRRRR.5L_2.F2
;
R4RL.w_mWgha_CIv y8R524dR4L4_Wmwh_agX]4CRR5
R3RRL[(_Wd1_P5WRL[(_Wd1_P,W2
RRRR(3L_KuiNk_gR(5L_KuiNk_g2R,
R3RRLm6_Pd$]R65L_$mP],d2
RRRRd3L_$upR45LjF_mxhwI_pi)2R,
R3RRLud_p5wRLud_p,w2
RRRR(3L_#HptpVWRU5L_wwZwYpX 
2,RRRR3_LU[_qqimDBRU5L_q[q_BiDm
2,RRRR3dL4_1PFOVd_GL.sk5TRL_4cPOF1ds_#.]	wT,x2
RRRRU3L_$mP]Yd_tLR5gF_mxhwI_2NLR
2;
NRRD$IN#@R@5_LgmhwWaNg_LL2RCMoH
RRRR4L4_#.wtk_gsLXARR<=4j'L;R
RR.RL_R.F<4=R';Lj
RRRR5HVR_LgmhwWaNg_LRR2LHCoMR
RRRRRL.._F=R<RL4'4R;
RRRRR4L4_#.wtk_gsLXARR<=44'L;R
RRMRC8R
RC
M8
NRRD$IN#@R@5_LUM_YKAtwvRRFsLmg_FIxwhL_N2CRLo
HMRRRRL_44Ptw#_sgkXRAL<4=R';Lj
RRRR5HV5gRL_xmFw_IhN2LRRR&&5URL_KMY_vAwtcr.429R2R
RRRRRL_44Ptw#_sgkXRAL<4=R';L4
CRRM
8
RDRNI#N$R5@@bCF#8RoCLmc_iRKN2CRLo
HMRRRRHRV5LP6_Fd1ORL2RCMoH
RRRRLRRg__.l7xBYRX#<'=RL
j;RRRRRURL_wwZwYpX =R<Rj'L;R
RRRRRL[U_qiq_DRBm<4=R';Lj
RRRR8CMR#CDCVRH54RL4w_.#gt_kAsXLRR2LHCoMR
RRRRRLwU_ZpwwXRY <L=Rg__.l7xBY;X#
RRRRHRRVL5Rg__.l7xBYRX#=U=R4Rg42CRLo
HMRRRRRRRRL.g__Blx7#YXRR<=';Lj
RRRRRRRR_LU[_qqimDBRR<=44'L;R
RRRRRCRM8CCD#
RRRRRRRR_Lg.x_lBX7Y#=R<R_Lg.x_lBX7Y#RR+4R;
RCRRMR8
R8CM
R
RNNDI$@#R@F5b#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_1PFO#d_sw.	]RTx2R
RRRRRLPg__Blx7#YXRR<=';Lj
RRRR#CDCVRH54RL4w_P#gt_kAsXLRR2LHCoMR
RRRRRHRV5LPg__Blx7#YXRR==U44gRR2
RRRRRLRRg__Pl7xBYRX#<'=RL
j;RRRRRDRC#RC
RRRRRLRRg__Pl7xBYRX#<L=R4Pj__Blx7#YX0RR+4R;
RCRRMR8
R8CM
R
RNH##oLMR4Pj__Blx7#YX0RR=LPg__Blx7#YX;R
RNH##oLMRUY_MKw_AvRtRRL=R(Y_MKw_AvR;
R#N#HRoML_4jmwFxIih_)=pRR_L(m$.$Vj_ ;R
RNNDI$@#R@F5b#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_1PFO#d_sw.	]RTx2CRLo
HMRRRRR(RL_KMY_vAwrRj9<4=R';L4
RRRRLRR(Y_MKw_Avcr.4RR:4<9R=LR'jR;
RCRRMC8RDR#CHRV5Lmg_FIxwhL_NRR2
RRRRR_L(M_YKARwv<{=RLMU_YAK_wrvt.Rcj:9Rj,URL_KMY_vAwtcr.4;9}
CRRM
8
RDRNI#N$R5@@LP(_wuW_DFvRs(RL_KMY_vAw2CRLo
HMRRRRLm(_.V$$_.wrc:jRRRj9=(RL_WPw_vuDRL&R(Y_MKw_Avcr.4RR:4
9;RRRRLm(_.V$$_.wrcR49='R4L
j;RRRRLm(_.V$$_.wrcR.9='R4L
j;RRRRLm(_.V$$_.wrcRd9='R4L
j;RRRRLm(_.V$$_jtr9RR=Lm(_.V$$_jwr9|R|R_L(m$.$Vr_w4|9R|(RL_$m.$wV_rR.9|L|R(._m$_$Vw9rd;R
RR(RL_$m.$tV_rR49=(RL_$m.$wV_rRc9|L|R(._m$_$Vw9r6RR||Lm(_.V$$_nwr9|R|R_L(m$.$Vr_w(
9;RRRRLm(_.V$$_.tr9RR=Lm(_.V$$_Uwr9|R|R_L(m$.$Vr_wg|9R|(RL_$m.$wV_r94jRR||Lm(_.V$$_4wr4
9;RRRRLm(_.V$$_dtr9RR=Lm(_.V$$_4wr.|9R|(RL_$m.$wV_r94dRR||Lm(_.V$$_4wrc|9R|(RL_$m.$wV_r946;R
RR(RL_$m.$tV_rRc9=(RL_$m.$wV_r94nRR||Lm(_.V$$_4wr(|9R|(RL_$m.$wV_r94URR||Lm(_.V$$_4wrg
9;RRRRLm(_.V$$_6tr9RR=Lm(_.V$$_.wrj|9R|(RL_$m.$wV_r9.4RR||Lm(_.V$$_.wr.|9R|(RL_$m.$wV_r9.d;R
RR(RL_$m.$tV_rRn9=(RL_$m.$wV_r9.cRR||Lm(_.V$$_.wr6|9R|(RL_$m.$wV_r9.nRR||Lm(_.V$$_.wr(
9;RRRRLm(_.V$$_(tr9RR=Lm(_.V$$_.wrU|9R|(RL_$m.$wV_r9.gRR||Lm(_.V$$_dwrj|9R|(RL_$m.$wV_r9d4;R
RR(RL_$m.$tV_rRU9=(RL_$m.$wV_r9d.RR||Lm(_.V$$_dwrd|9R|(RL_$m.$wV_r9dcRR||Lm(_.V$$_dwr6
9;RRRRLm(_.V$$_gtr9RR=Lm(_.V$$_dwrn|9R|(RL_$m.$wV_r9d(RR||Lm(_.V$$_dwrU|9R|(RL_$m.$wV_r9dg;R
RR(RL_$m.$tV_r94jRL=R(._m$_$Vwjrc9|R|R_L(m$.$Vr_wcR49|L|R(._m$_$Vw.rc9|R|R_L(m$.$Vr_wc;d9
RRRR_L(m$.$Vr_t4R49=(RL_$m.$wV_r9ccRR||Lm(_.V$$_cwr6|9R|(RL_$m.$wV_r9cnRR||Lm(_.V$$_cwr(
9;RRRRLm(_.V$$_4tr.=9RR_L(m$.$Vr_wcRU9|L|R(._m$_$Vwgrc9|R|R_L(m$.$Vr_w6Rj9|L|R(._m$_$Vw4r69R;
RLRR(._m$_$Vtdr49RR=Lm(_.V$$_6wr.|9R|(RL_$m.$wV_r96dRR||Lm(_.V$$_6wrc|9R|(RL_$m.$wV_r966;R
RR(RL_$m.$tV_r94cRL=R(._m$_$Vwnr69|R|R_L(m$.$Vr_w6R(9|L|R(._m$_$VwUr69|R|R_L(m$.$Vr_w6;g9
RRRR_L(m$.$Vr_t4R69=(RL_$m.$wV_r9njRR||Lm(_.V$$_nwr4|9R|(RL_$m.$wV_r9n.RR||Lm(_.V$$_nwrd
9;RRRRLm(_.V$$_4trn=9RR_L(m$.$Vr_wnRc9|L|R(._m$_$Vw6rn9|R|R_L(m$.$Vr_wnRn9|L|R(._m$_$Vw(rn9R;
RLRR(._m$_$Vt(r49RR=Lm(_.V$$_nwrU|9R|(RL_$m.$wV_r9ngRR||Lm(_.V$$_(wrj|9R|(RL_$m.$wV_r9(4;R
RR(RL_$m.$tV_r94URL=R(._m$_$Vw.r(9|R|R_L(m$.$Vr_w(Rd9|L|R(._m$_$Vwcr(9|R|R_L(m$.$Vr_w(;69
RRRR_L(m$.$Vr_t4Rg9=(RL_$m.$wV_r9(nRR||Lm(_.V$$_(wr(|9R|(RL_$m.$wV_r9(URR||Lm(_.V$$_(wrg
9;RRRRLm(_.V$$_.trj=9RR_L(m$.$Vr_wURj9|L|R(._m$_$Vw4rU9|R|R_L(m$.$Vr_wUR.9|L|R(._m$_$VwdrU9R;
RLRR(._m$_$Vt4r.9RR=Lm(_.V$$_Uwrc|9R|(RL_$m.$wV_r9U6RR||Lm(_.V$$_Uwrn|9R|(RL_$m.$wV_r9U(;R
RR(RL_$m.$tV_r9..RL=R(._m$_$VwUrU9|R|R_L(m$.$Vr_wURg9|L|R(._m$_$Vwjrg9|R|R_L(m$.$Vr_wg;49
RRRR_L(m$.$Vr_t.Rd9=(RL_$m.$wV_r9g.RR||Lm(_.V$$_gwrd|9R|(RL_$m.$wV_r9gcRR||Lm(_.V$$_gwr6
9;RRRRLm(_.V$$_.trc=9RR_L(m$.$Vr_wgRn9|L|R(._m$_$Vw(rg9|R|R_L(m$.$Vr_wgRU9|L|R(._m$_$Vwgrg9R;
RLRR(._m$_$Vt6r.9RR=Lm(_.V$$_4wrjRj9|L|R(._m$_$Vwjr44|9R|(RL_$m.$wV_r.4j9|R|R_L(m$.$Vr_w49jd;R
RR(RL_$m.$tV_r9.nRL=R(._m$_$Vwjr4c|9R|(RL_$m.$wV_r64j9|R|R_L(m$.$Vr_w49jnRR||Lm(_.V$$_4wrj;(9
RRRR_L(m$.$Vr_t.R(9=(RL_$m.$wV_rU4j9|R|R_L(m$.$Vr_w49jgRR||Lm(_.V$$_4wr4Rj9|L|R(._m$_$Vw4r44
9;RRRRLm(_.V$$_.trU=9RR_L(m$.$Vr_w494.RR||Lm(_.V$$_4wr4Rd9|L|R(._m$_$Vw4r4c|9R|(RL_$m.$wV_r6449R;
RLRR(._m$_$Vtgr.9RR=Lm(_.V$$_4wr4Rn9|L|R(._m$_$Vw4r4(|9R|(RL_$m.$wV_rU449|R|R_L(m$.$Vr_w494g;R
RR(RL_$m.$tV_r9djRL=R(._m$_$Vw.r4j|9R|(RL_$m.$wV_r44.9|R|R_L(m$.$Vr_w49..RR||Lm(_.V$$_4wr.;d9
RRRR_L(m$.$Vr_tdR49=(RL_$m.$wV_rc4.9|R|R_L(m$.$Vr_w49.6RR||Lm(_.V$$_4wr.Rn9|L|R(._m$_$Vw.r4(
9;RRRRLm(_.V$$_dtr.=9RR_L(m$.$Vr_w49.URR||Lm(_.V$$_4wr.Rg9|L|R(._m$_$Vwdr4j|9R|(RL_$m.$wV_r44d9R;
RLRR(._m$_$Vtdrd9RR=Lm(_.V$$_4wrdR.9|L|R(._m$_$Vwdr4d|9R|(RL_$m.$wV_rc4d9|R|R_L(m$.$Vr_w49d6;R
RR(RL_$m.$tV_r9dcRL=R(._m$_$Vwdr4n|9R|(RL_$m.$wV_r(4d9|R|R_L(m$.$Vr_w49dURR||Lm(_.V$$_4wrd;g9
RRRR_L(m$.$Vr_tdR69=(RL_$m.$wV_rj4c9|R|R_L(m$.$Vr_w49c4RR||Lm(_.V$$_4wrcR.9|L|R(._m$_$Vwcr4d
9;RRRRLm(_.V$$_dtrn=9RR_L(m$.$Vr_w49ccRR||Lm(_.V$$_4wrcR69|L|R(._m$_$Vwcr4n|9R|(RL_$m.$wV_r(4c9R;
RLRR(._m$_$Vt(rd9RR=Lm(_.V$$_4wrcRU9|L|R(._m$_$Vwcr4g|9R|(RL_$m.$wV_rj469|R|R_L(m$.$Vr_w4964;R
RR(RL_$m.$tV_r9dURL=R(._m$_$Vw6r4.|9R|(RL_$m.$wV_rd469|R|R_L(m$.$Vr_w496cRR||Lm(_.V$$_4wr6;69
RRRR_L(m$.$Vr_tdRg9=(RL_$m.$wV_rn469|R|R_L(m$.$Vr_w496(RR||Lm(_.V$$_4wr6RU9|L|R(._m$_$Vw6r4g
9;RRRRLm(_.V$$_ctrj=9RR_L(m$.$Vr_w49njRR||Lm(_.V$$_4wrnR49|L|R(._m$_$Vwnr4.|9R|(RL_$m.$wV_rd4n9R;
RLRR(._m$_$Vt4rc9RR=Lm(_.V$$_4wrnRc9|L|R(._m$_$Vwnr46|9R|(RL_$m.$wV_rn4n9|R|R_L(m$.$Vr_w49n(;R
RR(RL_$m.$tV_r9c.RL=R(._m$_$Vwnr4U|9R|(RL_$m.$wV_rg4n9|R|R_L(m$.$Vr_w49(jRR||Lm(_.V$$_4wr(;49
RRRR_L(m$.$Vr_tcRd9=(RL_$m.$wV_r.4(9|R|R_L(m$.$Vr_w49(dRR||Lm(_.V$$_4wr(Rc9|L|R(._m$_$Vw(r46
9;RRRRLm(_.V$$_ctrc=9RR_L(m$.$Vr_w49(nRR||Lm(_.V$$_4wr(R(9|L|R(._m$_$Vw(r4U|9R|(RL_$m.$wV_rg4(9R;
RLRR(._m$_$Vt6rc9RR=Lm(_.V$$_4wrURj9|L|R(._m$_$VwUr44|9R|(RL_$m.$wV_r.4U9|R|R_L(m$.$Vr_w49Ud;R
RR(RL_$m.$tV_r9cnRL=R(._m$_$VwUr4c|9R|(RL_$m.$wV_r64U9|R|R_L(m$.$Vr_w49UnRR||Lm(_.V$$_4wrU;(9
RRRR_L(m$.$Vr_tcR(9=(RL_$m.$wV_rU4U9|R|R_L(m$.$Vr_w49UgRR||Lm(_.V$$_4wrgRj9|L|R(._m$_$Vwgr44
9;RRRRLm(_.V$$_ctrU=9RR_L(m$.$Vr_w49g.RR||Lm(_.V$$_4wrgRd9|L|R(._m$_$Vwgr4c|9R|(RL_$m.$wV_r64g9R;
RLRR(._m$_$Vtgrc9RR=Lm(_.V$$_4wrgRn9|L|R(._m$_$Vwgr4(|9R|(RL_$m.$wV_rU4g9|R|R_L(m$.$Vr_w49gg;R
RR(RL_$m.$tV_r96jRL=R(._m$_$Vwjr.j|9R|(RL_$m.$wV_r4.j9|R|R_L(m$.$Vr_w.9j.RR||Lm(_.V$$_.wrj;d9
RRRR_L(m$.$Vr_t6R49=(RL_$m.$wV_rc.j9|R|R_L(m$.$Vr_w.9j6RR||Lm(_.V$$_.wrjRn9|L|R(._m$_$Vwjr.(
9;RRRRLm(_.V$$_6tr.=9RR_L(m$.$Vr_w.9jURR||Lm(_.V$$_.wrjRg9|L|R(._m$_$Vw4r.j|9R|(RL_$m.$wV_r4.49R;
RLRR(._m$_$Vtdr69RR=Lm(_.V$$_.wr4R.9|L|R(._m$_$Vw4r.d|9R|(RL_$m.$wV_rc.49|R|R_L(m$.$Vr_w.946;R
RR(RL_$m.$tV_r96cRL=R(._m$_$Vw4r.n|9R|(RL_$m.$wV_r(.49|R|R_L(m$.$Vr_w.94URR||Lm(_.V$$_.wr4;g9
RRRR_L(m$.$Vr_t6R69=(RL_$m.$wV_rj..9|R|R_L(m$.$Vr_w.9.4RR||Lm(_.V$$_.wr.R.9|L|R(._m$_$Vw.r.d
9;RRRRLm(_.V$$_6trn=9RR_L(m$.$Vr_w.9.cRR||Lm(_.V$$_.wr.R69|L|R(._m$_$Vw.r.n|9R|(RL_$m.$wV_r(..9R;
RLRR(._m$_$Vt(r69RR=Lm(_.V$$_.wr.RU9|L|R(._m$_$Vw.r.g|9R|(RL_$m.$wV_rj.d9|R|R_L(m$.$Vr_w.9d4;R
RR(RL_$m.$tV_r96URL=R(._m$_$Vwdr..|9R|(RL_$m.$wV_rd.d9|R|R_L(m$.$Vr_w.9dcRR||Lm(_.V$$_.wrd;69
RRRR_L(m$.$Vr_t6Rg9=(RL_$m.$wV_rn.d9|R|R_L(m$.$Vr_w.9d(RR||Lm(_.V$$_.wrdRU9|L|R(._m$_$Vwdr.g
9;RRRRLm(_.V$$_ntrj=9RR_L(m$.$Vr_w.9cjRR||Lm(_.V$$_.wrcR49|L|R(._m$_$Vwcr..|9R|(RL_$m.$wV_rd.c9R;
RLRR(._m$_$Vt4rn9RR=4j'L;R
RR(RL_$m.$tV_r9n.R4=R';Lj
RRRR_L(m$.$Vr_tnRd9='R4L
j;RRRRLm(_.V$$_jIr9RR=Lm(_.V$$_jtr9|R|R_L(m$.$Vr_t4|9R|(RL_$m.$tV_rR.9|L|R(._m$_$Vt9rd;R
RR(RL_$m.$IV_rR49=(RL_$m.$tV_rRc9|L|R(._m$_$Vt9r6RR||Lm(_.V$$_ntr9|R|R_L(m$.$Vr_t(
9;RRRRLm(_.V$$_.Ir9RR=Lm(_.V$$_Utr9|R|R_L(m$.$Vr_tg|9R|(RL_$m.$tV_r94jRR||Lm(_.V$$_4tr4
9;RRRRLm(_.V$$_dIr9RR=Lm(_.V$$_4tr.|9R|(RL_$m.$tV_r94dRR||Lm(_.V$$_4trc|9R|(RL_$m.$tV_r946;R
RR(RL_$m.$IV_rRc9=(RL_$m.$tV_r94nRR||Lm(_.V$$_4tr(|9R|(RL_$m.$tV_r94URR||Lm(_.V$$_4trg
9;RRRRLm(_.V$$_6Ir9RR=Lm(_.V$$_.trj|9R|(RL_$m.$tV_r9.4RR||Lm(_.V$$_.tr.|9R|(RL_$m.$tV_r9.d;R
RR(RL_$m.$IV_rRn9=(RL_$m.$tV_r9.cRR||Lm(_.V$$_.tr6|9R|(RL_$m.$tV_r9.nRR||Lm(_.V$$_.tr(
9;RRRRLm(_.V$$_(Ir9RR=Lm(_.V$$_.trU|9R|(RL_$m.$tV_r9.gRR||Lm(_.V$$_dtrj|9R|(RL_$m.$tV_r9d4;R
RR(RL_$m.$IV_rRU9=(RL_$m.$tV_r9d.RR||Lm(_.V$$_dtrd|9R|(RL_$m.$tV_r9dcRR||Lm(_.V$$_dtr6
9;RRRRLm(_.V$$_gIr9RR=Lm(_.V$$_dtrn|9R|(RL_$m.$tV_r9d(RR||Lm(_.V$$_dtrU|9R|(RL_$m.$tV_r9dg;R
RR(RL_$m.$IV_r94jRL=R(._m$_$Vtjrc9|R|R_L(m$.$Vr_tcR49|L|R(._m$_$Vt.rc9|R|R_L(m$.$Vr_tc;d9
RRRR_L(m$.$Vr_I4R49=(RL_$m.$tV_r9ccRR||Lm(_.V$$_ctr6|9R|(RL_$m.$tV_r9cnRR||Lm(_.V$$_ctr(
9;RRRRLm(_.V$$_4Ir.=9RR_L(m$.$Vr_tcRU9|L|R(._m$_$Vtgrc9|R|R_L(m$.$Vr_t6Rj9|L|R(._m$_$Vt4r69R;
RLRR(._m$_$VIdr49RR=Lm(_.V$$_6tr.|9R|(RL_$m.$tV_r96dRR||Lm(_.V$$_6trc|9R|(RL_$m.$tV_r966;R
RR(RL_$m.$IV_r94cRL=R(._m$_$Vtnr69|R|R_L(m$.$Vr_t6R(9|L|R(._m$_$VtUr69|R|R_L(m$.$Vr_t6;g9
RRRR_L(m$.$Vr_I4R69=(RL_$m.$tV_r9njRR||Lm(_.V$$_ntr4|9R|(RL_$m.$tV_r9n.RR||Lm(_.V$$_ntrd
9;RRRRLm(_.V$$_jCr9RR=Lm(_.V$$_jIr9|R|R_L(m$.$Vr_I4|9R|(RL_$m.$IV_rR.9|L|R(._m$_$VI9rd;R
RR(RL_$m.$CV_rR49=(RL_$m.$IV_rRc9|L|R(._m$_$VI9r6RR||Lm(_.V$$_nIr9|R|R_L(m$.$Vr_I(
9;RRRRLm(_.V$$_.Cr9RR=Lm(_.V$$_UIr9|R|R_L(m$.$Vr_Ig|9R|(RL_$m.$IV_r94jRR||Lm(_.V$$_4Ir4
9;RRRRLm(_.V$$_dCr9RR=Lm(_.V$$_4Ir.|9R|(RL_$m.$IV_r94dRR||Lm(_.V$$_4Irc|9R|(RL_$m.$IV_r946;R
RR(RL_$m.$ V_jRR=Lm(_.V$$_jCr9|R|R_L(m$.$Vr_C4|9R|(RL_$m.$CV_rR.9|L|R(._m$_$VC9rd;R
RC
M8
8CMlkF8D
C
lkF8DLCR4M._Pplw_4DNG5$]RdL4_lMPwVp_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNT_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpN)_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpN]_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNb_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNu_L
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_paN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pxN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pQN2LR;R

RsbNN0lCCLsRUH_h_UmNg=.RR
c;RNRbsCNl0RCsL_4dmOFKAWX_G)zniRR=cj'Lj;jj
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=pRRLc'j4jj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)A='RcL4jjjR;
RsbNN0lCCLsR4md_FAKOXG_Wz[n)Rc=R'jLj4
4;RNRbsCNl0RCsL_4dmOFKAWX_G)znK=jRRLc'jj4j;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)h='RcLjj44R;
RsbNN0lCCLsR4md_FAKOXG_Wz0n)Rc=R'4Lj4
j;RNRbsCNl0RCsL_4dmOFKAWX_G)znBRR=cj'L4;44
R
RHkMb0LRrUH_h_UmNg4.:94RLdP_Ml_wpVsG.L;kT
HRRM0bkR4L4_sk)Ok_gsLXA;R
RFbk0kL0RgP_MlTwp_;NL
FRRkk0b0gRL_lMPw_p)N
L;RkRF00bkR_LgMwPlpN]_LR;
R0FkbRk0LMg_PplwbL_N;R
RFbk0kL0RgP_Mluwp_jNL;R
RFbk0kL0RgP_Mlawp_;NL
FRRkk0b0gRL_lMPw_pxN
L;RkRF00bkR_LgMwPlpNQ_LR;
RosCR_LgMwPlpNT_LR;
RosCR_LgMwPlpN)_LR;
RosCR_LgMwPlpN]_LR;
RosCR_LgMwPlpNb_LR;
RosCR_LgMwPlpNu_L
j;RCRsogRL_lMPw_paN
L;RCRsogRL_lMPw_pxN
L;RCRsogRL_lMPw_pQN
L;
R
RNNDI$@#R@LR54Md_Pplw_.VGsTLkRRFsL_44kO)s_sgkX2ALRoLCHRM
RLRRgP_MlTwp_RNL<4=R';Lj
RRRR_LgMwPlpN)_L=R<RL4'jR;
RLRRgP_Ml]wp_RNL<4=R';Lj
RRRR_LgMwPlpNb_L=R<RL4'jR;
RLRRgP_Mluwp_jNLRR<=4j'L;R
RRgRL_lMPw_paN<LR='R4L
j;RRRRLMg_PplwxL_NRR<=4j'L;R
RRgRL_lMPw_pQN<LR='R4L
j;RRRRH5VRL_44kO)s_sgkXRAL=4=R'2L4RoLCHRM
RRRRR#ONCL5R4Md_Pplw_.VGsTLkR/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRRRRRRdL4_KmFO_AXWnGz)Ri:LMg_PplwTL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)pR_LgMwPlpN)_L=R<RL4'4R;
RRRRRLRR4md_FAKOXG_WzAn):gRL_lMPw_p]N<LR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)zn[L:RgP_Mlbwp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz):KjR_LgMwPlpNu_L<jR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)znhL:RgP_Mlawp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)R0:LMg_PplwxL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)BR_LgMwPlpNQ_L=R<RL4'4R;
RRRRR8CMOCN#
RRRR8CM
CRRMC8
MF8l8CkD
F
l8CkDR_L(u_pwn5DhRdL4_lMPwVp_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
 ,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
w,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
P,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
8,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL,7j
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,L]
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,LM
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LduRpw2
;
RNRbsCNl0RCsLhU_HN_mURg.=;Rc
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=iRRLc'jjjj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)p='RcLjjj4R;
RsbNN0lCCLsR4md_FAKOXG_WzAn)Rc=R'jLj4
j;RNRbsCNl0RCsL_4dmOFKAWX_G)zn[RR=cj'Lj;44
bRRNlsNCs0CRdL4_KmFO_AXWnGz)RKj='RcLjj4jR;
RsbNN0lCCLsR4md_FAKOXG_Wzhn)Rc=R'4Ljj
4;RNRbsCNl0RCsL_4dmOFKAWX_G)zn0RR=cj'L4;4j
R
RbNNslCC0s4RLdF_mKXOA_zWGnR)B='RcL4j44
;
RbHMkr0RLhU_HN_mU:g.4L9R4Md_Pplw_.VGsTLk;H
RM0bkR4RLjp_uwo_AV 7L;H
RM0bkR4RLjp_uwo_AVw7L;H
RM0bkR4RLjp_uwo_AVP7L;H
RM0bkR4RLjp_uwo_AV87L;H
RM0bkR4RLjp_uwo_AV77LjR;
HkMb0LRR4uj_pAw_oLV7]R;
HkMb0LRR4uj_pAw_oLV7MR;
Fbk0kL0Rdp_uwR;
sRCoLud_p
w;
NRRD$IN#@R@54RLdP_Ml_wpVsG.LRkTFRs
RRRRRRRRRLRR4uj_pAw_oLV7 sRF
RRRRRRRRRRRRjL4_wup_VAo7RLwFRs
RRRRRRRRRLRR4uj_pAw_oLV7PsRF
RRRRRRRRRRRRjL4_wup_VAo7RL8FRs
RRRRRRRRRLRR4uj_pAw_oLV77FjRsR
RRRRRRRRRR4RLjp_uwo_AV]7LR
FsRRRRRRRRRRRRL_4ju_pwA7oVL2MRRoLCHRM
RORRN5#CRdL4_lMPwVp_GL.sk2TRRR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRRdL4_KmFO_AXWnGz)Ri:Lud_p<wR=4RLjp_uwo_AV 7L;R
RRRRRL_4dmOFKAWX_G)znpL:Rdp_uw=R<RjL4_wup_VAo7;Lw
RRRRLRR4md_FAKOXG_WzAn):dRL_wupRR<=L_4ju_pwA7oVL
P;RRRRR4RLdF_mKXOA_zWGn:)[R_LduRpw<L=R4uj_pAw_oLV78R;
RRRRRdL4_KmFO_AXWnGz):KjR_LduRpw<L=R4uj_pAw_oLV77
j;RRRRR4RLdF_mKXOA_zWGn:)hR_LduRpw<L=R4uj_pAw_oLV7]R;
RRRRRdL4_KmFO_AXWnGz)R0:Lud_p<wR=4RLjp_uwo_AVM7L;R
RRRRRL_4dmOFKAWX_G)znBL:Rdp_uw=R<RjL4_wup_VAo7;L 
RRRR8RRCkVNDR0:RRRRRRRRRRRRLud_p<wR='R4L
j;RRRRCOM8N
#CRMRC8M
C88lFk
DC
8lFkRDCLkd_i5sR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4L4_sk)Ok_gsLXA,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,p$
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L(u_p$u,Dv
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_$u1HVAo7LL_8R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4u._1.$HXwVY_,L8
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRcL4_Wmwh	agE]WJ_,dH
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_$u1HVAo7ZL_c
7,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4duH1$.YXVwc_Z7R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4m6_waWhgW	EJ)]_g
	,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.MTzaA7oVL8_L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLc8_4aIOp_ApVuH_d,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLdz_MaoTAV_7LZ,c7
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR6L4_EMYQ#dgI vC8o_v,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLnY_MEgQd#CIv q8_(
U,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_44PZqAdYJ#_,X]
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_APqZ#dJY$_pER,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4k4_).sOX_VYX
],RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.kO)s.YXV_Ep$2*R/RM#$0#ECH##R$EM_H=Cs"sEN8*"R/
R;
bRRNlsNCs0CR_LUhmH_N.UgRc=R;R
RHkMb04RL4)_ksgO_kAsXLR;
RbHMkr0RLhU_HN_mU:g.4L9R4Md_Pplw_.VGsTLk;R
RHkMb0dRL_$up;R
RFbk0kL0Rdp_uwR;
R0FkbRk0Lu(_pu$_D
v;RkRF00bkR.L4_$u1HVAo7LL_8R;
R0FkbRk0L_4.uH1$.YXVw8_L;R
RFbk0kL0R4mc_waWhgW	EJd]_HR;
R0FkbRk0L_4.MTzaA7oVL8_L;R
RFbk0kL0R44c_8paOIV_pAdu_HR;
R0FkbRk0L_46MQYEdIg#v8C _;vo
FRRkk0b04RL4q_PAJZd#XY_]R;
R0FkbRk0L_44kO)s.YXV_;X]
HRRM0bkRdL4_$u1HVAo7ZL_c
7;RMRHbRk0L_4duH1$.YXVwc_Z7R;
RbHMkL0R4m6_waWhgW	EJ)]_g
	;RMRHbRk0L_4dMTzaA7oVLc_Z7R;
RbHMkL0R4Mn_YdEQgv#IC_ 8q;(U
HRRM0bkR.L4_APqZ#dJY$_pER;
RbHMkL0R4k._).sOX_VYp;$E
R
RICHsR_L(u_pwQ;wv
R
RICHsRcL4_AMYjBKK__w0N,xqRnL4_$u1HVAo7LL_8o_VlL,R4mU_waWhgW	EJd]_HB_4eL,R4Mg_YdEQgv#IC_ 8vxo_7RG,L_46PZqAdYJ#__X]I;H$
IRRHRsCL_46kO)s.YXV__X]I;H$
IRRHRsCL_4U4O8appI_V_Aud4H_B
e;
LRR4M._Pplw_4DNGR$]L_4jMOP#At_s#5pR
RRRR3RRL_44kO)s_sgkXRALRRRR54RL4)_ksgO_kAsXL,R2
RRRR3RRL_4dMwPlpG_V.ksLTRRRRRR5L_4dMwPlpG_V.ksLT,R2
RRRR3RRLMg_PplwTL_NRL5R4Mc_YKAjKwB_0x_Nq,R2
RRRR3RRLMg_Pplw)L_NRL5R4un_1A$HoLV7__L8VRol2R,
RRRRRg3L_lMPw_p]N5LRRUL4_Wmwh	agE]WJ__dH4RBe2R,
RRRRRg3L_lMPw_pbN5LRRnL4_$u1HV.XYLw_8o_Vl,R2
RRRR3RRLMg_PplwuL_NjRR5L_4gMQYEdIg#v8C __voxR7G2R,
RRRRRg3L_lMPw_paN5LRR6L4_APqZ#dJY]_X_$IHR
2,RRRRRLR3gP_Mlxwp_RNL54RL6)_ksXO.VXY_]H_I$,R2
RRRR3RRLMg_PplwQL_NRL5R44U_8paOIV_pAdu_HB_4e2R2;R

R_L(u_pwnRDhL_4.u_pwn_DhUP0YRR5
RRRRR43LdP_Ml_wpVsG.LRkTR5RRRdL4_lMPwVp_GL.sk2TR,R
RRRRR3jL4_wup_VAo7RL 54RLdz_MaoTAV_7LZRc72R,
RRRRR43Ljp_uwo_AVw7LRL5R4ud_1A$HoLV7_7ZcR
2,RRRRRLR34uj_pAw_oLV7PRR5L_46mhwWaEg	W_J])Rg	2R,
RRRRR43Ljp_uwo_AV87LRL5R4ud_1.$HXwVY_7ZcR
2,RRRRRLR34uj_pAw_oLV775jRRnL4_EMYQ#dgI vC8(_qU,R2
RRRR3RRL_4ju_pwA7oVL5]RR.L4_APqZ#dJY$_pE,R2
RRRR3RRL_4ju_pwA7oVL5MRR.L4_sk)OV.XY$_pE,R2
RRRR3RRLud_pRwRRRRRRRR5Lu(_pQw_w2vR2
;
R#RN#MHoR_LduRpwRRRRR=RRR_L(u_pwQRwv&4RL4)_ksgO_kAsXLR;
R#N#HRoMLu(_pu$_DRvRRRRRRRR=Lud_p
$;R#RN#MHoR.L4_$u1HVAo7LL_8RRR=4RLn1_u$oHAV_7LLV8_o
l;R#RN#MHoR.L4_$u1HV.XYLw_8RRR=4RLn1_u$XH.V_YwLV8_o
l;R#RN#MHoRcL4_Wmwh	agE]WJ_RdH=4RLUw_mWgha	JEW]H_d_e4B;R
RNH##oLMR4M._zAaToLV7_RL8RRRR=4RLcY_MAKjKB0_w_qNx;R
RNH##oLMR4M6_YdEQgv#IC_ 8vRoRR=RRRgL4_EMYQ#dgI vC8o_v_Gx7;R
RNH##oLMR4P4_qdAZJ_#YXR]RR=RRR6L4_APqZ#dJY]_X_$IH;R
RNH##oLMR4k4_).sOX_VYXR]RR=RRR6L4_sk)OV.XY]_X_$IH;R
RNH##oLMR44c_8paOIV_pAdu_HRRRRRR=L_4U4O8appI_V_Aud4H_B
e;ClM8FD8kCl

FD8kCURL__M)$slJtL5R(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_#MV_,Vw
RRRRRRRRRRRRRRRRRRRRRRRRRRRLMn_zVa_wR,
RRRRRRRRRRRRRRRRRRRRRRRRR4RL4q_PAJZd#XY_]R,
RRRRRRRRRRRRRRRRRRRRRRRRR4RLc8_4aIOp_ApVuH_d,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_L6m]P$dR,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
$,RRRRRRRRRRRRRRRRRRRRRRRRRLRRnO_mlWjs,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LdM,V#
RRRRRRRRRRRRRRRRRRRRRRRRRRRLMd_z
a,RRRRRRRRRRRRRRRRRRRRRRRRRLRRUq_PAJZd#
Y,RRRRRRRRRRRRRRRRRRRRRRRRRLRR(w_Mt7jsYR,
RRRRRRRRRRRRRRRRRRRRRRRRR(RL_#MV_$dI,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_L(M_zad,I$
RRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.PZqAdYJ#_Ep$,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LnuZ16V2XR;R
RbNNslCC0s(RL_aMzZYQkR4=R;R
RbNNslCC0sURL_chs_HgcbRR=6R;
RsbNN0lCCLsRUs_hcU_NzRbR='R6Ljjjj
j;
HRRM0bkR_L([_W1d;PW
HRRM0bkR_LnM_V#V
w;RMRHbRk0LMn_zVa_wR;
RbHMkL0R4P4_qdAZJ_#YX
];RMRHbRk0L_4c4O8appI_V_Aud
H;RMRHbRk0Lm6_Pd$];R
RHkMb0nRL_#8Z0;dg
HRRM0bkR_Ldu;p$
HRRM0bkR_L(Mjwts;7Y
HRRM0bkRLrRUs_hcc_gH4b-:9jRR_LnmjOls
W;RMRHbRk0Lun_1V6ZXR;
R0FkbRk0rURL_chs_Hgcb:-4jRR9LMd_V
#;RkRF00bkRLrR(z_MakZQY:-4jRR9LMd_z
a;RkRF00bkR_LUPZqAdYJ#;R
RFbk0kL0R(V_M#I_d$R;
R0FkbRk0LM(_zda_I
$;RkRF00bkR.L4_APqZ#dJY$_pE
;
RCRsoLRrUs_hcc_gH-bRRj4:94RLjV_M#g_v	sYV;R
RICHsRUrL_chs_HgcbRR-49:4R4L4_#MV_	vgY]Vs;R
RsRCor_L(MZzaQRkY-:R4jL9R4Mj_zva_gV	YsR;
RsIHCLRr(z_MakZQYRR-49:4R4L4_aMz_	vgY]Vs;R
RsRCoL_46PZqAdYJ#_dkL);lC
IRRHRsCr_LUh_scgbcH-j4:96RL_#MV_
a;RHRIsrCRLM(_zQaZk4Y-:Rj9LM6_zaa_;R
RICHsRjL4_APqZ#dJY;_A
sRRCroRR_LUh_scgbcH-j4:RL9RdV_M#R;
RosCRLrR(z_MakZQY:-4jRR9LMd_z
a;RCRsoURL_APqZ#dJY
;
R#RN#MHoR_L6M_V#aRR=L_4jM_V#vYg	VLsrUs_hcc_gH4b-:;j9
NRR#o#HM6RL_aMz_=aRRjL4_aMz_	vgYrVsLM(_zQaZk-YRRj4:9R;
R#N#HRoML_4jPZqAdYJ#_=ARR6L4_APqZ#dJYL_kdC)l;R
RNH##oLMR(V_M#I_d$RR=L_4jM_V#vYg	Vjsr9R;
R#N#HRoMLM(_zda_I=$RRjL4_aMz_	vgYrVsj
9;R#RN#MHoR.L4_APqZ#dJY$_pERR=L_46PZqAdYJ#_dkL);lC
R
RNNDI$@#R@b5RF8#CoLCRnZ_8#g0dRL2RCMoH
RRRR5HVR_LnM_V#V2wRRoLCHRM
RRRRR_LdMRV#<L=R6V_M#;_a
RRRR8CM
CRRM
8
RDRNI#N$R5@@R#bFCC8oR_Ln80Z#d2gRRoLCHRM
RHRRVL5Rnz_Maw_VRL2RCMoH
RRRRLRRdz_Ma=R<R_L6M_zaaR;
RCRRMR8
R8CM
R
RNNDI$@#R@b5RF8#CoLCRnZ_8#g0dRRFsbCF#8RoCLun_1V6ZXRR2LHCoMR
RRVRH5nRL_6u1ZRVX2R
RRRRRLPU_qdAZJR#Y<4=R';Lj
RRRR#CDCVRH54RL4q_PAJZd#XY_]RR2LHCoMR
RRRRRLPU_qdAZJR#Y<L=R4Pj_qdAZJ_#YAR;
RCRRMR8
R8CM
R
RNNDI$@#R@b5RF8#CoLCR(W_[1P_dWRR2LHCoMR
RRVRH5nRL_#MV_RVw|L|R44c_8paOIV_pAdu_HRR2LHCoMR
RRRRRHRV5LM(_wstj72YR
RRRRRRRRjL4_#MV_	vgYrVsLhU_sgc_cRHb-:R4j<9R=nRL_lmOj;sW
RRRRCRRDR#CHRV5Lm6_Pd$]RR2
RRRRRLRR4Mj_Vv#_gV	Ys=R<Rd{L_$up,4RL4V_M#g_v	sYV]
};RRRRC
M8RRRRHRV5LMn_zVa_w&R&R_L6m]P$dRR2LHCoMR
RRRRRL_4jM_zavYg	V<sR=LR{dp_u$L,R4M4_zva_gV	Ys;]}
RRRR8CM
RRRR5HVR4L4_APqZ#dJY]_XRR&&Lm6_Pd$]RL2RCMoH
RRRRLRR4P6_qdAZJ_#Yk)Ldl<CR=dRL_$up;R
RRMRC8R
RC
M8R#RN#MHoR4L4_#MV_	vgY]VsRL=R4Mj_Vv#_gV	YsUrL_chs_HgcbRR-4RR:4
9;R#RN#MHoR4L4_aMz_	vgY]VsRL=R4Mj_zva_gV	Ys(rL_aMzZYQkR4-RR4:R9C;
MF8l8CkD
F
l8CkDR_Ld4R.l5R
RLmc_i,KN
LRR(W_[1P_dWR,
R_L(uNiK_,gk
LRR6P_m$,]d
LRRdp_u$R,
RdL4_6kpQ0dBFu_[w
A,R4RL.z_MaoTAV_7LL
8,R4RLc8_4aIOp_ApVuH_d,R
RL_46MQYEdIg#v8C _,vo
LRR4P4_qdAZJ_#YX
],R4RL4)_ksXO.VXY_]R,
R_L(Mjwts,7Y
LRRdp_uwR,
R_L6mxOauR,
RdL4_aMzTVAo7ZL_c
7,R4RLnY_MEgQd#CIv q8_(
U,R4RL.q_PAJZd#pY_$
E,R4RL.)_ksXO.VpY_$
E,R4RL4F_P1sOdNXwNwR,
R_LgmhwWaNg_LR,
RjL4_WmwhDags,0C
LRRgp_1$h$_s2t7;R

RbHMkL0Rci_mK
N;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lu(_i_KNg
k;RMRHbRk0Lm6_Pd$];R
RHkMb0dRL_$up;R
RHkMb04RLdp_k6BQd0[F_u;wA
HRRM0bkR_L(Mjwts;7Y
HRRM0bkR.L4_aMzTVAo7LL_8R;
RbHMkL0R44c_8paOIV_pAdu_HR;
RbHMkL0R4M6_YdEQgv#IC_ 8v
o;RMRHbRk0L_44PZqAdYJ#_;X]
HRRM0bkR4L4_sk)OV.XY]_X;R
RFbk0kL0Rdp_uwR;
R0FkbRk0Lm6_Ouax;R
RFbk0kL0R4Md_zAaToLV7_7Zc;R
RFbk0kL0R4Mn_YdEQgv#IC_ 8q;(U
FRRkk0b04RL.q_PAJZd#pY_$
E;RkRF00bkR.L4_sk)OV.XY$_pER;
R0FkbRk0L_44POF1dwsNN;Xw
FRRkk0b0gRL_Wmwh_agN
L;RkRF00bkR:rj.9cjRjL4_WmwhDags;0C
HRRM0bkR:rj.9c4R_Lg1$p$_ths7
;
RHRIsLCR4P6_Fd1OsNNwXIw_H
$;RHRIsLCR61_HW;OB
IRRHRsCL_4jkjzaKoBcw
s;RHRIsrCR4:gRRRj9L_4jMhYWaIghL
p;RCRso4RrgRR:jL9R4Mc_YaWhgLhIpd_L1
;
R#RN#MHoR_L6mxOauRR=4j'L;R

R#N#HRoML_44POF1dwsNNRXw=4RL6F_P1sOdNXwNwH_I$
;
R#RN#MHoR4L4_aMzZvdJ_p0	RL=R4Mc_YaWhgLhIpd_L19rj;R

R#N#HRoML_4jmhwWasgD0=CRRg{L_$1p$s_htj7rRd:R4R9,L1g_p_$$h7strRd.:dRn9L,Rgp_1$h$_srt7n:cRR9n(,gRL_$1p$s_htn7rURR:(,49R_Lg1$p$_ths7.r(R(:R6R9,L1g_p_$$h7strR(n:gR(9
,RRRRRRRRRRRRRR_Lg1$p$_ths7jrURU:RjR9,L1g_p_$$h7strRU4:4RU9L,Rgp_1$h$_srt7U:.RR9U.,gRL_$1p$s_htU7rdRR:U,d9R_Lg1$p$_ths7crURU:RcR9,L1g_p_$$h7strRU6:6RU9
,RRRRRRRRRRRRRR_Lg1$p$_ths7nrUR4:R4,(9R_Lg1$p$_ths74r4URR:49.j,gRL_$1p$s_ht47r.:4RR.469L,Rgp_1$h$_srt74R6d:6R4dR9,L1g_p_$$h7strc46R4:R6,c9R_Lg1$p$_ths76r46RR:496n,RR
RRRRRRRRRRRRL1g_p_$$h7str(46R4:Rn,j9R_Lg1$p$_ths7nr44RR:49nd,gRL_$1p$s_ht47rn:cRR64n9L,Rgp_1$h$_srt74Rnn:gR4(R9,L1g_p_$$h7strU4gR4:Rg,U9R_Lg1$p$_ths7gr4gRR:.9j(,RR
RRRRRRRRRRRRL1g_p_$$h7strU.jR.:R4,n9R_Lg1$p$_ths74r.(RR:.94(,gRL_$1p$s_ht.7r4:URRU.49L,Rgp_1$h$_srt7.R4g:4R.gR9,L1g_p_$$h7strj..R.:R.,j9R_Lg1$p$_ths7.r.4RR:.9.4,RR
RRRRRRRRRRRRL1g_p_$$h7str...R.:R.,.9R_Lg1$p$_ths7.r.dRR:.9.d,gRL_$1p$s_ht.7r.:cRRc..9L,Rgp_1$h$_srt7.R.6:.R.6R9,L1g_p_$$h7strn..R.:R.,n9R_Lg1$p$_ths7.r.(RR:.9.(,RR
RRRRRRRRRRRRL1g_p_$$h7strU..R.:R.,U9R_Lg1$p$_ths7.r.gRR:.9.g,gRL_$1p$s_ht.7rd:jRRj.d9L,Rgp_1$h$_srt7.Rd4:dR.4R9,L1g_p_$$h7str..dR.:Rd,.9R_Lg1$p$_ths7dr.dRR:.9dd,RR
RRRRRRRRRRRRL1g_p_$$h7strc.dR.:Rd,c9R_Lg1$p$_ths7dr.6RR:.9d6,gRL_$1p$s_ht.7rd:nRRn.d9L,Rgp_1$h$_srt7.Rd(:dR.(R9,L1g_p_$$h7strU.dR.:Rd,U9R_Lg1$p$_ths7dr.gRR:.9dg,RR
RRRRRRRRRRRRL1g_p_$$h7strj.cR.:Rc}j9;R
RNNDI$@#R@b5RF8#CoLCR(W_[1P_dWRR2LHCoMR
RRVRH54RLc8_4aIOp_ApVuH_dRR||L_44kO)s.YXV_2X]RoLCHRM
RRRRRRHV5(RL_tMwjYs72R
RRRRRR4RLcY_MWghahpIL_1LdRL=R4Mj_YaWhgLhIpR;
RRRRR#CDCVRHR65L_$mP]
d2RRRRRRRRL_4cMhYWaIghLLp_d=1RRd{L_$up,4RLcY_MWghahpIL_1Ldr:4g4;9}
RRRR8CM
CRRMR8
R_L(m$BApRXByd5426RL_aMzt5aR
RRRRc3L_KmiNc5L_KmiN
2,RRRR3_L(uH1$D5g#L_4jkjzaKoBcw,s2
RRRR(3L_1[W_WdP5_L([_W1d2PW,R
RRLR36P_m$5]dLm6_Pd$]2R,
R3RRL8n_Zd#0g45Ldp_k6BQd0[F_u2wA,R
RRLR3dp_u$d5L_$up2R,
R3RRLMn_VV#_w45L.z_MaoTAV_7LL,82
RRRR43Lc8_4aIOp_ApVuH_d5cL4_a48O_pIpuVA_2dH,R
RRLR34Mj_YdEQgw#_045L6Y_MEgQd#CIv v8_o
2,RRRR34L4_APqZ#dJY]_X54L4_APqZ#dJY]_X2R,
R3RRL_44kO)s.YXV_5X]L_44kO)s.YXV_2X],R
RRLR361_HW5OBLH6_1BWO2R,
R3RRLmg_waWhgL_N5_LgmhwWaNg_L
2,RRRR3.L4_1PFOod_lLN#L45L6F_P1sOdNXwNwH_I$
2,RRRR3_L(Mjwts57YLM(_wstj7,Y2
RRRR(3L_#MV_$dI5dL4_aMzTVAo7ZL_c,72
RRRR(3L_aMz_$dI5nL4_EMYQ#dgI vC8(_qU
2,RRRR3.L4_APqZ#dJY$_pE45L.q_PAJZd#pY_$,E2
RRRR43L4z_MaJZdv	_0p45L4z_MaJZdv	_0p
2,RRRR3.L4_sk)OV.XY$_pE45L.)_ksXO.VpY_$2E2;R

R_L(uxVwsRhYLuc_VRwx5R
RRLR3ci_mKLN5ci_mK,N2
RRRR63L_1PFOLd54P6_Fd1OsNNwXIw_H,$2
RRRR63L_WH1OLB561_HW2OB,R
RRLR3gp_1$h$_s5t7L1g_p_$$h7st2R,
R3RRLu(_1D$HgL#54kj_zKajBwcos
2,RRRR3_L([_W1d5PWL[(_Wd1_P,W2
RRRR(3L_KuiNk_g5_L(uNiK_2gk,R
RRLR3dp_u$d5L_$up2R,
R3RRLm6_Pd$]5_L6m]P$d
2,RRRR3jL4_WMYhhagI5LpL_4jMhYWaIghL,p2
RRRRd3L_wup5_Ldu2pw2
;
ClM8FD8kCl

FD8kC8RDH_O4jR5
RHN8M
,RR8RNF,k0RR
RN_sLo_M0L
,RRsRNLC_sJ,_LRR
ROHLCM,_LRR
ROFLCkL0_,RR
RP8C#HCDM,_LRR
R8#CPCkDF0,_LRR
RVlsNC_HML
,RRsRVNFlCkL0_,RR
RHbO_	OD,RR
RHbO_#sCCR0,
kRRbMDH	,_dRR
R8MFID	HM_244;H

M0bkR4rd:Rj9NM8H;M
HbRk0r:d4jN9R80Fk;M
HbRk0r4c:9sRNLM_o0;_L
bHMkr0Rc9:4RLNs_JsC_
L;HkMb0dRr:Rj9OHLCM;_L
bHMkr0Rd9:jRCOLF_k0LH;
M0bkRP8C#HCDM;_L
bHMk80RCCP#D0Fk_
L;HkMb0sRVNHlCM;_L
bHMkV0RsCNlF_k0LH;
M0bkRHbO_	OD;M
HbRk0b_OHsCC#0F;
kk0b0jRr:4.c9bRkD	HM_
d;HkMb0jRr:6469FR8IHMDM4	_4
;
R#RN#MHoRDkbH_M	d:rjdR49=8RNH
M;R#RN#MHoRDkbH_M	d.rd:9ndRN=R80Fk;R
RNH##okMRbMDH	r_dnnc:(=9RRLNs_0oM_
L;R#RN#MHoRDkbH_M	dUrn:9(4RN=RssL_CLJ_;R
RNH##okMRbMDH	r_d((.:6=9RRCOLHLM_;R
RNH##okMRbMDH	r_d((n:g=9RRCOLF_k0LR;
R#N#HRoMkHbDMd	_r9UjR8=RCCP#D_HMLR;
R#N#HRoMkHbDMd	_r9U4R8=RCCP#D0Fk_
L;R#RN#MHoRDkbH_M	d.rU9RR=VlsNC_HMLR;
R#N#HRoMkHbDMd	_r9UdRV=RsCNlF_k0LR;
R#N#HRoMkHbDMd	_r9UcRb=ROOH_D
	;R#RN#MHoRDkbH_M	d6rU9RR=b_OHsCC#0R;
R#N#HRoMkHbDMd	_r:Un.9c4R8=RFDIMH_M	4
4;ClM8FD8kCl

FD8kC8RDH_O6jR5
R7]q71)_.
,RRAR]za)1_,1.RR
R]q)7a1q_.
,RR)R] Yq7__Qh1R.,
]RR)7 qYz_ma._1,RR
R ])11u_.
,RR1R] bp_ORH,
]RR1 QZ_,1.RR
R]qa)h11_.
,RRWR]7qqa_,1.RR
R]QW)a1 _.
,RRsRNLM_o0,_LRR
RN_sLs_CJL
,RRMRo0,_LRR
RHC8#D
,RRsRH8M$H_RL,
HRRsF8$kL0_,RR
R_FCNR8,
FRRCL_OC
,RRCRF_P8C#,CDRR
RFVC_sCNl,RR
R_FCH$s8,RR
R_FCb,NsRR
RFbC_C,ssRR
RFsC_CRJ,
FRRC0_#FRb,
FRRCs_08R$,
bRRNMsH,RR
RsbNF,k0RR
RbsCsHLM_,RR
RsbCs0Fk_RL,
sRRCkJF0,_LRR
R#sCsF_k0L
,RR0R#FMbH_RL,
#RR0FFbkL0_,RR
R80s$_HML
,RRsR08k$F0,_LRR
RqiBp_1Az,RR
RDkbH_M	4;j2
M
HbRk0r:d4j]9Rq)77_;1.
bHMkr0R.9:jRz]A)_1a1
.;HkMb0dRr49:jR7])q_aq1
.;HkMb0)R] Yq7__Qh1
.;HkMb0)R] Yq7_amz_;1.
bHMkr0R49:jR ])11u_.H;
M0bkR:rdj]9R1_ pb;OH
bHMkr0R.9:jRQ]1Z1 _.H;
M0bkR:r4j]9Rah)q1._1;M
HbRk0r:d4j]9RWa7qq._1;M
HbRk0]QW)a1 _.H;
M0bkR:rUjN9RsoL_ML0_;M
HbRk0rjU:9sRNLC_sJ;_L
bHMko0RML0_;M
HbRk0HC8#DH;
M0bkR8Hs$_HMLH;
M0bkR8Hs$0Fk_
L;HkMb0CRF_;N8
bHMkF0RCL_OCH;
M0bkR_FC8#CPC
D;HkMb0CRF_NVsl
C;HkMb0CRF_8Hs$H;
M0bkR_FCb;Ns
bHMkF0RCC_bs
s;HkMb0CRF_JsC;M
HbRk0F#C_0;Fb
bHMkF0RCs_08
$;HkMb0NRbs;HM
bHMkb0RNksF0H;
M0bkRsbCs_HMLH;
M0bkRsbCs0Fk_
L;HkMb0CRsJ0Fk_
L;HkMb0CR#sksF0;_L
bHMk#0R0HFbM;_L
bHMk#0R0FFbkL0_;M
HbRk00$s8HLM_;M
HbRk00$s8F_k0LH;
M0bkRpqBiz_A1F;
kk0b0jRr:6469bRkD	HM_;4j
R
RNH##okMRbMDH	j_4rdj:4=9RR7]q71)_.R;
R#N#HRoMkHbDM4	_j.rd:9dcR]=RA1z)a._1;R
RNH##okMRbMDH	j_4r:d6nRn9=)R]7qqa_;1.
NRR#o#HMbRkD	HM_r4jnR(9=)R] Yq7__Qh1
.;R#RN#MHoRDkbH_M	4njrU=9RR ])q_7Ym_za1
.;R#RN#MHoRDkbH_M	4njrgj:(9RR=]1) u._1;R
RNH##okMRbMDH	j_4r:(4(Rc9=1R] bp_O
H;R#RN#MHoRDkbH_M	4(jr6(:(9RR=]Z1Q ._1;R
RNH##okMRbMDH	j_4r:(U(Rg9=aR])1qh_;1.
NRR#o#HMbRkD	HM_r4jU4j:4R49=WR]7qqa_;1.
NRR#o#HMbRkD	HM_r4j494.R]=RWa)Q ._1;R
RNH##okMRbMDH	j_4rd44:44.9RR=N_sLo_M0LR;
R#N#HRoMkHbDM4	_j.r4.d:4j=9RRLNs_JsC_
L;R#RN#MHoRDkbH_M	44jrdR49=MRo0;_L
NRR#o#HMbRkD	HM_r4j49d.RH=R8D#C;R
RNH##okMRbMDH	j_4rd4d9RR=H$s8HLM_;R
RNH##okMRbMDH	j_4rc4d9RR=H$s8F_k0LR;
R#N#HRoMkHbDM4	_jdr46=9RR_FCN
8;R#RN#MHoRDkbH_M	44jrdRn9=CRF_COL;R
RNH##okMRbMDH	j_4r(4d9RR=F8C_CCP#DR;
R#N#HRoMkHbDM4	_jdr4U=9RR_FCVlsNCR;
R#N#HRoMkHbDM4	_jdr4g=9RR_FCH$s8;R
RNH##okMRbMDH	j_4rj4c9RR=FbC_N
s;R#RN#MHoRDkbH_M	44jrcR49=CRF_sbCsR;
R#N#HRoMkHbDM4	_jcr4.=9RR_FCs;CJ
NRR#o#HMbRkD	HM_r4j49cdRF=RC0_#F
b;R#RN#MHoRDkbH_M	44jrcRc9=CRF_80s$R;
R#N#HRoMkHbDM4	_jcr46=9RRsbNH
M;R#RN#MHoRDkbH_M	44jrcRn9=NRbs0Fk;R
RNH##okMRbMDH	j_4r(4c9RR=bsCsHLM_;R
RNH##okMRbMDH	j_4rU4c9RR=bsCsF_k0LR;
R#N#HRoMkHbDM4	_jcr4g=9RRJsCF_k0LR;
R#N#HRoMkHbDM4	_j6r4j=9RRs#Cs0Fk_
L;R#RN#MHoRDkbH_M	44jr6R49=0R#FMbH_
L;R#RN#MHoRDkbH_M	44jr6R.9=0R#FkbF0;_L
NRR#o#HMbRkD	HM_r4j496dR0=RsH8$M;_L
NRR#o#HMbRkD	HM_r4j496cR0=RsF8$kL0_;R
RNH##okMRbMDH	j_4r6469RR=qiBp_1Az;M
C88lFk
DC
8lFkRDCHCHO_
j5RFROlHl.H_OCD	HM_OHHC,_jRR
RHCHO.lOFlH_DMH	_H_OCj
,RR8RlHDO_H2M	RR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*RR;
RbHMkr0Rj9:gRlOFlH.HODC_H_M	HCHO_
j;RkRF00bkR:rjjH9RH.OCOlFl_MDH	H_HOjC_;R
RHkMb0jRr:4.c98RlHDO_H;M	
R
RICHsR_LcmNiK;R
RICHsR_L(wwYLA,_wR_L(wwYLA;_t
IRRHRsCLuc_p;$w
IRRHRsCLuU_1A$Ho,YtR_LUuH1$.tXY,4RLjw_mWgha	0Ew,(RL_$u1H$dI,gRL_$u1Hv.XG
V;RHRIsLCRgw_mWghav,GVR_LU1tFWVYWY,URL_WmwhYagtR;
RsIHC.Rrcjj:94RLjw_mWghaDCs0;R
RsRCor.j:cR49lO8H_MDH	C_so*R/RM#$0#ECH##R$bM_sCC#s=PC4/R*;R

R#N#HRoMLw(_YALw_=tRRL4'4R;
R#N#HRoMLw(_YALw_=wRRL4'jR;
R#N#HRoMLmc_iRKN=8RlHDO_HrM	.9c4;R
RNNDI$@#R@(5L_LwYwwA_RRFslO8H_MDH	L2RCMoHRl:R8_HOD	HM_0#CkRb
RlRR8_HOD	HM_osCr4.c9=R<R_L(wwYLA;_w
CRRM
8
RDRNI#N$R5@@bCF#8RoCLmc_i2KNRoLCH:MRRHl8OH_DMD	_NE0O
RRRRHl8OH_DMs	_CjorRd:R4<9R=8RlHDO_HrM	jRR:d;49
RRRRHl8OH_DMs	_Cdor.RR:nRd9<l=R8_HOD	HMrRd.:dRn9R;
RlRR8_HOD	HM_osCrRnc:(Rn9=R<RHl8OH_DMn	rcRR:n;(9
RRRRHl8OH_DMs	_CnorURR:(R49<l=R8_HOD	HMrRnU:4R(9R;
RlRR8_HOD	HM_osCrR(.:6R(9=R<RHl8OH_DM(	r.RR:(;69
RRRRHl8OH_DMs	_C(ornRR:(Rg9<l=R8_HOD	HMrR(n:gR(9R;
RlRR8_HOD	HM_osCrRUj:jRU9=R<RHl8OH_DMU	rjRR:U;j9
RRRRHl8OH_DMs	_CUor4RR:UR49<l=R8_HOD	HMrRU4:4RU9R;
RlRR8_HOD	HM_osCrRU.:.RU9=R<RHl8OH_DMU	r.RR:U;.9
RRRRHl8OH_DMs	_CUordRR:URd9<l=R8_HOD	HMrRUd:dRU9R;
RlRR8_HOD	HM_osCrRUc:cRU9=R<RHl8OH_DMU	rcRR:U;c9
RRRRHl8OH_DMs	_CUor6RR:UR69<l=R8_HOD	HMrRU6:6RU9R;
RlRR8_HOD	HM_osCrRUn:4R4(<9R=8RlHDO_HrM	U:nRR(449R;
RlRR8_HOD	HM_osCrU44R4:R.Rj9<l=R8_HOD	HMrU44R4:R.;j9
RRRRHl8OH_DMs	_C4or.:4RR.469=R<RHl8OH_DM4	r.:4RR.469R;
RlRR8_HOD	HM_osCrd46R4:R6Rd9<l=R8_HOD	HMrd46R4:R6;d9
RRRRHl8OH_DMs	_C4or6:cRRc469=R<RHl8OH_DM4	r6:cRRc469R;
RlRR8_HOD	HM_osCr646R4:R6Rn9<l=R8_HOD	HMr646R4:R6;n9
RRRRHl8OH_DMs	_C4or6:(RRj4n9=R<RHl8OH_DM4	r6:(RRj4n9R;
RlRR8_HOD	HM_osCr44nR4:RnRd9<l=R8_HOD	HMr44nR4:Rn;d9
RRRRHl8OH_DMs	_C4orn:cRR64n9=R<RHl8OH_DM4	rn:cRR64n9R;
RlRR8_HOD	HM_osCrn4nR4:RgR(9<l=R8_HOD	HMrn4nR4:Rg;(9
RRRRHl8OH_DMs	_C4org:URRU4g9=R<RHl8OH_DM4	rg:URRU4g9R;
RlRR8_HOD	HM_osCrg4gR.:RjR(9<l=R8_HOD	HMrg4gR.:Rj;(9
RRRRHl8OH_DMs	_C.orj:URRn.49=R<RHl8OH_DM.	rj:URRn.49R;
RlRR8_HOD	HM_osCr(.4R.:R4R(9<l=R8_HOD	HMr(.4R.:R4;(9
RRRRHl8OH_DMs	_C.or4:URRU.49=R<RHl8OH_DM.	r4:URRU.49R;
RlRR8_HOD	HM_osCrg.4R.:R4Rg9<l=R8_HOD	HMrg.4R.:R4;g9
RRRRHl8OH_DMs	_C.or.:jRRj..9=R<RHl8OH_DM.	r.:jRRj..9R;
RlRR8_HOD	HM_osCr4..R.:R.R49<l=R8_HOD	HMr4..R.:R.;49
RRRRHl8OH_DMs	_C.or.:.RR...9=R<RHl8OH_DM.	r.:.RR...9R;
RlRR8_HOD	HM_osCrd..R.:R.Rd9<l=R8_HOD	HMrd..R.:R.;d9
RRRRHl8OH_DMs	_C.or.:cRRc..9=R<RHl8OH_DM.	r.:cRRc..9R;
RlRR8_HOD	HM_osCr6..R.:R.R69<l=R8_HOD	HMr6..R.:R.;69
RRRRHl8OH_DMs	_C.or.:nRRn..9=R<RHl8OH_DM.	r.:nRRn..9R;
RlRR8_HOD	HM_osCr(..R.:R.R(9<l=R8_HOD	HMr(..R.:R.;(9
RRRRHl8OH_DMs	_C.or.:URRU..9=R<RHl8OH_DM.	r.:URRU..9R;
RlRR8_HOD	HM_osCrg..R.:R.Rg9<l=R8_HOD	HMrg..R.:R.;g9
RRRRHl8OH_DMs	_C.ord:jRRj.d9=R<RHl8OH_DM.	rd:jRRj.d9R;
RlRR8_HOD	HM_osCr4.dR.:RdR49<l=R8_HOD	HMr4.dR.:Rd;49
RRRRHl8OH_DMs	_C.ord:.RR..d9=R<RHl8OH_DM.	rd:.RR..d9R;
RlRR8_HOD	HM_osCrd.dR.:RdRd9<l=R8_HOD	HMrd.dR.:Rd;d9
RRRRHl8OH_DMs	_C.ord:cRRc.d9=R<RHl8OH_DM.	rd:cRRc.d9R;
RlRR8_HOD	HM_osCr6.dR.:RdR69<l=R8_HOD	HMr6.dR.:Rd;69
RRRRHl8OH_DMs	_C.ord:nRRn.d9=R<RHl8OH_DM.	rd:nRRn.d9R;
RlRR8_HOD	HM_osCr(.dR.:RdR(9<l=R8_HOD	HMr(.dR.:Rd;(9
RRRRHl8OH_DMs	_C.ord:URRU.d9=R<RHl8OH_DM.	rd:URRU.d9R;
RlRR8_HOD	HM_osCrg.dR.:RdRg9<l=R8_HOD	HMrg.dR.:Rd;g9
RRRRHl8OH_DMs	_C.orc:jRRj.c9=R<RHl8OH_DM.	rc:jRRj.c9R;
R8CM
R
RL4d_.LlRU._4lw_Qp5YR
RRRRc3L_KmiNRRRR5RRLmc_i2KN,R
RRLR3(W_[1P_dWRRR5lOFlH.HODC_H_M	HCHO_gjr9
2,RRRR3dL4_6kpQ0dBFu_[wRARRF5OlHl.H_OCD	HM_OHHCr_jn,92
RRRR(3L_tMwjYs7R5RROlFl.OHHCH_DMH	_H_OCj9r(2R,
R3RRLu(_i_KNgRkRRU5L_$u1HYAot
2,RRRR3_L6m]P$dRRRROR5F.llHCHO_MDH	H_HOjC_r2U9,R
RRLR3dp_u$RRRRRRR5_Lcuwp$2R,
R3RRLud_pRwRRRRRR(5L_$u1H$dI2R,
R3RRLm6_OuaxRRRRRg5L_$u1Hv.XG,V2
RRRR43Ldz_MaoTAV_7LZRc75dL4_aMzTVAo7ZL_c,72
RRRR43L.z_MaoTAV_7LL58RL_4.MTzaA7oVL8_L2R,
R3RRL_4c4O8appI_V_Aud5HRL_4c4O8appI_V_Aud,H2
RRRR43LnY_MEgQd#CIv q8_(5URL_4nMQYEdIg#v8C _Uq(2R,
R3RRL_46MQYEdIg#v8C _Rvo56L4_EMYQ#dgI vC8o_v2R,
R3RRL_4.PZqAdYJ#_Ep$R45L.q_PAJZd#pY_$,E2
RRRR43L4q_PAJZd#XY_]LR54P4_qdAZJ_#YX,]2
RRRR43L.)_ksXO.VpY_$5ERL_4.kO)s.YXV_Ep$2R,
R3RRL_44kO)s.YXV_RX]54L4_sk)OV.XY]_X2R,
R3RRL_44POF1dwsNNRXw5_LU1tFWVYWY2R,
R3RRLmg_waWhgL_NR5RRLmU_waWhg2Yt,R
RRLR34mj_waWhg0DsC5RRL_4jmhwWasgD0,C2
RRRRg3L_$1p$s_htR7RR85lHDO_H_M	s2Co
2RRRR/*#0$MEHC##$R#MF_MbMskCR=4*
/;
LRRdi_ksURL_ski_pQwY
R5RRRR34L4_sk)Ok_gsLXAROR5F.llHCHO_MDH	H_HOjC_r2c9,R
RRLR34Md_Pplw_.VGsTLkRF5OlHl.H_OCD	HM_OHHCr_jj9:d2R,
R3RRLud_pR$R5lOFlH.HODC_H_M	HCHO_6jr9
2,RRRR3_LduRpwRH5HOOC.F_llD	HM_OHHCr_jj,92
RRRR(3L_$up_vuDRc5L_$upw
2,RRRR3.L4_$u1HVAo7LL_8LR5U1_u$oHAY,t2
RRRR43L.1_u$XH.V_YwL58RLuU_1.$HX2Yt,R
RRLR34mc_waWhgW	EJd]_HLR54mj_waWhgw	E0
2,RRRR3dL4_$u1HVAo7ZL_c57RLu(_1d$HI,$2
RRRR43Ld1_u$XH.V_YwZRc75_LguH1$.GXvV
2,RRRR36L4_Wmwh	agE]WJ_	)gRg5L_WmwhvagG,V2
RRRR43L.z_MaoTAV_7LL58RL_4.MTzaA7oVL8_L2R,
R3RRL_4c4O8appI_V_Aud5HRL_4c4O8appI_V_Aud,H2
RRRR43Ldz_MaoTAV_7LZRc7R45Ldz_MaoTAV_7LZ2c7,R
RRLR34M6_YdEQgv#IC_ 8v5oRL_46MQYEdIg#v8C _2vo,R
RRLR34Mn_YdEQgv#IC_ 8qR(UR45LnY_MEgQd#CIv q8_(,U2
RRRR43L4q_PAJZd#XY_]5RRL_44PZqAdYJ#_2X],R
RRLR34P._qdAZJ_#YpR$ER45L.q_PAJZd#pY_$,E2
RRRR43L4)_ksXO.VXY_]5RRL_44kO)s.YXV_2X],R
RRLR34k._).sOX_VYpR$ER45L.)_ksXO.VpY_$
E2RRR2/#*R$EM0C##HRM#$_bMFsCkM=*4R/R;
R_L(mhwWaRg#L1d_F5WR
RRRRc3L_KmiNRRRR5RRLmc_i2KN,R
RRLR3(W_[1P_dWRRR5lOFlH.HODC_H_M	HCHO_gjr9
2,RRRR3_L(uNiK_RgkRLR54mj_waWhgw	E0
2,RRRR3_L6m]P$dRRRROR5F.llHCHO_MDH	H_HOjC_r2U9,R
RRLR3dp_uwRRRRRRR5_LgmhwWaGgvV
2,RRRR3_L6POF1dRRRRLR5UF_1WWtVY,Y2
RRRR(3L_WmwhpagR5RRL_4jmhwWasgD0,C2
RRRRg3L_Wmwh_agN5LRLmU_waWhg2Yt
2RRRR/*#0$MEHC##$R#MF_MbMskCR=4*;/R
8CMlkF8D
C

