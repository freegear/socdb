/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
    File name	: gpio.h
    Description	: External SMC Test SDI v5
-----------------------------------------------------------*/
#ifndef	__GPIO_H__
#define	__GPIO_H__

/*
/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// 
*/

#include "sysinc.h"

/*
/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// 
*/
smtUint32 GPIOInOut(void);

#endif /* __GPIO_H__ */

