/*----------------------------------------------------------
	File Name   : dma2d.h
	Description : 2D DMA controller API code
	Created by  : SHMT SoC Team
-----------------------------------------------------------*/
#ifndef _DMA2D_H_
#define _DMA2D_H_

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        DEFINITION
///////////////////////////////////////////////////////// */
typedef struct _dma2d_str
{
	smtUint8 *Addr;
	smtUint16 Xsize;
	smtUint16 Ysize;
	smtInt16  Stride;
} dma2d_t;

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */
void DMA2DCopy(dma2d_t *source, dma2d_t *dest);
/*/////////////////////////////////////////////////////////
        VARIABLE DECLARATION
///////////////////////////////////////////////////////// */
#endif
