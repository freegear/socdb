@E8lFkRDCLmg_)ILQXwN 5LRR(W_[1P_dWR,RLMU_Pplw_,YtR6RL_$mP]Rd,R_L(Mjwts,7YRdRL_$up,LRRdp_uw
2;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0LMU_Pplw_;Yt
HRRM0bkR_L6m]P$dR;
RbHMkL0R(w_Mt7jsYR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;
bRRNlsNCs0CR6L4_Ge[lnO	ahz_BB.XRd=R.R;
RsbNN0lCCLsR4e6_[OGl	zna_Z	 z=ZRR4'Ljjj444jjjjj4jjj444j44j44j44j4R44;R

RosCR4rL6[_eG	lOn_azhXB.BRR:4RR9Lmd_)/LR*$R#MC0E#RH##_$M##sD0C$D=C"so0H#C"s#RR*/;R

RsIHCLRr4e6_[OGl	zna_.hBX:BRR9.RR_LcmQ)L;R

RINDNR$#@b@5F8#CoLCR(W_[1P_dWL2RCMoH
RRRR5HVLMU_Pplw_RYt2CRLoRHM
RRRRHRRVL5R(w_Mt7jsY
R2RRRRRRRRLmd_)=LRR6L4_Ge[lnO	a	z_ ZZz;R
RRRRRCCD#R5HVR_L6m]P$d
R2RRRRRRRRLmd_)=LRRd{L_$up,cRL_Lm)Q
};RRRRC
M8RMRC8R

R#N#HRoMLmc_)RLQ=dRL_Lm)r4RL6[_eG	lOn_azhXB.BRR:.;R9
R
RNH##oLMRdp_uwRR=Lmd_)4Lr9C;
MF8l8CkD
l

FD8kC0R[NHo_Ms0CVCNORR5
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_L(F_17d,PW
RRRRRRRRRRRRRRRR(RL_xUi_sdI,R
RRRRRRRRRRRRRRLRRnP_M_BjB,R
RRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRL_44U_ixAYJx),sL
RRRRRRRRRRRRRRRR4RLji_Uxi_sDXs0,R
RRRRRRRRRRRRRRLRR4Uj_iVx_w[V#XR,
RRRRRRRRRRRRRRRRLUg_i.x_o0sw,R
RRRRRRRRRRRRRRLRR4Mj_PI_$igvlXR,
RRRRRRRRRRRRRRRRLMg_PT_FIwVY,R
RRRRRRRRRRRRRRLRRgP_M_JOpo,mw
RRRRRRRRRRRRRRRRURL__MPZ0lBY
2;RMRHbRk0R_Ldu;pw
FRRkk0b0(RL_xUi_sdI;R
RFbk0kL0RnP_M_BjB;R
RFbk0kL0R4U4_iAx_J)xYs
L;RkRF00bkRjL4_xUi_Dsis;0X
FRRkk0b04RLji_Uxw_VVX#[;R
RFbk0kL0Rgi_Uxo_.s;w0
FRRkk0b04RLjP_M_i$IvXlg;R
RFbk0kL0RgP_M_IFTV;Yw
FRRkk0b0gRL__MPOopJm
w;RkRF00bkR_LUMZP_lYB0;R
RFbk0kL0Rdi_udR;
R0FkbRk0LF(_1d7_P
W;
IRRHRsCHM8C0$HV_	ODRR/*#0$MEHC##$R#MC_	C4b=R/R*R
;
RHRIsHCR80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88*R/RM#$0#ECH##R$	M_C=Cb4/R*R
;
RHRIsLCR(i_UxI_dsR;
RsIHCnRL__MPj;BB
IRRHRsCLUg_i.x_o0sw;R
RICHsR4L4_xUi_xAJYL)s;R
RICHsRjL4_xUi_Dsis;0X
IRRHRsCL_4jU_ixV#wV[
X;RHRIsLCRUP_M_BZl0
Y;RHRIsLCR4Mj_PI_$igvlXR;
RsIHCgRL__MPFVTIY
w;RHRIsLCRgP_M_JOpo;mw
ARRzRwtOLD	k5VR
RRRR53QRCH8MV0H$D_O	l_0b,R2
RRRR53mRCH8MV0H$D_O	2R2;R
RAq1BhQ_e)Xa c0R[Nbo_s4HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RR)  1a5RRR_L6POF1d,R2
RRRRu3z7 qaRL5RgP_M_IFTVRYw2R,
R3RR1w]Qa5RRR_LUMZP_lYB0R
2,RRRR3B7)iRRR58RHCHM0VO$_D0	_l2bR,R
RR1R3 RpRRRR5LMg_Pp_OJwomR
2,RRRR3Qa7RRRR5nRL__MPjRBB2R,
R3RRBaquzR) 54RLjP_M_i$IvXlgRR22/#*R$EM0C##HRM#$_bMFsCkM=*4R/
R;RCR8VsbNN[lR0_NoblsH4a3KqBt_]hqQR4=R;R
RAq1BhQ_e)Xa c0R[Nbo_s.HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RRzqu7a5 RRjL4_xUi_DsisR0X2R,
R3RR1w]Qa5RRR_LgU_ix.wos0,R2
RRRR)37BRiRRH5R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88,R2
RRRR 31pRRRRL5R4Uj_iVx_w[V#X,R2
RRRR73aQRRRRL5R(i_UxI_ds,R2
RRRRq3Bu)az RR5L_44U_ixAYJx)RsL2/2R*$R#MC0E#RH##_$MMsFbk=MC4/R*RR;
RV8CbNNsl0R[Nbo_s.Hl3qKat]_BqRQh=;R.
NRR#o#HMdRL_duiRH=R80CMH_V$O;D	
NRR#o#HM(RL_7F1_WdPRH=R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88
;
ClM8FD8kCl

FD8kC4RLnO_)lJH_D_Gg$l]b(5$R
RRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_Lnu_p$Q
w,RRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRgRL_wup_	aKs
[,RRRRRRRRRRRRRRRRR_L(Mjwts,7Y
RRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRnRL_l4zk,ag
RRRRRRRRRRRRRRRR6RL_$mP]
d,RRRRRRRRRRRRRRRRR.L4_Lm)QNIX Lw_8
2;RkRF00bkR:rdjL9R4Md_Pplw_.VGsTLk;R
RFbk0kr0Rj9:jR4L4_sk)Ok_gsLXA;R
RFbk0kL0Rdp_uwR;
R0FkbRk0L_4.mQ)LI XNw8_L;R
RHkMb0LRRgp_uwK_a	;s[
HRRM0bkRnRL_$up_;Qw
HRRM0bkR6RL_$mP]
d;RMRHbRk0R_L(Mjwts;7Y
HRRM0bkRnRL_#8Z0;dg
HRRM0bkRnRL_l4zk;ag
HRRM0bkRdRL_dui;R
RsRCorj6:94RLjZ_8#g0d_d w;R
RsRCorj6:9gRL_$mP]#d_N
p;RHRIsrCRc9:jRdL4_LPFwY.X __0a
 ;
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2R
RLHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRR4RLjZ_8#g0d_d wRL=RgP_m$_]d#;Np
RRRR8CM
CRRM
8
RDRNI#N$R5@@bCF#8RoCLud_iRd2LHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRRVRH5LR!(w_Mt7jsYRR2LHCoMR
RRRRRRVRH56RL_$mP]2dRRoLCHRM
RRRRRRRRR_Lgm]P$dN_#pRR={_Lnu_p$QRw,L_4dPwFL. XY_a0_ ;R}
RRRRRRRR8CM
RRRRCRRMR8
RCRRMR8
R8CM
R
RNH##oLMR4Pd_F.LwX_Y 0 _aRL=RgP_m$_]d#rNp69:4;R
RNH##oLMR4Md_Pplw_.VGsTLkRL=R48j_Zd#0gw_ d:rc4
9;R#RN#MHoR4L4_sk)Ok_gsLXAR=RRRjL4_#8Z0_dg rwdj9:j;R
RNH##oLMR4m._)ILQXwN _RL8RL=R48j_Zd#0gw_ d9r6;R
RNH##oLMRdp_uwRR=L4n_zalkgRR?Lmg_Pd$]_p#NrRj9:gRL_wup_	aKs
[;ClM8FD8kCl

FD8kCFROlLl_D	FO5R
ROlFl.OHHCH_DMH	_H_OCj
,RRHRHOOC.F_llD	HM_OHHC2_jRR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*RR;
R0FkbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
HRRM0bkR:rjjH9RH.OCOlFl_MDH	H_HOjC_;


RHRIsrCRd9:jRdL4_lMPwVp_GL.sk
T;RHRIsrCRj9:jR4L4_sk)Ok_gsLXA;R
RICHsR:rjjL9R4k4_)_sOWwYm[
Z;RHRIsrCRj9:jR_Lnu_pwQ
w;RHRIsLCRdi_udL,R(i_UxI_dsL,RnP_M_BjB,nRL_wup_,AJRcL4_wup_$i74 _Jd,dxR.L4_Lm)QNIX Lw_8L,Rgp_uwK_a	;s[
IRRHRsC0_8F#RHo/#*R$EM0C##HRM#$_C	CbR=4*;/R
IRRHRsCLMg_Pp_OJwom,gRL__MPFVTIYRw,L_4jM$P_IlivgRX,LMU_Pl_ZB;0Y
IRRHRsCL_4jU_ixV#wV[RX,L_4jU_ixssiD0RX,L_44U_ixAYJx),sLR_LgU_ix.wos0
;
`8HVC1VRQpvzqmaQhM
HHN0HDR
RfHbD10FVBDNLCHQM085HCHM0V[$_0_No0,O	RCH8MV0H$0_[N0o_lR#,HM8C0$HV_N[0o8_0HH,R80CMH_V$[o0N_F082`;
CHM8VR

R#N#HRoMLun_pQw_w9rjRH=RH.OCOlFl_MDH	H_HOjC_;R
RNH##oOMRF.llHCHO_MDH	H_HOjC_R{=RRdL4_lMPwVp_GL.skRT,L_44kO)s_sgkXrALjR9,LMn_PB_jBL,RgP_M_IFTV,YwRjL4__MP$vIil,gXR_LUMZP_lYB0,dRL_duiR
};R#RN#MHoRcL4_wup_$i74 _JdRdx=LR|np_uww_Q;R
RNH##oLMRgp_uwK_a	Rs[=LR54m._)ILQXwN _2L8?F08_o#H:cL4_wup_$i74 _Jd;dx
NRR#o#HM4RL4)_ksgO_kAsXLRR=5_LgMOP_pmJowL2?4k4_)_sOWwYm[4Z:';Lj
R
R[o0N_0HMCNsVO[CR0HNoRR5
R3RRLud_iRdRRRRRR5RRLud_i,d2
RRRR(3L_7F1_WdPRRRRR(5L_7F1_WdP2R,
R3RRLU(_idx_IRsRR5RRLU(_idx_I,s2
RRRRn3L__MPjRBBRRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRRRRRRLR5np_uwJ_A2R,
R3RRL_44U_ixAYJx)RsL54L4_xUi_xAJYL)s2R,
R3RRL_4jU_ixssiD0RXR5jL4_xUi_Dsis20X,R
RRLR34Uj_iVx_w[V#X5RRL_4jU_ixV#wV[,X2
RRRRg3L_xUi_s.owR0RRg5L_xUi_s.ow,02
RRRR43LjP_M_i$IvXlgRLR54Mj_PI_$igvlX
2,RRRR3_LgMFP_TYIVwRRR5_LgMFP_TYIVw
2,RRRR3_LgMOP_pmJowRRR5_LgMOP_pmJow
2,RRRR3_LUMZP_lYB0RRRR5_LUMZP_lYB02
2;
LRR4)n_O_lHJgDG_b$]lR($L)(_O_lHJ5DR
RRRR43LdP_Ml_wpVsG.L5kTL_4dMwPlpG_V.ksLT
2,RRRR34L4_sk)Ok_gsLXARLR54k4_)_sOWwYm[,Z2
RRRRd3L_duiRRRRRRRRRLR5(1_F7P_dW
2,RRRR3_Lnu_p$QRwRRRRRR(5L_xUi_sdI2R,
R3RRLud_pRwRRRRRRRRR5_Lnu_pwA,J2
RRRRg3L_wup_	aKsR[RRLR5gp_uwK_a	2s[,R
RRLR3(w_Mt7jsYRRRR5RRL_44U_ixAYJx)2sL,R
RRLR3nZ_8#g0dRRRRR5RRL_4jU_ixssiD0,X2
RRRRn3L_l4zkRagRRRRRLR54Uj_iVx_w[V#X
2,RRRR3_L6m]P$dRRRRRRRRg5L_xUi_s.ow,02
RRRR43L.)_mLXQIN_ wL58RL_4.mQ)LI XNw8_L2
2;
LRRg)_mLXQINR wLmg_)GL_h7$IRR5
R3RRL[(_Wd1_PRWRRRRR5_Ldu2id,R
RRLR3UP_Ml_wpY5tRL_4.mQ)LI XNw8_L2R,
R3RRLm6_Pd$]RRRR5_LUMZP_lYB02R,
R3RRLM(_wstj7RYRRLR54Mj_PI_$igvlX
2,RRRR3_LduRp$RRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRR5RR0_8F#2HoR
2;
8CMlkF8D
C
lkF8DLCR((_e4JmKxLR5d)_FA
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmd_FRA,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LcmNiK,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR.6_H,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLH._nR,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L.HRW,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.RL_,H RRR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRcY_FE
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmc_YjEjR
2;RMRHbRk0LFd_);Aj
HRRM0bkR_Ldm;FA
HRRM0bkR_LcmNiK;R
RHkMb0.RL_;H6
HRRM0bkR_L.H
n;RMRHbRk0LH._WR;
RbHMkL0R. _H;R
RFbk0kL0RcY_FE
j;RkRF00bkR_LcmjYEjR;
Rp1)B 4nR_LUm]P$do7YRR5
R3RR7RRR5_LdFj)A2R,
R3RRBR R5_Ldm2FA,R
RRBR3p5iRLmc_i2KN,R
RRqR3j5RRLH._6
2,RRRR3Rq4R.5L_2Hn,R
RRqR3.5RRLH._W
2,RRRR3RqdR.5L_2H ,R
RRTR3R5RRLFc_Y2Ej,R
RRTR3456RLmc_YjEj2;R2
M
C88lFk
DC
8lFkRDCL_44[0wKpYPYg5JELmc_i,KNRRH,F
2;RNRbsCNl0RCsLmc_)RJO=;R4
HRRM0bkR_LcmNiK;R
RHkMb0;RH
FRRkk0b0;RF
HRRMo0CC[sR;R
RsRCor_LcmO)JR4:R9nRL_s$Fj;u7
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoH
RRRR_Ln$jFsu47r9=R<R
H;RRRRV5Fs[RR=.[;RRR<=Lmc_);JOR=[RR+[RR
42RRRRRnRL_s$Fjru7[<9R=nRL_s$Fjru7[RR-4
9;RMRC8R
RNH##oFMRRL=RnF_$s7jur_LcmO)J9C;
MF8l8CkD
F
l8CkDRjL4_WMYhhagIRLp5R
RLmc_i,KN
LRR6F_P1,Od
LRR(1_u$BH_kR,
R_L6HO1WBR,
R_Lc1OY#,R
RLM(_YIWh7
Y,R(RL_$u1H#Dg,R
RL_4jMhYWaIghL;p2
R
RbNNslCC0sgRL_aMz_DoBY=vRR;4n
HRRM0bkRcRL_KmiNL,R6F_P1,OdR_L(uH1$_,BkR_L6HO1WBR;
RbHMkR0Rrj4:9cRL_#1YOR;
RbHMkR0Rr_LgM_zaoYBDvRR-4RR:jL9R(Y_MW7hIYR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRLRrgz_MaB_oDRYv-RR4:9RjRjL4_WMYhhagI;Lp
sRRCRoRR(RL_$u1H#Dg;R

RsbNN0lCCLsR($_WjdM_gRRRRRRR='RdLjjj;R
RbNNslCC0sURL_UY(s1C_DRRRR=RRRLd'j;j4
bRRNlsNCs0CRdL4_o0EMJYcB_ztA=CRRLd'j;4j
bRRNlsNCs0CR4L4_XLx_aJ1Bz(OR.=R'jLj;R
RbNNslCC0sgRL_XLx_i4#nRzRR.=R'4Lj;R
RbNNslCC0sURL_o7DY)(UBRRRR.=R'jL4;R
RbNNslCC0s4RLjI_64pnkaugTRRR=.4'L4R;
RosCR:rj.L9RnL_Mag0d,nRL_aGL0;dg
sRRCroRLMg_zoa_BvDYR4-RRj:R9(RL_EMYQ#dg;R
RsRCoLM6__.xO,cRL_6M_QR;
RosCR_LguH1$DNg#.R;
RosCRjL4_$u1H#DgG,wAR4L4_$u1H#Dgtu.X,4RL41_u$gHD#AGwaR;
RsIHCnRL_aMz_;VL
NRRD$IN#@R@5#bFCC8oR_LcmNiK2R
RRgRL_$u1H#DgN<.R=6RL_WH1O&BRR_L(uH1$_;Bk
R
RNH##oLMRnz_MaL_VR5=RLM(_YdEQg=#R=(RL_WMYhYI72
;
R#RN#MHoRjL4_WMYhhagIRLp=(RL_EMYQ#dg;R

RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:LM(_z.a_gRj
RHRRV65L_xM_O|.RR_L6POF1dR2
RRRRR_L(MQYEdRg#<'=RL
j;RRRRCCD#R5HVLMc__26Q
RRRRLRR(Y_MEgQd#=R<R_L(MQYEdRg#+;R4
CRRMR8
RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:Lmn_OV_ZLR
RRRRRLMn_Lda0g=R<R_LnG0Lad
g;RRRRRVRH5_L6POF1d
R2RRRRRRRRLMn_Lda0g=R<R_L(WM$j_;dg
CRRMR8
RINDNR$#@L@5nL_Mag0dRRFsLug_1D$Hg.#NRRFsLMn_zVa_LsRFR_L6HO1WBsRFR_Lc1OY#2R
RLHCoMRR:Lmn_On_$sR
RRnRL_aGL0Rdg<L=RnL_Mag0d;R
RR4RL41_u$gHD#Xt.u=R<R
j;RRRRL_4juH1$DGg#w<AR=;Rj
RRRR_LcMQ_6RR<=jR;
RLRR6__MxRO.<j=R;R
RRNRO#LC5nL_Mag0d2R
RR(RL_jW$Mg_dRL:RCMoH
RRRRLRR6__MxRO.<4=R;R
RRRRRHLV561_HW2OB
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RCRRMR8
RLRRU(_YU_sC1:DR
RRRRORRN5#CL1c_Y2#O
RRRRLRR4L4_xJX_1(aBO:zR
RRRRRRRR5HVLug_1D$Hg.#N2R
RRRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRRRRRL_4juH1$DGg#w<AR=;R4
RRRRRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRRMRC8DRC#RC
RRRRRRRRRLRRc__M6<QR=;R4
RRRRLRRgx_LX#_4iRnz:R
RRRRRRVRH5_LguH1$DNg#.R2
RRRRRRRRR5HVLMn_zVa_LR2
RRRRRRRRRLRR4uj_1D$Hgw#GA=R<R
4;RRRRRRRRRDRC#LCRCMoH
RRRRRRRRRRRR_LcMQ_6RR<=4R;
RRRRRRRRRLRRnL_Gag0dRR<=L_4d0MEoYBcJzAt_CR;
RRRRRRRRR8CM
RRRRLRR46j_Ik4npTaguRR:LHCoMR
RRRRRRcRL_6M_Q=R<R
4;RRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRR4RL41_u$gHD#Xt.u=R<R
4;RRRRRRRRR6RL_xM_O<.R=;R4
RRRRRRRR8CMR#CDCVRH5g!L_$u1H#DgN
.2RRRRRRRRR6RL_xM_O<.R=;R4
RRRRCRRMR8
RRRRR_LU7YDo(BU)RL:RCMoH
RRRRRRRR_LcMQ_6RR<=4R;
RRRRRHRRVn5L_aMz_2VLRoLCHRM
RRRRRRRRR4L4_$u1H#Dgtu.XRR<=4R;
RRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRCRM8CCD#R5HVLug_1D$Hg.#N2R
RRRRRRRRRLM6__.xORR<=4R;
RRRRR8CM
RRRR8RRCkVND:0R
RRRRRRRRR;
RRRRR8CMOCN#
RRRRdL4_o0EMJYcB_ztA:CRRoLCHRM
RRRRR_LcMQ_6RR<=4R;
RRRRR5HVLMn_zVa_LL2RCMoH
RRRRRRRRjL4_$u1H#DgGRwA<4=R;R
RRRRRR6RL_xM_O<.R=;R4
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RRRRR8CM
RRRR8CM
RRRRV8CN0kDRR:
RRRRRR;
RCRRMN8O#RC
R8CM
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoHRL:Rc1_u$RH
RHRRVLR56F_P1ROd|!|RLH6_1BWO2CRLo
HMRRRRR(RL_$u1H#DgRR<=jR;
RRRRR4L4_$u1H#DgGawARR<=jR;
RCRRMC8RDR#CLHCoMR
RRRRRLu(_1D$Hg<#R=4RL41_u$gHD#Xt.uR;
RRRRR4L4_$u1H#DgGawARR<=L_4juH1$DGg#w
A;RRRRRNRO#5CRL1c_Y2#ORR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRR4L4_XLx_aJ1Bz(O:RR
RRRRRLRR(1_u$gHD#=R<R4L4_$u1H#DgGawA;R
RRRRRLLg_x4X_#zin:R
RRRRRR(RL_$u1H#DgRR<=L_44uH1$DGg#w;Aa
RRRR8RRCkVND
0:RRRRRRRR;R
RRRRRCOM8N
#CRRRRC
M8RMRC8M
C88lFk
DC
8lFkRDCLmg_.V$$_.VtR,5HR;F2
HRRM0bkRRrj:9RdR
H;RkRF00bkR
F;
NRR#o#HMRRF=rRHj&9RR4Hr9RR&H9r.RH&Rr;d9
8CMlkF8D
C
lkF8DLCR4Bn_)atOB_kNC_]ck5XoLmc_i,KNRRH,F
2;RMRHbRk0Lmc_i;KN
HRRM0bkRRrj:UR4jH9R;R
RFbk0kF0R;R
RICHsR_LcAhOW;R
RICHsRRrj:UR4jL9RgZ_B1VjIY;_l
IRRHRsCr:jRRd4U94RL6Z_B1VjIY__lwHEV(R;
RsIHCjRrRc:R6L9RgZ_B1VjIY;_M
IRRHRsCr:jRR9c(R6L4_1BZjYIV_wM_E(VH;R
RICHsRRrj:4R49gRL_1BZjYIV_
8;RHRIsrCRjRR:.L9RgZ_B1VjIY;_e
IRRHRsCr:jRRRd9L_46BjZ1I_VYeE_wV;H(
IRRHRsCr:jRRR.9L_4dBjZ1I_VYe]_wgR;
RosCRRrj:9R.RcL4_1BZjYIV_we_];gl
NRR#o#HMgRL_1BZjYIV_=lRR
H;R#RN#MHoR=FRR_LcAhOW;R
RNH##oLMR4B6_ZI1jVlY__VwEHj(rR4:RURj9=gRL_1BZjYIV_
l;R#RN#MHoR6L4_1BZjYIV_wl_E(VHr44UR4:RURd9='RdL444;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFgL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(Rrj:9Rd23,RFg5L_1BZjYIV_jMr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_N5R
RRHR356L4_1BZjYIV_wl_E(VHr:cRR2(9,FR35_LgBjZ1I_VYM9r42
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5jR
RRRR53HL_46BjZ1I_VYlE_wVrH(URR:4249,FR35_LgBjZ1I_VYM9r.2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5QR
RRRR53HL_46BjZ1I_VYlE_wVrH(4:.RR94623,RFg5L_1BZjYIV_dMr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_U5R
RRHR356L4_1BZjYIV_wl_E(VHrR4n:gR49R2,3LF5gZ_B1VjIYr_Mc292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFOL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(jr.R.:Rd,92R53FLBg_ZI1jVMY_r2692R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FL1
R5RRRR3LH54B6_ZI1jVlY__VwEH.(rcRR:.2(9,FR35_LgBjZ1I_VYM9rn2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_54R
RRRR53HL_46BjZ1I_VYlE_wVrH(.:URR9d423,RFg5L_1BZjYIV_(Mr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_w5R
RRHR356L4_1BZjYIV_wl_E(VHrRd.:6Rd9R2,3LF5gZ_B1VjIYr_MU292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMF8L_RR5
R3RRH45L6Z_B1VjIY__lwHEV(nrdRd:Rg,92R53FLBg_ZI1jVMY_r2g92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5nR
RRRR53HL_46BjZ1I_VYlE_wVrH(c:jRR9cd23,RFg5L_1BZjYIV_4Mrj292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_(
R5RRRR3LH54B6_ZI1jVlY__VwEHc(rcRR:c2(9,FR35_LgBjZ1I_VYM4r49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLX_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(UrcR6:R4,92R53FLBg_ZI1jVMY_r94.2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNw5R
RRHR356L4_1BZjYIV_wl_E(VHrR6.:6R69R2,3LF5gZ_B1VjIYr_M42d92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN56R
RRRR53HL_46BjZ1I_VYlE_wVrH(6:nRR96g23,RFg5L_1BZjYIV_4Mrc292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_g
R5RRRR3LH54B6_ZI1jVlY__VwEHn(rjRR:n2d9,FR35_LgBjZ1I_VYM6r49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLu_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(crnRn:R(,92R53FLBg_ZI1jVMY_r94n2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNY5R
RRHR356L4_1BZjYIV_wl_E(VHrRnU:4R(9R2,3LF5gZ_B1VjIYr_M42(92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5BR
RRRR53HL_46BjZ1I_VYlE_wVrH((:.RR9(623,RFg5L_1BZjYIV_4MrU292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_N
R5RRRR3LH54B6_ZI1jVlY__VwEH((rnRR:(2g9,FR35_LgBjZ1I_VYMgr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLn_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(jrURU:Rd,92R53FLBg_ZI1jVMY_r9.j2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rj(5R
RRHR356L4_1BZjYIV_wl_E(VHrRUc:(RU9R2,3LF5gZ_B1VjIYr_M.2492R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5XR
RRRR53HL_46BjZ1I_VYlE_wVrH(U:URR9g423,RFg5L_1BZjYIV_.Mr.292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFjL_w
R5RRRR3LH54B6_ZI1jVlY__VwEHg(r.RR:g269,FR35_LgBjZ1I_VYMdr.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGL6_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(nrgRg:Rg,92R53FLBg_ZI1jVMY_r9.c2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rjg5R
RRHR356L4_1BZjYIV_wl_E(VHrj4jR4:Rj2d9,FR35_LgBjZ1I_VYM6r.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLu_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(jr4cRR:49j(23,RFg5L_1BZjYIV_.Mrn292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFjL_Y
R5RRRR3LH54B6_ZI1jVlY__VwEH4(rj:URR4449R2,3LF5gZ_B1VjIYr_M.2(92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5BR
RRRR53HL_46BjZ1I_VYlE_wVrH(4R4.:4R46,92R53FLBg_ZI1jVMY_r9.U2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RjN5R
RRHR356L4_1BZjYIV_wl_E(VHrn44R4:R42g9,FR35_LgBjZ1I_VYMgr.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLn_QRR5
R3RRH45L6Z_B1VjIY__lwHEV(.r4jRR:49.d23,RFg5L_1BZjYIV_dMrj292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFQL_(
R5RRRR3LH54B6_ZI1jVlY__VwEH4(r.:cRR(4.9R2,3LF5gZ_B1VjIYr_Md2492R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLQ5XR
RRRR53HL_46BjZ1I_VYlE_wVrH(4R.U:dR44,92R53FLBg_ZI1jVMY_r9d.2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RQw5R
RRHR356L4_1BZjYIV_wl_E(VHr.4dR4:Rd269,FR35_LgBjZ1I_VYMdrd9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGL6_QRR5
R3RRH45L6Z_B1VjIY__lwHEV(dr4nRR:49dg23,RFg5L_1BZjYIV_dMrc292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFQL_g
R5RRRR3LH54B6_ZI1jVlY__VwEH4(rc:jRRd4c9R2,3LF5gZ_B1VjIYr_Md2692R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLQ5uR
RRRR53HL_46BjZ1I_VYlE_wVrH(4Rcc:cR4(,92R53FLBg_ZI1jVMY_r9dn2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RQY5R
RRHR356L4_1BZjYIV_wl_E(VHrU4cR4:R6249,FR35_LgBjZ1I_VYM(rd9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLB_QRR5
R3RRH45L6Z_B1VjIY__lwHEV(6r4.RR:496623,RFg5L_1BZjYIV_dMrU292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFQL_N
R5RRRR3LH54B6_ZI1jVlY__VwEH4(r6:nRRg469R2,3LF5gZ_B1VjIYr_Md2g92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLU5nR
RRRR53HL_46BjZ1I_VYlE_wVrH(4Rnj:nR4d,92R53FLBg_ZI1jVMY_r9cj2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RU(5R
RRHR356L4_1BZjYIV_wl_E(VHrc4nR4:Rn2(9,FR35_LgBjZ1I_VYM4rc9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLX_URR5
R3RRH45L6Z_B1VjIY__lwHEV(nr4URR:49(423,RFg5L_1BZjYIV_cMr.292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFUL_w
R5RRRR3LH54B6_ZI1jVlY__VwEH4(r(:.RR64(9R2,3LF5gZ_B1VjIYr_Mc2d92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLU56R
RRRR53HL_46BjZ1I_VYlE_wVrH(4R(n:(R4g,92R53FLBg_ZI1jVMY_r9cc2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RUg5R
RRHR356L4_1BZjYIV_wl_E(VHrj4UR4:RU2d9,FR35_LgBjZ1I_VYM6rc9;22
NRR#o#HM4RL6Z_B1VjIY__MwHEV(Rrj:6Rc9RR=LBg_ZI1jVMY_;R
RNH##oLMR4B6_ZI1jVMY__VwEHc(rnRR:cR(9='R.L;44
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_g5R
RRHR356L4_1BZjYIV_wM_E(VHr:jRR2d9,FR35_LgBjZ1I_VY89rj2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_5NR
RRRR53HL_46BjZ1I_VYME_wVrH(cRR:(,92R53FLBg_ZI1jV8Y_r2492R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLj
R5RRRR3LH54B6_ZI1jVMY__VwEHU(rR4:R4,92R53FLBg_ZI1jV8Y_r2.92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLQ
R5RRRR3LH54B6_ZI1jVMY__VwEH4(r.RR:4269,FR35_LgBjZ1I_VY89rd2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_5UR
RRRR53HL_46BjZ1I_VYME_wVrH(4:nRR94g23,RFg5L_1BZjYIV_c8r9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_O5R
RRHR356L4_1BZjYIV_wM_E(VHrR.j:dR.9R2,3LF5gZ_B1VjIYr_86292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMF1L_RR5
R3RRH45L6Z_B1VjIY__MwHEV(cr.R.:R(,92R53FLBg_ZI1jV8Y_r2n92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FL4
R5RRRR3LH54B6_ZI1jVMY__VwEH.(rURR:d249,FR35_LgBjZ1I_VY89r(2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_5wR
RRRR53HL_46BjZ1I_VYME_wVrH(d:.RR9d623,RFg5L_1BZjYIV_U8r9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_85R
RRHR356L4_1BZjYIV_wM_E(VHrRdn:gRd9R2,3LF5gZ_B1VjIYr_8g292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq sn__GDMFNL_n
R5RRRR3LH54B6_ZI1jVMY__VwEHc(rjRR:c2d9,FR35_LgBjZ1I_VY8jr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__sDFMGL(_NRR5
R3RRH45L6Z_B1VjIY__MwHEV(crcRc:R(,92R53FLBg_ZI1jV8Y_r9442
2;RgRL_$m.$VV_tL.R.m4_.V$$_.Vt_TvHqn4 _$E_RR5
R3RRHg5L_1BZjYIV_j8rRd:R9R2,3LF54Bd_ZI1jVeY__gw]r2j92R;
R_Lgm$.$Vt_V..RL4._m$_$VV_t.vqHT4_ nER_x5R
RRHR35_LgBjZ1I_VY8Rrc:9R(23,RF45LdZ_B1VjIY__ewr]g4292;R
RLmg_.V$$_.VtR4L._$m.$VV_tv._H4Tq En__5bR
RRRR53HLBg_ZI1jV8Y_r:URR94423,RF45LdZ_B1VjIY__ewr]g.292;R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoH
RRRRcL4_1BZjYIV_we_]Rgl<L=R4Bd_ZI1jVeY__gw];R
RC
M8R#RN#MHoR_LgBjZ1I_VYeRR=L_4cBjZ1I_VYe]_wg
l;R#RN#MHoR6L4_1BZjYIV_we_E(VHr:jRRR.9=gRL_1BZjYIV_
e;R#RN#MHoR6L4_1BZjYIV_we_E(VHr:dRRRd9='R4L
4;RgRL_$m.$VV_tL.R.m6_.V$$_.Vt_TvHqn4 _DZ_MLGF5R
RRHR356L4_1BZjYIV_we_E(VH23,RFc5L_WAOh;22
8CMlkF8D
C
lkF8DLCR4u4_1D$HgV#4	
a5RcRL_KmiNR,
R_L([_W1d,PW
LRR6i_ud,Op
LRRdp_u$R,
R_Ldu,pw
LRR6P_m$,]d
LRRnZ_.#J0d,R
RLP6_Fd1O,R
RLH6_1BWO,R
RLu(_1D$Hg
#,R4RLjY_MWghahpIL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L6uOidpR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;RMRHbRk0Lm6_Pd$];R
RHkMb0jRrRd:RnR49L.n_Zd#0JR;
RbHMkL0R6F_P1;Od
HRRM0bkR_L6HO1WBR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRRr(:9RjRjL4_WMYhhagI;Lp
IRRHRsCLm(_Pd$]g
k;RHRIsrCR4RR:49U4R_L6Mtwx0R;
RsIHCjRrR4:RUR49LMn_w0xtwR;
RosCR4RrR4:RUR49Lug_VIt$7L#F;R
RICHsR_L(kjzaK;Bc
sRRCRoRr:gRRRj9L$n_Fusj7R;
RsIHCrRRgRR:4L9R(F_$s7jukR;
RsIHCjRrR(:R9gRL_aMz$0uw7
p;RHRIsrCRjRR:4L9R(z_MaIduYR;
RsIHC(RL_aMzjcKB;R
RICHsR_Lg.tZaQNVcgR;
RsIHCjRrRd:RnR49L_4j.0Z#dNJ	U
A;RHRIsrCRjRR:d9n4R.L4_q.Z]vBJs 4XDR;
RosCRjRrRd:RnR49L_44.]ZqAmgsg;XE
IRRHRsCr:jRRj4U9nRL_a.Zt;QV
NRR#o#HM(RL_$mP]kdgRL=R6P_m$R]d&6RL_duiO
p;R#RN#MHoR_LnMtwx0jwr9RR=Lud_p
$;R#RN#MHoRjL4_#.Z0	dJNrUAjRR:d9n4RL=RnZ_.#J0d;R
RNH##oLMR4.._ZBq]J4vsXr DjRR:d9n4RL=R4.4_ZAq]ggsmX
E;RDRNI#N$R5@@bCF#8RoCLmc_i2KN
RRRR4L4_q.Z]sAgmEgXRL=RnZ_.#J0d;R

R_L(em(4KRJxL4U_poLOiR_)5R
RRLR3d)_FARjR5_LnMtwx0jwr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA9r42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD9r42R,
R3RRLFc_YREj5_Ln.tZaQjVr9
2,RRRR3_LcmjYEjLR56w_Mxrt04R922
;
R(RL_4e(mxKJR_LU4OpLo1i_RR5
R3RRLFd_)RAjRn5L_xMwtr0w4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr9
2,RRRR3_LcFjYERn5L_a.ZtrQV4,92
RRRRc3L_EmYj5jRLM6_w0xtr2.9R
2;
LRR((_e4JmKxURL_L4pO_oiQ
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA9rc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD9rc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6,92
RRRRc3L_EFYjLR5nZ_.aVtQr2.9,R
RRLR3cY_mERjj5_L6Mtwx09rd2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5JR
RRRRd3L_AF)j5RRLMn_w0xtw9rd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDr9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r2(9,R
RRLR3cY_FE5jRL.n_ZQatV9rd2R,
R3RRLmc_YjEjR65L_xMwtc0r922R;R

R_L(em(4KRJxL4U_poLOij_TRR5
R3RRLFd_)RAjRn5L_xMwtr0wc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 gDr9
2,RRRR3_LcFjYERn5L_a.ZtrQVc,92
RRRRc3L_EmYj5jRLM6_w0xtr269R
2;
LRR((_e4JmKxURL_L4pO_oiz
R5RRRR3_LdFj)ARLR5nw_Mxwt0r269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr269,R
RRLR3cY_mERjj5_L6Mtwx09rn2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5qR
RRRRd3L_AF)j5RRLMn_w0xtw9rn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D42.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D42d9,R
RRLR3cY_FE5jRL.n_ZQatV9rn2R,
R3RRLmc_YjEjR65L_xMwt(0r922R;R

R_L(em(4KRJxL4U_poLOiR_K5R
RRLR3d)_FARjR5_LnMtwx0(wr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r94c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9462R,
R3RRLFc_YREj5_Ln.tZaQ(Vr9
2,RRRR3_LcmjYEjLR56w_Mxrt0UR922
;
R(RL_4e(mxKJR_LU4OpLoMi_RR5
R3RRLFd_)RAjRn5L_xMwtr0wU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr94n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr94(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r49
2,RRRR3_LcFjYERn5L_a.ZtrQVU,92
RRRRc3L_EmYj5jRLM6_w0xtr2g9R
2;
LRR((_e4JmKxURL_L4pO_oie
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr4922R;R

R_L(em(4KRJxL4g_poLOil_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr94j2R,
R3RRLmc_YjEjR65L_xMwt40r4R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9442R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r49
2,RRRR3_LcmjYEjLR56w_Mxrt042.9R
2;
LRR((_e4JmKxgRL_L4pO_oi158R
RRRRd3L_AF)j5RRLMn_w0xtw.r49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9.c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9.62R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr94d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1e5R
RRLR3d)_FARjR5_LnMtwx04wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9.n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9.(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r.9
2,RRRR3_LcFjYERn5L_a.ZtrQV42d9,R
RRLR3cY_mERjj5_L6Mtwx0cr4922R;R

R_L(em(4KRJxL4g_poLOiD_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr94c2R,
R3RRLmc_YjEjR65L_xMwt40r6R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9462R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd249,R
RRLR3cY_FE5jRL.n_ZQatV6r49
2,RRRR3_LcmjYEjLR56w_Mxrt042n9R
2;
LRR((_e4JmKxgRL_L4pO_oi156R
RRRRd3L_AF)j5RRLMn_w0xtwnr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9d.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9dd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr94(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1C5R
RRLR3d)_FARjR5_LnMtwx04wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9dc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9d62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rd9
2,RRRR3_LcFjYERn5L_a.ZtrQV42(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur4922R;R

R_L(em(4KRJxL4g_poLOi1_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnrd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(rd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr94U2R,
R3RRLmc_YjEjR65L_xMwt40rgR922
;
R(RL_4e(mxKJR_Lg4OpLo1i_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r94g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgr49
2,RRRR3_LcmjYEjLR56w_Mxrt0.2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9c42R,
R3RRLFc_YREj5_Ln.tZaQ.Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9.42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQM5R
RRLR3d)_FARjR5_LnMtwx0.wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9c.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9cd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrc9
2,RRRR3_LcFjYERn5L_a.ZtrQV.249,R
RRLR3cY_mERjj5_L6Mtwx0.r.922R;R

R_L(em(4KRJxL4g_poLOi8_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcrc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 cDrc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 cDr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr9..2R,
R3RRLmc_YjEjR65L_xMwt.0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoQi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UcArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dc2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UcAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9cg2R,
R3RRLFc_YREj5_Ln.tZaQ.Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9.62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQb5R
RRLR3d)_FARjR5_LnMtwx0.wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9642R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r69
2,RRRR3_LcFjYERn5L_a.ZtrQV.269,R
RRLR3cY_mERjj5_L6Mtwx0nr.922R;R

R_L(em(4KRJxL4g_poLOi6_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 6Dr.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 6Drd,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.n2R,
R3RRLmc_YjEjR65L_xMwt.0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoQi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U6Arc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D62c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U6Ar6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6269,R
RRLR3cY_FE5jRL.n_ZQatV(r.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ51R
RRRRd3L_AF)j5RRLMn_w0xtwUr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA62n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r96n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA62(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r96(2R,
R3RRLFc_YREj5_Ln.tZaQ.VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9.g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQJ5R
RRLR3d)_FARjR5_LnMtwx0.wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr96g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr69
2,RRRR3_LcFjYERn5L_a.ZtrQV.2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrd922R;R

R_L(em(4KRJxL4g_poLOil_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dj2R,
R3RRLmc_YjEjR65L_xMwtd0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dn2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UnArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ58R
RRRRd3L_AF)j5RRLMn_w0xtw.rd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAn2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9nc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAn269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9n62R,
R3RRLFc_YREj5_Ln.tZaQdVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9dd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJe5R
RRLR3d)_FARjR5_LnMtwx0dwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9nn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrn9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9n(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rn9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2d9,R
RRLR3cY_mERjj5_L6Mtwx0crd922R;R

R_L(em(4KRJxL4g_poLOiD_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgrn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDrg,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dc2R,
R3RRLmc_YjEjR65L_xMwtd0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(Arj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Ar4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(249,R
RRLR3cY_FE5jRL.n_ZQatV6rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ56R
RRRRd3L_AF)j5RRLMn_w0xtwnrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA(2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9(.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA(2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9(d2R,
R3RRLFc_YREj5_Ln.tZaQdVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9d(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJC5R
RRLR3d)_FARjR5_LnMtwx0dwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9(c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9(62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r(9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urd922R;R

R_L(em(4KRJxL4g_poLOi1_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 (Drn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 (Dr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dU2R,
R3RRLmc_YjEjR65L_xMwtd0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoJi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9dg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(ArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Arg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrd9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRlj5R
RRLR3d)_FARjR5_LnMtwx0cwrj,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2j9,R
RRLR3cY_mERjj5_L6Mtwx04rc922R;R

R_L(em(4KRJxL4g_poLOiM_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR8j5R
RRLR3d)_FARjR5_LnMtwx0cwr.,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2.9,R
RRLR3cY_mERjj5_L6Mtwx0drc922R;R

R_L(em(4KRJxL4g_poLOie_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRDj5R
RRLR3d)_FARjR5_LnMtwx0cwrc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9Ug2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgrU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2c9,R
RRLR3cY_mERjj5_L6Mtwx06rc922R;R

R_L(em(4KRJxL4g_poLOib_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg249,R
RRLR3cY_FE5jRL.n_ZQatV6rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR6j5R
RRLR3d)_FARjR5_LnMtwx0cwrn,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9g.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2n9,R
RRLR3cY_mERjj5_L6Mtwx0(rc922R;R

R_L(em(4KRJxL4g_poLOiC_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg269,R
RRLR3cY_FE5jRL.n_ZQatV(rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR1j5R
RRLR3d)_FARjR5_LnMtwx0cwrU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9g(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2U9,R
RRLR3cY_mERjj5_L6Mtwx0grc922R;R

R_L(em(4KRJxL4g_poLOiJ_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrc9
2,RRRR3_LcmjYEjLR56w_Mxrt062j9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49j42R,
R3RRLFc_YREj5_Ln.tZaQ6Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9642;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzM5R
RRLR3d)_FARjR5_LnMtwx06wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4j9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arj2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4j9
2,RRRR3_LcFjYERn5L_a.ZtrQV6249,R
RRLR3cY_mERjj5_L6Mtwx0.r6922R;R

R_L(em(4KRJxL4g_poLOi8_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49jc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49j62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr96.2R,
R3RRLmc_YjEjR65L_xMwt60rdR922
;
R(RL_4e(mxKJR_Lg4OpLozi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arj2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drj2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr69
2,RRRR3_LcmjYEjLR56w_Mxrt062c9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49jg2R,
R3RRLFc_YREj5_Ln.tZaQ6Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9662;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rzb5R
RRLR3d)_FARjR5_LnMtwx06wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4449
2,RRRR3_LcFjYERn5L_a.ZtrQV6269,R
RRLR3cY_mERjj5_L6Mtwx0nr6922R;R

R_L(em(4KRJxL4g_poLOi6_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D494.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA494d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr96n2R,
R3RRLmc_YjEjR65L_xMwt60r(R922
;
R(RL_4e(mxKJR_Lg4OpLozi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc449
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6449
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4269,R
RRLR3cY_FE5jRL.n_ZQatV(r69
2,RRRR3_LcmjYEjLR56w_Mxrt062U9R
2;
LRR((_e4JmKxgRL_L4pO_oiz51R
RRRRd3L_AF)j5RRLMn_w0xtwUr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA494n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D494(2R,
R3RRLFc_YREj5_Ln.tZaQ6VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr96g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzJ5R
RRLR3d)_FARjR5_LnMtwx06wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg449
2,RRRR3_LcFjYERn5L_a.ZtrQV62g9,R
RRLR3cY_mERjj5_L6Mtwx0jrn922R;R

R_L(em(4KRJxL4g_poLOil_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nj2R,
R3RRLmc_YjEjR65L_xMwtn0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiq58R
RRRRd3L_AF)j5RRLMn_w0xtw.rn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49.c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49.62R,
R3RRLFc_YREj5_Ln.tZaQnVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9nd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rqe5R
RRLR3d)_FARjR5_LnMtwx0nwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar.2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4.9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2d9,R
RRLR3cY_mERjj5_L6Mtwx0crn922R;R

R_L(em(4KRJxL4g_poLOiD_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nc2R,
R3RRLmc_YjEjR65L_xMwtn0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd249,R
RRLR3cY_FE5jRL.n_ZQatV6rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiq56R
RRRRd3L_AF)j5RRLMn_w0xtwnrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49d.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49dd2R,
R3RRLFc_YREj5_Ln.tZaQnVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9n(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RqC5R
RRLR3d)_FARjR5_LnMtwx0nwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4d9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drd2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64d9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urn922R;R

R_L(em(4KRJxL4g_poLOi1_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49dn2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49d(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nU2R,
R3RRLmc_YjEjR65L_xMwtn0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoqi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9ng2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrn9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49c42R,
R3RRLFc_YREj5_Ln.tZaQ(Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9(42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKM5R
RRLR3d)_FARjR5_LnMtwx0(wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4c9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drc2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arc2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4c9
2,RRRR3_LcFjYERn5L_a.ZtrQV(249,R
RRLR3cY_mERjj5_L6Mtwx0.r(922R;R

R_L(em(4KRJxL4g_poLOi8_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49cc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49c62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(.2R,
R3RRLmc_YjEjR65L_xMwt(0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoKi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9(d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arc2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4c9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4c9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49cg2R,
R3RRLFc_YREj5_Ln.tZaQ(Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9(62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKb5R
RRLR3d)_FARjR5_LnMtwx0(wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar6249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4469
2,RRRR3_LcFjYERn5L_a.ZtrQV(269,R
RRLR3cY_mERjj5_L6Mtwx0nr(922R;R

R_L(em(4KRJxL4g_poLOi6_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D496.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA496d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(n2R,
R3RRLmc_YjEjR65L_xMwt(0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoKi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9((2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar62c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc469
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6469
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr6269,R
RRLR3cY_FE5jRL.n_ZQatV(r(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiK51R
RRRRd3L_AF)j5RRLMn_w0xtwUr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA496n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D496(2R,
R3RRLFc_YREj5_Ln.tZaQ(VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9(g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKJ5R
RRLR3d)_FARjR5_LnMtwx0(wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar62g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg469
2,RRRR3_LcFjYERn5L_a.ZtrQV(2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrU922R;R

R_L(em(4KRJxL4g_poLOil_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49n42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uj2R,
R3RRLmc_YjEjR65L_xMwtU0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arn2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4n9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4n9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiM58R
RRRRd3L_AF)j5RRLMn_w0xtw.rU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49nc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAnr46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49n62R,
R3RRLFc_YREj5_Ln.tZaQUVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9Ud2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMe5R
RRLR3d)_FARjR5_LnMtwx0Uwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4n9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drn2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arn2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4n9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2d9,R
RRLR3cY_mERjj5_L6Mtwx0crU922R;R

R_L(em(4KRJxL4g_poLOiD_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49ng2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uc2R,
R3RRLmc_YjEjR65L_xMwtU0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(249,R
RRLR3cY_FE5jRL.n_ZQatV6rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiM56R
RRRRd3L_AF)j5RRLMn_w0xtwnrU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49(.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49(d2R,
R3RRLFc_YREj5_Ln.tZaQUVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9U(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMC5R
RRLR3d)_FARjR5_LnMtwx0Uwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr(2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar(269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64(9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2(9,R
RRLR3cY_mERjj5_L6Mtwx0UrU922R;R

R_L(em(4KRJxL4g_poLOi1_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA(r4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49(n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49((2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9UU2R,
R3RRLmc_YjEjR65L_xMwtU0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoMi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9Ug2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrU9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2j9R
2;
LRR((_e4JmKxgRL_L4pO_oie5lR
RRRRd3L_AF)j5RRLMn_w0xtwjrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49U42R,
R3RRLFc_YREj5_Ln.tZaQgVrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9g42;R2
R
RLe(_(K4mJLxRgp_4LiOo_ReM5R
RRLR3d)_FARjR5_LnMtwx0gwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4U9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4ArU2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4U9
2,RRRR3_LcFjYERn5L_a.ZtrQVg249,R
RRLR3cY_mERjj5_L6Mtwx0.rg922R;R

R_L(em(4KRJxL4g_poLOi8_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49Uc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDUr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9g.2R,
R3RRLmc_YjEjR65L_xMwtg0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoei_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9gd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4ArU2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4U9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4U9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4DrU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2c9R
2;
LRR((_e4JmKxgRL_L4pO_oie5DR
RRRRd3L_AF)j5RRLMn_w0xtwcrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49Ug2R,
R3RRLFc_YREj5_Ln.tZaQgVrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9g62;R2
R
RLe(_(K4mJLxRgp_4LiOo_Reb5R
RRLR3d)_FARjR5_LnMtwx0gwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj4g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arg249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r44g9
2,RRRR3_LcFjYERn5L_a.ZtrQVg269,R
RRLR3cY_mERjj5_L6Mtwx0nrg922R;R

R_L(em(4KRJxL4g_poLOi6_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAgr4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49g.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9gn2R,
R3RRLmc_YjEjR65L_xMwtg0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoei_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9g(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arg2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc4g9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr64g9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg269,R
RRLR3cY_FE5jRL.n_ZQatV(rg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2U9R
2;
LRR((_e4JmKxgRL_L4pO_oie51R
RRRRd3L_AF)j5RRLMn_w0xtwUrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDgr4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49g(2R,
R3RRLFc_YREj5_Ln.tZaQgVrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9gg2;R2
R
RLe(_(K4mJLxRgp_4LiOo_ReJ5R
RRLR3d)_FARjR5_LnMtwx0gwrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU4g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arg2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg4g9
2,RRRR3_LcFjYERn5L_a.ZtrQVg2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr4jR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1Rl 5R
RRLR3d)_FARjR5_LnMtwx04wrj2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9jj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9j42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr.4,92
RRRRc3L_EFYjLR5nZ_.aVtQrj4j9
2,RRRR3_LcmjYEjLR56w_Mxrt049j42;R2
R
RLe(_(K4mJLxR44j_poLOil_1w
R5RRRR3_LdFj)ARLR5nw_Mxwt0r44j9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9j.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr..,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr.d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9jd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrj249,R
RRLR3cY_mERjj5_L6Mtwx0jr4.R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RlP5R
RRLR3d)_FARjR5_LnMtwx04wrj2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9jc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9j62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr.6,92
RRRRc3L_EFYjLR5nZ_.aVtQr.4j9
2,RRRR3_LcmjYEjLR56w_Mxrt049jd2;R2
R
RLe(_(K4mJLxR44j_poLOil_18
R5RRRR3_LdFj)ARLR5nw_Mxwt0rd4j9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9jn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr.n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr.(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9j(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrj2d9,R
RRLR3cY_mERjj5_L6Mtwx0jr4cR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1jl7RR5
R3RRLFd_)RAjRn5L_xMwtr0w49jc2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arj2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU.j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg.j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drj2g9,R
RRLR3cY_FE5jRL.n_ZQatVjr4c,92
RRRRc3L_EmYj5jRLM6_w0xtr64j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5]R
RRRRd3L_AF)j5RRLMn_w0xtwjr46,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49j62R,
R3RRLmc_YjEjR65L_xMwt40rj2n9R
2;
LRR((_e4JmKx4RLjp_4LiOo_M1lRR5
R3RRLFd_)RAjRn5L_xMwtr0w49jn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar42.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r..49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd.49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr42d9,R
RRLR3cY_FE5jRL.n_ZQatVjr4n,92
RRRRc3L_EmYj5jRLM6_w0xtr(4j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5IR
RRRRd3L_AF)j5RRLMn_w0xtwjr4(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49j(2R,
R3RRLmc_YjEjR65L_xMwt40rj2U9R
2;
LRR((_e4JmKx4RLjp_4LiOo_N1lRR5
R3RRLFd_)RAjRn5L_xMwtr0w49jU2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar42n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn.49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(.49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr42(9,R
RRLR3cY_FE5jRL.n_ZQatVjr4U,92
RRRRc3L_EmYj5jRLM6_w0xtrg4j922R;R

R_L(em(4KRJxL_4j4OpLo1i_l5QR
RRRRd3L_AF)j5RRLMn_w0xtwjr4g,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU.49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr42U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg.49
2,RRRR3_LcFjYERn5L_a.ZtrQV49jg2R,
R3RRLmc_YjEjR65L_xMwt40r42j9R
2;
LRR((_e4JmKx4RLjp_4LiOo_ 1MRR5
R3RRLFd_)RAjRn5L_xMwtr0w494j2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj..9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4..9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr.249,R
RRLR3cY_FE5jRL.n_ZQatV4r4j,92
RRRRc3L_EmYj5jRLM6_w0xtr444922R;R

R_L(em(4KRJxL_4j4OpLo1i_M5wR
RRRRd3L_AF)j5RRLMn_w0xtw4r44,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr...9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar.2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd..9
2,RRRR3_LcFjYERn5L_a.ZtrQV49442R,
R3RRLmc_YjEjR65L_xMwt40r42.9R
2;
LRR((_e4JmKx4RLjp_4LiOo_P1MRR5
R3RRLFd_)RAjRn5L_xMwtr0w494.2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc..9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6..9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr.269,R
RRLR3cY_FE5jRL.n_ZQatV4r4.,92
RRRRc3L_EmYj5jRLM6_w0xtrd44922R;R

R_L(em(4KRJxL_4j4OpLo1i_M58R
RRRRd3L_AF)j5RRLMn_w0xtw4r4d,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn..9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar.2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(..9
2,RRRR3_LcFjYERn5L_a.ZtrQV494d2R,
R3RRLmc_YjEjR65L_xMwt40r42c9R
2;
LRR((_e4JmKx4RLjp_4LiOo_71Mj
R5RRRR3_LdFj)ARLR5nw_Mxwt0rc449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9.U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r.U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r.g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9.g2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42c9,R
RRLR3cY_mERjj5_L6Mtwx04r46R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RM]5R
RRLR3d)_FARjR5_LnMtwx04wr4269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9d42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.4,92
RRRRc3L_EFYjLR5nZ_.aVtQr6449
2,RRRR3_LcmjYEjLR56w_Mxrt0494n2;R2
R
RLe(_(K4mJLxR44j_poLOiM_1M
R5RRRR3_LdFj)ARLR5nw_Mxwt0rn449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9d.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr..,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr.d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9dd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42n9,R
RRLR3cY_mERjj5_L6Mtwx04r4(R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RMI5R
RRLR3d)_FARjR5_LnMtwx04wr42(9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9d62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.6,92
RRRRc3L_EFYjLR5nZ_.aVtQr(449
2,RRRR3_LcmjYEjLR56w_Mxrt0494U2;R2
R
RLe(_(K4mJLxR44j_poLOiM_1N
R5RRRR3_LdFj)ARLR5nw_Mxwt0rU449
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9dn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr.n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr.(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9d(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr42U9,R
RRLR3cY_mERjj5_L6Mtwx04r4gR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RMQ5R
RRLR3d)_FARjR5_LnMtwx04wr42g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr.U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9dU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9dg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr.g,92
RRRRc3L_EFYjLR5nZ_.aVtQrg449
2,RRRR3_LcmjYEjLR56w_Mxrt049.j2;R2
R
RLe(_(K4mJLxR44j_poLOi8_1 
R5RRRR3_LdFj)ARLR5nw_Mxwt0rj4.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9cj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr.j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr.4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9c42R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.2j9,R
RRLR3cY_mERjj5_L6Mtwx0.r44R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1R8w5R
RRLR3d)_FARjR5_LnMtwx04wr.249,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr..,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9c.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9cd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr.d,92
RRRRc3L_EFYjLR5nZ_.aVtQr44.9
2,RRRR3_LcmjYEjLR56w_Mxrt049..2;R2
R
RLe(_(K4mJLxR44j_poLOi8_1P
R5RRRR3_LdFj)ARLR5nw_Mxwt0r.4.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9cc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr.c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr.6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9c62R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.2.9,R
RRLR3cY_mERjj5_L6Mtwx0.r4dR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1R885R
RRLR3d)_FARjR5_LnMtwx04wr.2d9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr.n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9cn2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9c(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr.(,92
RRRRc3L_EFYjLR5nZ_.aVtQrd4.9
2,RRRR3_LcmjYEjLR56w_Mxrt049.c2;R2
R
RLe(_(K4mJLxR44j_poLOi8_175jR
RRRRd3L_AF)j5RRLMn_w0xtw.r4c,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU.c9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drc2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arc2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg.c9
2,RRRR3_LcFjYERn5L_a.ZtrQV49.c2R,
R3RRLmc_YjEjR65L_xMwt40r.269R
2;
LRR((_e4JmKx4RLjp_4LiOo_]18RR5
R3RRLFd_)RAjRn5L_xMwtr0w49.62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar62j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj.69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4.69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr6249,R
RRLR3cY_FE5jRL.n_ZQatV.r46,92
RRRRc3L_EmYj5jRLM6_w0xtrn4.922R;R

R_L(em(4KRJxL_4j4OpLo1i_85MR
RRRRd3L_AF)j5RRLMn_w0xtw.r4n,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr..69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr62.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar62d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd.69
2,RRRR3_LcFjYERn5L_a.ZtrQV49.n2R,
R3RRLmc_YjEjR65L_xMwt40r.2(9R
2;
LRR((_e4JmKx4RLjp_4LiOo_I18RR5
R3RRLFd_)RAjRn5L_xMwtr0w49.(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar62c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc.69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6.69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr6269,R
RRLR3cY_FE5jRL.n_ZQatV.r4(,92
RRRRc3L_EmYj5jRLM6_w0xtrU4.922R;R

R_L(em(4KRJxL_4j4OpLo1i_85NR
RRRRd3L_AF)j5RRLMn_w0xtw.r4U,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn.69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Dr62n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ar62(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(.69
2,RRRR3_LcFjYERn5L_a.ZtrQV49.U2R,
R3RRLmc_YjEjR65L_xMwt40r.2g9R
2;
LRR((_e4JmKx4RLjp_4LiOo_Q18RR5
R3RRLFd_)RAjRn5L_xMwtr0w49.g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar62U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU.69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg.69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr62g9,R
RRLR3cY_FE5jRL.n_ZQatV.r4g,92
RRRRc3L_EmYj5jRLM6_w0xtrj4d922R;R

R_L(em(4KRJxL_4j4OpLo1i_e5 R
RRRRd3L_AF)j5RRLMn_w0xtwdr4j,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj.n9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drn2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arn249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4.n9
2,RRRR3_LcFjYERn5L_a.ZtrQV49dj2R,
R3RRLmc_YjEjR65L_xMwt40rd249R
2;
LRR((_e4JmKx4RLjp_4LiOo_w1eRR5
R3RRLFd_)RAjRn5L_xMwtr0w49d42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arn2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r..n9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd.n9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drn2d9,R
RRLR3cY_FE5jRL.n_ZQatVdr44,92
RRRRc3L_EmYj5jRLM6_w0xtr.4d922R;R

R_L(em(4KRJxL_4j4OpLo1i_e5PR
RRRRd3L_AF)j5RRLMn_w0xtwdr4.,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc.n9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drn2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arn269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6.n9
2,RRRR3_LcFjYERn5L_a.ZtrQV49d.2R,
R3RRLmc_YjEjR65L_xMwt40rd2d9R
2;
LRR((_e4JmKx4RLjp_4LiOo_81eRR5
R3RRLFd_)RAjRn5L_xMwtr0w49dd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arn2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn.n9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(.n9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drn2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr4d,92
RRRRc3L_EmYj5jRLM6_w0xtrc4d922R;R

R_L(em(4KRJxL_4j4OpLo1i_eR7j5R
RRLR3d)_FARjR5_LnMtwx04wrd2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr.U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9nU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9ng2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr.g,92
RRRRc3L_EFYjLR5nZ_.aVtQrc4d9
2,RRRR3_LcmjYEjLR56w_Mxrt049d62;R2
R
RLe(_(K4mJLxR44j_poLOie_1]
R5RRRR3_LdFj)ARLR5nw_Mxwt0r64d9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9(j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r.j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r.4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9(42R,
R3RRLFc_YREj5_Ln.tZaQ4Vrd269,R
RRLR3cY_mERjj5_L6Mtwx0dr4nR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1ReM5R
RRLR3d)_FARjR5_LnMtwx04wrd2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA(r..,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9(.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9(d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r.d,92
RRRRc3L_EFYjLR5nZ_.aVtQrn4d9
2,RRRR3_LcmjYEjLR56w_Mxrt049d(2;R2
R
RLe(_(K4mJLxR44j_poLOie_1I
R5RRRR3_LdFj)ARLR5nw_Mxwt0r(4d9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9(c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r.c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r.6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9(62R,
R3RRLFc_YREj5_Ln.tZaQ4Vrd2(9,R
RRLR3cY_mERjj5_L6Mtwx0dr4UR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1ReN5R
RRLR3d)_FARjR5_LnMtwx04wrd2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA(r.n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9(n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9((2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r.(,92
RRRRc3L_EFYjLR5nZ_.aVtQrU4d9
2,RRRR3_LcmjYEjLR56w_Mxrt049dg2;R2
R
RLe(_(K4mJLxR44j_poLOie_1Q
R5RRRR3_LdFj)ARLR5nw_Mxwt0rg4d9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9(U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r.U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r.g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9(g2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrd2g9,R
RRLR3cY_mERjj5_L6Mtwx0cr4jR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RD 5R
RRLR3d)_FARjR5_LnMtwx04wrc2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr.j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9Uj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9U42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDUr.4,92
RRRRc3L_EFYjLR5nZ_.aVtQrj4c9
2,RRRR3_LcmjYEjLR56w_Mxrt049c42;R2
R
RLe(_(K4mJLxR44j_poLOiD_1w
R5RRRR3_LdFj)ARLR5nw_Mxwt0r44c9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9U.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr..,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr.d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9Ud2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrc249,R
RRLR3cY_mERjj5_L6Mtwx0cr4.R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RDP5R
RRLR3d)_FARjR5_LnMtwx04wrc2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr.c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.9Uc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.9U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDUr.6,92
RRRRc3L_EFYjLR5nZ_.aVtQr.4c9
2,RRRR3_LcmjYEjLR56w_Mxrt049cd2;R2
R
RLe(_(K4mJLxR44j_poLOiD_18
R5RRRR3_LdFj)ARLR5nw_Mxwt0rd4c9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.9Un2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr.n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr.(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.9U(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrc2d9,R
RRLR3cY_mERjj5_L6Mtwx0cr4cR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1jD7RR5
R3RRLFd_)RAjRn5L_xMwtr0w49cc2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.ArU2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU.U9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg.U9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .DrU2g9,R
RRLR3cY_FE5jRL.n_ZQatVcr4c,92
RRRRc3L_EmYj5jRLM6_w0xtr64c922R;R

R_L(em(4KRJxL_4j4OpLo1i_D5]R
RRRRd3L_AF)j5RRLMn_w0xtwcr46,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj.g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arg249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4.g9
2,RRRR3_LcFjYERn5L_a.ZtrQV49c62R,
R3RRLmc_YjEjR65L_xMwt40rc2n9R
2;
LRR((_e4JmKx4RLjp_4LiOo_M1DRR5
R3RRLFd_)RAjRn5L_xMwtr0w49cn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arg2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r..g9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd.g9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drg2d9,R
RRLR3cY_FE5jRL.n_ZQatVcr4n,92
RRRRc3L_EmYj5jRLM6_w0xtr(4c922R;R

R_L(em(4KRJxL_4j4OpLo1i_D5IR
RRRRd3L_AF)j5RRLMn_w0xtwcr4(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc.g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drg2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arg269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6.g9
2,RRRR3_LcFjYERn5L_a.ZtrQV49c(2R,
R3RRLmc_YjEjR65L_xMwt40rc2U9R
2;
LRR((_e4JmKx4RLjp_4LiOo_N1DRR5
R3RRLFd_)RAjRn5L_xMwtr0w49cU2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Arg2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn.g9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(.g9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drg2(9,R
RRLR3cY_FE5jRL.n_ZQatVcr4U,92
RRRRc3L_EmYj5jRLM6_w0xtrg4c922R;R

R_L(em(4KRJxL_4j4OpLo1i_D5QR
RRRRd3L_AF)j5RRLMn_w0xtwcr4g,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU.g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Arg2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg.g9
2,RRRR3_LcFjYERn5L_a.ZtrQV49cg2R,
R3RRLmc_YjEjR65L_xMwt40r62j9R
2;
LRR((_e4JmKx4RLjp_4LiOo_ 1bRR5
R3RRLFd_)RAjRn5L_xMwtr0w496j2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArj2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rjdj9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4dj9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrj249,R
RRLR3cY_FE5jRL.n_ZQatV6r4j,92
RRRRc3L_EmYj5jRLM6_w0xtr446922R;R

R_L(em(4KRJxL_4j4OpLo1i_b5wR
RRRRd3L_AF)j5RRLMn_w0xtw6r44,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.dj9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrj2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArj2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rddj9
2,RRRR3_LcFjYERn5L_a.ZtrQV49642R,
R3RRLmc_YjEjR65L_xMwt40r62.9R
2;
LRR((_e4JmKx4RLjp_4LiOo_P1bRR5
R3RRLFd_)RAjRn5L_xMwtr0w496.2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArj2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rcdj9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6dj9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrj269,R
RRLR3cY_FE5jRL.n_ZQatV6r4.,92
RRRRc3L_EmYj5jRLM6_w0xtrd46922R;R

R_L(em(4KRJxL_4j4OpLo1i_b58R
RRRRd3L_AF)j5RRLMn_w0xtw6r4d,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrndj9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrj2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArj2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(dj9
2,RRRR3_LcFjYERn5L_a.ZtrQV496d2R,
R3RRLmc_YjEjR65L_xMwt40r62c9R
2;
LRR((_e4JmKx4RLjp_4LiOo_71bj
R5RRRR3_LdFj)ARLR5nw_Mxwt0rc469
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd9jU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrdU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjrdg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd9jg2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr62c9,R
RRLR3cY_mERjj5_L6Mtwx06r46R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1Rb]5R
RRLR3d)_FARjR5_LnMtwx04wr6269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4rdj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd94j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9442R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rd4,92
RRRRc3L_EFYjLR5nZ_.aVtQr6469
2,RRRR3_LcmjYEjLR56w_Mxrt0496n2;R2
R
RLe(_(K4mJLxR44j_poLOib_1M
R5RRRR3_LdFj)ARLR5nw_Mxwt0rn469
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd94.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4rd.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rdd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd94d2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr62n9,R
RRLR3cY_mERjj5_L6Mtwx06r4(R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RbI5R
RRLR3d)_FARjR5_LnMtwx04wr62(9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4rdc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd94c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9462R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rd6,92
RRRRc3L_EFYjLR5nZ_.aVtQr(469
2,RRRR3_LcmjYEjLR56w_Mxrt0496U2;R2
R
RLe(_(K4mJLxR44j_poLOib_1N
R5RRRR3_LdFj)ARLR5nw_Mxwt0rU469
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd94n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4rdn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rd(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd94(2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr62U9,R
RRLR3cY_mERjj5_L6Mtwx06r4gR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RbQ5R
RRLR3d)_FARjR5_LnMtwx04wr62g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4rdU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd94U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd94g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rdg,92
RRRRc3L_EFYjLR5nZ_.aVtQrg469
2,RRRR3_LcmjYEjLR56w_Mxrt049nj2;R2
R
RLe(_(K4mJLxR44j_poLOi6_1 
R5RRRR3_LdFj)ARLR5nw_Mxwt0rj4n9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd9.j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rdj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.rd4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd9.42R,
R3RRLFc_YREj5_Ln.tZaQ4Vrn2j9,R
RRLR3cY_mERjj5_L6Mtwx0nr44R922
;
R(RL_4e(mxKJRjL4_L4pO_oi1R6w5R
RRLR3d)_FARjR5_LnMtwx04wrn249,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.rd.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd9..2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9.d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.rdd,92
RRRRc3L_EFYjLR5nZ_.aVtQr44n9
2,RRRR3_LcmjYEjLR56w_Mxrt049n.2;R2
R
RLe(_(K4mJLxR44j_poLOi6_1P
R5RRRR3_LdFj)ARLR5nw_Mxwt0r.4n9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd9.c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rdc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.rd6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd9.62R,
R3RRLFc_YREj5_Ln.tZaQ4Vrn2.9,R
RRLR3cY_mERjj5_L6Mtwx0nr4dR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1R685R
RRLR3d)_FARjR5_LnMtwx04wrn2d9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.rdn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd9.n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9.(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.rd(,92
RRRRc3L_EFYjLR5nZ_.aVtQrd4n9
2,RRRR3_LcmjYEjLR56w_Mxrt049nc2;R2
R
RLe(_(K4mJLxR44j_poLOi6_175jR
RRRRd3L_AF)j5RRLMn_w0xtwnr4c,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrUd.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDr.2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr.2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rgd.9
2,RRRR3_LcFjYERn5L_a.ZtrQV49nc2R,
R3RRLmc_YjEjR65L_xMwt40rn269R
2;
LRR((_e4JmKx4RLjp_4LiOo_]16RR5
R3RRLFd_)RAjRn5L_xMwtr0w49n62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArd2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rjdd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr4dd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrd249,R
RRLR3cY_FE5jRL.n_ZQatVnr46,92
RRRRc3L_EmYj5jRLM6_w0xtrn4n922R;R

R_L(em(4KRJxL_4j4OpLo1i_65MR
RRRRd3L_AF)j5RRLMn_w0xtwnr4n,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.dd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrd2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArd2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rddd9
2,RRRR3_LcFjYERn5L_a.ZtrQV49nn2R,
R3RRLmc_YjEjR65L_xMwt40rn2(9R
2;
LRR((_e4JmKx4RLjp_4LiOo_I16RR5
R3RRLFd_)RAjRn5L_xMwtr0w49n(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArd2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rcdd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6dd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrd269,R
RRLR3cY_FE5jRL.n_ZQatVnr4(,92
RRRRc3L_EmYj5jRLM6_w0xtrU4n922R;R

R_L(em(4KRJxL_4j4OpLo1i_65NR
RRRRd3L_AF)j5RRLMn_w0xtwnr4U,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrndd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrd2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArd2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(dd9
2,RRRR3_LcFjYERn5L_a.ZtrQV49nU2R,
R3RRLmc_YjEjR65L_xMwt40rn2g9R
2;
LRR((_e4JmKx4RLjp_4LiOo_Q16RR5
R3RRLFd_)RAjRn5L_xMwtr0w49ng2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArd2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rUdd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrgdd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrd2g9,R
RRLR3cY_FE5jRL.n_ZQatVnr4g,92
RRRRc3L_EmYj5jRLM6_w0xtrj4(922R;R

R_L(em(4KRJxL_4j4OpLo1i_C5 R
RRRRd3L_AF)j5RRLMn_w0xtw(r4j,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrjdc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrc2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArc249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4dc9
2,RRRR3_LcFjYERn5L_a.ZtrQV49(j2R,
R3RRLmc_YjEjR65L_xMwt40r(249R
2;
LRR((_e4JmKx4RLjp_4LiOo_w1CRR5
R3RRLFd_)RAjRn5L_xMwtr0w49(42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArc2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.dc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrddc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrc2d9,R
RRLR3cY_FE5jRL.n_ZQatV(r44,92
RRRRc3L_EmYj5jRLM6_w0xtr.4(922R;R

R_L(em(4KRJxL_4j4OpLo1i_C5PR
RRRRd3L_AF)j5RRLMn_w0xtw(r4.,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrcdc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrc2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArc269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r6dc9
2,RRRR3_LcFjYERn5L_a.ZtrQV49(.2R,
R3RRLmc_YjEjR65L_xMwt40r(2d9R
2;
LRR((_e4JmKx4RLjp_4LiOo_81CRR5
R3RRLFd_)RAjRn5L_xMwtr0w49(d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArc2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rndc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(dc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDrc2(9,R
RRLR3cY_FE5jRL.n_ZQatV(r4d,92
RRRRc3L_EmYj5jRLM6_w0xtrc4(922R;R

R_L(em(4KRJxL_4j4OpLo1i_CR7j5R
RRLR3d)_FARjR5_LnMtwx04wr(2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcrdU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd9cU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9cg2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcrdg,92
RRRRc3L_EFYjLR5nZ_.aVtQrc4(9
2,RRRR3_LcmjYEjLR56w_Mxrt049(62;R2
R
RLe(_(K4mJLxR44j_poLOiC_1]
R5RRRR3_LdFj)ARLR5nw_Mxwt0r64(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd96j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6rdj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rd4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd9642R,
R3RRLFc_YREj5_Ln.tZaQ4Vr(269,R
RRLR3cY_mERjj5_L6Mtwx0(r4nR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RCM5R
RRLR3d)_FARjR5_LnMtwx04wr(2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6rd.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd96.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd96d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rdd,92
RRRRc3L_EFYjLR5nZ_.aVtQrn4(9
2,RRRR3_LcmjYEjLR56w_Mxrt049((2;R2
R
RLe(_(K4mJLxR44j_poLOiC_1I
R5RRRR3_LdFj)ARLR5nw_Mxwt0r(4(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd96c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6rdc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rd6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd9662R,
R3RRLFc_YREj5_Ln.tZaQ4Vr(2(9,R
RRLR3cY_mERjj5_L6Mtwx0(r4UR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1RCN5R
RRLR3d)_FARjR5_LnMtwx04wr(2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6rdn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd96n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd96(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rd(,92
RRRRc3L_EFYjLR5nZ_.aVtQrU4(9
2,RRRR3_LcmjYEjLR56w_Mxrt049(g2;R2
R
RLe(_(K4mJLxR44j_poLOiC_1Q
R5RRRR3_LdFj)ARLR5nw_Mxwt0rg4(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd96U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6rdU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rdg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd96g2R,
R3RRLFc_YREj5_Ln.tZaQ4Vr(2g9,R
RRLR3cY_mERjj5_L6Mtwx0Ur4jR922
;
R(RL_4e(mxKJRjL4_L4pO_oi1R1 5R
RRLR3d)_FARjR5_LnMtwx04wrU2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnrdj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd9nj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd9n42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnrd4,92
RRRRc3L_EFYjLR5nZ_.aVtQrj4U9
2,RRRR3_LcmjYEjLR56w_Mxrt049U42;R2
R
RL_4nBO)taNBk_cC]_okXR_Ln.wZtT5gR
RRRRc3L_KmiNc5L_KmiNR2,3LH5nZ_.aVtQ23,RFg5L_a.ZtcQVN2g2;R
RNH##oLMR(z_kaBjKcRR=L.g_ZQatVgcN;R
RNNDI$@#R@C5MooC8C(RL_1[W_WdP2R
RRRRRLug_VIt$7L#FRL=R6w_Mx;t0
NRR#o#HMnRL_xMwtr0w4RR:49U4RL=RgV_ut7$I#;FL
R
RL_4jMhYWaIghLypR5RU2LMc_iRAj5R
RRLR3ci_mKLN5ci_mK,N2
RRRR63L_1PFOLd56F_P12Od,R
RRLR3(1_u$BH_k(5L_akzjcKB2R,
R3RRLH6_1BWO5_L6HO1WB
2,RRRR3_Lc1OY#5_L(Mdzau2IY,R
RRLR3(Y_MW7hIYg5L_aMz$0uw7,p2
RRRR(3L_$u1H#Dg5_L(MjzaK2Bc,R
RRLR34Mj_YaWhgLhIp45LjY_MWghahpIL2
2;
NRR#o#HM(RL_$u1H#DgRL=R(z_MaBjKc
;
R#RN#MHoR_LgM$zau7w0pRR=L$n_Fusj7Rrg:9R.;R
RNH##oLMR(z_MaIduYRRR=nRL_s$Fjru74RR:j
9;R#RN#MHoR_LduRpw=nRL_s$Fjru7j
9;RDRNI#N$R5@@bCF#8RoCL[(_Wd1_P
W2RRRRH5VRLu6_ipdORL&R6P_m$2]d
RRRRLRRnF_$s7juR{=RLMn_w0xtwUr44R9,L$(_Fusj7;k}
R
RNH##oLMR(F_$s7jukRR=L$n_Fusj7Rrg:9R4;C

MF8l8CkD
F
l8CkDR_L(uxVws5hY
LRRci_mK
N,R6RL_1PFO
d,R6RL_WH1O
B,RgRL_$1p$s_ht
7,R(RL_$u1H#Dg,R
RL[(_Wd1_P
W,R(RL_KuiNk_g,R
RLud_p
$,R6RL_$mP]
d,RdRL_wup,R
RL_4jMhYWaIghL;p2
R
RHkMb0cRL_KmiNR;
RbHMkL0R6F_P1;Od
HRRM0bkR_L6HO1WBR;
RbHMkr0Rjn:d.L9Rgp_1$h$_s;t7
FRRkk0b0(RL_$u1H#Dg;R
RHkMb0(RL_1[W_WdP;R
RHkMb0(RL_KuiNk_g;R
RHkMb0dRL_$up;R
RHkMb06RL_$mP]
d;RkRF00bkR_Ldu;pw
FRRkk0b0(RrRj:R94RLjY_MWghahpIL;R
RICHsRRr4:9R4R_LUuH1$DXg#;R
RICHsRRr4:9R4R4L4_akzjcKBoYws;R
RICHsRRr.:9R4R_L6Mtwx0R;
RsIHC.RrR4:R9nRL_xMwt;0w
IRRHRsCr:jRR4dn9(RL_#.Z0tdJ;R
RICHsR_L6HO1WB
;
R#RN#MHoR_L(.0Z#dRJt=LR{gp_1$h$_srt7j9:j,gRL_$1p$s_ht47r:9d.,gRL_$1p$s_htd7rdc:n9L,Rgp_1$h$_srt7nn6:(R9,L1g_p_$$h7str:nU(,j9R_Lg1$p$_ths74r(:9(c,RR
RRRRRRRRRRRRL1g_p_$$h7str:(6(,U9R_Lg1$p$_ths7gr(:j449L,Rgp_1$h$_srt74:444944,gRL_$1p$s_ht47r44.:4,.9R_Lg1$p$_ths74r4d4:4cR9,L1g_p_$$h7str644:n449
,RRRRRRRRRRRRRR_Lg1$p$_ths74r4(4:4(R9,L1g_p_$$h7strU44:U449L,Rgp_1$h$_srt74:4g49.4,gRL_$1p$s_ht47r.4.:.,c9R_Lg1$p$_ths7.r46.:4nR9,L1g_p_$$h7str(4.:U4.9
,RRRRRRRRRRRRRR_Lg1$p$_ths7.r4gn:4jR9,L1g_p_$$h7str44n:.4g9L,Rgp_1$h$_srt74:gd49gd,gRL_$1p$s_ht47rg4c:g,c9R_Lg1$p$_ths7gr46j:.(R9,L1g_p_$$h7strU.j:j..9
,RRRRRRRRRRRRRR_Lg1$p$_ths7.r.4.:.4R9,L1g_p_$$h7str...:...9L,Rgp_1$h$_srt7.:.d.96c,gRL_$1p$s_ht.7r6.6:U,n9R_Lg1$p$_ths7Ur.(4:dUR9,L1g_p_$$h7strgd4:jd69
,RRRRRRRRRRRRRR_Lg1$p$_ths76rd46:d4R9,L1g_p_$$h7str.d6:.d69L,Rgp_1$h$_srt7d:6dd96d,gRL_$1p$s_htd7r6dc:6,(9R_Lg1$p$_ths76rdUn:d4;9}
NRR#o#HMURL_$u1H#DgX9r4RL=R4k4_zKajBwcos4Yr9R;
R#N#HRoMLu(_1D$Hg=#RR_LUuH1$DXg#r;49
R
RNH##oLMRnw_Mxwt0rR49=dRL_$up;R
RNH##oLMRdp_uwRR=LM6_w0xtr;49
R
RL_44uH1$D4g#VR	aLu(_LDa0g5tR
RRRRc3L_KmiNLR5ci_mK,N2
RRRR(3L_1[W_WdPR(5L_1[W_WdP2R,
R3RRLu6_ipdOR(5L_KuiNk_g2R,
R3RRLud_p5$RLMn_w0xtw9r42R,
R3RRLud_p5wRLM6_w0xtr249,R
RRLR36P_m$R]d5_L6m]P$d
2,RRRR3_Ln.0Z#d5JRL.(_Zd#0J,t2
RRRR63L_1PFO5dRLP6_Fd1O2R,
R3RRLH6_1BWOR65L_WH1O,B2
RRRR(3L_$u1H#DgR45L4z_kaBjKcsowY9r42R,
R3RRL_4jMhYWaIghL5pRL_4jMhYWaIghL2p2;C

MF8l8CkD
F
l8CkDR_L(m$BAp5XBR_LcmNiK,(RL_$u1H#Dg,(RL_1[W_WdP,6RL_$mP]Rd,L8n_Zd#0gL,Rdp_u$L,RnV_M#w_V,4RLc8_4aIOp_ApVuH_d,4RLjY_MEgQd#0_w,4RL4q_PAJZd#XY_]L,R4k4_).sOX_VYXR],LH6_1BWO,gRL_Wmwh_agNRL,L_4.POF1dl_oNL#L,(RL_tMwjYs7,(RL_#MV_$dI,(RL_aMz_$dI,4RL.q_PAJZd#pY_$RE,L_4.kO)s.YXV_Ep$,4RL4z_MaJZdv	_0p;R2
bRRNlsNCs0CR_L(MZzaQRkY=;R4
bRRNlsNCs0CRdL4_lmOjaV_	nqU =ZRRLc'jjjj;R
RbNNslCC0s4RLdO_ml_jVqU(qnR)P='RcLjjj4R;
RsbNN0lCCLsR4md_OVlj_u]H(Pn)Rc=R'jLj4
j;RNRbsCNl0RCsL_4dmjOlV6_bA)anPRR=cj'Lj;44
bRRNlsNCs0CR.L4_lmOjTV_(JAUtRR=cj'L4;jj
bRRNlsNCs0CR(L4_lmOjaV_	zTOJeLTh=6RRLc'444j;R
RbNNslCC0sURL_chs_HgcbRR=6
;
RNRbsCNl0RCsLhU_sNc_URzbR6=R'jLjj;jj
bRRNlsNCs0CR_L(h_scYREURRR=6j'Lj4jj;R
RbNNslCC0sgRL_chs_1YFb=TRRL6'j4jjjR;
RsbNN0lCCLsR(s_hc[_NgRRR='R6L444j
4;RNRbsCNl0RCsL_..h_scY_EUi76UYh8w6P_Nh=KRRL6'jjj4jR;
RsbNN0lCCLsR.h._sYc_EiU_6YU786wh_. iIRR=6j'L4jjj;R
RbNNslCC0s4RL(s_hcE_YUa_Bht l_Rso='R6Lj4jj
j;
bRRNlsNCs0CR_LgeMx._ncXzRRR='R6Ljjjj
j;RNRbsCNl0RCsLeg_x_.MmYncR=RRRL6'jjjj4R;
RsbNN0lCCLsR4e4_x_.M4TenO=NRRL6'j4jjjR;
RsbNN0lCCLsRgx_e.qM_aRnARRR=6j'Ljj4j;R
RbNNslCC0sURL_.exMU_cDRRRR6=R'4Ljj;jj
R
RbNNslCC0s4RLj(_OjF ]]bnBRRR=(j'Lj4jjj
j;
HRRM0bkR_LcmNiK;R
RHkMb0(RL_$u1H#Dg;R
RHkMb0(RL_1[W_WdP;R
RHkMb06RL_$mP]
d;RMRHbRk0L8n_Zd#0gR;
RbHMkL0Rdp_u$R;
RbHMkL0RnV_M#w_V;R
RHkMb04RLc8_4aIOp_ApVuH_d;R
RHkMb04RLjY_MEgQd#0_w;R
RHkMb04RL4q_PAJZd#XY_]R;
RbHMkL0R4k4_).sOX_VYX
];RMRHbRk0LM(_wstj7
Y;RMRHbRk0L_44MZzad_Jv0;	p
FRRkk0b06RL_WH1O
B;RkRF00bkR_LgmhwWaNg_LR;
R0FkbRk0L_4.POF1dl_oNL#L;R
RFbk0kL0R(V_M#I_d$R;
R0FkbRk0LM(_zda_I
$;RkRF00bkR.L4_APqZ#dJY$_pER;
R0FkbRk0L_4.kO)s.YXV_Ep$;R

RosCR_LgmhwWaNg_LR;
RosCRUrL_chs_Hgcb:-4jL9RnO_mlWjs;R
RsRCoL_4.POF1dl_oNL#L;R
RsRCoLH6_1BWO;R

RosCR:rdjL9R4Md_qVxtw#v_pd#P;R
RsRCorjd:94RLjF_GzWj_vXs0;R
RsRCor_LUh_scgbcH-j4:9dRL_#MV;R
RsRCor_L(MZzaQRkY-:R4jL9Rdz_MaR;
RosCR_LnM_zaV
w;RCRsoURL_aMz_VaKGL,R4Md_zaa_K_VGpguY;R

RosCR(rL_aMzZYQkR4-R:Rj9LM(_YdEQg
#;RHRIsrCRLhU_sgc_c-Hb49:jR_LnM_V#Q
w;RHRIsrCRLM(_zQaZk-YRRj4:9nRL_aMz_;Qw
IRRHRsCLPU_qdAZJ;#Y
IRRHRsCL_4jMQYEdl_k[
A;RHRIsLCR4uj_1V6ZX[_IeR;
RsIHC(RL_$up_hnD;R
RsRCor_L(MZzaQRkY+RRc+URL_chs_Hgcb4+RR4-R:Rj9L_4.kO)s.YXV_hsL;R
R/#/R$bMF#R$#0MsN#0DNCV_FVR
RH0MHHRNDL_4dMtqxV_wv#Pp#dRR=L_4dmjOlVH_]u)(nPR;
RHHM0DHNR_LdMRza=LR'jR;
RR//#F$Mb##$RN0sMN#D0FC_MR

R#N#HRoML_4jMQYEdl_k[=ARRL5R(Y_MEgQd#=R=Rj'LR
2;R#RN#MHoRjL4_6u1Z_VXIR[e=RR5LMn_VQ#_w9r4R
2;
NRRD$IN#@R@5FRb#oC8CcRL_KmiNsRFR#bFCC8oRjL4_6u1Z_VXIR[e2R
RRVRH54RLj1_u6XZV_eI[RL2RCMoH
RRRRLRRdV_M#=R<R_LUh_scNbUz;R
RRRRRLMd_z<aR=;Rj
RRRR8CMR#CDCCRLo
HMRRRRRdRL_#MVRR<=LMn_VQ#_wR;
RRRRR_LdMRza<L=Rnz_Maw_Q;R
RC
M8RRR
RINDNR$#@R@5bCF#8RoCLmc_iRKN2R
RRVRH5URL_aMz_VaKG
R2RRRRR(RL_EMYQ#dgRR<=LMd_z
a;RRRRCCD#R5HVRdL4_aMz_VaKGu_pY2gR
RRRRLRR(Y_MEgQd#=R<RjL4_jO( ]]Fn;Bb
RRRR#CDCVRH5L5Rnz_Maw_VR&2R&!R5L_4jMQYEdl_k[2AR2R
RRRRRLM(_YdEQg<#R=(RL_EMYQ#dgR4-R;R

RINDNR$#@R@5bCF#8RoCLmc_iRKNFbsRF8#CoLCR4uj_1V6ZX[_IeR2
RHRRVL5R4uj_1V6ZX[_Ie
R2RRRRR4RLdq_MxwtVvp_##RPd<L=R4md_OVlj_qa	UZn ;R
RRDRC#RC
RRRRRdL4_xMqtvVw_##pP<dR=4RLjF_GzWj_vXs0;R

RINDN@$#@LR54Md_qVxtw#v_pd#PRRFsLMd_zFaRsdRL_#MVRRFsLu(_1D$HgF#Rs4RLjY_ME_QdkAl[RRFsLPU_qdAZJ2#YRoLCHRM
RLRR4Gj_F_zjW0vsX=R<RdL4_xMqtvVw_##pP
d;RRRRLMn_zVa_w=R<RL4'jR;
RLRRgw_mWgha_RNL<4=R';Lj
RRRR_L6HO1WB=R<RL4'jR;
RLRRUz_MaK_aV<GR='R4L
j;RRRRL_4dM_zaaGKV_Ypug=R<RL4'jR;
RLRRnO_mlWjsRR<=Leg_x_.MmYnc;R
RR4RL.F_P1_Odo#lNL<LR='R4L
j;
RRRR#ONCL5R4Md_qVxtw#v_pd#PR/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRRLRR4md_OVlj_qa	UZn :CRLo
HMRRRRRRRRL_4.POF1dl_oNL#LRR<=44'L;R
RRRRRR4RLjF_GzWj_vXs0RR<=L_4dmjOlV(_qq)UnPR;
RRRRRLRRnO_mlWjsRR<=Leg_x_.MczXn;R
RRRRRR4RLdz_MaK_aVpG_uRYg<4=R';L4
RRRRCRRMR8
RRRRRdL4_lmOjqV_(nqU)RP:LHCoMR
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLmn_OsljW=R<R_LgeMx._ncXzR;
RRRRRHRRVU5L_APqZ#dJYRR&5dRL_#MVrRj9|dRL_#MVrR.9|dRL_#MVrRd9|dRL_#MVr2c92CRLo
HMRRRRRRRRRnRL_aMz_RVw<4=R;R
RRRRRRRRRHRV5L_4jMQYEdl_k[2ARRoLCHRM
RRRRRRRRRLRRUz_MaK_aV<GR=;R4
RRRRRRRRRRRR_LnM_zaV<wR=;Rj
RRRRRRRRRRRR_LgmhwWaNg_L=R<R
j;RRRRRRRRRRRRL_4.POF1dl_oNL#LRR<=4R;
RRRRRRRRRORRN5#CR_LdMRV#2/R/RM#$F$b##NRbsDNDCOD_N
#CRRRRRRRRRRRRR(RL_chs_UYE:CRLo
HMRRRRRRRRRRRRRRRRL_4jGjFz_sWv0<XR=4RLdO_ml_jV](Hun;)P
RRRRRRRRRRRRRRRR_LgmhwWaNg_L=R<R
4;RRRRRRRRRRRRRRRRL_4.POF1dl_oNL#LRR<=j
;
RRRRRRRRRRRRRMRC8R
RRRRRRRRRRRRR8NCVk:D0RR;
RRRRRRRRRCRRMN8O#RC
RRRRRRRRR8CM
RRRRRRRR8CM
RRRRCRRMR8
RRRRRdL4_lmOj]V_Hnu()RP:LHCoMR
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLH6_1BWORR<=44'L;R
RRRRRRVRH5(RL_$u1H#DgRR==44'LRL2RCMoH
RRRRRRRRHRRVL5R4Mj_YdEQ_[klA=R=RL4'4RR2LHCoMR
RRRRRRRRRR4RLjF_GzWj_vXs0RR<=L_4.mjOlV(_TAtUJ;R
RRRRRRRRRCRM8CCD#RoLCHRM
RRRRRRRRRLRR4Gj_F_zjW0vsX=R<RdL4_lmOjbV_6nAa)
P;RRRRRRRRRMRC8R
RRRRRRMRC8DRC#HCRVL5RdV_M#9rc2CRLoRHM/L/R(s_hc[_NgR
RRRRRRRRRL_4jGjFz_sWv0<XR=4RL(O_ml_jVaO	TzTJLe;h6
RRRRRRRR8CM
RRRRCRRMR8
RRRRRdL4_lmOjbV_6nAa)RP:LHCoMR
RRRRRRnRL_lmOjRsW<L=Rgx_e.qM_a;nA
RRRRRRRR_LgmhwWaNg_L=R<RL4'4R;
RRRRRLRRnz_Maw_VRR<=44'L;R
RRRRRRVRH54RLjY_ME_QdkAl[RR==44'LRL2RCMoH
RRRRRRRRLRR4Gj_F_zjW0vsX=R<R.L4_lmOjTV_(JAUtR;
RRRRRCRRMR8
RRRRR8CM
RRRRLRR4m._OVlj_AT(U:JtRoLCHRM
RRRRRLRRnO_mlWjsRR<=L_44eMx._n4eT;ON
RRRRCRRMR8
RRRRR(L4_lmOjaV_	zTOJeLThR6:LHCoMR
RRRRRRnRL_lmOjRsW<L=RUx_e.cM_U
D;RRRRRMRC8R
RRMRC8#ONCR
RC
M8
NRR#o#HM4RL.)_ksXO.VpY_$=ERR.L4_sk)OV.XYL_sh9rj;R

R#N#HRoMLu(_pn$_D=hRRcL4_a48O_pIpuVA_RdH?4RL.)_ksXO.VsY_Ljhr9RR:Lud_p
$;RDRNI#N$R5@@R#bFCC8oR_L([_W1dRPW2CRLo
HMRRRRHRV5L_4c4O8appI_V_Aud|HR|4RL4)_ksXO.VXY_]L2RCMoH
RRRRHRRVRR5LM(_wstj7
Y2RRRRRRRRL_4.kO)s.YXV_hsLR{=RLM(_YdEQgR#,L_4dMtqxV_wv#Pp#dL,RdV_M#L,R61_HW}OB;R
RRRRRCCD#RRHV5_L6m]P$dR2
RRRRRLRR4k._).sOX_VYsRLh=LR{4M4_zdaZJ0v_	Rp,L_4.kO)s.YXV_hsLr_L(MZzaQRkY+RRc+URL_chs_HgcbRR+4RR-49:4}R;
RCRRMR8
R8CM
LRRU)_M_J$lsytR5R(2R4L4_aMzt	a_E]WJRR5
R3RRL[(_Wd1_P5WRL[(_Wd1_P,W2
RRRRn3L_#MV_RVw5_LnM_V#V,w2
RRRRn3L_aMz_RVw5jL4_EMYQ#dg_2w0,R
RRLR34P4_qdAZJ_#YX5]RL_44PZqAdYJ#_2X],R
RRLR344c_8paOIV_pAdu_HLR544c_8paOIV_pAdu_H
2,RRRR3_L6m]P$dRRR5_L6m]P$d
2,RRRR3_Ln80Z#dRgR5_Ln80Z#d,g2
RRRRd3L_$upRRRRR(5L_$up_hnD2R,
R3RRLmn_OsljW5RRLmn_OsljW
2,RRRR3_LdMRV#RRRR5_LnM_V#Q,w2
RRRRd3L_aMzRRRRRn5L_aMz_2Qw,R
RRLR3Uq_PAJZd#RYRR5RRLPU_qdAZJ2#Y,R
RRLR3(w_Mt7jsYRRRRLR5(w_Mt7jsY
2,RRRR3_L(M_V#dRI$RRRR5_L(M_V#d2I$,R
RRLR3(z_MaI_d$RRRRLR5(z_MaI_d$
2,RRRR3.L4_APqZ#dJY$_pERRRRLR54P._qdAZJ_#Yp2$E,R
RRLR3n1_u6XZVRRRRR45Lj1_u6XZV_eI[2
2;
8CMlkF8D
C
lkF8DLCR4m._waWhgv_IC5 8R_L([_W1d,PW
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR(RL_KuiNk_g,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR6P_m$,]d
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdRL_$up,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLH(_pV#tW
p,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LU[_qqimDB,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4Pd_Fd1O_.VGsTLk,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRUP_m$_]dY2tR;R

RsbNN0lCCLsR6)_.#Rjl=;R6
R
RHkMb0(RL_1[W_WdP;R
RHkMb0(RL_KuiNk_g;R
RHkMb06RL_$mP]
d;RMRHbRk0Lud_p
$;RkRF00bkR_Ldu;pw
HRRM0bkR6rL_#.)j4l:9(RL_#HptpVW;R
RHkMb0URL_q[q_BiDmR;
R0FkbRk0L_4dPOF1dG_V.ksLTR;
R0FkbRk0LmU_Pd$]_;Yt
R
RsRCor_L6.j)#l9:jR_Ln$jFsu
7;RHRIsrCRL.6_)l#j:R49L$(_Fusj7
k;RCRso4RLdF_P1_OdVsG.L;kT
sRRCLoRUP_m$_]dY
t;
NRR#o#HMdRL_wupRL=RnF_$s7jur;j9
R
RNNDI$@#R@65L_$mP]FdRs(RL_KuiNk_g2CRLo
HMRRRRL_4dPOF1dG_V.ksLT=R<RL4'jR;
RLRRUP_m$_]dY<tR='R4L
j;RRRRHRV5Lu(_i_KNg2kRRoLCHRM
RRRRR5HVR6!L_$mP]2dR
RRRRRRRRdL4_1PFOVd_GL.sk<TR='R4L
4;RRRRRDRC#RC
RRRRRLRRUP_m$_]dY<tR='R4L
4;RRRRC
M8RMRC8R

RINDNR$#@R@5bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5R(i_uKgN_kRR2LHCoMR
RRRRRHRV5!_L6m]P$dRR2LHCoMR
RRRRRRnRL_s$Fjru7L.6_)l#j:R49<L=R(p_H#WtVpR;
RRRRRLRRnF_$s7jurRj9<L=RUq_[qD_iB
m;RRRRRMRC8DRC#RC
RRRRRLRRnF_$s7juRR<={_Ldu,p$R_L($jFsu}7k;R
RRMRC8R
RC
M8
NRR#o#HM(RL_s$Fjku7RL=RnF_$s7jur_L6.j)#lRR:4
9;ClM8FD8kC


lkF8DtCRCsMCHqO)vlsN_FLDO5	Rs8N8sL,R.0#_OR	,8NN0_0Fk,NRI8,8sRMIC,OR#DR	,8NN0_,HMRHIs0CC_MDNLC;R2
bHMkL0R.0#_O
	;HkMb0gRrR4-R:Rj9s8N8sF;
kk0b0dRrnRR-49:jR08NNk_F0H;
M0bkRMIC,OR#D
	;HkMb0gRrR4-R:Rj9I8N8sH;
M0bkRnrdR4-R:Rj98NN0_;HM
bHMkI0RsCH0_NCML;DC
sIHC_RsCLMN,_RICLMN;R

R#N#HRoMsM_CN=LRRI!RC
M;R#RN#MHoRCI_MRNL=sRIH_0CCLMND&CRRMIC;R
R)Aqv41n_d1n_d#nR$LM_D	FO_lsNRR5
R3RRq)77qI5RNs88RR2,
RRRRQ37qR5RR08NNM_HrRd.-:R4RRj92
,RRRRR3q7m5R2,
RRRRR
RRqR37A7)5NRs8R8s2
,RRRRR3A7Q5RRRdL.'j,R2RR
RR7R3mRA5RNR80FN_kd0r.RR-4j:R9,R2RR
RRRR
R3RR7qQu58RRN_0NHdMrnRR-4.:d9,R2RR
RR7R3m5uq2
,RRRRR3u7QAR5Rcj'LRR2,
RRRRm37uRA5R08NNk_F0nrdR4-R:9d.RR2,
RRRRR
RRWR3 Rq5RL4'4,R2RR
RR1R315)qRL4'j,R2RR
RR R3hRq5RCI_MRNL2
,RRRRR3iBpq#5RORD	2
,RRRRR3AW 54RR'RLj2
,RRRRR3)11A45R'RLj2
,RRRRR3A h5sRR_NCML,R2RR
RRBR3p5iAR#L._	0OR;22RM
C88lFk
DC
8lFkRDCs1NlDCHOs_NlLODF	RR5s8N8sL,R.0#_OR	,8NN0_0Fk,NRI8,8sRMIC,OR#DR	,8NN0_RHM2H;
M0bkR#L._	0O;M
HbRk0rjn:9NRs8;8s
0FkbRk0r:d6j89RN_0NF;k0
bHMkI0RCRM,#	OD;M
HbRk0rjn:9NRI8;8s
bHMkr0Rdj6:9NR80HN_M
;
tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0j5sR3Ns885'{.LRj,s8N8s:rnj29},RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k08NN0_0Fk2R,
RIR3Ns885'{.LRj,I8N8s:rnj29},R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5'R4L24R2C;
MF8l8CkD
F
l8CkDRlsN_FLDO5	RR8sN8Rs,L_.#0,O	R08NNk_F0I,RNs88,CRIN#,RO,D	R08NNM_HR
2;HkMb0.RL#O_0	H;
M0bkRRrn:9RjR8sN8
s;Fbk0kr0RdRn4:9RjR08NNk_F0H;
M0bkRNIC,OR#D
	;HkMb0nRrRj:R9NRI8;8s
bHMkr0RdRn4:9RjR08NNM_H;H
IsrCRd:g6j89RN_0NF_k00;lb
N
slH1DONCslD_LFRO	s1NlDCHOQ0M#jRR538sN8ss5Ns88r:nRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_ldbr6RR:j,92
RRR38IN8Is5Ns88r-(RRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NHdMr6RR:j292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#4RR538sN8ss5Ns88r:nRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l(br4RR:d2n9,R
RRN3I858sI8N8sRr(-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM(:4RR9dn2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0.5sR3Ns8858sN8nsrRj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr(4jR(:R.,92
RRR38IN8Is5Ns88r-(RRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mrj:(RR9(.2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0d5sR3Ns8858sN8nsrRj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrd4cR4:Rj2U9,R
RRN3I858sI8N8sRr(-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4Rcd:jR4U292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#cRR538sN8ss5Ns88r:nRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4br(:gRRc4c9
2,R3RRI8N8sN5I8r8s(RR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M(r4gRR:49cc2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R065sR3Ns8858sN8nsrRj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr6.4R4:RU2j9,R
RRN3I858sI8N8sRr(-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM.R46:UR4j292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#nRR538sN8ss5Ns88r:nRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l.br6:4RRn.49
2,R3RRI8N8sN5I8r8s(RR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M6r.4RR:.94n2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0(5sR3Ns8858sN8nsrRj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lr(.UR.:R62.9,R
RRN3I858sI8N8sRr(-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM.RU(:6R..292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#URR538sN8ss5Ns88r:nRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_ldbr.:dRRU.U9
2,R3RRI8N8sN5I8r8s(RR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M.rddRR:.9UU2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0g5sR3Ns8858sN8nsrRj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrgd6Rd:R.2c9,R
RRN3I858sI8N8sRr(-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMdR6g:.Rdc292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45jRRN3s858ss8N8sRrn:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlbdRg6:nRdj,92
RRR38IN8Is5Ns88r-(RRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH{M5dLc'j8,RN_0NHdMrn:4RRjdn92}2;N
R#o#HMNR80FN_k=0RR08NNk_F0l_0bnrd4RR:j
9;ClM8FD8kCl

FD8kC(RL_Wmwh#ag5cRL_KmiNR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(i_uKgN_kR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR6P_m$,]d
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L6POF1dR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(w_mWghapR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRgw_mWgha_RNL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L(uNiK_;gk
HRRM0bkR_L6m]P$dR;
R0FkbRk0Lud_p
w;RMRHbRk0LP6_Fd1O;R
RHkMb0dRrn:4RRRj9Lm(_waWhg
p;RMRHbRk0Lmg_waWhgL_N;R

RosCRRrn:9RjR_LgPx_lBX7Y#L,Rg__.l7xBY,X#R_LUwwZwp XY;R
RICHsRRrn:9RjRjL4_lP_xYB7X;#0
IRRHRsCr4dnRj:R9(RL_WPw_vuD;R
RICHsRjL4_xmFw_Ihi;)p
IRRHRsCL_4cPOF1ds_#.]	wT
x;RHRIsLCRgF_mxhwI_;NL
sRRCLoR.F_.;R
RsRCoL_44.tw#_sgkX;AL
sRRCLoR4P4_w_#tgXksA
L;RCRsoURL_q[q_BiDmR;
RosCRnrd.RR:jL9R(Y_MKw_AvR;
RsIHCdRrn:.RRRj9LMU_YAK_w;vt
sRRCroRdRnd:9RjR_L(m$.$V;_w
sRRCroRg:4RRRj9Lm(_.V$$_
t;RCRso.RrdRR:jL9R(._m$_$VIR;
RosCRRr(:9RjR_L(m$.$V;_C
sRRCroRdRR:jL9R(._m$_$V 
j;RCRso(RL_$m.$QV_;R

RR//#F$Mb##$RN0sMN#D0FC_VRV
RHHM0DHNR_LgPx_lBX7Y#RR=5'~RL;j2
HRRMHH0NLDRg__.l7xBYRX#=~R5Rj'L2R;
RR//#F$Mb##$RN0sMN#D0FC_MR

RlsN_FLDOL	RdF_1W
R5RRRR3#L._	0ORLR5(W_[1P_dW
2,RRRR3D#O	RRRRLR5ci_mK,N2
RRRRN3s8R8sR5RRLPg__Blx7#YX2R,
R3RRI8N8sRRRRg5L_l._xYB7X,#2
RRRRN380HN_M5RRLm(_waWhg,p2
RRRRN380FN_k50RLP(_wuW_D,v2
RRRRC3INRRRR5RRL.._F;22
R
RL_4.mhwWaIg_v8C R(y524RL4w_mWgha_CX4]
R5RRRR3_L([_W1dRPW5_L([_W1d2PW,R
RRLR3(i_uKgN_kLR5(i_uKgN_k
2,RRRR3_L6m]P$dLR56P_m$2]d,R
RRLR3dp_u$LR54mj_FIxwh)_ip
2,RRRR3_LduRpw5_Ldu2pw,R
RRLR3(p_H#WtVpLR5UZ_wwXwpY, 2
RRRRU3L_q[q_BiDmLR5Uq_[qD_iB,m2
RRRR43LdF_P1_OdVsG.LRkT5cL4_1PFO#d_sw.	]2Tx,R
RRLR3UP_m$_]dY5tRLmg_FIxwhL_N2;R2
R
RNNDI$@#R@g5L_Wmwh_agNRL2LHCoMR
RR4RL4w_.#gt_kAsXL=R<RL4'jR;
RLRR.F_.RR<=4j'L;R
RRVRH5gRL_Wmwh_agN2LRRoLCHRM
RRRRR_L..<FR='R4L
4;RRRRR4RL4w_.#gt_kAsXL=R<RL4'4R;
RCRRMR8
R8CM
R
RNNDI$@#R@U5L_KMY_vAwtsRFR_LgmwFxINh_LL2RCMoH
RRRR4L4_#Pwtk_gsLXARR<=4j'L;R
RRVRH5L5RgF_mxhwI_RNL2&R&RL5RUY_MKw_AvdtrnR.92R2
RRRRR4L4_#Pwtk_gsLXARR<=44'L;R
RC
M8
NRRD$IN#@R@5#bFCC8oR_LcmNiKRL2RCMoH
RRRR5HVR_L6POF1dRR2LHCoMR
RRRRRL.g__Blx7#YXRR<=';Lj
RRRRLRRUZ_wwXwpY< R=LR'jR;
RRRRR_LU[_qqimDBRR<=4j'L;R
RRMRC8DRC#HCRVL5R4.4_w_#tgXksA2LRRoLCHRM
RRRRR_LUwwZwp XYRR<=L.g__Blx7#YX;R
RRRRRHRV5L.g__Blx7#YXRR==4R.(2CRLo
HMRRRRRRRRL.g__Blx7#YXRR<=';Lj
RRRRRRRR_LU[_qqimDBRR<=44'L;R
RRRRRCRM8CCD#
RRRRRRRR_Lg.x_lBX7Y#=R<R_Lg.x_lBX7Y#RR+4R;
RCRRMR8
R8CM
R
RNNDI$@#R@F5b#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_1PFO#d_sw.	]RTx2R
RRRRRLPg__Blx7#YXRR<=';Lj
RRRR#CDCVRH54RL4w_P#gt_kAsXLRR2LHCoMR
RRRRRHRV5LPg__Blx7#YXRR==4R.(2R
RRRRRRgRL_lP_xYB7X<#R=LR'jR;
RRRRR#CDCR
RRRRRRgRL_lP_xYB7X<#R=4RLj__Pl7xBY0X#R4+R;R
RRMRC8R
RC
M8
NRR#o#HM4RLj__Pl7xBY0X#RL=Rg__Pl7xBY;X#
NRR#o#HMURL_KMY_vAwtRRR=(RL_KMY_vAw;R
RNH##oLMR4mj_FIxwh)_ipRR=Lm(_.V$$_
Q;RDRNI#N$R5@@bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5R4Pc_Fd1O_.#s	Tw]xRR2LHCoMR
RRRRRLM(_YAK_wjvr9=R<RL4'4R;
RRRRR_L(M_YKArwvdRn.:9R4RR<=';Lj
RRRR8CMR#CDCVRH5gRL_xmFw_IhN2LR
RRRRLRR(Y_MKw_Av=R<RU{L_KMY_vAwtnrd4RR:jR9,LMU_YAK_wrvtd9n.}R;
R8CM
R
RNNDI$@#R@(5L_WPw_vuDRRFsLM(_YAK_wRv2LHCoMR
RR(RL_$m.$wV_r4dnRj:R9RR=LP(_wuW_D&vRR_L(M_YKArwvdRn.:9R4;R
RR(RL_$m.$wV_r.dn9RR=4j'L;R
RR(RL_$m.$wV_rddn9RR=4j'L;R
RR(RL_$m.$tV_rRj9=(RL_$m.$wV_rRj9|L|R(._m$_$Vw9r4RR||Lm(_.V$$_.wr9|R|R_L(m$.$Vr_wd
9;RRRRLm(_.V$$_4tr9RR=Lm(_.V$$_cwr9|R|R_L(m$.$Vr_w6|9R|(RL_$m.$wV_rRn9|L|R(._m$_$Vw9r(;R
RR(RL_$m.$tV_rR.9=(RL_$m.$wV_rRU9|L|R(._m$_$Vw9rgRR||Lm(_.V$$_4wrj|9R|(RL_$m.$wV_r944;R
RR(RL_$m.$tV_rRd9=(RL_$m.$wV_r94.RR||Lm(_.V$$_4wrd|9R|(RL_$m.$wV_r94cRR||Lm(_.V$$_4wr6
9;RRRRLm(_.V$$_ctr9RR=Lm(_.V$$_4wrn|9R|(RL_$m.$wV_r94(RR||Lm(_.V$$_4wrU|9R|(RL_$m.$wV_r94g;R
RR(RL_$m.$tV_rR69=(RL_$m.$wV_r9.jRR||Lm(_.V$$_.wr4|9R|(RL_$m.$wV_r9..RR||Lm(_.V$$_.wrd
9;RRRRLm(_.V$$_ntr9RR=Lm(_.V$$_.wrc|9R|(RL_$m.$wV_r9.6RR||Lm(_.V$$_.wrn|9R|(RL_$m.$wV_r9.(;R
RR(RL_$m.$tV_rR(9=(RL_$m.$wV_r9.URR||Lm(_.V$$_.wrg|9R|(RL_$m.$wV_r9djRR||Lm(_.V$$_dwr4
9;RRRRLm(_.V$$_Utr9RR=Lm(_.V$$_dwr.|9R|(RL_$m.$wV_r9ddRR||Lm(_.V$$_dwrc|9R|(RL_$m.$wV_r9d6;R
RR(RL_$m.$tV_rRg9=(RL_$m.$wV_r9dnRR||Lm(_.V$$_dwr(|9R|(RL_$m.$wV_r9dURR||Lm(_.V$$_dwrg
9;RRRRLm(_.V$$_4trj=9RR_L(m$.$Vr_wcRj9|L|R(._m$_$Vw4rc9|R|R_L(m$.$Vr_wcR.9|L|R(._m$_$Vwdrc9R;
RLRR(._m$_$Vt4r49RR=Lm(_.V$$_cwrc|9R|(RL_$m.$wV_r9c6RR||Lm(_.V$$_cwrn|9R|(RL_$m.$wV_r9c(;R
RR(RL_$m.$tV_r94.RL=R(._m$_$VwUrc9|R|R_L(m$.$Vr_wcRg9|L|R(._m$_$Vwjr69|R|R_L(m$.$Vr_w6;49
RRRR_L(m$.$Vr_t4Rd9=(RL_$m.$wV_r96.RR||Lm(_.V$$_6wrd|9R|(RL_$m.$wV_r96cRR||Lm(_.V$$_6wr6
9;RRRRLm(_.V$$_4trc=9RR_L(m$.$Vr_w6Rn9|L|R(._m$_$Vw(r69|R|R_L(m$.$Vr_w6RU9|L|R(._m$_$Vwgr69R;
RLRR(._m$_$Vt6r49RR=Lm(_.V$$_nwrj|9R|(RL_$m.$wV_r9n4RR||Lm(_.V$$_nwr.|9R|(RL_$m.$wV_r9nd;R
RR(RL_$m.$tV_r94nRL=R(._m$_$Vwcrn9|R|R_L(m$.$Vr_wnR69|L|R(._m$_$Vwnrn9|R|R_L(m$.$Vr_wn;(9
RRRR_L(m$.$Vr_t4R(9=(RL_$m.$wV_r9nURR||Lm(_.V$$_nwrg|9R|(RL_$m.$wV_r9(jRR||Lm(_.V$$_(wr4
9;RRRRLm(_.V$$_4trU=9RR_L(m$.$Vr_w(R.9|L|R(._m$_$Vwdr(9|R|R_L(m$.$Vr_w(Rc9|L|R(._m$_$Vw6r(9R;
RLRR(._m$_$Vtgr49RR=Lm(_.V$$_(wrn|9R|(RL_$m.$wV_r9((RR||Lm(_.V$$_(wrU|9R|(RL_$m.$wV_r9(g;R
RR(RL_$m.$tV_r9.jRL=R(._m$_$VwjrU9|R|R_L(m$.$Vr_wUR49|L|R(._m$_$Vw.rU9|R|R_L(m$.$Vr_wU;d9
RRRR_L(m$.$Vr_t.R49=(RL_$m.$wV_r9UcRR||Lm(_.V$$_Uwr6|9R|(RL_$m.$wV_r9UnRR||Lm(_.V$$_Uwr(
9;RRRRLm(_.V$$_.tr.=9RR_L(m$.$Vr_wURU9|L|R(._m$_$VwgrU9|R|R_L(m$.$Vr_wgRj9|L|R(._m$_$Vw4rg9R;
RLRR(._m$_$Vtdr.9RR=Lm(_.V$$_gwr.|9R|(RL_$m.$wV_r9gdRR||Lm(_.V$$_gwrc|9R|(RL_$m.$wV_r9g6;R
RR(RL_$m.$tV_r9.cRL=R(._m$_$Vwnrg9|R|R_L(m$.$Vr_wgR(9|L|R(._m$_$VwUrg9|R|R_L(m$.$Vr_wg;g9
RRRR_L(m$.$Vr_t.R69=(RL_$m.$wV_rj4j9|R|R_L(m$.$Vr_w49j4RR||Lm(_.V$$_4wrjR.9|L|R(._m$_$Vwjr4d
9;RRRRLm(_.V$$_.trn=9RR_L(m$.$Vr_w49jcRR||Lm(_.V$$_4wrjR69|L|R(._m$_$Vwjr4n|9R|(RL_$m.$wV_r(4j9R;
RLRR(._m$_$Vt(r.9RR=Lm(_.V$$_4wrjRU9|L|R(._m$_$Vwjr4g|9R|(RL_$m.$wV_rj449|R|R_L(m$.$Vr_w4944;R
RR(RL_$m.$tV_r9.URL=R(._m$_$Vw4r4.|9R|(RL_$m.$wV_rd449|R|R_L(m$.$Vr_w494cRR||Lm(_.V$$_4wr4;69
RRRR_L(m$.$Vr_t.Rg9=(RL_$m.$wV_rn449|R|R_L(m$.$Vr_w494(RR||Lm(_.V$$_4wr4RU9|L|R(._m$_$Vw4r4g
9;RRRRLm(_.V$$_dtrj=9RR_L(m$.$Vr_w49.jRR||Lm(_.V$$_4wr.R49|L|R(._m$_$Vw.r4.|9R|(RL_$m.$wV_rd4.9R;
RLRR(._m$_$Vt4rd9RR=Lm(_.V$$_4wr.Rc9|L|R(._m$_$Vw.r46|9R|(RL_$m.$wV_rn4.9|R|R_L(m$.$Vr_w49.(;R
RR(RL_$m.$tV_r9d.RL=R(._m$_$Vw.r4U|9R|(RL_$m.$wV_rg4.9|R|R_L(m$.$Vr_w49djRR||Lm(_.V$$_4wrd;49
RRRR_L(m$.$Vr_tdRd9=(RL_$m.$wV_r.4d9|R|R_L(m$.$Vr_w49ddRR||Lm(_.V$$_4wrdRc9|L|R(._m$_$Vwdr46
9;RRRRLm(_.V$$_dtrc=9RR_L(m$.$Vr_w49dnRR||Lm(_.V$$_4wrdR(9|L|R(._m$_$Vwdr4U|9R|(RL_$m.$wV_rg4d9R;
RLRR(._m$_$Vt6rd9RR=Lm(_.V$$_4wrcRj9|L|R(._m$_$Vwcr44|9R|(RL_$m.$wV_r.4c9|R|R_L(m$.$Vr_w49cd;R
RR(RL_$m.$tV_r9dnRL=R(._m$_$Vwcr4c|9R|(RL_$m.$wV_r64c9|R|R_L(m$.$Vr_w49cnRR||Lm(_.V$$_4wrc;(9
RRRR_L(m$.$Vr_tdR(9=(RL_$m.$wV_rU4c9|R|R_L(m$.$Vr_w49cgRR||Lm(_.V$$_4wr6Rj9|L|R(._m$_$Vw6r44
9;RRRRLm(_.V$$_dtrU=9RR_L(m$.$Vr_w496.RR||Lm(_.V$$_4wr6Rd9|L|R(._m$_$Vw6r4c|9R|(RL_$m.$wV_r6469R;
RLRR(._m$_$Vtgrd9RR=Lm(_.V$$_4wr6Rn9|L|R(._m$_$Vw6r4(|9R|(RL_$m.$wV_rU469|R|R_L(m$.$Vr_w496g;R
RR(RL_$m.$tV_r9cjRL=R(._m$_$Vwnr4j|9R|(RL_$m.$wV_r44n9|R|R_L(m$.$Vr_w49n.RR||Lm(_.V$$_4wrn;d9
RRRR_L(m$.$Vr_tcR49=(RL_$m.$wV_rc4n9|R|R_L(m$.$Vr_w49n6RR||Lm(_.V$$_4wrnRn9|L|R(._m$_$Vwnr4(
9;RRRRLm(_.V$$_ctr.=9RR_L(m$.$Vr_w49nURR||Lm(_.V$$_4wrnRg9|L|R(._m$_$Vw(r4j|9R|(RL_$m.$wV_r44(9R;
RLRR(._m$_$Vtdrc9RR=Lm(_.V$$_4wr(R.9|L|R(._m$_$Vw(r4d|9R|(RL_$m.$wV_rc4(9|R|R_L(m$.$Vr_w49(6;R
RR(RL_$m.$tV_r9ccRL=R(._m$_$Vw(r4n|9R|(RL_$m.$wV_r(4(9|R|R_L(m$.$Vr_w49(URR||Lm(_.V$$_4wr(;g9
RRRR_L(m$.$Vr_tcR69=(RL_$m.$wV_rj4U9|R|R_L(m$.$Vr_w49U4RR||Lm(_.V$$_4wrUR.9|L|R(._m$_$VwUr4d
9;RRRRLm(_.V$$_ctrn=9RR_L(m$.$Vr_w49UcRR||Lm(_.V$$_4wrUR69|L|R(._m$_$VwUr4n|9R|(RL_$m.$wV_r(4U9R;
RLRR(._m$_$Vt(rc9RR=Lm(_.V$$_4wrURU9|L|R(._m$_$VwUr4g|9R|(RL_$m.$wV_rj4g9|R|R_L(m$.$Vr_w49g4;R
RR(RL_$m.$tV_r9cURL=R(._m$_$Vwgr4.|9R|(RL_$m.$wV_rd4g9|R|R_L(m$.$Vr_w49gcRR||Lm(_.V$$_4wrg;69
RRRR_L(m$.$Vr_tcRg9=(RL_$m.$wV_rn4g9|R|R_L(m$.$Vr_w49g(RR||Lm(_.V$$_4wrgRU9|L|R(._m$_$Vwgr4g
9;RRRRLm(_.V$$_6trj=9RR_L(m$.$Vr_w.9jjRR||Lm(_.V$$_.wrjR49|L|R(._m$_$Vwjr..|9R|(RL_$m.$wV_rd.j9R;
RLRR(._m$_$Vt4r69RR=Lm(_.V$$_.wrjRc9|L|R(._m$_$Vwjr.6|9R|(RL_$m.$wV_rn.j9|R|R_L(m$.$Vr_w.9j(;R
RR(RL_$m.$tV_r96.RL=R(._m$_$Vwjr.U|9R|(RL_$m.$wV_rg.j9|R|R_L(m$.$Vr_w.94jRR||Lm(_.V$$_.wr4;49
RRRR_L(m$.$Vr_t6Rd9=(RL_$m.$wV_r..49|R|R_L(m$.$Vr_w.94dRR||Lm(_.V$$_.wr4Rc9|L|R(._m$_$Vw4r.6
9;RRRRLm(_.V$$_6trc=9RR_L(m$.$Vr_w.94nRR||Lm(_.V$$_.wr4R(9|L|R(._m$_$Vw4r.U|9R|(RL_$m.$wV_rg.49R;
RLRR(._m$_$Vt6r69RR=Lm(_.V$$_.wr.Rj9|L|R(._m$_$Vw.r.4|9R|(RL_$m.$wV_r...9|R|R_L(m$.$Vr_w.9.d;R
RR(RL_$m.$tV_r96nRL=R(._m$_$Vw.r.c|9R|(RL_$m.$wV_r6..9|R|R_L(m$.$Vr_w.9.nRR||Lm(_.V$$_.wr.;(9
RRRR_L(m$.$Vr_t6R(9=(RL_$m.$wV_rU..9|R|R_L(m$.$Vr_w.9.gRR||Lm(_.V$$_.wrdRj9|L|R(._m$_$Vwdr.4
9;RRRRLm(_.V$$_6trU=9RR_L(m$.$Vr_w.9d.RR||Lm(_.V$$_.wrdRd9|L|R(._m$_$Vwdr.c|9R|(RL_$m.$wV_r6.d9R;
RLRR(._m$_$Vtgr69RR=Lm(_.V$$_.wrdRn9|L|R(._m$_$Vwdr.(|9R|(RL_$m.$wV_rU.d9|R|R_L(m$.$Vr_w.9dg;R
RR(RL_$m.$tV_r9njRL=R(._m$_$Vwcr.j|9R|(RL_$m.$wV_r4.c9|R|R_L(m$.$Vr_w.9c.RR||Lm(_.V$$_.wrc;d9
RRRR_L(m$.$Vr_tnR49=(RL_$m.$wV_rc.c9|R|R_L(m$.$Vr_w.9c6RR||Lm(_.V$$_.wrcRn9|L|R(._m$_$Vwcr.(
9;RRRRLm(_.V$$_ntr.=9RR_L(m$.$Vr_w.9cURR||Lm(_.V$$_.wrcRg9|L|R(._m$_$Vw6r.j|9R|(RL_$m.$wV_r4.69R;
RLRR(._m$_$Vtdrn9RR=Lm(_.V$$_.wr6R.9|L|R(._m$_$Vw6r.d|9R|(RL_$m.$wV_rc.69|R|R_L(m$.$Vr_w.966;R
RR(RL_$m.$tV_r9ncRL=R(._m$_$Vw6r.n|9R|(RL_$m.$wV_r(.69|R|R_L(m$.$Vr_w.96URR||Lm(_.V$$_.wr6;g9
RRRR_L(m$.$Vr_tnR69=(RL_$m.$wV_rj.n9|R|R_L(m$.$Vr_w.9n4RR||Lm(_.V$$_.wrnR.9|L|R(._m$_$Vwnr.d
9;RRRRLm(_.V$$_ntrn=9RR_L(m$.$Vr_w.9ncRR||Lm(_.V$$_.wrnR69|L|R(._m$_$Vwnr.n|9R|(RL_$m.$wV_r(.n9R;
RLRR(._m$_$Vt(rn9RR=Lm(_.V$$_.wrnRU9|L|R(._m$_$Vwnr.g|9R|(RL_$m.$wV_rj.(9|R|R_L(m$.$Vr_w.9(4;R
RR(RL_$m.$tV_r9nURL=R(._m$_$Vw(r..|9R|(RL_$m.$wV_rd.(9|R|R_L(m$.$Vr_w.9(cRR||Lm(_.V$$_.wr(;69
RRRR_L(m$.$Vr_tnRg9=(RL_$m.$wV_rn.(9|R|R_L(m$.$Vr_w.9((RR||Lm(_.V$$_.wr(RU9|L|R(._m$_$Vw(r.g
9;RRRRLm(_.V$$_(trj=9RR_L(m$.$Vr_w.9UjRR||Lm(_.V$$_.wrUR49|L|R(._m$_$VwUr..|9R|(RL_$m.$wV_rd.U9R;
RLRR(._m$_$Vt4r(9RR=Lm(_.V$$_.wrURc9|L|R(._m$_$VwUr.6|9R|(RL_$m.$wV_rn.U9|R|R_L(m$.$Vr_w.9U(;R
RR(RL_$m.$tV_r9(.RL=R(._m$_$VwUr.U|9R|(RL_$m.$wV_rg.U9|R|R_L(m$.$Vr_w.9gjRR||Lm(_.V$$_.wrg;49
RRRR_L(m$.$Vr_t(Rd9=(RL_$m.$wV_r..g9|R|R_L(m$.$Vr_w.9gdRR||Lm(_.V$$_.wrgRc9|L|R(._m$_$Vwgr.6
9;RRRRLm(_.V$$_(trc=9RR_L(m$.$Vr_w.9gnRR||Lm(_.V$$_.wrgR(9|L|R(._m$_$Vwgr.U|9R|(RL_$m.$wV_rg.g9R;
RLRR(._m$_$Vt6r(9RR=Lm(_.V$$_dwrjRj9|L|R(._m$_$Vwjrd4|9R|(RL_$m.$wV_r.dj9|R|R_L(m$.$Vr_wd9jd;R
RR(RL_$m.$tV_r9(nRL=R(._m$_$Vwjrdc|9R|(RL_$m.$wV_r6dj9|R|R_L(m$.$Vr_wd9jnRR||Lm(_.V$$_dwrj;(9
RRRR_L(m$.$Vr_t(R(9=(RL_$m.$wV_rUdj9|R|R_L(m$.$Vr_wd9jgRR||Lm(_.V$$_dwr4Rj9|L|R(._m$_$Vw4rd4
9;RRRRLm(_.V$$_(trU=9RR_L(m$.$Vr_wd94.RR||Lm(_.V$$_dwr4Rd9|L|R(._m$_$Vw4rdc|9R|(RL_$m.$wV_r6d49R;
RLRR(._m$_$Vtgr(9RR=Lm(_.V$$_dwr4Rn9|L|R(._m$_$Vw4rd(|9R|(RL_$m.$wV_rUd49|R|R_L(m$.$Vr_wd94g;R
RR(RL_$m.$tV_r9UjRL=R(._m$_$Vw.rdj|9R|(RL_$m.$wV_r4d.9|R|R_L(m$.$Vr_wd9..RR||Lm(_.V$$_dwr.;d9
RRRR_L(m$.$Vr_tUR49=(RL_$m.$wV_rcd.9|R|R_L(m$.$Vr_wd9.6RR||Lm(_.V$$_dwr.Rn9|L|R(._m$_$Vw.rd(
9;RRRRLm(_.V$$_Utr.=9RR_L(m$.$Vr_wd9.URR||Lm(_.V$$_dwr.Rg9|L|R(._m$_$Vwdrdj|9R|(RL_$m.$wV_r4dd9R;
RLRR(._m$_$VtdrU9RR=Lm(_.V$$_dwrdR.9|L|R(._m$_$Vwdrdd|9R|(RL_$m.$wV_rcdd9|R|R_L(m$.$Vr_wd9d6;R
RR(RL_$m.$tV_r9UcRL=R(._m$_$Vwdrdn|9R|(RL_$m.$wV_r(dd9|R|R_L(m$.$Vr_wd9dURR||Lm(_.V$$_dwrd;g9
RRRR_L(m$.$Vr_tUR69=(RL_$m.$wV_rjdc9|R|R_L(m$.$Vr_wd9c4RR||Lm(_.V$$_dwrcR.9|L|R(._m$_$Vwcrdd
9;RRRRLm(_.V$$_Utrn=9RR_L(m$.$Vr_wd9ccRR||Lm(_.V$$_dwrcR69|L|R(._m$_$Vwcrdn|9R|(RL_$m.$wV_r(dc9R;
RLRR(._m$_$Vt(rU9RR=Lm(_.V$$_dwrcRU9|L|R(._m$_$Vwcrdg|9R|(RL_$m.$wV_rjd69|R|R_L(m$.$Vr_wd964;R
RR(RL_$m.$tV_r9UURL=R(._m$_$Vw6rd.|9R|(RL_$m.$wV_rdd69|R|R_L(m$.$Vr_wd96cRR||Lm(_.V$$_dwr6;69
RRRR_L(m$.$Vr_tURg9=(RL_$m.$wV_rnd69|R|R_L(m$.$Vr_wd96(RR||Lm(_.V$$_dwr6RU9|L|R(._m$_$Vw6rdg
9;RRRRLm(_.V$$_gtrj=9RR_L(m$.$Vr_wd9njRR||Lm(_.V$$_dwrnR49|L|R(._m$_$Vwnrd.|9R|(RL_$m.$wV_rddn9R;
RLRR(._m$_$Vt4rg9RR=4j'L;R
RR(RL_$m.$IV_rRj9=(RL_$m.$tV_rRj9|L|R(._m$_$Vt9r4RR||Lm(_.V$$_.tr9|R|R_L(m$.$Vr_td
9;RRRRLm(_.V$$_4Ir9RR=Lm(_.V$$_ctr9|R|R_L(m$.$Vr_t6|9R|(RL_$m.$tV_rRn9|L|R(._m$_$Vt9r(;R
RR(RL_$m.$IV_rR.9=(RL_$m.$tV_rRU9|L|R(._m$_$Vt9rgRR||Lm(_.V$$_4trj|9R|(RL_$m.$tV_r944;R
RR(RL_$m.$IV_rRd9=(RL_$m.$tV_r94.RR||Lm(_.V$$_4trd|9R|(RL_$m.$tV_r94cRR||Lm(_.V$$_4tr6
9;RRRRLm(_.V$$_cIr9RR=Lm(_.V$$_4trn|9R|(RL_$m.$tV_r94(RR||Lm(_.V$$_4trU|9R|(RL_$m.$tV_r94g;R
RR(RL_$m.$IV_rR69=(RL_$m.$tV_r9.jRR||Lm(_.V$$_.tr4|9R|(RL_$m.$tV_r9..RR||Lm(_.V$$_.trd
9;RRRRLm(_.V$$_nIr9RR=Lm(_.V$$_.trc|9R|(RL_$m.$tV_r9.6RR||Lm(_.V$$_.trn|9R|(RL_$m.$tV_r9.(;R
RR(RL_$m.$IV_rR(9=(RL_$m.$tV_r9.URR||Lm(_.V$$_.trg|9R|(RL_$m.$tV_r9djRR||Lm(_.V$$_dtr4
9;RRRRLm(_.V$$_UIr9RR=Lm(_.V$$_dtr.|9R|(RL_$m.$tV_r9ddRR||Lm(_.V$$_dtrc|9R|(RL_$m.$tV_r9d6;R
RR(RL_$m.$IV_rRg9=(RL_$m.$tV_r9dnRR||Lm(_.V$$_dtr(|9R|(RL_$m.$tV_r9dURR||Lm(_.V$$_dtrg
9;RRRRLm(_.V$$_4Irj=9RR_L(m$.$Vr_tcRj9|L|R(._m$_$Vt4rc9|R|R_L(m$.$Vr_tcR.9|L|R(._m$_$Vtdrc9R;
RLRR(._m$_$VI4r49RR=Lm(_.V$$_ctrc|9R|(RL_$m.$tV_r9c6RR||Lm(_.V$$_ctrn|9R|(RL_$m.$tV_r9c(;R
RR(RL_$m.$IV_r94.RL=R(._m$_$VtUrc9|R|R_L(m$.$Vr_tcRg9|L|R(._m$_$Vtjr69|R|R_L(m$.$Vr_t6;49
RRRR_L(m$.$Vr_I4Rd9=(RL_$m.$tV_r96.RR||Lm(_.V$$_6trd|9R|(RL_$m.$tV_r96cRR||Lm(_.V$$_6tr6
9;RRRRLm(_.V$$_4Irc=9RR_L(m$.$Vr_t6Rn9|L|R(._m$_$Vt(r69|R|R_L(m$.$Vr_t6RU9|L|R(._m$_$Vtgr69R;
RLRR(._m$_$VI6r49RR=Lm(_.V$$_ntrj|9R|(RL_$m.$tV_r9n4RR||Lm(_.V$$_ntr.|9R|(RL_$m.$tV_r9nd;R
RR(RL_$m.$IV_r94nRL=R(._m$_$Vtcrn9|R|R_L(m$.$Vr_tnR69|L|R(._m$_$Vtnrn9|R|R_L(m$.$Vr_tn;(9
RRRR_L(m$.$Vr_I4R(9=(RL_$m.$tV_r9nURR||Lm(_.V$$_ntrg|9R|(RL_$m.$tV_r9(jRR||Lm(_.V$$_(tr4
9;RRRRLm(_.V$$_4IrU=9RR_L(m$.$Vr_t(R.9|L|R(._m$_$Vtdr(9|R|R_L(m$.$Vr_t(Rc9|L|R(._m$_$Vt6r(9R;
RLRR(._m$_$VIgr49RR=Lm(_.V$$_(trn|9R|(RL_$m.$tV_r9((RR||Lm(_.V$$_(trU|9R|(RL_$m.$tV_r9(g;R
RR(RL_$m.$IV_r9.jRL=R(._m$_$VtjrU9|R|R_L(m$.$Vr_tUR49|L|R(._m$_$Vt.rU9|R|R_L(m$.$Vr_tU;d9
RRRR_L(m$.$Vr_I.R49=(RL_$m.$tV_r9UcRR||Lm(_.V$$_Utr6|9R|(RL_$m.$tV_r9UnRR||Lm(_.V$$_Utr(
9;RRRRLm(_.V$$_.Ir.=9RR_L(m$.$Vr_tURU9|L|R(._m$_$VtgrU9|R|R_L(m$.$Vr_tgRj9|L|R(._m$_$Vt4rg9R;
RLRR(._m$_$VIdr.9RR=4j'L;R
RR(RL_$m.$CV_rRj9=(RL_$m.$IV_rRj9|L|R(._m$_$VI9r4RR||Lm(_.V$$_.Ir9|R|R_L(m$.$Vr_Id
9;RRRRLm(_.V$$_4Cr9RR=Lm(_.V$$_cIr9|R|R_L(m$.$Vr_I6|9R|(RL_$m.$IV_rRn9|L|R(._m$_$VI9r(;R
RR(RL_$m.$CV_rR.9=(RL_$m.$IV_rRU9|L|R(._m$_$VI9rgRR||Lm(_.V$$_4Irj|9R|(RL_$m.$IV_r944;R
RR(RL_$m.$CV_rRd9=(RL_$m.$IV_r94.RR||Lm(_.V$$_4Ird|9R|(RL_$m.$IV_r94cRR||Lm(_.V$$_4Ir6
9;RRRRLm(_.V$$_cCr9RR=Lm(_.V$$_4Irn|9R|(RL_$m.$IV_r94(RR||Lm(_.V$$_4IrU|9R|(RL_$m.$IV_r94g;R
RR(RL_$m.$CV_rR69=(RL_$m.$IV_r9.jRR||Lm(_.V$$_.Ir4|9R|(RL_$m.$IV_r9..RR||Lm(_.V$$_.Ird
9;RRRRLm(_.V$$_nCr9RR=4j'L;R
RR(RL_$m.$CV_rR(9='R4L
j;RRRRLm(_.V$$_r jj=9RR_L(m$.$Vr_Cj|9R|(RL_$m.$CV_rR49|L|R(._m$_$VC9r.RR||Lm(_.V$$_dCr9R;
RLRR(._m$_$V 4jr9RR=Lm(_.V$$_cCr9|R|R_L(m$.$Vr_C6|9R|(RL_$m.$CV_rRn9|L|R(._m$_$VC9r(;R
RR(RL_$m.$ V_j9r.R4=R';Lj
RRRR_L(m$.$Vj_ rRd9='R4L
j;RRRRLm(_.V$$_=QRR_L(m$.$Vj_ rRj9|L|R(._m$_$V 4jr9|R|R_L(m$.$Vj_ rR.9|L|R(._m$_$V djr9R;
R8CM
M
C88lFk
DC
8lFkRDCL_4.MwPlpN_D4]G$54RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4k4_)_sOgXksA
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pTN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_p)N
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_p]N
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pbN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_puN,Lj
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRgP_Mlawp_,NL
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRgP_Mlxwp_,NL
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRgP_MlQwp_RNL2
;
RNRbsCNl0RCsLhU_HN_mURg.=;Rc
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=iRRLc'jjjj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)p='RcLjjj4R;
RsbNN0lCCLsR4md_FAKOXG_WzAn)Rc=R'jLj4
j;RNRbsCNl0RCsL_4dmOFKAWX_G)zn[RR=cj'Lj;44
bRRNlsNCs0CRdL4_KmFO_AXWnGz)RKj='RcLjj4jR;
RsbNN0lCCLsR4md_FAKOXG_Wzhn)Rc=R'4Ljj
4;RNRbsCNl0RCsL_4dmOFKAWX_G)zn0RR=cj'L4;4j
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=BRRLc'j444;R

RbHMkr0RLhU_HN_mU:g.4L9R4Md_Pplw_.VGsTLk;R
RHkMb04RL4)_ksgO_kAsXLR;
R0FkbRk0LMg_PplwTL_N;R
RFbk0kL0RgP_Ml)wp_;NL
FRRkk0b0gRL_lMPw_p]N
L;RkRF00bkR_LgMwPlpNb_LR;
R0FkbRk0LMg_PplwuL_NjR;
R0FkbRk0LMg_PplwaL_N;R
RFbk0kL0RgP_Mlxwp_;NL
FRRkk0b0gRL_lMPw_pQN
L;RCRsogRL_lMPw_pTN
L;RCRsogRL_lMPw_p)N
L;RCRsogRL_lMPw_p]N
L;RCRsogRL_lMPw_pbN
L;RCRsogRL_lMPw_puN;Lj
sRRCLoRgP_Mlawp_;NL
sRRCLoRgP_Mlxwp_;NL
sRRCLoRgP_MlQwp_;NL
R

RINDNR$#@5@RL_4dMwPlpG_V.ksLTsRFR4L4_sk)Ok_gsLXA2CRLo
HMRRRRLMg_PplwTL_NRR<=4j'L;R
RRgRL_lMPw_p)N<LR='R4L
j;RRRRLMg_Pplw]L_NRR<=4j'L;R
RRgRL_lMPw_pbN<LR='R4L
j;RRRRLMg_PplwuL_Nj=R<RL4'jR;
RLRRgP_Mlawp_RNL<4=R';Lj
RRRR_LgMwPlpNx_L=R<RL4'jR;
RLRRgP_MlQwp_RNL<4=R';Lj
RRRRRHV54L4_sk)Ok_gsLXARR==44'L2CRLo
HMRRRRRNRO#RC5L_4dMwPlpG_V.ksLTRR2/#/R$bMF#R$#bNNsDDDC_#ONCR
RRRRRR4RLdF_mKXOA_zWGn:)iR_LgMwPlpNT_L=R<RL4'4R;
RRRRRLRR4md_FAKOXG_Wzpn):gRL_lMPw_p)N<LR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)znAL:RgP_Ml]wp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)R[:LMg_PplwbL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGnj)K:gRL_lMPw_puNRLj<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)Rh:LMg_PplwaL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)0R_LgMwPlpNx_L=R<RL4'4R;
RRRRRLRR4md_FAKOXG_WzBn):gRL_lMPw_pQN<LR='R4L
4;RRRRRMRC8#ONCR
RRMRC8R
RC
M8ClM8FD8kCl

FD8kC(RL_wup_hnD54RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,L 
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,Lw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,LP
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,L8
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7jL7,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLjp_uwo_AV]7L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLjp_uwo_AVM7L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdRL_wupR
2;
bRRNlsNCs0CR_LUhmH_N.UgRc=R;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)i='RcLjjjjR;
RsbNN0lCCLsR4md_FAKOXG_Wzpn)Rc=R'jLjj
4;RNRbsCNl0RCsL_4dmOFKAWX_G)znARR=cj'Lj;4j
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=[RRLc'j4j4;R
RbNNslCC0s4RLdF_mKXOA_zWGnj)KRc=R'4Ljj
j;RNRbsCNl0RCsL_4dmOFKAWX_G)znhRR=cj'L4;j4
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=0RRLc'jj44;R

RsbNN0lCCLsR4md_FAKOXG_WzBn)Rc=R'4Lj4
4;
MRHbRk0r_LUhmH_N.Ug:R49L_4dMwPlpG_V.ksLTR;
HkMb0LRR4uj_pAw_oLV7 R;
HkMb0LRR4uj_pAw_oLV7wR;
HkMb0LRR4uj_pAw_oLV7PR;
HkMb0LRR4uj_pAw_oLV78R;
HkMb0LRR4uj_pAw_oLV77
j;RbHMkR0RL_4ju_pwA7oVL
];RbHMkR0RL_4ju_pwA7oVL
M;R0FkbRk0Lud_p
w;RosCR_Ldu;pw
R
RNNDI$@#R@L5R4Md_Pplw_.VGsTLkR
FsRRRRRRRRRRRRL_4ju_pwA7oVLF RsR
RRRRRRRRRR4RLjp_uwo_AVw7LR
FsRRRRRRRRRRRRL_4ju_pwA7oVLFPRsR
RRRRRRRRRR4RLjp_uwo_AV87LR
FsRRRRRRRRRRRRL_4ju_pwA7oVLR7jFRs
RRRRRRRRRLRR4uj_pAw_oLV7]sRF
RRRRRRRRRRRRjL4_wup_VAo7RLM2CRLo
HMRRRROCN#54RLdP_Ml_wpVsG.LRkT2/R/RM#$F$b##NRbsDNDCOD_N
#CRRRRR4RLdF_mKXOA_zWGn:)iR_LduRpw<L=R4uj_pAw_oLV7 R;
RRRRRdL4_KmFO_AXWnGz)Rp:Lud_p<wR=4RLjp_uwo_AVw7L;R
RRRRRL_4dmOFKAWX_G)znAL:Rdp_uw=R<RjL4_wup_VAo7;LP
RRRRLRR4md_FAKOXG_Wz[n):dRL_wupRR<=L_4ju_pwA7oVL
8;RRRRR4RLdF_mKXOA_zWGnj)K:dRL_wupRR<=L_4ju_pwA7oVL;7j
RRRRLRR4md_FAKOXG_Wzhn):dRL_wupRR<=L_4ju_pwA7oVL
];RRRRR4RLdF_mKXOA_zWGn:)0R_LduRpw<L=R4uj_pAw_oLV7MR;
RRRRRdL4_KmFO_AXWnGz)RB:Lud_p<wR=4RLjp_uwo_AV 7L;R
RRRRR8NCVk:D0RRRRRRRRRRRRR_LduRpw<4=R';Lj
RRRR8CMOCN#
CRRMC8
MF8l8CkD
F
l8CkDR_LdkRis5R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4Md_Pplw_.VGsTLk,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdRL_$up,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdRL_wup,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR(RL_$up_vuD,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL.1_u$oHAV_7LL
8,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.uH1$.YXVw8_L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLcw_mWgha	JEW]H_d,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLd1_u$oHAV_7LZ,c7
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_$u1HV.XYZw_c
7,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_46mhwWaEg	W_J]),g	
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_aMzTVAo7LL_8R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR44c_8paOIV_pAdu_HR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4Md_zAaToLV7_7Zc,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL6Y_MEgQd#CIv v8_oR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4Mn_YdEQgv#IC_ 8q,(U
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4L4_APqZ#dJY]_X,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL.q_PAJZd#pY_$
E,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_44kO)s.YXV_,X]
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_sk)OV.XY$_pE/2R*$R#MC0E#RH##_$MEsHC=N"EsR8"*;/R
R
RbNNslCC0sURL__hHmgNU.RR=cR;
RbHMkL0R4k4_)_sOgXksA
L;RMRHbRk0r_LUhmH_N.Ug:R49L_4dMwPlpG_V.ksLTR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;RkRF00bkR_L(u_p$u;Dv
FRRkk0b04RL.1_u$oHAV_7LL
8;RkRF00bkR.L4_$u1HV.XYLw_8R;
R0FkbRk0L_4cmhwWaEg	W_J]d
H;RkRF00bkR.L4_aMzTVAo7LL_8R;
R0FkbRk0L_4c4O8appI_V_Aud
H;RkRF00bkR6L4_EMYQ#dgI vC8o_v;R
RFbk0kL0R4P4_qdAZJ_#YX
];RkRF00bkR4L4_sk)OV.XY]_X;R
RHkMb04RLd1_u$oHAV_7LZ;c7
HRRM0bkRdL4_$u1HV.XYZw_c
7;RMRHbRk0L_46mhwWaEg	W_J]);g	
HRRM0bkRdL4_aMzTVAo7ZL_c
7;RMRHbRk0L_4nMQYEdIg#v8C _Uq(;R
RHkMb04RL.q_PAJZd#pY_$
E;RMRHbRk0L_4.kO)s.YXV_Ep$;R

RsIHC(RL_wup_vQw;R

RsIHC4RLcY_MAKjKB0_w_qNx,4RLn1_u$oHAV_7LLV8_oRl,L_4UmhwWaEg	W_J]d4H_BRe,L_4gMQYEdIg#v8C __vox,7GR6L4_APqZ#dJY]_X_$IH;R
RICHsR6L4_sk)OV.XY]_X_$IH;R
RICHsRUL4_a48O_pIpuVA__dH4;Be
R
RL_4.MwPlpN_D4]G$RjL4_#MPOsA_tR#p5R
RRRRR34L4_sk)Ok_gsLXARRRRRL5R4k4_)_sOgXksA2LR,R
RRRRR3dL4_lMPwVp_GL.skRTRR5RRRdL4_lMPwVp_GL.sk2TR,R
RRRRR3_LgMwPlpNT_LRR5L_4cMjYAK_KBwN0_x2qR,R
RRRRR3_LgMwPlpN)_LRR5L_4nuH1$A7oVL8_L_lVoR
2,RRRRRLR3gP_Ml]wp_RNL54RLUw_mWgha	JEW]H_d_e4BR
2,RRRRRLR3gP_Mlbwp_RNL54RLn1_u$XH.V_YwLV8_o2lR,R
RRRRR3_LgMwPlpNu_L5jRRgL4_EMYQ#dgI vC8o_v_Gx7R
2,RRRRRLR3gP_Mlawp_RNL54RL6q_PAJZd#XY_]H_I$,R2
RRRR3RRLMg_PplwxL_NRL5R4k6_).sOX_VYXI]_H2$R,R
RRRRR3_LgMwPlpNQ_LRR5L_4U4O8appI_V_Aud4H_B2eR2
;
R(RL_wup_hnDR.L4_wup_hnD_YU0P
R5RRRRRLR34Md_Pplw_.VGsTLkRRRR54RLdP_Ml_wpVsG.LRkT2R,
RRRRR43Ljp_uwo_AV 7LRL5R4Md_zAaToLV7_7ZcR
2,RRRRRLR34uj_pAw_oLV7wRR5L_4duH1$A7oVLc_Z7,R2
RRRR3RRL_4ju_pwA7oVL5PRR6L4_Wmwh	agE]WJ_	)gR
2,RRRRRLR34uj_pAw_oLV78RR5L_4duH1$.YXVwc_Z7,R2
RRRR3RRL_4ju_pwA7oVLR7j54RLnY_MEgQd#CIv q8_(2UR,R
RRRRR3jL4_wup_VAo7RL]54RL.q_PAJZd#pY_$2ER,R
RRRRR3jL4_wup_VAo7RLM54RL.)_ksXO.VpY_$2ER,R
RRRRR3_LduRpwRRRRR5RRR_L(u_pwQRwv2
2;
NRR#o#HMdRL_wupRRRRRRRR=(RL_wup_vQwRL&R4k4_)_sOgXksA
L;R#RN#MHoR_L(u_p$uRDvRRRRR=RRR_Ldu;p$
NRR#o#HM4RL.1_u$oHAV_7LLR8RRL=R4un_1A$HoLV7__L8V;ol
NRR#o#HM4RL.1_u$XH.V_YwLR8RRL=R4un_1.$HXwVY__L8V;ol
NRR#o#HM4RLcw_mWgha	JEW]H_dRL=R4mU_waWhgW	EJd]_HB_4eR;
R#N#HRoML_4.MTzaA7oVL8_LRRRRRL=R4Mc_YKAjKwB_0x_NqR;
R#N#HRoML_46MQYEdIg#v8C _RvoRRRR=4RLgY_MEgQd#CIv v8_o7_xGR;
R#N#HRoML_44PZqAdYJ#_RX]RRRR=4RL6q_PAJZd#XY_]H_I$R;
R#N#HRoML_44kO)s.YXV_RX]RRRR=4RL6)_ksXO.VXY_]H_I$R;
R#N#HRoML_4c4O8appI_V_AudRHRR=RRRUL4_a48O_pIpuVA__dH4;Be
8CMlkF8D
C
lkF8DLCRU)_M_J$lsRt5L[(_Wd1_P
W,RRRRRRRRRRRRRRRRRRRRRRRRRLRRnV_M#w_V,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LnM_zaV
w,RRRRRRRRRRRRRRRRRRRRRRRRRLRR4P4_qdAZJ_#YX
],RRRRRRRRRRRRRRRRRRRRRRRRRLRR44c_8paOIV_pAdu_HR,
RRRRRRRRRRRRRRRRRRRRRRRRR6RL_$mP]
d,RRRRRRRRRRRRRRRRRRRRRRRRRLRRnZ_8#g0d,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,p$
RRRRRRRRRRRRRRRRRRRRRRRRRRRLmn_OsljWR,
RRRRRRRRRRRRRRRRRRRRRRRRRdRL_#MV,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LdM,za
RRRRRRRRRRRRRRRRRRRRRRRRRRRLPU_qdAZJ,#Y
RRRRRRRRRRRRRRRRRRRRRRRRRRRLM(_wstj7
Y,RRRRRRRRRRRRRRRRRRRRRRRRRLRR(V_M#I_d$R,
RRRRRRRRRRRRRRRRRRRRRRRRR(RL_aMz_$dI,R
RRRRRRRRRRRRRRRRRRRRRRRRRR.L4_APqZ#dJY$_pER,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_6u1ZRVX2R;
RsbNN0lCCLsR(z_MakZQYRR=4R;
RsbNN0lCCLsRUs_hcc_gH=bRR
6;RNRbsCNl0RCsLhU_sNc_URzbR6=R'jLjj;jj
R
RHkMb0(RL_1[W_WdP;R
RHkMb0nRL_#MV_;Vw
HRRM0bkR_LnM_zaV
w;RMRHbRk0L_44PZqAdYJ#_;X]
HRRM0bkRcL4_a48O_pIpuVA_;dH
HRRM0bkR_L6m]P$dR;
RbHMkL0RnZ_8#g0d;R
RHkMb0dRL_$up;R
RHkMb0(RL_tMwjYs7;R
RHkMb0RRrLhU_sgc_c-Hb4R:j9nRL_lmOj;sW
HRRM0bkR_LnuZ16V
X;RkRF00bkRLrRUs_hcc_gH4b-:9jRR_LdM;V#
FRRkk0b0RRrLM(_zQaZk4Y-:9jRR_LdM;za
FRRkk0b0URL_APqZ#dJYR;
R0FkbRk0LM(_Vd#_I
$;RkRF00bkR_L(M_zad;I$
FRRkk0b04RL.q_PAJZd#pY_$
E;
sRRCroRLhU_sgc_cRHb-:R4jL9R4Mj_Vv#_gV	YsR;
RsIHCLRrUs_hcc_gH-bRR44:94RL4V_M#g_v	sYV]R;
RosCR(rL_aMzZYQkR4-R:Rj9L_4jM_zavYg	V
s;RHRIsrCRLM(_zQaZk-YRR44:94RL4z_Mag_v	sYV]R;
RosCR6L4_APqZ#dJYL_kdC)l;R
RICHsRUrL_chs_Hgcb:-4jL9R6V_M#;_a
IRRHRsCr_L(MZzaQ-kY49:jR_L6M_zaaR;
RsIHC4RLjq_PAJZd#AY_;R
RsRCorURL_chs_Hgcb:-4jRR9LMd_V
#;RCRsoRRrLM(_zQaZk4Y-:9jRR_LdM;za
sRRCLoRUq_PAJZd#
Y;
NRR#o#HM6RL_#MV_=aRRjL4_#MV_	vgYrVsLhU_sgc_c-Hb49:j;R
RNH##oLMR6z_MaR_a=4RLjz_Mag_v	sYVr_L(MZzaQRkY-:R4j
9;R#RN#MHoRjL4_APqZ#dJYR_A=4RL6q_PAJZd#kY_Lld)CR;
R#N#HRoMLM(_Vd#_I=$RRjL4_#MV_	vgYrVsj
9;R#RN#MHoR_L(M_zadRI$=4RLjz_Mag_v	sYVr;j9
NRR#o#HM4RL.q_PAJZd#pY_$=ERR6L4_APqZ#dJYL_kdC)l;R

RINDNR$#@R@5bCF#8RoCL8n_Zd#0gRR2LHCoMR
RRVRH5nRL_#MV_RVw2CRLo
HMRRRRRdRL_#MVRR<=LM6_Va#_;R
RRMRC8R
RC
M8
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2CRLo
HMRRRRHRV5LMn_zVa_wRR2LHCoMR
RRRRRLMd_z<aR=6RL_aMz_
a;RRRRC
M8RMRC8R

RINDNR$#@R@5bCF#8RoCL8n_Zd#0gsRFR#bFCC8oR_LnuZ16V2XRRoLCHRM
RHRRVL5Rn1_u6XZVRR2
RRRRR_LUPZqAdYJ#RR<=4j'L;R
RRDRC#HCRVL5R4P4_qdAZJ_#YX2]RRoLCHRM
RRRRR_LUPZqAdYJ#RR<=L_4jPZqAdYJ#_
A;RRRRC
M8RMRC8R

RINDNR$#@R@5bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5RnV_M#w_VRR||L_4c4O8appI_V_Aud2HRRoLCHRM
RRRRR5HVR_L(MjwtsR7Y2R
RRRRRR4RLjV_M#g_v	sYVr_LUh_scgbcHR4-R:Rj9<L=RnO_mlWjs;R
RRRRRCCD#R5HVR_L6m]P$d
R2RRRRRRRRL_4jM_V#vYg	V<sR=LR{dp_u$L,R4M4_Vv#_gV	Ys;]}
RRRR8CM
RRRR5HVR_LnM_zaV&wR&6RL_$mP]2dRRoLCHRM
RRRRRjL4_aMz_	vgYRVs<{=RLud_pR$,L_44M_zavYg	V}s];R
RRMRC8R
RRVRH54RL4q_PAJZd#XY_]&R&R_L6m]P$dRR2LHCoMR
RRRRRL_46PZqAdYJ#_dkL)RlC<L=Rdp_u$R;
RCRRMR8
R8CM
NRR#o#HM4RL4V_M#g_v	sYV]RR=L_4jM_V#vYg	VLsrUs_hcc_gH-bRR:4RR;49
NRR#o#HM4RL4z_Mag_v	sYV]RR=L_4jM_zavYg	VLsr(z_MakZQYRR-4RR:4
9;ClM8FD8kCl

FD8kCdRL_l4.RR5
R_LcmNiK,R
RL[(_Wd1_P
W,R(RL_KuiNk_g,R
RLm6_Pd$],R
RLud_p
$,R4RLdp_k6BQd0[F_u,wA
LRR4M._zAaToLV7_,L8
LRR44c_8paOIV_pAdu_HR,
R6L4_EMYQ#dgI vC8o_v,R
RL_44PZqAdYJ#_,X]
LRR4k4_).sOX_VYX
],R(RL_tMwjYs7,R
RLud_p
w,R6RL_amOx
u,R4RLdz_MaoTAV_7LZ,c7
LRR4Mn_YdEQgv#IC_ 8q,(U
LRR4P._qdAZJ_#Yp,$E
LRR4k._).sOX_VYp,$E
LRR4P4_Fd1OsNNwX
w,RgRL_Wmwh_agN
L,R4RLjw_mWghaDCs0,R
RL1g_p_$$h7st2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L(uNiK_;gk
HRRM0bkR_L6m]P$dR;
RbHMkL0Rdp_u$R;
RbHMkL0R4kd_pd6QB_0F[Auw;R
RHkMb0(RL_tMwjYs7;R
RHkMb04RL.z_MaoTAV_7LL
8;RMRHbRk0L_4c4O8appI_V_Aud
H;RMRHbRk0L_46MQYEdIg#v8C _;vo
HRRM0bkR4L4_APqZ#dJY]_X;R
RHkMb04RL4)_ksXO.VXY_]R;
R0FkbRk0Lud_p
w;RkRF00bkR_L6mxOauR;
R0FkbRk0L_4dMTzaA7oVLc_Z7R;
R0FkbRk0L_4nMQYEdIg#v8C _Uq(;R
RFbk0kL0R4P._qdAZJ_#Yp;$E
FRRkk0b04RL.)_ksXO.VpY_$
E;RkRF00bkR4L4_1PFONdswwNX;R
RFbk0kL0Rgw_mWgha_;NL
FRRkk0b0jRr:4dn94RLjw_mWghaDCs0;R
RHkMb0jRr:.dn9gRL_$1p$s_ht
7;
IRRHRsCL_46POF1dwsNN_XwI;H$
IRRHRsCLH6_1BWO;R
RICHsRjL4_akzjcKBo;ws
IRRHRsCr:(RRRj9L_4jMhYWaIghL
p;RCRso(RrRj:R94RLcY_MWghahpIL_1Ld;R

R#N#HRoMLm6_OuaxR4=R';Lj
R
RNH##oLMR4P4_Fd1OsNNwX=wRR6L4_1PFONdswwNX_$IH;R

R#N#HRoML_44MZzad_Jv0R	p=4RLcY_MWghahpIL_1Ldr;j9
R
RNH##oLMR4mj_waWhg0DsCRR={_Lg1$p$_ths7Rrj:9Rj,gRL_$1p$s_ht47rRd:R.R9,L1g_p_$$h7strRdd:cRn9L,Rgp_1$h$_srt7n:6RR9n(,gRL_$1p$s_htn7rURR:(,j9R_Lg1$p$_ths74r(R(:RcR9,
RRRRRRRRRRRRgRL_$1p$s_ht(7r6RR:(,U9R_Lg1$p$_ths7gr(R4:R4,j9R_Lg1$p$_ths74r44RR:4944,gRL_$1p$s_ht47r4:.RR.449L,Rgp_1$h$_srt74R4d:4R4cR9,L1g_p_$$h7str644R4:R4,n9RR
RRRRRRRRRRLRRgp_1$h$_srt74R4(:4R4(R9,L1g_p_$$h7strU44R4:R4,U9R_Lg1$p$_ths74r4gRR:49.4,gRL_$1p$s_ht47r.:.RRc4.9L,Rgp_1$h$_srt74R.6:.R4nR9,L1g_p_$$h7str(4.R4:R.,U9RR
RRRRRRRRRRLRRgp_1$h$_srt74R.g:nR4jR9,L1g_p_$$h7str44nR4:Rg,.9R_Lg1$p$_ths7gr4dRR:49gd,gRL_$1p$s_ht47rg:cRRc4g9L,Rgp_1$h$_srt74Rg6:jR.(R9,L1g_p_$$h7strU.jR.:R.,j9RR
RRRRRRRRRRLRRgp_1$h$_srt7.R.4:.R.4R9,L1g_p_$$h7str...R.:R.,.9R_Lg1$p$_ths7.r.dRR:.96c,gRL_$1p$s_ht.7r6:6RRn.U9L,Rgp_1$h$_srt7.RU(:4RdUR9,L1g_p_$$h7strgd4Rd:R6,j9RR
RRRRRRRRRRLRRgp_1$h$_srt7dR64:6Rd4R9,L1g_p_$$h7str.d6Rd:R6,.9R_Lg1$p$_ths76rddRR:d96d,gRL_$1p$s_htd7r6:cRR(d69L,Rgp_1$h$_srt7dR6U:nRd4;9}
NRRD$IN#@R@5FRb#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_a48O_pIpuVA_RdH|L|R4k4_).sOX_VYXR]2LHCoMR
RRRRRH5VRR_L(Mjwts27Y
RRRRRRRRcL4_WMYhhagI_LpLRd1=4RLjY_MWghahpIL;R
RRRRRCCD#RRHV5_L6m]P$dR2
RRRRRLRR4Mc_YaWhgLhIpd_L1RR={_Ldu,p$RcL4_WMYhhagI_LpLrd1(9:4}R;
RCRRMR8
R8CM
LRR(B_mAX$pB5Ry(L2R6z_MaRta5R
RRLR3ci_mKLN5ci_mK,N2
RRRR(3L_$u1H#Dg5jL4_akzjcKBo2ws,R
RRLR3(W_[1P_dW(5L_1[W_WdP2R,
R3RRLm6_Pd$]5_L6m]P$d
2,RRRR3_Ln80Z#dLg54kd_pd6QB_0F[Auw2R,
R3RRLud_pL$5dp_u$
2,RRRR3_LnM_V#VLw54M._zAaToLV7_2L8,R
RRLR344c_8paOIV_pAdu_H45Lc8_4aIOp_ApVuH_d2R,
R3RRL_4jMQYEd_g#wL054M6_YdEQgv#IC_ 8v,o2
RRRR43L4q_PAJZd#XY_]45L4q_PAJZd#XY_]
2,RRRR34L4_sk)OV.XY]_X54L4_sk)OV.XY]_X2R,
R3RRLH6_1BWO5_L6HO1WB
2,RRRR3_LgmhwWaNg_Lg5L_Wmwh_agN,L2
RRRR43L.F_P1_Odo#lNLLL54P6_Fd1OsNNwXIw_H,$2
RRRR(3L_tMwjYs75_L(Mjwts27Y,R
RRLR3(V_M#I_d$45Ldz_MaoTAV_7LZ2c7,R
RRLR3(z_MaI_d$45LnY_MEgQd#CIv q8_(,U2
RRRR43L.q_PAJZd#pY_$LE54P._qdAZJ_#Yp2$E,R
RRLR34M4_zdaZJ0v_	Lp54M4_zdaZJ0v_	,p2
RRRR43L.)_ksXO.VpY_$LE54k._).sOX_VYp2$E2
;
R(RL_wuVxYshR_LcuxVwRR5
R3RRLmc_i5KNLmc_i2KN,R
RRLR36F_P15OdL_46POF1dwsNN_XwI2H$,R
RRLR361_HW5OBLH6_1BWO2R,
R3RRL1g_p_$$h7st5_Lg1$p$_ths7
2,RRRR3_L(uH1$D5g#L_4jkjzaKoBcw,s2
RRRR(3L_1[W_WdP5_L([_W1d2PW,R
RRLR3(i_uKgN_k(5L_KuiNk_g2R,
R3RRLud_pL$5dp_u$
2,RRRR3_L6m]P$d65L_$mP],d2
RRRR43LjY_MWghahpIL5jL4_WMYhhagI2Lp,R
RRLR3dp_uwd5L_wup2
2;
8CMlkF8D
C
lkF8DDCR84HO_
j5RBRqpAi_zR1,
]RRq)77_,1jRR
R]7q7)4_1,RR
Rz]A)_1a1Rj,
]RRA1z)a4_1,RR
R)]um1a_j
,RRuR])_ma1R4,
]RR)a7qqj_1,RR
R ])q_7Ym_za1Rj,
]RR)7 qYz_ma4_1,RR
R ])11u_j
,RR)R] _1u1R4,
]RR1_ p1Rj,
]RR1_ p1R4,
]RR1 QZ_,1jRR
R]Z1Q 4_1,RR
R)]aq_h11Rj,
]RRah)q14_1,RR
R7]Wq_aq1Rj,
]RRWa7qq4_1,RR
R)]WQ_a 1Rj,
]RRWa)Q 4_1,RR
R8N8sRj,
NRR848s,RR
RLO#j
,RR#ROLR4,
8RRH,MjRR
R84HM,RR
Rk8F0Rj,
8RRF4k0,RR
R M)1, aRR
RFjCL,RR
RLFC4
,RRsRILRj,
IRRs,L4RR
RB,piRR
RkHbDMd	_2
;
HkMb0BRqpAi_z
1;HkMb0dRr49:jR7]q71)_jH;
M0bkR4rd:Rj9]7q7)4_1;M
HbRk0rj.:9AR]za)1_;1j
bHMkr0R.9:jRz]A)_1a1
4;HkMb0dRr:Rj9]mu)aj_1;M
HbRk0rjd:9uR])_ma1
4;HkMb0dRr49:jR7])q_aq1
j;HkMb0)R] Yq7_amz_;1j
bHMk]0R)7 qYz_ma4_1;M
HbRk0rj4:9)R] _1u1
j;HkMb04Rr:Rj9]1) u4_1;M
HbRk0]p1 _;1j
bHMk]0R1_ p1
4;HkMb0.Rr:Rj9]Z1Q j_1;M
HbRk0rj.:91R]Q_Z 1
4;HkMb04Rr:Rj9]qa)h11_jH;
M0bkR:r4j]9Rah)q14_1;M
HbRk0r:d4j]9RWa7qqj_1;M
HbRk0r:d4j]9RWa7qq4_1;M
HbRk0]QW)a1 _jH;
M0bkR)]WQ_a 1
4;HkMb04Rr.9:jR8N8s
j;HkMb04Rr.9:jR8N8s
4;HkMb0#ROL
j;HkMb0#ROL
4;HkMb0dRr49:jRM8HjH;
M0bkR4rd:Rj984HM;M
HbRk0r:d4j89RFjk0;M
HbRk0r:d4j89RF4k0;M
HbRk0M1)  
a;HkMb0CRFL
j;HkMb0CRFL
4;HkMb0dRr:Rj9IjsL;M
HbRk0rjd:9sRIL
4;HkMb0pRBiF;
kk0b0jRr:.dn9bRkD	HM_
d;
NRR#o#HMbRkD	HM_jdr9RR=qiBp_1Az;R
RNH##okMRbMDH	r_d4.:d9RR=]7q7)j_1;R
RNH##okMRbMDH	r_ddnd:c=9RR7]q71)_4R;
R#N#HRoMkHbDMd	_r:n6nR(9=AR]za)1_;1j
NRR#o#HMbRkD	HM_ndrUj:(9RR=])Az11a_4R;
R#N#HRoMkHbDMd	_r:(4(Rc9=uR])_ma1
j;R#RN#MHoRDkbH_M	d6r(:9(UR]=Rua)m_;14
NRR#o#HMbRkD	HM_(drg4:4j=9RR7])q_aq1
j;R#RN#MHoRDkbH_M	d4r44=9RR ])q_7Ym_za1
j;R#RN#MHoRDkbH_M	d4r4.=9RR ])q_7Ym_za1
4;R#RN#MHoRDkbH_M	d4r4d4:4c=9RR ])11u_jR;
R#N#HRoMkHbDMd	_r644:n449RR=]1) u4_1;R
RNH##okMRbMDH	r_d494(R]=R1_ p1
j;R#RN#MHoRDkbH_M	d4r4U=9RR ]1p4_1;R
RNH##okMRbMDH	r_d4:4g49.4R]=R1 QZ_;1j
NRR#o#HMbRkD	HM_4dr.4.:.Rc9=1R]Q_Z 1
4;R#RN#MHoRDkbH_M	d.r46.:4n=9RR)]aq_h11
j;R#RN#MHoRDkbH_M	d.r4(.:4U=9RR)]aq_h11
4;R#RN#MHoRDkbH_M	d.r4gn:4j=9RR7]Wq_aq1
j;R#RN#MHoRDkbH_M	dnr44g:4.=9RR7]Wq_aq1
4;R#RN#MHoRDkbH_M	dgr4d=9RR)]WQ_a 1
j;R#RN#MHoRDkbH_M	dgr4c=9RR)]WQ_a 1
4;R#RN#MHoRDkbH_M	dgr46j:.(=9RR8N8s
j;R#RN#MHoRDkbH_M	djr.U.:.j=9RR8N8s
4;R#RN#MHoRDkbH_M	d.r.4=9RRLO#jR;
R#N#HRoMkHbDMd	_r...9RR=O4#L;R
RNH##okMRbMDH	r_d.:.d.96cR8=RH;Mj
NRR#o#HMbRkD	HM_.dr6.6:URn9=HR8M
4;R#RN#MHoRDkbH_M	dUr.(4:dU=9RRk8F0
j;R#RN#MHoRDkbH_M	d4rdg6:dj=9RRk8F0
4;R#RN#MHoRDkbH_M	d6rd4=9RR M)1; a
NRR#o#HMbRkD	HM_ddr6R.9=CRFL
j;R#RN#MHoRDkbH_M	d6rdd=9RRLFC4R;
R#N#HRoMkHbDMd	_rcd6:(d69RR=IjsL;R
RNH##okMRbMDH	r_dd:6Ud9n4RI=Rs;L4
NRR#o#HMbRkD	HM_ddrnR.9=pRBiC;
MF8l8CkD
F
l8CkDROHHC5_j
ORRF.llHCHO_MDH	H_HOjC_,RR
ROHHCF.OlDl_H_M	HCHO_Rj,
lRR8_HOD	HM2*R/RM#$0#ECH##R$EM_H=Cs"sEN8*"R/
R;RMRHbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
FRRkk0b0jRr:Rj9HCHO.lOFlH_DMH	_H_OCjR;
RbHMkr0Rjn:d.l9R8_HOD	HM;R

RsIHCcRL_KmiNR;
RsIHC(RL_LwYwwA_,(RL_LwYwtA_;R
RICHsR_Lcuwp$;R
RICHsR_LUuH1$AtoY,URL_$u1HY.XtL,R4mj_waWhgw	E0L,R(1_u$IHd$L,Rg1_u$XH.v;GV
IRRHRsCLmg_waWhgVvG,URL_W1FtYVWYL,RUw_mWghaY
t;RHRIsrCRd:n4jL9R4mj_waWhg0DsCR;
RosCR:rjd9n.RHl8OH_DMs	_C/oR*$R#MC0E#RH##_$Mb#sCCCsP=*4R/
;
R#RN#MHoR_L(wwYLAR_t='R4L
4;R#RN#MHoR_L(wwYLAR_w='R4L
j;R#RN#MHoR_LcmNiKRl=R8_HOD	HMr.dn9R;
RINDNR$#@L@5(Y_wL_wAwsRFRHl8OH_DMR	2LHCoMRR:lO8H_MDH	C_#0
kbRRRRlO8H_MDH	C_sonrd.<9R=(RL_LwYwwA_;R
RC
M8
NRRD$IN#@R@5#bFCC8oR_LcmNiK2CRLoRHM:8RlHDO_H_M	DON0ER
RR8RlHDO_H_M	srCojRR:j<9R=8RlHDO_HrM	jRR:j
9;RRRRlO8H_MDH	C_soRr4:.Rd9=R<RHl8OH_DM4	rRd:R.
9;RRRRlO8H_MDH	C_sodrdRn:Rc<9R=8RlHDO_HrM	d:dRR9nc;R
RR8RlHDO_H_M	srCon:6RR9n(RR<=lO8H_MDH	6rnRn:R(
9;RRRRlO8H_MDH	C_soUrnR(:Rj<9R=8RlHDO_HrM	n:URR9(j;R
RR8RlHDO_H_M	srCo(:4RR9(cRR<=lO8H_MDH	4r(R(:Rc
9;RRRRlO8H_MDH	C_so6r(R(:RU<9R=8RlHDO_HrM	(:6RR9(U;R
RR8RlHDO_H_M	srCo(:gRRj449=R<RHl8OH_DM(	rgRR:494j;R
RR8RlHDO_H_M	srCo4R44:4R44<9R=8RlHDO_HrM	4R44:4R44
9;RRRRlO8H_MDH	C_so4r4.RR:494.RR<=lO8H_MDH	4r4.RR:494.;R
RR8RlHDO_H_M	srCo4R4d:4R4c<9R=8RlHDO_HrM	4R4d:4R4c
9;RRRRlO8H_MDH	C_so4r46RR:494nRR<=lO8H_MDH	4r46RR:494n;R
RR8RlHDO_H_M	srCo4R4(:4R4(<9R=8RlHDO_HrM	4R4(:4R4(
9;RRRRlO8H_MDH	C_so4r4URR:494URR<=lO8H_MDH	4r4URR:494U;R
RR8RlHDO_H_M	srCo4R4g:.R44<9R=8RlHDO_HrM	4R4g:.R44
9;RRRRlO8H_MDH	C_so.r4.RR:49.cRR<=lO8H_MDH	.r4.RR:49.c;R
RR8RlHDO_H_M	srCo4R.6:.R4n<9R=8RlHDO_HrM	4R.6:.R4n
9;RRRRlO8H_MDH	C_so.r4(RR:49.URR<=lO8H_MDH	.r4(RR:49.U;R
RR8RlHDO_H_M	srCo4R.g:nR4j<9R=8RlHDO_HrM	4R.g:nR4j
9;RRRRlO8H_MDH	C_sonr44RR:49g.RR<=lO8H_MDH	nr44RR:49g.;R
RR8RlHDO_H_M	srCo4Rgd:gR4d<9R=8RlHDO_HrM	4Rgd:gR4d
9;RRRRlO8H_MDH	C_sogr4cRR:49gcRR<=lO8H_MDH	gr4cRR:49gc;R
RR8RlHDO_H_M	srCo4Rg6:jR.(<9R=8RlHDO_HrM	4Rg6:jR.(
9;RRRRlO8H_MDH	C_sojr.URR:.9.jRR<=lO8H_MDH	jr.URR:.9.j;R
RR8RlHDO_H_M	srCo.R.4:.R.4<9R=8RlHDO_HrM	.R.4:.R.4
9;RRRRlO8H_MDH	C_so.r..RR:.9..RR<=lO8H_MDH	.r..RR:.9..;R
RR8RlHDO_H_M	srCo.R.d:6R.c<9R=8RlHDO_HrM	.R.d:6R.c
9;RRRRlO8H_MDH	C_so6r.6RR:.9UnRR<=lO8H_MDH	6r.6RR:.9Un;R
RR8RlHDO_H_M	srCo.RU(:4RdU<9R=8RlHDO_HrM	.RU(:4RdU
9;RRRRlO8H_MDH	C_so4rdgRR:d96jRR<=lO8H_MDH	4rdgRR:d96j;R
RR8RlHDO_H_M	srCodR64:6Rd4<9R=8RlHDO_HrM	dR64:6Rd4
9;RRRRlO8H_MDH	C_so6rd.RR:d96.RR<=lO8H_MDH	6rd.RR:d96.;R
RR8RlHDO_H_M	srCodR6d:6Rdd<9R=8RlHDO_HrM	dR6d:6Rdd
9;RRRRlO8H_MDH	C_so6rdcRR:d96(RR<=lO8H_MDH	6rdcRR:d96(;R
RR8RlHDO_H_M	srCodR6U:nRd4<9R=8RlHDO_HrM	dR6U:nRd4
9;RMRC8R

R_Ld4R.lL4U_.Ql_wRpY5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR43Ldp_k6BQd0[F_uRwAROR5F.llHCHO_MDH	H_HOjC_r2n9,R
RRLR3(w_Mt7jsYRRR5lOFlH.HODC_H_M	HCHO_(jr9
2,RRRR3_L(uNiK_RgkRLR5U1_u$oHAY,t2
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pR$RRRRRRc5L_$upw
2,RRRR3_LduRpwRRRRRLR5(1_u$IHd$
2,RRRR3_L6mxOauRRRRLR5g1_u$XH.v2GV,R
RRLR34Md_zAaToLV7_7ZcR45Ldz_MaoTAV_7LZ2c7,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Mn_YdEQgv#IC_ 8qR(U5nL4_EMYQ#dgI vC8(_qU
2,RRRR36L4_EMYQ#dgI vC8o_vR45L6Y_MEgQd#CIv v8_o
2,RRRR3.L4_APqZ#dJY$_pELR54P._qdAZJ_#Yp2$E,R
RRLR34P4_qdAZJ_#YX5]RL_44PZqAdYJ#_2X],R
RRLR34k._).sOX_VYpR$E5.L4_sk)OV.XY$_pE
2,RRRR34L4_sk)OV.XY]_XR45L4)_ksXO.VXY_]
2,RRRR34L4_1PFONdswwNXRU5L_W1FtYVWY
2,RRRR3_LgmhwWaNg_LRRR5_LUmhwWatgY2R,
R3RRL_4jmhwWasgD0RCR5jL4_WmwhDags20C,R
RRLR3gp_1$h$_sRt7RlR58_HOD	HM_osC2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=R;*/
R
RLkd_iLsRUi_ksw_Qp5YR
RRRR43L4)_ksgO_kAsXL5RROlFl.OHHCH_DMH	_H_OCj9rc2R,
R3RRL_4dMwPlpG_V.ksLTOR5F.llHCHO_MDH	H_HOjC_rdj:9
2,RRRR3_LduRp$RF5OlHl.H_OCD	HM_OHHCr_j6,92
RRRRd3L_wupRHR5H.OCOlFl_MDH	H_HOjC_r2j9,R
RRLR3(p_u$D_uvLR5cp_u$,w2
RRRR43L.1_u$oHAV_7LL58RLuU_1A$Ho2Yt,R
RRLR34u._1.$HXwVY_RL85_LUuH1$.tXY2R,
R3RRL_4cmhwWaEg	W_J]d5HRL_4jmhwWaEg	w,02
RRRR43Ld1_u$oHAV_7LZRc75_L(uH1$d2I$,R
RRLR34ud_1.$HXwVY_7ZcRg5L_$u1Hv.XG,V2
RRRR43L6w_mWgha	JEW]g_)	LR5gw_mWghav2GV,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Md_zAaToLV7_7ZcRLR54Md_zAaToLV7_7Zc2R,
R3RRL_46MQYEdIg#v8C _Rvo56L4_EMYQ#dgI vC8o_v2R,
R3RRL_4nMQYEdIg#v8C _Uq(RLR54Mn_YdEQgv#IC_ 8q2(U,R
RRLR34P4_qdAZJ_#YXR]R54L4_APqZ#dJY]_X2R,
R3RRL_4.PZqAdYJ#_Ep$RLR54P._qdAZJ_#Yp2$E,R
RRLR34k4_).sOX_VYXR]R54L4_sk)OV.XY]_X2R,
R3RRL_4.kO)s.YXV_Ep$RLR54k._).sOX_VYp2$E
2RRRR/*#0$MEHC##$R#MF_MbMskCR=4*
/;R(RL_Wmwh#agR_Ld1RFW5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR(3L_KuiNk_gR5RRL_4jmhwWaEg	w,02
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pRwRRRRRRg5L_WmwhvagG,V2
RRRR63L_1PFORdRR5RRL1U_FVWtW2YY,R
RRLR3(w_mWghapRRR5jL4_WmwhDags20C,R
RRLR3gw_mWgha_RNL5_LUmhwWatgY2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=RR*/;M
C88lFk
DC
