
// ===================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology      
// -------------------------------------------------------------------
// Version and Release information:
// 
// File Name           : SIN_ROM_FPGA.v
// File Revision       : 0.1
// -----------------------------------------------------------------------
// Purpose            : This module is sin rom table in 
//                      video Encoder
// =======================================================================

module SIN_ROM_FPGA (
   Q,
   CLK,
   CEN,
   A
);
    output [8:0] Q;
    input CLK;
    input CEN;
    input [7:0] A;

    reg [8:0] Q;

always @(posedge CLK) begin
    if(!CEN) begin
    case (A) //sin table
        8'd0: Q = 9'h1;
        8'd1: Q = 9'h2;
        8'd2: Q = 9'h4;
        8'd3: Q = 9'h5;
        8'd4: Q = 9'h7;
        8'd5: Q = 9'h9;
        8'd6: Q = 9'ha;
        8'd7: Q = 9'hc;
        8'd8: Q = 9'hd;
        8'd9: Q = 9'hf;
        8'd10: Q = 9'h10;
        8'd11: Q = 9'h12;
        8'd12: Q = 9'h14;
        8'd13: Q = 9'h15;
        8'd14: Q = 9'h17;
        8'd15: Q = 9'h18;
        8'd16: Q = 9'h1a;
        8'd17: Q = 9'h1b;
        8'd18: Q = 9'h1d;
        8'd19: Q = 9'h1f;
        8'd20: Q = 9'h20;
        8'd21: Q = 9'h22;
        8'd22: Q = 9'h23;
        8'd23: Q = 9'h25;
        8'd24: Q = 9'h26;
        8'd25: Q = 9'h28;
        8'd26: Q = 9'h2a;
        8'd27: Q = 9'h2b;
        8'd28: Q = 9'h2d;
        8'd29: Q = 9'h2e;
        8'd30: Q = 9'h30;
        8'd31: Q = 9'h31;
        8'd32: Q = 9'h33;
        8'd33: Q = 9'h35;
        8'd34: Q = 9'h36;
        8'd35: Q = 9'h38;
        8'd36: Q = 9'h39;
        8'd37: Q = 9'h3b;
        8'd38: Q = 9'h3c;
        8'd39: Q = 9'h3e;
        8'd40: Q = 9'h3f;
        8'd41: Q = 9'h41;
        8'd42: Q = 9'h43;
        8'd43: Q = 9'h44;
        8'd44: Q = 9'h46;
        8'd45: Q = 9'h47;
        8'd46: Q = 9'h49;
        8'd47: Q = 9'h4a;
        8'd48: Q = 9'h4c;
        8'd49: Q = 9'h4d;
        8'd50: Q = 9'h4f;
        8'd51: Q = 9'h51;
        8'd52: Q = 9'h52;
        8'd53: Q = 9'h54;
        8'd54: Q = 9'h55;
        8'd55: Q = 9'h57;
        8'd56: Q = 9'h58;
        8'd57: Q = 9'h5a;
        8'd58: Q = 9'h5b;
        8'd59: Q = 9'h5d;
        8'd60: Q = 9'h5e;
        8'd61: Q = 9'h60;
        8'd62: Q = 9'h62;
        8'd63: Q = 9'h63;
        8'd64: Q = 9'h65;
        8'd65: Q = 9'h66;
        8'd66: Q = 9'h68;
        8'd67: Q = 9'h69;
        8'd68: Q = 9'h6b;
        8'd69: Q = 9'h6c;
        8'd70: Q = 9'h6e;
        8'd71: Q = 9'h6f;
        8'd72: Q = 9'h71;
        8'd73: Q = 9'h72;
        8'd74: Q = 9'h74;
        8'd75: Q = 9'h76;
        8'd76: Q = 9'h77;
        8'd77: Q = 9'h79;
        8'd78: Q = 9'h7a;
        8'd79: Q = 9'h7c;
        8'd80: Q = 9'h7d;
        8'd81: Q = 9'h7f;
        8'd82: Q = 9'h80;
        8'd83: Q = 9'h82;
        8'd84: Q = 9'h83;
        8'd85: Q = 9'h85;
        8'd86: Q = 9'h86;
        8'd87: Q = 9'h88;
        8'd88: Q = 9'h89;
        8'd89: Q = 9'h8b;
        8'd90: Q = 9'h8c;
        8'd91: Q = 9'h8e;
        8'd92: Q = 9'h8f;
        8'd93: Q = 9'h91;
        8'd94: Q = 9'h92;
        8'd95: Q = 9'h94;
        8'd96: Q = 9'h95;
        8'd97: Q = 9'h97;
        8'd98: Q = 9'h98;
        8'd99: Q = 9'h9a;
        8'd100: Q = 9'h9b;
        8'd101: Q = 9'h9d;
        8'd102: Q = 9'h9e;
        8'd103: Q = 9'ha0;
        8'd104: Q = 9'ha1;
        8'd105: Q = 9'ha3;
        8'd106: Q = 9'ha4;
        8'd107: Q = 9'ha6;
        8'd108: Q = 9'ha7;
        8'd109: Q = 9'ha9;
        8'd110: Q = 9'haa;
        8'd111: Q = 9'hac;
        8'd112: Q = 9'had;
        8'd113: Q = 9'haf;
        8'd114: Q = 9'hb0;
        8'd115: Q = 9'hb2;
        8'd116: Q = 9'hb3;
        8'd117: Q = 9'hb5;
        8'd118: Q = 9'hb6;
        8'd119: Q = 9'hb8;
        8'd120: Q = 9'hb9;
        8'd121: Q = 9'hba;
        8'd122: Q = 9'hbc;
        8'd123: Q = 9'hbd;
        8'd124: Q = 9'hbf;
        8'd125: Q = 9'hc0;
        8'd126: Q = 9'hc2;
        8'd127: Q = 9'hc3;
        8'd128: Q = 9'hc5;
        8'd129: Q = 9'hc6;
        8'd130: Q = 9'hc8;
        8'd131: Q = 9'hc9;
        8'd132: Q = 9'hca;
        8'd133: Q = 9'hcc;
        8'd134: Q = 9'hcd;
        8'd135: Q = 9'hcf;
        8'd136: Q = 9'hd0;
        8'd137: Q = 9'hd2;
        8'd138: Q = 9'hd3;
        8'd139: Q = 9'hd4;
        8'd140: Q = 9'hd6;
        8'd141: Q = 9'hd7;
        8'd142: Q = 9'hd9;
        8'd143: Q = 9'hda;
        8'd144: Q = 9'hdc;
        8'd145: Q = 9'hdd;
        8'd146: Q = 9'hde;
        8'd147: Q = 9'he0;
        8'd148: Q = 9'he1;
        8'd149: Q = 9'he3;
        8'd150: Q = 9'he4;
        8'd151: Q = 9'he5;
        8'd152: Q = 9'he7;
        8'd153: Q = 9'he8;
        8'd154: Q = 9'hea;
        8'd155: Q = 9'heb;
        8'd156: Q = 9'hec;
        8'd157: Q = 9'hee;
        8'd158: Q = 9'hef;
        8'd159: Q = 9'hf1;
        8'd160: Q = 9'hf2;
        8'd161: Q = 9'hf3;
        8'd162: Q = 9'hf5;
        8'd163: Q = 9'hf6;
        8'd164: Q = 9'hf8;
        8'd165: Q = 9'hf9;
        8'd166: Q = 9'hfa;
        8'd167: Q = 9'hfc;
        8'd168: Q = 9'hfd;
        8'd169: Q = 9'hfe;
        8'd170: Q = 9'h100;
        8'd171: Q = 9'h101;
        8'd172: Q = 9'h102;
        8'd173: Q = 9'h104;
        8'd174: Q = 9'h105;
        8'd175: Q = 9'h107;
        8'd176: Q = 9'h108;
        8'd177: Q = 9'h109;
        8'd178: Q = 9'h10b;
        8'd179: Q = 9'h10c;
        8'd180: Q = 9'h10d;
        8'd181: Q = 9'h10f;
        8'd182: Q = 9'h110;
        8'd183: Q = 9'h111;
        8'd184: Q = 9'h113;
        8'd185: Q = 9'h114;
        8'd186: Q = 9'h115;
        8'd187: Q = 9'h117;
        8'd188: Q = 9'h118;
        8'd189: Q = 9'h119;
        8'd190: Q = 9'h11a;
        8'd191: Q = 9'h11c;
        8'd192: Q = 9'h11d;
        8'd193: Q = 9'h11e;
        8'd194: Q = 9'h120;
        8'd195: Q = 9'h121;
        8'd196: Q = 9'h122;
        8'd197: Q = 9'h124;
        8'd198: Q = 9'h125;
        8'd199: Q = 9'h126;
        8'd200: Q = 9'h127;
        8'd201: Q = 9'h129;
        8'd202: Q = 9'h12a;
        8'd203: Q = 9'h12b;
        8'd204: Q = 9'h12d;
        8'd205: Q = 9'h12e;
        8'd206: Q = 9'h12f;
        8'd207: Q = 9'h130;
        8'd208: Q = 9'h132;
        8'd209: Q = 9'h133;
        8'd210: Q = 9'h134;
        8'd211: Q = 9'h135;
        8'd212: Q = 9'h137;
        8'd213: Q = 9'h138;
        8'd214: Q = 9'h139;
        8'd215: Q = 9'h13a;
        8'd216: Q = 9'h13c;
        8'd217: Q = 9'h13d;
        8'd218: Q = 9'h13e;
        8'd219: Q = 9'h13f;
        8'd220: Q = 9'h141;
        8'd221: Q = 9'h142;
        8'd222: Q = 9'h143;
        8'd223: Q = 9'h144;
        8'd224: Q = 9'h145;
        8'd225: Q = 9'h147;
        8'd226: Q = 9'h148;
        8'd227: Q = 9'h149;
        8'd228: Q = 9'h14a;
        8'd229: Q = 9'h14b;
        8'd230: Q = 9'h14d;
        8'd231: Q = 9'h14e;
        8'd232: Q = 9'h14f;
        8'd233: Q = 9'h150;
        8'd234: Q = 9'h151;
        8'd235: Q = 9'h153;
        8'd236: Q = 9'h154;
        8'd237: Q = 9'h155;
        8'd238: Q = 9'h156;
        8'd239: Q = 9'h157;
        8'd240: Q = 9'h158;
        8'd241: Q = 9'h15a;
        8'd242: Q = 9'h15b;
        8'd243: Q = 9'h15c;
        8'd244: Q = 9'h15d;
        8'd245: Q = 9'h15e;
        8'd246: Q = 9'h15f;
        8'd247: Q = 9'h160;
        8'd248: Q = 9'h162;
        8'd249: Q = 9'h163;
        8'd250: Q = 9'h164;
        8'd251: Q = 9'h165;
        8'd252: Q = 9'h166;
        8'd253: Q = 9'h167;
        8'd254: Q = 9'h168;
        8'd255: Q = 9'h169;
    endcase
    end
end

endmodule
