// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module ab_masb(
big_endian,
clk,
m_haddr,
m_hbar,
m_hburst,
m_hrdata,
m_hready,
m_hresp,
m_hsize,
m_htrans,
m_hwdata,
m_hwrite,
m_hgrant,
m_hbusreq,
m_hlock,
m_hprot,

cpu_adr,
db6_wea,
pci_bar,
tack_b,
trdreq_b,
trd_abort,
trd_addra,
trd_be_b,
trd_dina,
trd_dlysize,
trd_retry,
twrreq_b,
twr_addrb,
twr_be_b,
twr_doutb,
twr_dword_empty,
twr_dword_full,
valid_bit,

reset_b,
swap
);
input big_endian;
input clk;
output[31:0] m_haddr;
output[6:0] m_hbar;
output[2:0] m_hburst;
input[31:0] m_hrdata;
input m_hready;
input[1:0] m_hresp;
output[2:0] m_hsize;
output[1:0] m_htrans;
output[31:0] m_hwdata;
output m_hwrite;
input m_hgrant;
output m_hbusreq;
output m_hlock;
output[3:0] m_hprot;
input[31:0] cpu_adr;
output db6_wea;
input[6:0] pci_bar;
output tack_b;
input trdreq_b;
output trd_abort;
output[3:0] trd_addra;
input[3:0] trd_be_b;
output[31:0] trd_dina;
input[4:0] trd_dlysize;
output trd_retry;
input twrreq_b;
output[3:0] twr_addrb;
input[63:0] twr_be_b;
input[31:0] twr_doutb;
input[15:0] twr_dword_empty;
input[15:0] twr_dword_full;
output[15:0] valid_bit;
input reset_b;
input swap;
wire[4:0] IO01ll10IOO01Il;wire OOIl1IlI0OO01Il;wire[6:0] O1lIOIlO01O01Il;wire IOIl0OIl01O01Il;wire IlI0OIlO01OOIl1;wire O01IlOIl01OOIl1;
wire lIO10O1lIOOOIl1;wire l0IO1O01IllO10I;wire[3:0] I01lOOlI1OlO10I;wire[4:0] IlO01l0IO1lO10I;wire OOIl1OlI1OO1lIO;wire[31:0] O1lIOl0IO1O1lIO;
wire IOIl0IOIl0O1lIO;wire IlI0OlIO10l0IO1;wire[3:0] O01IlIIO0ll0IO1;wire lO10II01lOl0IO1;wire[4:0] l0IO1IIO0lIIO0l;wire I1lO0I01lOIIO0l;
wire IlO01OlI01IIO0l;wire[4:0] OOl1II1lO0I1lO0;wire O1lIOOI01lI1lO0;wire[3:0] IOIl0OOl1II1lO0;wire OI01llO10II1lO0;wire O01IlOOl1IIlI0O;
wire lO10IlO10IIlI0O;wire l10IOIO0lIIlI0O;wire[4:0] I1lO0OIl01IO01l;wire IlO01O1lIOIO01l;wire OOIl1l10IOIO01l;wire O1lIOO1lIOOlI01;
wire IIO0ll10IOOlI01;wire[4:0] OI01lIlI0OOlI01;wire[15:0] OlI01l10IOOOl1I;wire[3:0] lO10IIlI0OOOl1I;wire l0IO1IlO01OOl1I;wire[4:0] I1lO0IOIl0OIl01;
wire IO01lIO01lOIl01;wire[2:0] OOIl1O01IlOIl01;wire OlI1OIO01lOlI1O;wire IIO0lO01IlOlI1O;wire OI01lOlI1OOlI1O;wire O01Ill0IO1OlI1O;
wire OlI01OlI01lIO10;wire lO10IOOIl1lIO10;wire l0IO1lIO10lIO10;wire[3:0] I01lOIIO0llIO10;wire IO01llIO10IO0lI;wire OOIl1IIO0lIO0lI;
wire O1lIOI01lOIO0lI;wire IIO0lIO0lIl10IO;wire IlI0OI1lO0l10IO;wire[4:0] O01IlOI01ll10IO;wire[15:0] OIl01I1lO0IOIl0;wire l0IO1OI01lIOIl0;
wire[29:0] I01lOOOl1IIOIl0;wire[4:0] IO01lIlI0OI01lO;wire OOl1IIlO01I01lO;wire[2:0] O1lIOOIl01I01lO;wire IO0lIIlO01OI01l;wire IlI0OOIl01OI01l;
wire[31:0] O01IlO1lIOOI01l;wire lO10Il10IOOI01l;wire[4:0] OIl01O01IlIlO01;wire l0IO1OlI1OIlO01;wire I1lO0l0IO1IlO01;wire IlO01IOIl0IlO01;
wire OOl1Il0IO1O01Il;wire O1lIOIOIl0O01Il;wire IIO0lIO01lO01Il;wire[4:0] IlI0OIOIl0OOIl1;wire OlI01IO01lOOIl1;wire lO10IO01IlOOIl1;
wire lIO10I01lOlO10I;wire I1lO0OlI01lO10I;wire[29:0] IlO01OOIl1lO10I;wire[4:0] OOl1IOlI01O1lIO;wire O1lIOOOIl1O1lIO;wire[2:0] IIO0llIO10O1lIO;
wire[4:0] IlI0OOOl1Il0IO1;wire OlI01lO10Il0IO1;wire lO10IIO0lIl0IO1;wire l0IO1I1lO0l0IO1;wire lIO10lO10IIIO0l;wire[31:0] I1lO0IO0lIIIO0l;
wire[3:0] IO01lI1lO0IIO0l;wire[6:0] OOIl1OI01lIIO0l;wire OlI1Ol10IOI1lO0;wire IIO0lIlI0OI1lO0;wire IlI0OIlO01I1lO0;wire[6:0] OlI01IlI0OIlI0O;
wire OIl01IlO01IlI0O;wire l0IO1OIl01IlI0O;wire l10IOIO01lIO01l;wire IO01lO01IlIO01l;wire OOIl1OlI1OIO01l;wire[4:0] OlI1OO01IlOlI01;
wire[3:0] IIO0lOlI1OOlI01;wire IlI0Ol0IO1OlI01;wire[4:0] OlI01OlI1OOOl1I;wire OIl01l0IO1OOl1I;wire[1:0] l0IO1IOIl0OOl1I;wire I1lO0IO01lOOl1I;
wire l10IOlIO10OIl01;wire[31:0] IO01lIIO0lOIl01;wire[4:0] OOl1II01lOOIl01;wire O1lIOOlI01OIl01;wire[5:2] IO0lII01lOOlI1O;wire IlI0OOlI01OlI1O;
wire O01IlOOIl1OlI1O;wire[15:0] OIl01OI01llIO10;wire l0IO1OOl1IlIO10;wire[4:0] I1lO0lO10IlIO10;wire IO01lOOl1IIO0lI;wire OOl1IlO10IIO0lI;
wire O1lIOIO0lIIO0lI;wire[4:0] IO0lIOIl01l10IO;wire IlI0OO1lIOl10IO;wire[2:0] OlI01l10IOl10IO;wire[4:0] OIl01O1lIOIOIl0;wire lIO10l10IOIOIl0;
wire I1lO0IlI0OIOIl0;wire IO01lIlO01IOIl0;wire I01lOl0IO1I01lO;wire[63:0] OOl1IIOIl0I01lO;wire[6:0] OlI1OIO01lI01lO;wire IIO0lO01IlI01lO;
wire IOIl0IO01lOI01l;wire[8:0] OlI01O01IlOI01l;wire lO10IOlI1OOI01l;wire lIO10OlI01IlO01;wire[31:0] I1lO0OOIl1IlO01;wire[4:0] IO01llIO10IlO01;
wire OOl1IOOIl1O01Il;wire[31:0] OlI1OlIO10O01Il;wire IIO0lIIO0lO01Il;wire[3:0] IOIl0lIO10OOIl1;wire[4:0] OlI01IIO0lOOIl1;wire[2:0] OIl01I01lOOOIl1;
wire[4:0] lIO10IO0lIlO10I;wire l10IOI1lO0lO10I;wire IO01lOI01llO10I;wire[4:0] IlO01I1lO0O1lIO;wire OlI1OOI01lO1lIO;wire[3:0] IIO0lOOl1IO1lIO;
wire IlI0OlO10IO1lIO;wire OI01lIlO01l0IO1;wire OIl01OIl01l0IO1;wire l0IO1O1lIOl0IO1;wire l10IOOIl01IIO0l;wire IO01lO1lIOIIO0l;wire[4:0] OOl1Il10IOIIO0l;
wire OlI1OOlI1OI1lO0;wire[6:0] IO0lIl0IO1I1lO0;wire IlI0OIOIl0I1lO0;wire OI01ll0IO1IlI0O;wire[3:0] OIl01IOIl0IlI0O;wire lIO10IO01lIlI0O;
wire[4:0] l10IOIIO0lIO01l;wire I01lOI01lOIO01l;wire OOl1IOlI01IO01l;wire OOIl1I01lOOlI01;wire IO0lIOlI01OlI01;wire IlI0OOOIl1OlI01;
wire OlI01lIO10OlI01;wire OIl01OOIl1OOl1I;wire lIO10lIO10OOl1I;wire[31:0] I1lO0IIO0lOOl1I;wire[4:0] I01lOlO10IOIl01;wire[31:0] OOl1IIO0lIOIl01;
wire OlI1OI1lO0OIl01;wire IO0lIIO0lIOlI1O;wire[3:0] IOIl0I1lO0OlI1O;wire[4:0] OlI01OI01lOlI1O;wire[15:0] O01Ill10IOlIO10;wire lIO10IlI0OlIO10;
wire l10IOIlO01lIO10;wire[4:0] I01lOIlI0OIO0lI;wire IlO01IlO01IO0lI;wire[2:0] OlI1OOIl01IO0lI;wire[3:0] O1lIOIO01ll10IO;wire IOIl0O01Ill10IO;
wire OlI01OlI1Ol10IO;wire OIl01l0IO1l10IO;wire[4:0] O01IlO01IlIOIl0;wire lIO10OlI1OIOIl0;wire l10IOl0IO1IOIl0;wire IO01lIOIl0IOIl0;
wire IlO01lIO10I01lO;wire OlI1OIIO0lI01lO;wire IO0lII01lOI01lO;wire[63:0] IOIl0IIO0lOI01l;wire[31:0] OI01lI01lOOI01l;wire OIl01OlI01OI01l;
wire[15:0] lO10II1lO0IlO01;wire l10IOOI01lIlO01;wire[29:0] IO01lOOl1IIlO01;wire[4:0] IlO01OI01lO01Il;wire OlI1OOOl1IO01Il;wire[2:0] IO0lIlO10IO01Il;
wire IOIl0OOl1IOOIl1;wire OI01llO10IOOIl1;wire OIl01IO0lIOOIl1;wire lIO10I1lO0OOIl1;wire[15:0] lO10IOIl01lO10I;wire[31:0] l10IOO1lIOlO10I;
wire I01lOl10IOlO10I;wire[31:0] OOl1IIlI0OlO10I;wire OOIl1l10IOO1lIO;wire IO0lIIlI0OO1lIO;wire IOIl0IlO01O1lIO;wire[4:0] OI01lIOIl0l0IO1;
wire[31:0] O01IlIO01ll0IO1;wire lIO10O01Ill0IO1;wire[15:0] l0IO1IO01lIIO0l;wire I01lOO01IlIIO0l;wire OOl1IOlI1OIIO0l;wire[4:0] OOIl1OlI01I1lO0;
wire[3:0] IO0lIOOIl1I1lO0;wire IOIl0lIO10I1lO0;wire[4:0] OI01lOOIl1IlI0O;wire O01IllIO10IlI0O;wire lIO10IIO0lIlI0O;wire l10IOI01lOIlI0O;
wire l0IO1lO10IIO01l;wire[31:0] I01lOIO0lIIO01l;wire[3:0] IlO01I1lO0IO01l;wire OlI1OOI01lIO01l;wire O1lIOI1lO0OlI01;wire IOIl0OI01lOlI01;
wire[4:0] OlI01OOl1IOlI01;wire[31:0] O01IlOI01lOOl1I;wire[4:0] lIO10OOl1IOOl1I;wire l10IOlO10IOOl1I;wire I1lO0IlO01OIl01;wire[4:0] IlO01OIl01OIl01;
wire OlI1OO1lIOOIl01;wire[4:0] O1lIOOIl01OlI1O;wire IOIl0O1lIOOlI1O;wire[2:0] OI01ll10IOOlI1O;wire[4:0] O01IlOlI1OlIO10;wire lO10Il0IO1lIO10;
wire[1:0] l10IOIOIl0lIO10;wire I01lOIO01llIO10;wire I1lO0l0IO1IO0lI;wire[63:0] IlO01IOIl0IO0lI;wire[4:0] OOIl1IO01lIO0lI;wire IO0lIO01IlIO0lI;
wire[5:2] IIO0lI01lOl10IO;wire[7:0] OI01lOlI01l10IO;wire OIl01OOIl1l10IO;wire[15:0] lO10IOlI01IOIl0;wire l10IOOOIl1IOIl0;wire[4:0] I01lOlIO10IOIl0;
wire IlO01OOl1II01lO;wire OOIl1lO10II01lO;wire IO0lIIO0lII01lO;wire[3:0] IIO0llO10IOI01l;wire[4:0] OI01lIO0lIOI01l;wire[2:0] O01IlI1lO0OI01l;
wire[4:0] lO10IO1lIOIlO01;wire l0IO1l10IOIlO01;wire I01lOIlI0OIlO01;wire IlO01IlO01IlO01;
assign OlI01l10IOOOl1I[10]=O1lIOOOIl1O1lIO?twr_dword_full[10]:lIO10I01lOlO10I?O01Ill10IOlIO10[11]:O01Ill10IOlIO10[10];assign IO0lIl0IO1I1lO0[6]
=~(OlI01IlI0OIlI0O[6]&~OOl1Il0IO1O01Il);dffe IIlO01O1lIOO1lIO
(IOIl0IlO01O1lIO,IlI0OIlO01I1lO0,clk,reset_b,1'b1,IIO0lIO01lO01Il);assign I1lO0IOIl0OIl01[4:0]={4'b0000,~twr_dword_empty[8]};assign OIl01IOIl0IlI0O[3:0]
=(O1lIOOOIl1O1lIO)?4'b0000:
((OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|(IO01lIO01lOIl01&~IlO01lIO10I01lO)|(l0IO1l10IOIlO01&IlI0OO1lIOl10IO))?
lO10IIlI0OOOl1I[3:0]+4'b0001:lO10IIlI0OOOl1I[3:0];dff30 Il10IOOOl1IOIl01
(IlO01OOIl1lO10I,IO01lOOl1IIlO01,clk,reset_b,1'b1);assign O1lIOl0IO1O1lIO=O01IlIO01ll0IO1;assign valid_bit[15:0]
=lO10IOlI01IOIl0[15:0];assign IO01lOI01llO10I=(OOIl1l10IOIO01l&m_hready&I1lO0IlI0OIOIl0);dff32 IOIl01lIO10IIO0l
(OOl1IIOIl0I01lO[63:32],IlO01IOIl0IO0lI[63:32],clk,1'b1,reset_b);assign OOl1II01lOOIl01
=(IlI0OOlI01OlI1O)?OlI01OOl1IOlI01:OOIl1IO01lIO0lI;assign IlO01IOIl0IO0lI[43:40]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[43:40]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1010))?4'b1111:
OOl1IIOIl0I01lO[43:40];BUF II01lOOlI01O01Il
(O01IlOOIl1OlI1O,OIl01OOIl1l10IO);assign IO01lIIO0lOIl01[7:0]=(IO01lO01IlIO01l)?O01IlOI01lOOl1I[7:0]:O01IlOI01lOOl1I[31:24];assign m_hbar[6]
=~O1lIOIlO01O01Il[6];dff IOOIl1IOIl0l10IO(OOIl1l10IOO1lIO,OlI1Ol10IOI1lO0,clk,reset_b,1'b1);assign O01IlIO01ll0IO1=m_hrdata;assign I01lOl0IO1I01lO
=O1lIOOOIl1O1lIO|(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|(l0IO1l10IOIlO01&IlI0OO1lIOl10IO)|
(IO01lIO01lOIl01&lIO10lO10IIIO0l&~IlO01lIO10I01lO)|lO10Il0IO1lIO10;assign OIl01l0IO1OOl1I
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&~OOl1IlO10IIO0lI)|
(IO01lIO01lOIl01&~OOl1IlO10IIO0lI&OlI01IO01lOOIl1&(IlO01lIO10I01lO|~lIO10lO10IIIO0l))|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&~IIO0lIO0lIl10IO&~OOl1IlO10IIO0lI);assign OlI01l10IOOOl1I[2]
=O1lIOOOIl1O1lIO?twr_dword_full[2]:lIO10I01lOlO10I?O01Ill10IOlIO10[3]:O01Ill10IOlIO10[2];assign I01lOO01IlIIO0l
=l10IOOIl01IIO0l;dff IIOIl0IlI0Ol0IO1(I01lOIO01llIO10,OI01llO10II1lO0,clk,reset_b,1'b1);assign IO0lIOIl01l10IO[4:0]
={4'b0000,~twr_dword_empty[0]};dff5 II01lOI01lOO1lIO(OlI01IIO0lOOIl1[4:0],OI01lIO0lIOI01l[4:0],clk,reset_b,1'b1);assign OIl01OlI01OI01l
=((IOIl0IlO01O1lIO==1'b1)&&(OOl1Il10IOIIO0l==5'b00001))?1'b1:
((IOIl0IlO01O1lIO==1'b0)&&((OOl1Il10IOIIO0l==5'b00001)||(IO01lIOIl0IOIl0==1'b0)))?1'b1:
1'b0;assign trd_dina[31:0]
=IO01lIIO0lOIl01[31:0];assign OIl01OI01llIO10[7]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[7]|lO10IOlI01IOIl0[7]);assign OlI01l10IOl10IO
=
((IO01lI1lO0IIO0l==4'b0111)||(IO01lI1lO0IIO0l==4'b1011)||
(IO01lI1lO0IIO0l==4'b1101)||(IO01lI1lO0IIO0l==4'b1110))?3'b000:
((IO01lI1lO0IIO0l==4'b0011)||(IO01lI1lO0IIO0l==4'b1100))?3'b001:
3'b010;assign l0IO1IO01lIIO0l[6]
=(OlI01IIO0lOOIl1[4:0]==5'b00111)?1'b1:1'b0;assign lIO10IIO0lIlI0O
=OIl01IO0lIOOIl1|
((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&m_hready&OOIl1l10IOIO01l&~IIO0lIIO0lO01Il&~I1lO0l0IO1IlO01);assign IlO01IOIl0IO0lI[11:8]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[11:8]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0010))?4'b1111:
OOl1IIOIl0I01lO[11:8];dffe IOOl1IOIl01OlI01
(I1lO0l0IO1IlO01,l10IOl0IO1IOIl0,clk,reset_b,1'b1,IlI0OOlI01OlI1O);assign IOIl0lIO10OOIl1[2]
=(IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[2]:
(~IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[1]:1'b0;assign m_hsize
=OIl01I01lOOOIl1;assign l10IOO1lIOlO10I[31:0]=cpu_adr[31:0];assign IO01lIOIl0IOIl0=IO01lO1lIOIIO0l;dff IOlI01IlO01lO10I
(IOIl0OOl1IOOIl1,trdreq_b,clk,1'b1,reset_b);dff IOI01lO1lIOlIO10(IOIl0O01Ill10IO,IIO0lO01IlOlI1O,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[10]
=O1lIOOOIl1O1lIO?twr_dword_empty[10]:lIO10I01lOlO10I?lO10II1lO0IlO01[11]:lO10II1lO0IlO01[10];dff5 IIlO01IO01lOlI01
(I1lO0OIl01IO01l[4:0],I01lOlO10IOIl01[4:0],clk,reset_b,1'b1);assign IlI0OlO10IO1lIO
=(I01lOIO01llIO10&m_hready&m_hgrant)|
(I01lOIO01llIO10&m_hready&IIO0lIIO0lO01Il)|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&~OIl01OlI01OI01l&m_hgrant)|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&~m_hready);assign OlI01l10IOOOl1I[13]
=O1lIOOOIl1O1lIO?twr_dword_full[13]:lIO10I01lOlO10I?O01Ill10IOlIO10[14]:O01Ill10IOlIO10[13];assign trd_retry=OI01lIlO01l0IO1;assign lO10II01lOl0IO1
=(OIl01OlI01OI01l)?1'b0:
((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&m_hready);assign lIO10IO0lIlO10I[4:0]
={4'b0000,~twr_dword_empty[11]};assign OIl01OI01llIO10[15]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[15]|lO10IOlI01IOIl0[15]);assign l10IOIlO01lIO10
=IlI0OOlI01OlI1O;assign OOl1IlO10IIO0lI=1'b1;assign l0IO1IO01lIIO0l[14]=(OlI01IIO0lOOIl1[4:0]==5'b01111)?1'b1:1'b0;assign OOIl1O01IlOIl01
=
(OlI01OI01lOlI1O==5'b00010)?3'b000:
(OOIl1IO01lIO0lI==5'b00000)?3'b001:
(OlI01OI01lOlI1O==5'b00101)?3'b011:
(OlI01OI01lOlI1O==5'b01001)?3'b101:
(OlI01OI01lOlI1O==5'b10001)?3'b111:
3'b001;assign O01IlIIO0ll0IO1[3:0]
=
(IIO0lOlI1OOlI01[3:0]==4'b0000)?IOIl0IIO0lOI01l[3:0]:
(IIO0lOlI1OOlI01[3:0]==4'b0001)?IOIl0IIO0lOI01l[7:4]:
(IIO0lOlI1OOlI01[3:0]==4'b0010)?IOIl0IIO0lOI01l[11:8]:
(IIO0lOlI1OOlI01[3:0]==4'b0011)?IOIl0IIO0lOI01l[15:12]:
(IIO0lOlI1OOlI01[3:0]==4'b0100)?IOIl0IIO0lOI01l[19:16]:
(IIO0lOlI1OOlI01[3:0]==4'b0101)?IOIl0IIO0lOI01l[23:20]:
(IIO0lOlI1OOlI01[3:0]==4'b0110)?IOIl0IIO0lOI01l[27:24]:
(IIO0lOlI1OOlI01[3:0]==4'b0111)?IOIl0IIO0lOI01l[31:28]:
(IIO0lOlI1OOlI01[3:0]==4'b1000)?IOIl0IIO0lOI01l[35:32]:
(IIO0lOlI1OOlI01[3:0]==4'b1001)?IOIl0IIO0lOI01l[39:36]:
(IIO0lOlI1OOlI01[3:0]==4'b1010)?IOIl0IIO0lOI01l[43:40]:
(IIO0lOlI1OOlI01[3:0]==4'b1011)?IOIl0IIO0lOI01l[47:44]:
(IIO0lOlI1OOlI01[3:0]==4'b1100)?IOIl0IIO0lOI01l[51:48]:
(IIO0lOlI1OOlI01[3:0]==4'b1101)?IOIl0IIO0lOI01l[55:52]:
(IIO0lOlI1OOlI01[3:0]==4'b1110)?IOIl0IIO0lOI01l[59:56]:IOIl0IIO0lOI01l[63:60];dff IIO0lIl0IO1OOIl1
(OlI01OlI1Ol10IO,OI01lOlI1OOlI1O,clk,1'b1,reset_b);assign IlO01IOIl0IO0lI[55:52]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[55:52]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1101))?4'b1111:
OOl1IIOIl0I01lO[55:52];assign OlI1OI1lO0OIl01
=m_hresp[0]&~m_hresp[1];assign IO01lIIO0lOIl01[31:24]=(IO01lO01IlIO01l)?O01IlOI01lOOl1I[31:24]:O01IlOI01lOOl1I[7:0];assign lO10IlO10IIlI0O
=(IIO0llIO10O1lIO==3'b001)?1'b1:1'b0;dff16 IIO01lIO0lII1lO0(lO10II1lO0IlO01[15:0],OIl01I1lO0IOIl0[15:0],clk,1'b1,reset_b);dff II1lO0OI01lI01lO
(O1lIOOOIl1O1lIO,OlI1OOOl1IO01Il,clk,1'b1,reset_b);assign OIl01I1lO0IOIl0[2]
=O1lIOOOIl1O1lIO?twr_dword_empty[2]:lIO10I01lOlO10I?lO10II1lO0IlO01[3]:lO10II1lO0IlO01[2];assign IIO0lO01IlOlI1O
=(OI01llO10IOOIl1&OOl1IlO10IIO0lI&OlI01IO01lOOIl1&~IlO01lIO10I01lO&I1lO0OlI01lO10I)|
(IOIl0O01Ill10IO&~lO10IOOIl1lIO10);assign OlI01l10IOOOl1I[5]
=O1lIOOOIl1O1lIO?twr_dword_full[5]:lIO10I01lOlO10I?O01Ill10IOlIO10[6]:O01Ill10IOlIO10[5];assign IO0lIl0IO1I1lO0[1]
=~(OlI01IlI0OIlI0O[1]&~OOl1Il0IO1O01Il);dff IO1lIOIIO0ll10IO(l0IO1I1lO0l0IO1,IIO0lO01IlI01lO,clk,reset_b,1'b1);assign OOIl1OlI01I1lO0[4:0]
={4'b0000,~twr_dword_empty[3]};dff5 Il0IO1l10IOIO0lI(OI01lIOIl0l0IO1[4:0],IlI0OIOIl0OOIl1[4:0],clk,reset_b,1'b1);assign IOIl0IOIl0O1lIO
=(IIO0lIIO0lO01Il)?1'b0:
((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&m_hready)|lO10Il10IOOI01l;assign OlI01IO01lOOIl1=l10IOOOIl1IOIl0;assign OIl01OI01llIO10[4]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[4]|lO10IOlI01IOIl0[4]);dff3 IlO10IIlO01IIO0l
(IIO0llIO10O1lIO,IO0lIlO10IO01Il,clk,reset_b,1'b1);assign l0IO1IO01lIIO0l[3]=(OlI01IIO0lOOIl1[4:0]==5'b00100)?1'b1:1'b0;assign IOIl0OI01lOlI01
=((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&IIO0lIIO0lO01Il);assign IlO01IOIl0IO0lI[23:20]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[23:20]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0101))?4'b1111:
OOl1IIOIl0I01lO[23:20];dffe4 IIlO01O01IlI1lO0
(IlO01I1lO0IO01l,IO01lI1lO0IIO0l,clk,1'b1,reset_b,I01lOl10IOlO10I);assign OlI1OlIO10O01Il[31:24]
=(IO01lO01IlIO01l)?I01lOIO0lIIO01l[31:24]:I01lOIO0lIIO01l[7:0];assign m_hbar[1]=~O1lIOIlO01O01Il[1];assign OI01lI01lOOI01l[5:2]
=IIO0lI01lOl10IO[5:2];assign I1lO0IIO0lOOl1I=I1lO0OOIl1IlO01;assign lO10IOOIl1lIO10=IO0lIIlO01OI01l;assign OlI1OOOl1IO01Il
=((O1lIOOOIl1O1lIO|OOl1IIlO01I01lO)&IOIl0IO01lOI01l&lO10IOOIl1lIO10)|
(IO01lIO01lOIl01&(~OlI01IO01lOOIl1|(~IlO01lIO10I01lO&lIO10lO10IIIO0l&I1lO0OlI01lO10I))&IOIl0IO01lOI01l)|
(I1lO0I01lOIIO0l&IOIl0IO01lOI01l)|
((IOIl0O01Ill10IO|IO0lIOlI01OlI01|OlI1OOI01lO1lIO)&lO10IOOIl1lIO10);assign OIl01I1lO0IOIl0[13]
=O1lIOOOIl1O1lIO?twr_dword_empty[13]:lIO10I01lOlO10I?lO10II1lO0IlO01[14]:lO10II1lO0IlO01[13];assign OOIl1OlI1OO1lIO
=OOl1IIlO01I01lO&(~IOIl0IO01lOI01l|~lO10IOOIl1lIO10);assign IO0lIO01IlIO0lI=(l0IO1I1lO0l0IO1&OOl1IOlI1OIIO0l);assign IO01ll10IOO01Il[4:0]
=
(OlI01l10IOOOl1I[15:0]==16'b1111111111111111)?5'b10000:
(OlI01l10IOOOl1I[15:0]==16'b0111111111111111)?5'b01111:
(OlI01l10IOOOl1I[14:0]==15'b011111111111111)?5'b01110:
(OlI01l10IOOOl1I[13:0]==14'b01111111111111)?5'b01101:
(OlI01l10IOOOl1I[12:0]==13'b0111111111111)?5'b01100:
(OlI01l10IOOOl1I[11:0]==12'b011111111111)?5'b01011:
(OlI01l10IOOOl1I[10:0]==11'b01111111111)?5'b01010:
(OlI01l10IOOOl1I[9:0]==10'b0111111111)?5'b01001:
(OlI01l10IOOOl1I[8:0]==9'b011111111)?5'b01000:
(OlI01l10IOOOl1I[7:0]==8'b01111111)?5'b00111:
(OlI01l10IOOOl1I[6:0]==7'b0111111)?5'b00110:
(OlI01l10IOOOl1I[5:0]==6'b011111)?5'b00101:
(OlI01l10IOOOl1I[4:0]==5'b01111)?5'b00100:
(OlI01l10IOOOl1I[3:0]==4'b0111)?5'b00011:
(OlI01l10IOOOl1I[2:0]==3'b011)?5'b00010:
(OlI01l10IOOOl1I[1:0]==2'b01)?5'b00001:
(OIl01I1lO0IOIl0[0]==1'b0)?5'b00001:5'b00000;assign trd_abort
=OIl01OOIl1OOl1I;assign IO01llIO10IlO01
=
((OlI01O01IlOI01l<={4'b0000,OlI01OOl1IOlI01})||(OlI01OOl1IOlI01==5'b00000))?I01lOlIO10IOIl0:
OlI01OOl1IOlI01;assign O01IlOlI1OlIO10[4:0]
={4'b0000,~twr_dword_empty[14]};assign OIl01OI01llIO10[12]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[12]|lO10IOlI01IOIl0[12]);assign OlI01O01IlOI01l
=9'b100000000-{1'b0,OI01lOlI01l10IO};assign OIl01IlO01IlI0O=I01lOO01IlIIO0l;assign l0IO1IO01lIIO0l[11]
=(OlI01IIO0lOOIl1[4:0]==5'b01100)?1'b1:1'b0;assign OOIl1OlI1OIO01l=l0IO1I1lO0l0IO1;assign lIO10OlI01IlO01
=~lIO10IlI0OlIO10&(l10IOIO01lIO01l|l0IO1O01IllO10I);assign OlI1OIO01lI01lO=(IlI0OOlI01OlI1O)?OOIl1OI01lIIO0l:
O1lIOIlO01O01Il;assign IIO0llO10IOI01l[3]
=(IO01lO01IlIO01l)?O01IlIIO0ll0IO1[3]:O01IlIIO0ll0IO1[0];assign l10IOIOIl0lIO10
=(((big_endian==1'b0)&&(IlO01I1lO0IO01l==4'b0111))||
((big_endian==1'b1)&&(IlO01I1lO0IO01l==4'b1110)))?2'b11:
(((big_endian==1'b0)&&(IlO01I1lO0IO01l==4'b1011))||
((big_endian==1'b1)&&(IlO01I1lO0IO01l==4'b1101)))?2'b10:
(((big_endian==1'b0)&&(IlO01I1lO0IO01l==4'b1101))||
((big_endian==1'b1)&&(IlO01I1lO0IO01l==4'b1011)))?2'b01:
(((big_endian==1'b0)&&(IlO01I1lO0IO01l==4'b1110))||
((big_endian==1'b1)&&(IlO01I1lO0IO01l==4'b0111)))?2'b00:
(((big_endian==1'b0)&&(IlO01I1lO0IO01l==4'b0011))||
((big_endian==1'b1)&&(IlO01I1lO0IO01l==4'b1100)))?2'b10:
2'b00;dff4 IOI01lOIl01IOIl0
(IO0lII01lOOlI1O[5:2],IIO0lI01lOl10IO[5:2],clk,reset_b,1'b1);assign m_hprot=4'b0011;dffe5 Il10IOOlI1OI01lO
(OI01lOOIl1IlI0O[4:0],IlI0OOOl1Il0IO1[4:0],clk,reset_b,1'b1,O1lIOOOIl1O1lIO);dff IlIO10IOIl0IO01l
(I1lO0I01lOIIO0l,l10IOI1lO0lO10I,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[5]
=O1lIOOOIl1O1lIO?twr_dword_empty[5]:lIO10I01lOlO10I?lO10II1lO0IlO01[6]:lO10II1lO0IlO01[5];dff IIIO0lOOIl1l0IO1
(l0IO1OlI1OIlO01,lIO10OlI1OIOIl0,clk,1'b1,reset_b);assign OlI01l10IOOOl1I[8]
=O1lIOOOIl1O1lIO?twr_dword_full[8]:lIO10I01lOlO10I?O01Ill10IOlIO10[9]:O01Ill10IOlIO10[8];assign IO0lIl0IO1I1lO0[4]
=~(OlI01IlI0OIlI0O[4]&~OOl1Il0IO1O01Il);dff IOOl1IO1lIOI1lO0(OIl01l0IO1l10IO,OlI1OOI01lIO01l,clk,reset_b,1'b1);assign IO01lIlI0OI01lO[4:0]
={4'b0000,~twr_dword_empty[6]};assign OI01lIO0lIOI01l[4:0]
=(O1lIOOOIl1O1lIO)?5'b00000:
(OI01llO10IOOIl1&~IlO01lIO10I01lO&OlI01IO01lOOIl1)?OlI01IIO0lOOIl1[4:0]+5'b00001:
OlI01IIO0lOOIl1[4:0];assign IIO0lIIO0lO01Il
=((IOIl0IlO01O1lIO==1'b1)&&(OlI01OI01lOlI1O==5'b00001))?1'b1:
((IOIl0IlO01O1lIO==1'b0)&&((OlI01OI01lOlI1O==5'b00001)||(IO01lIOIl0IOIl0==1'b0)))?1'b1:
OOIl1IIO0lIO0lI;assign I01lOOlI1OlO10I
=IOIl0I1lO0OlI1O;assign OIl01OI01llIO10[1]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[1]|lO10IOlI01IOIl0[1]);assign IlO01OlI01IIO0l
=(lIO10I1lO0OOIl1);assign l0IO1IO01lIIO0l[0]=(OlI01IIO0lOOIl1[4:0]==5'b00001)?1'b1:1'b0;BUF IIOIl0l10IOIlI0O
(O1lIOIOIl0O01Il,IIO0lIlI0OI1lO0);assign IlO01IOIl0IO0lI[35:32]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[35:32]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1000))?4'b1111:
OOl1IIOIl0I01lO[35:32];BUF IIO01lO01IlO1lIO
(lO10IOlI1OOI01l,lIO10O1lIOOOIl1);assign OlI1OlIO10O01Il[7:0]=(IO01lO01IlIO01l)?I01lOIO0lIIO01l[7:0]:I01lOIO0lIIO01l[31:24];assign m_hbar[4]
=~O1lIOIlO01O01Il[4];dff IO1lIOOI01lOOIl1(O1lIOO1lIOOlI01,OlI1OOlI1OI1lO0,clk,reset_b,1'b1);assign l0IO1OOl1IlIO10
=l0IO1O1lIOl0IO1;assign OlI1Ol10IOI1lO0=OOl1IIlO01I01lO|l0IO1l10IOIlO01|(O01IllIO10IlI0O&OI01ll0IO1IlI0O);assign l10IOI1lO0lO10I
=(IO01lIO01lOIl01&(~OlI01IO01lOOIl1|(~IlO01lIO10I01lO&lIO10lO10IIIO0l&I1lO0OlI01lO10I))&~IOIl0IO01lOI01l)|
(I1lO0I01lOIIO0l&~IOIl0IO01lOI01l)|
(l0IO1l10IOIlO01&IIO0lIO0lIl10IO);assign OlI01l10IOOOl1I[0]
=O1lIOOOIl1O1lIO?twr_dword_full[0]:lIO10I01lOlO10I?O01Ill10IOlIO10[1]:O01Ill10IOlIO10[0];assign IlI0OI1lO0l10IO
=O1lIOI1lO0OlI01;dff IOI01lOlI01OOl1I(IlO01IlO01IlO01,O01Ill0IO1OlI1O,clk,1'b1,reset_b);assign IO0lIIO0lIOlI1O
=
twr_dword_empty[0]&twr_dword_empty[1]&twr_dword_empty[2]&twr_dword_empty[3]&
twr_dword_empty[4]&twr_dword_empty[5]&twr_dword_empty[6]&twr_dword_empty[7]&
twr_dword_empty[8]&twr_dword_empty[9]&twr_dword_empty[10]&twr_dword_empty[11]&
twr_dword_empty[12]&twr_dword_empty[13]&twr_dword_empty[14]&twr_dword_empty[15];assign IlO01OIl01OIl01
=I01lOlO10IOIl01[4:0];assign l0IO1OIl01IlI0O=
(OOIl1l10IOIO01l&m_hready&lO10IO01IlOOIl1);assign db6_wea
=OI01llO10IOOIl1&~IlO01lIO10I01lO&OlI01IO01lOOIl1;assign OIl01OI01llIO10[9]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[9]|lO10IOlI01IOIl0[9]);assign IlI0Ol0IO1OlI01=IlI0OOlI01OlI1O;assign l0IO1IO01lIIO0l[8]
=(OlI01IIO0lOOIl1[4:0]==5'b01001)?1'b1:1'b0;assign lO10IIO0lIl0IO1
=IlI0OOlI01OlI1O&IlI0OIlO01I1lO0&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO);assign IlO01IOIl0IO0lI[3:0]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[3:0]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0000))?4'b1111:
OOl1IIOIl0I01lO[3:0];dffe IOOIl1lO10IOlI1O
(O01IlOIl01OOIl1,OIl01OIl01l0IO1,clk,reset_b,1'b1,IlI0OOlI01OlI1O);assign IIO0llO10IOI01l[0]
=(IO01lO01IlIO01l)?O01IlIIO0ll0IO1[0]:O01IlIIO0ll0IO1[3];assign m_haddr[31:2]=IlO01OOIl1lO10I;dffe4 IIIO0lOlI01IlI0O
(O1lIOIO01ll10IO[3:0],trd_be_b[3:0],clk,1'b1,reset_b,O1lIOOOIl1O1lIO);assign OOl1IIlI0OlO10I=OOl1IIO0lIOIl01;dff IlO10IOOl1IIO01l
(l10IOlIO10OIl01,twrreq_b,clk,1'b1,reset_b);dff IO01IlIO0lIIlO01(O01IllIO10IlI0O,OlI01lO10Il0IO1,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[8]
=O1lIOOOIl1O1lIO?twr_dword_empty[8]:lIO10I01lOlO10I?lO10II1lO0IlO01[9]:lO10II1lO0IlO01[8];dff IOOIl1IlO01l10IO
(OOl1IOOIl1O01Il,IlO01OOl1II01lO,clk,reset_b,1'b1);assign OlI01lIO10OlI01
=(IlO01IlO01IlO01&~IlO01IOIl0IlO01&~(m_hgrant&m_hready)&~OlI1OIIO0lI01lO)|
(lIO10I1lO0OOIl1&~(m_hgrant&m_hready))|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l&~IIO0lIIO0lO01Il&~m_hgrant)|
(IO01lIlO01IOIl0&~(m_hgrant&m_hready))|

(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
~(m_hgrant&m_hready))|
(lO10Il10IOOI01l&IOIl0IlO01O1lIO&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
~(m_hgrant&m_hready))|
(OIl01l0IO1l10IO&OOIl1l10IOIO01l&m_hready&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
~(m_hgrant&m_hready));assign OlI01l10IOOOl1I[11]
=O1lIOOOIl1O1lIO?twr_dword_full[11]:lIO10I01lOlO10I?O01Ill10IOlIO10[12]:O01Ill10IOlIO10[11];assign I1lO0IlO01OIl01
=(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&~OOl1IlO10IIO0lI)|(OI01llO10IOOIl1&~OOl1IlO10IIO0lI);assign IlO01l0IO1lO10I
=(l10IOlO10IOOl1I)?IO01llIO10IlO01:
(l0IO1OIl01IlI0O)?I1lO0lO10IlIO10:
(IOIl0IlO01O1lIO&~IO01lIOIl0IOIl0&~l0IO1O1lIOl0IO1)?5'b00001:
(~IOIl0IlO01O1lIO&~IO01lIOIl0IOIl0)?5'b00001:
(lO10II01lOl0IO1)?OOl1Il10IOIIO0l-5'b00001:OOl1Il10IOIIO0l;assign l10IOIIO0lIO01l[4:0]
={4'b0000,~twr_dword_empty[9]};assign IlI0OIOIl0OOIl1[4:0]
=((OOl1IIlO01I01lO&~IOIl0IO01lOI01l)|l0IO1l10IOIlO01)?IlO01I1lO0O1lIO[4:0]:
(IO01lIO01lOIl01&~IlO01lIO10I01lO)?OI01lIOIl0l0IO1[4:0]-5'b00001:OI01lIOIl0l0IO1[4:0];assign l0IO1IlO01OOl1I
=((~OIl01OlI01OI01l&I1lO0IO01lOOl1I)|I01lOIO01llIO10)&m_hready&~I1lO0l0IO1IlO01;assign I1lO0OOIl1IlO01=OlI1OlIO10O01Il;assign l10IOOI01lIlO01
=O1lIOOOIl1O1lIO&~lO10IOOIl1lIO10;assign I01lOIlI0OIlO01=I1lO0IO01lOOl1I&OIl01OlI01OI01l&~IIO0lIIO0lO01Il;dff IO01IllO10IlO10I
(l0IO1O01IllO10I,lIO10OlI01IlO01,clk,reset_b,1'b1);assign IlI0OOOIl1OlI01=(IlI0OOlI01OlI1O&~OlI01OlI1Ol10IO);assign IlO01IOIl0IO0lI[47:44]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[47:44]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1011))?4'b1111:
OOl1IIOIl0I01lO[47:44];assign l0IO1O1lIOl0IO1
=~(
(m_hready&OOIl1l10IOIO01l&lO10IOlI1OOI01l)|
O01IlOOIl1OlI1O);assign IO01lIIO0lOIl01[15:8]
=(IO01lO01IlIO01l)?O01IlOI01lOOl1I[15:8]:O01IlOI01lOOl1I[23:16];assign l0IO1lIO10lIO10=(OOl1Il10IOIIO0l!=5'b00001)?1'b1:1'b0;dff IOOl1IIOIl0OlI1O
(IO01llIO10IO0lI,IlO01lIO10I01lO,clk,1'b1,reset_b);assign OOIl1IIO0lIO0lI=1'b0;assign OIl01I1lO0IOIl0[0]
=O1lIOOOIl1O1lIO?twr_dword_empty[0]:lIO10I01lOlO10I?lO10II1lO0IlO01[1]:lO10II1lO0IlO01[0];assign OlI01lO10Il0IO1
=(lO10Il0IO1lIO10)|
(O01IllIO10IlI0O&~OOl1IlO10IIO0lI);assign OlI01l10IOOOl1I[3]
=O1lIOOOIl1O1lIO?twr_dword_full[3]:lIO10I01lOlO10I?O01Ill10IOlIO10[4]:O01Ill10IOlIO10[3];assign OOl1Il0IO1O01Il
=~((OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&OOl1IlO10IIO0lI)|
(IO01lIO01lOIl01)|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&OOl1IlO10IIO0lI)|
(O01IllIO10IlI0O&OOl1IlO10IIO0lI)|
(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&OOl1IlO10IIO0lI)|
(OI01llO10IOOIl1));dff IIIO0lIlI0OOOIl1
(I1lO0IO01lOOl1I,IlI0OlO10IO1lIO,clk,reset_b,1'b1);assign O1lIOOIl01OlI1O[4:0]={4'b0000,~twr_dword_empty[1]};dff4 II1lO0I1lO0O01Il
(IIO0lOlI1OOlI01[3:0],IO0lIOOIl1I1lO0[3:0],clk,reset_b,1'b1);assign O01IlOI01ll10IO
=(IlI0OIOIl0I1lO0)?OI01lIlI0OOlI01:
(IOIl0IlO01O1lIO&~IO01lIOIl0IOIl0&~l0IO1O1lIOl0IO1&~I1lO0l0IO1IlO01)?5'b00001:
(~IOIl0IlO01O1lIO&~IO01lIOIl0IOIl0)?5'b00001:
(IOIl0IOIl0O1lIO)?OlI01OI01lOlI1O-5'b00001:OlI01OI01lOlI1O;assign twr_addrb[3:0]
=OIl01IOIl0IlI0O[3:0];assign OIl01OI01llIO10[6]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[6]|lO10IOlI01IOIl0[6]);assign OI01ll10IOOlI1O
=
(~I1lO0l0IO1IlO01)?3'b010:
(IOIl0OOl1II1lO0[3:2]==2'b00)?3'b001:
3'b000;assign l0IO1IO01lIIO0l[5]
=(OlI01IIO0lOOIl1[4:0]==5'b00110)?1'b1:1'b0;dffe32 IOI01lI1lO0lIO10
(O01IlO1lIOOI01l,I1lO0IIO0lOOl1I,clk,reset_b,1'b1,lIO10IIO0lIlI0O);assign IlO01IOIl0IO0lI[15:12]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[15:12]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0011))?4'b1111:
OOl1IIOIl0I01lO[15:12];assign I01lOl10IOlO10I
=IlI0OOlI01OlI1O|((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&OOIl1l10IOIO01l&m_hready);assign IOIl0lIO10OOIl1[1]
=(IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[1]:
(~IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[2]:1'b0;assign m_hwrite
=IOIl0IlO01O1lIO;assign OI01lI01lOOI01l[31:6]=I1lO0IO0lIIIO0l[31:6];assign OOIl1OI01lIIO0l=IO0lIl0IO1I1lO0[6:0];dff IOI01lIO01lIlO01
(IO0lIIlO01OI01l,IOIl0OOl1IOOIl1,clk,1'b1,reset_b);dff IIlI0OO1lIOOOl1I(IO0lIOlI01OlI01,O1lIOOI01lI1lO0,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[11]
=O1lIOOOIl1O1lIO?twr_dword_empty[11]:lIO10I01lOlO10I?lO10II1lO0IlO01[12]:lO10II1lO0IlO01[11];assign lIO10OlI1OIOIl0
=l0IO1OI01lIOIl0|~(OOIl1OlI1OO1lIO|~l0IO1OlI1OIlO01);assign IOIl0OIl01O01Il
=(I1lO0IO01lOOl1I&IO0lII01lOI01lO)|
(I1lO0IO01lOOl1I&O1lIOI01lOIO0lI)|
(OIl01l0IO1l10IO&IO0lII01lOI01lO)|
(OIl01l0IO1l10IO&O1lIOI01lOIO0lI)|
(l10IOI01lOIlI0O&~m_hready);assign OlI01l10IOOOl1I[14]
=O1lIOOOIl1O1lIO?twr_dword_full[14]:lIO10I01lOlO10I?O01Ill10IOlIO10[15]:O01Ill10IOlIO10[14];assign IlO01OOl1II01lO
=OI01llO10IOOIl1&~OlI01IO01lOOIl1;assign l10IOlO10IOOl1I=IlI0OOlI01OlI1O;assign lO10IO1lIOIlO01[4:0]
={4'b0000,~twr_dword_empty[12]};assign OIl01OI01llIO10[14]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[14]|lO10IOlI01IOIl0[14]);assign I01lOOOl1IIOIl0
=OOl1IIlI0OlO10I[31:2];assign lIO10OOl1IOOl1I=IlO01OIl01OIl01;assign l0IO1IO01lIIO0l[13]
=(OlI01IIO0lOOIl1[4:0]==5'b01110)?1'b1:1'b0;assign O1lIOIO0lIIO0lI
=(OlI1OO1lIOOIl01)?1'b0:
(OOIl1OlI1OIO01l)?~IO0lIIO0lII01lO:IO0lIIO0lII01lO;assign lIO10IlI0OlIO10
=O1lIOOOIl1O1lIO&~lO10IOOIl1lIO10;assign IIO0lOOl1IO1lIO=(IlI0OOlI01OlI1O)?I01lOIIO0llIO10:
IOIl0OOl1II1lO0;assign IlO01IOIl0IO0lI[59:56]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[59:56]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1110))?4'b1111:
OOl1IIOIl0I01lO[59:56];assign O1lIOI01lOIO0lI
=~m_hresp[0]&m_hresp[1];assign IlO01lIO10I01lO=OOIl1lO10II01lO;assign m_hbusreq
=~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO|
(IO01lIlO01IOIl0)|
(lIO10I1lO0OOIl1)|
(I01lOIO01llIO10&lO10IlO10IIlI0O&l0IO1lIO10lIO10)|
(I1lO0IO01lOOl1I&lO10IlO10IIlI0O&lIO10lIO10OOl1I&IO01lIOIl0IOIl0);dff16 II01lOIO0lIO1lIO
(O01Ill10IOlIO10[15:0],OlI01l10IOOOl1I[15:0],clk,reset_b,1'b1);dff Il10IOOI01lIO0lI
(OOl1IIlO01I01lO,IlO01IlO01IO0lI,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[3]
=O1lIOOOIl1O1lIO?twr_dword_empty[3]:lIO10I01lOlO10I?lO10II1lO0IlO01[4]:lO10II1lO0IlO01[3];assign O1lIOOI01lI1lO0
=(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&~OOl1IlO10IIO0lI)|
(OI01llO10IOOIl1&~OOl1IlO10IIO0lI)|
(IO0lIOlI01OlI01&~lO10IOOIl1lIO10);assign OlI01l10IOOOl1I[6]
=O1lIOOOIl1O1lIO?twr_dword_full[6]:lIO10I01lOlO10I?O01Ill10IOlIO10[7]:O01Ill10IOlIO10[6];assign IO0lIl0IO1I1lO0[2]
=~(OlI01IlI0OIlI0O[2]&~OOl1Il0IO1O01Il);dff IOlI1OIIO0lOlI1O(lIO10I1lO0OOIl1,IO0lIO01IlIO0lI,clk,reset_b,1'b1);assign OOl1IOlI01O1lIO[4:0]
={4'b0000,~twr_dword_empty[4]};assign O01IlO01IlIOIl0[4:0]
=(OOl1IIlO01I01lO&~lO10IOOIl1lIO10)?OOl1II1lO0I1lO0[4:0]:
(OOl1IIlO01I01lO&~IOIl0IO01lOI01l)?OI01lOOIl1IlI0O[4:0]:
((IO01lIO01lOIl01|OI01llO10IOOIl1)&~IlO01lIO10I01lO)?OIl01O01IlIlO01[4:0]-5'b00001:OIl01O01IlIlO01[4:0];assign IlI0OIOIl0I1lO0
=IlI0OOlI01OlI1O;assign OOl1IIO0lIOIl01=OI01lI01lOOI01l;assign OIl01OI01llIO10[3]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[3]|lO10IOlI01IOIl0[3]);assign OOl1IOlI01IO01l=IlI0OOlI01OlI1O;assign l0IO1IO01lIIO0l[2]
=(OlI01IIO0lOOIl1[4:0]==5'b00011)?1'b1:1'b0;assign IIO0lIlI0OI1lO0=(lO10Il10IOOI01l&IIO0lIIO0lO01Il)|IlO01IlO01IlO01;assign IlO01IOIl0IO0lI[27:24]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[27:24]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0110))?4'b1111:
OOl1IIOIl0I01lO[27:24];assign l10IOIO0lIIlI0O
=~(~IOIl0IlO01O1lIO&lO10Il10IOOI01l);assign OlI1OlIO10O01Il[23:16]
=(IO01lO01IlIO01l)?I01lOIO0lIIO01l[23:16]:I01lOIO0lIIO01l[15:8];assign m_hbar[2]=~O1lIOIlO01O01Il[2];assign OI01lI01lOOI01l[1:0]
=2'b00;assign OlI01OOl1IOlI01=lIO10OOl1IOOl1I;assign OlI1OOlI1OI1lO0
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&~OOl1IlO10IIO0lI)|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&~OOl1IlO10IIO0lI);assign IlO01IlO01IO0lI
=O1lIOOOIl1O1lIO&(~IOIl0IO01lOI01l|~lO10IOOIl1lIO10);assign OIl01I1lO0IOIl0[14]
=O1lIOOOIl1O1lIO?twr_dword_empty[14]:lIO10I01lOlO10I?lO10II1lO0IlO01[15]:lO10II1lO0IlO01[14];assign tack_b=l0IO1OlI1OIlO01;assign O1lIOOlI01OIl01
=(I1lO0IO01lOOl1I&OlI1OI1lO0OIl01)|
(OIl01l0IO1l10IO&OlI1OI1lO0OIl01)|
(lO10Il10IOOI01l&IOIl0IlO01O1lIO&~IIO0lIIO0lO01Il);assign I1lO0l0IO1IO0lI
=(IlO01I1lO0O1lIO[4:0]==5'b00001)?1'b1:1'b0;assign IIO0ll10IOOlI01
=~((OOl1IIlO01I01lO&~IOIl0IO01lOI01l&OOl1IlO10IIO0lI&I1lO0l0IO1IO0lI)|
(IO01lIO01lOIl01&lIO10lO10IIIO0l)|
(l0IO1l10IOIlO01&OOl1IlO10IIO0lI&I1lO0l0IO1IO0lI)|
(O01IllIO10IlI0O&OOl1IlO10IIO0lI&lIO10lO10IIIO0l)|
(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&OOl1IlO10IIO0lI&OlI1OIO01lOlI1O)|
(OI01llO10IOOIl1&I1lO0OlI01lO10I));assign lIO10O01Ill0IO1
=((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&OIl01OlI01OI01l&~IIO0lIIO0lO01Il);assign OlI01OlI1OOOl1I[4:0]
={4'b0000,~twr_dword_empty[15]};assign OIl01OI01llIO10[11]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[11]|lO10IOlI01IOIl0[11]);assign O01IlI1lO0OI01l
=(IlI0Ol0IO1OlI01)?OlI01l10IOl10IO:
(IOIl0lIO10I1lO0)?OI01ll10IOOlI1O:
OIl01I01lOOOIl1;assign l0IO1IO01lIIO0l[10]
=(OlI01IIO0lOOIl1[4:0]==5'b01011)?1'b1:1'b0;assign OlI1OO1lIOOIl01=l10IOI01lOIlI0O&IIO0lO01IlI01lO;assign IOIl0I1lO0OlI1O
=(l0IO1O01IllO10I)?IIO0llO10IOI01l:IOIl0lIO10OOIl1;dff7 IOlI1OlO10Il10IO(O1lIOIlO01O01Il,OlI1OIO01lI01lO,clk,1'b1,reset_b);assign IIO0llO10IOI01l[2]
=(IO01lO01IlIO01l)?O01IlIIO0ll0IO1[2]:O01IlIIO0ll0IO1[1];assign l0IO1IOIl0OOl1I[1:0]
=(IOIl0OOl1II1lO0!=4'b0000)?l10IOIOIl0lIO10:2'b00;dffe IIlI0OO01IllIO10
(OlI1OIO01lOlI1O,OOIl1I01lOOlI01,clk,reset_b,1'b1,O1lIOOOIl1O1lIO);assign m_hwdata=O01IlO1lIOOI01l;dffe Il0IO1OlI1OIO0lI
(IIO0lIO0lIl10IO,IO0lIIO0lIOlI1O,clk,1'b1,reset_b,O1lIOOOIl1O1lIO);dff IlO10IIOIl0IIO0l
(l0IO1l10IOIlO01,lIO10l10IOIOIl0,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[6]
=O1lIOOOIl1O1lIO?twr_dword_empty[6]:lIO10I01lOlO10I?lO10II1lO0IlO01[7]:lO10II1lO0IlO01[6];dff IIO0lIOOIl1OOIl1
(IO01lOOl1IIO0lI,I1lO0IlO01OIl01,clk,reset_b,1'b1);assign OlI01l10IOOOl1I[9]
=O1lIOOOIl1O1lIO?twr_dword_full[9]:lIO10I01lOlO10I?O01Ill10IOlIO10[10]:O01Ill10IOlIO10[9];assign IO0lIl0IO1I1lO0[5]
=~(OlI01IlI0OIlI0O[5]&~OOl1Il0IO1O01Il);assign IIO0lIO01lO01Il=IlI0OOlI01OlI1O;assign I01lOIlI0OIO0lI[4:0]
={4'b0000,~twr_dword_empty[7]};assign IO0lIOOIl1I1lO0[3:0]
=(O1lIOOOIl1O1lIO)?4'b0000:
((OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|(IO01lIO01lOIl01&~IlO01lIO10I01lO)|(l0IO1l10IOIlO01&IlI0OO1lIOl10IO))?
IIO0lOlI1OOlI01[3:0]+4'b0001:IIO0lOlI1OOlI01[3:0];assign IO01lOOl1IIlO01
=(l10IOIlO01lIO10)?I01lOOOl1IIOIl0:
(l0IO1IlO01OOl1I)?IlO01OOIl1lO10I+30'h00000001:
(lIO10IO01lIlI0O)?IlO01OOIl1lO10I-30'h00000001:
IlO01OOIl1lO10I;assign IO01lO1lIOIIO0l
=IIO0ll10IOOlI01;assign OIl01OI01llIO10[0]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[0]|lO10IOlI01IOIl0[0]);assign OlI1OOIl01IO0lI
=
(OOl1Il10IOIIO0l==5'b00001)?3'b000:
(OOIl1IO01lIO0lI==5'b00000)?3'b001:
(OOl1Il10IOIIO0l==5'b00100)?3'b011:
(OOl1Il10IOIIO0l==5'b01000)?3'b101:
(OOl1Il10IOIIO0l==5'b10000)?3'b111:
3'b001;dff32 IlO10IlIO10IO01l
(OOl1IIOIl0I01lO[31:0],IlO01IOIl0IO0lI[31:0],clk,1'b1,reset_b);dff5 IIIO0ll0IO1l0IO1
(OOIl1IO01lIO0lI,OOl1II01lOOIl01,clk,reset_b,1'b1);assign IlO01IOIl0IO0lI[39:36]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[39:36]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1001))?4'b1111:
OOl1IIOIl0I01lO[39:36];assign OIl01OOIl1l10IO
=OIl01IO0lIOOIl1|(IOIl0IlO01O1lIO&lO10Il10IOOI01l&~IIO0lIIO0lO01Il&~I1lO0l0IO1IlO01);assign O01IlOI01lOOl1I=O1lIOl0IO1O1lIO;assign m_hbar[5]
=~O1lIOIlO01O01Il[5];dff IOlI1OIlI0OOI01l(OI01ll0IO1IlI0O,IlI0OlIO10l0IO1,clk,reset_b,1'b1);assign l10IOOOIl1IOIl0
=l10IOIO0lIIlI0O;assign lIO10I01lOlO10I
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|(l0IO1l10IOIlO01&IlI0OO1lIOl10IO)|
(IO01lIO01lOIl01&(OOIl1l10IOO1lIO|~IO01llIO10IO0lI))|(lO10Il0IO1lIO10&~IO01llIO10IO0lI);assign lIO10l10IOIOIl0
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|
(IO01lIO01lOIl01&OlI01IO01lOOIl1&~IlO01lIO10I01lO&lIO10lO10IIIO0l&~I1lO0OlI01lO10I)|
(l0IO1l10IOIlO01&IlI0OO1lIOl10IO&~IIO0lIO0lIl10IO);assign OlI01l10IOOOl1I[1]
=O1lIOOOIl1O1lIO?twr_dword_full[1]:lIO10I01lOlO10I?O01Ill10IOlIO10[2]:O01Ill10IOlIO10[1];assign l10IOOIl01IIO0l
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&OOl1IlO10IIO0lI)|
(IO01lIO01lOIl01)|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&OOl1IlO10IIO0lI)|
(O01IllIO10IlI0O&OOl1IlO10IIO0lI);dff IIlI0OOI01lIlI0O
(IO01lIlO01IOIl0,OlI01lIO10OlI01,clk,reset_b,1'b1);assign IOIl0O1lIOOlI1O
=
(IO0lIOOIl1I1lO0[3:0]==4'b0000)?lO10IOIl01lO10I[0]:
(IO0lIOOIl1I1lO0[3:0]==4'b0001)?lO10IOIl01lO10I[1]:
(IO0lIOOIl1I1lO0[3:0]==4'b0010)?lO10IOIl01lO10I[2]:
(IO0lIOOIl1I1lO0[3:0]==4'b0011)?lO10IOIl01lO10I[3]:
(IO0lIOOIl1I1lO0[3:0]==4'b0100)?lO10IOIl01lO10I[4]:
(IO0lIOOIl1I1lO0[3:0]==4'b0101)?lO10IOIl01lO10I[5]:
(IO0lIOOIl1I1lO0[3:0]==4'b0110)?lO10IOIl01lO10I[6]:
(IO0lIOOIl1I1lO0[3:0]==4'b0111)?lO10IOIl01lO10I[7]:
(IO0lIOOIl1I1lO0[3:0]==4'b1000)?lO10IOIl01lO10I[8]:
(IO0lIOOIl1I1lO0[3:0]==4'b1001)?lO10IOIl01lO10I[9]:
(IO0lIOOIl1I1lO0[3:0]==4'b1010)?lO10IOIl01lO10I[10]:
(IO0lIOOIl1I1lO0[3:0]==4'b1011)?lO10IOIl01lO10I[11]:
(IO0lIOOIl1I1lO0[3:0]==4'b1100)?lO10IOIl01lO10I[12]:
(IO0lIOOIl1I1lO0[3:0]==4'b1101)?lO10IOIl01lO10I[13]:
(IO0lIOOIl1I1lO0[3:0]==4'b1110)?lO10IOIl01lO10I[14]:lO10IOIl01lO10I[15];dff5 IIO01lI01lOI1lO0
(OIl01O01IlIlO01[4:0],O01IlO01IlIOIl0[4:0],clk,reset_b,1'b1);assign I1lO0lO10IlIO10=OlI01OI01lOlI1O-5'b00001;assign trd_addra[3:0]
=OlI01IIO0lOOIl1[3:0];assign OIl01OI01llIO10[8]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[8]|lO10IOlI01IOIl0[8]);assign IOIl0lIO10I1lO0
=((I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l);assign l0IO1IO01lIIO0l[7]
=(OlI01IIO0lOOIl1[4:0]==5'b01000)?1'b1:1'b0;dff IOlI01I01lOIOIl0(OIl01IO0lIOOIl1,lO10IIO0lIl0IO1,clk,reset_b,1'b1);assign IlO01IOIl0IO0lI[7:4]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[7:4]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0001))?4'b1111:
OOl1IIOIl0I01lO[7:4];assign l10IOl0IO1IOIl0
=((IlI0OOlI01OlI1O==1'b1)&&
(IlI0OIlO01I1lO0==1'b1)&&
(I01lOIIO0llIO10!=4'b0000)&&(I01lOIIO0llIO10!=4'b0011)&&
(I01lOIIO0llIO10!=4'b0111)&&(I01lOIIO0llIO10!=4'b1011)&&
(I01lOIIO0llIO10!=4'b1100)&&(I01lOIIO0llIO10!=4'b1101)&&
(I01lOIIO0llIO10!=4'b1110))?1'b1:1'b0;assign IOIl0lIO10OOIl1[3]
=(IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[3]:
(~IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[0]:1'b0;assign m_hburst
=IIO0llIO10O1lIO;dffe5 IIO0lIOI01ll0IO1(OOl1II1lO0I1lO0[4:0],trd_dlysize[4:0],clk,reset_b,1'b1,O1lIOOOIl1O1lIO);assign I01lOIIO0llIO10
=I01lOOlI1OlO10I;dff IOIl01OOl1IIIO0l(l0IO1lO10IIO01l,l10IOlIO10OIl01,clk,1'b1,reset_b);dff IOlI01IO0lIIOIl0
(OI01llO10IOOIl1,IlI0OOIl01OI01l,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[9]
=O1lIOOOIl1O1lIO?twr_dword_empty[9]:lIO10I01lOlO10I?lO10II1lO0IlO01[10]:lO10II1lO0IlO01[9];dff IOOl1IIlO01OlI1O
(OIl01OOIl1OOl1I,O01IlOOl1IIlI0O,clk,reset_b,1'b1);assign OI01llO10II1lO0
=
(IO01lIlO01IOIl0&m_hgrant&m_hready)|
(IlO01IlO01IlO01&~IlO01IOIl0IlO01&m_hgrant&m_hready&~OlI1OIIO0lI01lO)|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l&~IIO0lIIO0lO01Il&m_hgrant)|
(lIO10I1lO0OOIl1&m_hgrant&m_hready)|
(I01lOIO01llIO10&~m_hready)|

(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
m_hgrant&m_hready)|
(lO10Il10IOOI01l&IOIl0IlO01O1lIO&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
m_hgrant&m_hready)|
(OIl01l0IO1l10IO&OOIl1l10IOIO01l&m_hready&IIO0lIIO0lO01Il&(~IlO01IOIl0IlO01|~OlI01OlI1Ol10IO)&
m_hgrant&m_hready);assign OlI01l10IOOOl1I[12]
=O1lIOOOIl1O1lIO?twr_dword_full[12]:lIO10I01lOlO10I?O01Ill10IOlIO10[13]:O01Ill10IOlIO10[12];assign IlI0OIlO01OOIl1
=~(O1lIOOOIl1O1lIO&~lO10IOOIl1lIO10)&(IO01lOOl1IIO0lI|OI01lIlO01l0IO1);dff5 IIO01lOlI1OO01Il
(OOl1Il10IOIIO0l,IlO01l0IO1lO10I,clk,reset_b,1'b1);assign l0IO1IIO0lIIO0l[4:0]={4'b0000,~twr_dword_empty[10]};dff16 IlIO10l0IO1OIl01
(lO10IOlI01IOIl0[15:0],OIl01OI01llIO10[15:0],clk,reset_b,1'b1);assign lIO10IO01lIlI0O=l10IOI01lOIlI0O&~I1lO0l0IO1IlO01;assign OOIl1lO10II01lO
=l0IO1OOl1IlIO10;assign l0IO1IO01lIIO0l[15]=(OlI01IIO0lOOIl1[4:0]==5'b10000)?1'b1:1'b0;BUF IOIl01IO01llO10I
(I1lO0IlI0OIOIl0,I01lOIlI0OIlO01);assign IOIl0IIO0lOI01l[63:0]=OOl1IIOIl0I01lO[63:0];assign OI01lOlI1OOlI1O
=~((~IlI0OOlI01OlI1O&~IlO01IOIl0IlO01)|(~IlI0OOOIl1OlI01&~OlI01OlI1Ol10IO));assign IlO01IOIl0IO0lI[51:48]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[51:48]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1100))?4'b1111:
OOl1IIOIl0I01lO[51:48];assign OOIl1l10IOIO01l
=~m_hresp[0]&~m_hresp[1];assign IO01lIIO0lOIl01[23:16]=(IO01lO01IlIO01l)?O01IlOI01lOOl1I[23:16]:O01IlOI01lOOl1I[15:8];assign lIO10lIO10OOl1I
=((OOl1Il10IOIIO0l!=5'b00010)&&(OOl1Il10IOIIO0l!=5'b00001))?1'b1:1'b0;dffe5 IIlO01IIO0lOlI01
(IlO01I1lO0O1lIO[4:0],IO01ll10IOO01Il[4:0],clk,reset_b,1'b1,I01lOl0IO1I01lO);assign OlI1OIIO0lI01lO=1'b0;assign OIl01I1lO0IOIl0[1]
=O1lIOOOIl1O1lIO?twr_dword_empty[1]:lIO10I01lOlO10I?lO10II1lO0IlO01[2]:lO10II1lO0IlO01[1];assign IlI0OOIl01OI01l
=(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&OOl1IlO10IIO0lI)|
(OI01llO10IOOIl1&OOl1IlO10IIO0lI&OlI01IO01lOOIl1&(IlO01lIO10I01lO|~I1lO0OlI01lO10I));assign OlI01l10IOOOl1I[4]
=O1lIOOOIl1O1lIO?twr_dword_full[4]:lIO10I01lOlO10I?O01Ill10IOlIO10[5]:O01Ill10IOlIO10[4];assign IO0lIl0IO1I1lO0[0]
=~(OlI01IlI0OIlI0O[0]&~OOl1Il0IO1O01Il);dff IIO0lIIOIl0OI01l(l10IOI01lOIlI0O,IOIl0OIl01O01Il,clk,reset_b,1'b1);assign OlI1OO01IlOlI01[4:0]
={4'b0000,~twr_dword_empty[2]};dff4 Il10IOl10IOI01lO(lO10IIlI0OOOl1I[3:0],OIl01IOIl0IlI0O[3:0],clk,reset_b,1'b1);dff5 II1lO0OOIl1IO0lI
(OlI01OI01lOlI1O,O01IlOI01ll10IO,clk,reset_b,1'b1);assign I01lOIO0lIIO01l[31:0]=twr_doutb[31:0];assign OIl01OI01llIO10[5]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[5]|lO10IOlI01IOIl0[5]);assign IO0lIlO10IO01Il
=(OOl1IOlI01IO01l)?O1lIOOIl01I01lO:
(IO01lOI01llO10I)?OOIl1O01IlOIl01:
(IlO01OlI01IIO0l)?OlI1OOIl01IO0lI:
IIO0llIO10O1lIO;assign l0IO1IO01lIIO0l[4]
=(OlI01IIO0lOOIl1[4:0]==5'b00101)?1'b1:1'b0;assign IlI0OOlI01OlI1O
=
(OOIl1l10IOIO01l&m_hready&IO0lIIlI0OO1lIO)|
O1lIOIOIl0O01Il;assign IlO01IOIl0IO0lI[19:16]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[19:16]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0100))?4'b1111:
OOl1IIOIl0I01lO[19:16];assign IO01lI1lO0IIO0l
=
((IlI0OOlI01OlI1O==1'b1)&&((I01lOIIO0llIO10==4'b0000)||(I01lOIIO0llIO10==4'b0011)||(I01lOIIO0llIO10==4'b1100)||
(I01lOIIO0llIO10==4'b0111)||(I01lOIIO0llIO10==4'b1011)||(I01lOIIO0llIO10==4'b1101)||(I01lOIIO0llIO10==4'b1110)))?
I01lOIIO0llIO10:
(IlI0OOlI01OlI1O&~IlI0OIlO01I1lO0)?4'b0000:
(IlI0OOlI01OlI1O)?{2'b11,I01lOIIO0llIO10[1:0]}:
{IOIl0OOl1II1lO0[3:2],2'b11};assign IOIl0lIO10OOIl1[0]
=(IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[0]:
(~IO01lO01IlIO01l&OlI1OIO01lOlI1O)?O1lIOIO01ll10IO[3]:1'b0;assign m_hbar[0]
=~O1lIOIlO01O01Il[0];assign IIO0lI01lOl10IO[5:2]
=(OOl1IIlO01I01lO|l0IO1l10IOIlO01|O01IllIO10IlI0O)?(I1lO0IO0lIIIO0l[5:2]+IIO0lOlI1OOlI01[3:0]):IO0lII01lOOlI1O[5:2];assign IlI0OIlO01I1lO0
=OIl01IlO01IlI0O;assign IOIl0IO01lOI01l=l0IO1lO10IIO01l;dff IIOIl0OlI1OIlI0O(OlI1OOI01lO1lIO,OOIl1IlI0OO01Il,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[12]
=O1lIOOOIl1O1lIO?twr_dword_empty[12]:lIO10I01lOlO10I?lO10II1lO0IlO01[13]:lO10II1lO0IlO01[12];assign l0IO1OI01lIOIl0
=(IO01lIO01lOIl01&(~OlI01IO01lOOIl1|(~IlO01lIO10I01lO&I1lO0OlI01lO10I))&IOIl0IO01lOI01l)|
(I1lO0I01lOIIO0l&IOIl0IO01lOI01l)|
((IOIl0O01Ill10IO|IO0lIOlI01OlI01|OlI1OOI01lO1lIO)&lO10IOOIl1lIO10);assign IIO0lO01IlI01lO
=(l10IOI01lOIlI0O&m_hready)|
(l0IO1I1lO0l0IO1&~OOl1IOlI1OIIO0l)|
(OIl01l0IO1l10IO&OOIl1l10IOIO01l&m_hready&~IIO0lIIO0lO01Il);assign OlI01l10IOOOl1I[15]
=O1lIOOOIl1O1lIO?twr_dword_full[15]:lIO10I01lOlO10I?1'b0:O01Ill10IOlIO10[15];assign O01IlOOl1IIlI0O
=~(O1lIOOOIl1O1lIO&~lO10IOOIl1lIO10)&(OOl1IOOIl1O01Il|OIl01OOIl1OOl1I);assign I01lOlIO10IOIl0
=(OlI01O01IlOI01l<=9'b000010000)?OlI01O01IlOI01l[4:0]:5'b10000;assign OIl01O1lIOIOIl0[4:0]={4'b0000,~twr_dword_empty[13]};assign OIl01OI01llIO10[13]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[13]|lO10IOlI01IOIl0[13]);assign OI01lOlI01l10IO
=(~IlO01IlO01IlO01&~IIO0lIIO0lO01Il)?IlO01OOIl1lO10I[7:0]:OOl1IIlI0OlO10I[9:2];assign IO01lO01IlIO01l=~big_endian|swap;assign l0IO1IO01lIIO0l[12]
=(OlI01IIO0lOOIl1[4:0]==5'b01101)?1'b1:1'b0;dff IO01IlI01lOIlO01(IO0lIIO0lII01lO,O1lIOIO0lIIO0lI,clk,reset_b,1'b1);assign l10IOIO01lIO01l
=O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l;dff4 IO1lIOlIO10OI01l(IOIl0OOl1II1lO0,IIO0lOOl1IO1lIO,clk,1'b1,reset_b);assign IlO01IOIl0IO0lI[63:60]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[63:60]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b1111))?4'b1111:
OOl1IIOIl0I01lO[63:60];assign IO0lII01lOI01lO
=m_hresp[0]&m_hresp[1];dffe32 IOlI01OIl01IlO01(I1lO0IO0lIIIO0l,l10IOO1lIOlO10I,clk,reset_b,1'b1,O1lIOOOIl1O1lIO);assign m_hlock
=1'b0;dffe16 II1lO0O1lIOO01Il(lO10IOIl01lO10I[15:0],twr_dword_empty[15:0],clk,1'b1,reset_b,O1lIOOOIl1O1lIO);dff Il0IO1IlI0OOIl01
(IO01lIO01lOIl01,I01lOI01lOIO01l,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[4]
=O1lIOOOIl1O1lIO?twr_dword_empty[4]:lIO10I01lOlO10I?lO10II1lO0IlO01[5]:lO10II1lO0IlO01[4];assign OOIl1IlI0OO01Il
=(OI01llO10IOOIl1&~OlI01IO01lOOIl1)|
(OlI1OOI01lO1lIO&~lO10IOOIl1lIO10);assign OlI01l10IOOOl1I[7]
=O1lIOOOIl1O1lIO?twr_dword_full[7]:lIO10I01lOlO10I?O01Ill10IOlIO10[8]:O01Ill10IOlIO10[7];assign IO0lIl0IO1I1lO0[3]
=~(OlI01IlI0OIlI0O[3]&~OOl1Il0IO1O01Il);dff IOOIl1IO0lIOlI01(lO10Il10IOOI01l,O1lIOOlI01OIl01,clk,reset_b,1'b1);assign IlO01OI01lO01Il[4:0]
={4'b0000,~twr_dword_empty[5]};assign I1lO0OlI01lO10I=(OIl01O01IlIlO01[4:0]==5'b00001)?1'b1:1'b0;assign OI01lIlI0OOlI01
=
((IlI0OIlO01I1lO0==1'b1)&&
(I01lOIIO0llIO10!=4'b0000)&&(I01lOIIO0llIO10!=4'b0011)&&
(I01lOIIO0llIO10!=4'b0111)&&(I01lOIIO0llIO10!=4'b1011)&&
(I01lOIIO0llIO10!=4'b1100)&&(I01lOIIO0llIO10!=4'b1101)&&
(I01lOIIO0llIO10!=4'b1110))?5'b00010:
(OlI01OOl1IOlI01==5'b00000)?5'b10000:
OlI01OOl1IOlI01;assign IlO01O1lIOIO01l
=IlI0OI1lO0l10IO;assign OIl01OI01llIO10[2]=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[2]|lO10IOlI01IOIl0[2]);assign O1lIOOIl01I01lO
=
(IO01llIO10IlO01==5'b00001)?3'b000:
(OlI01OOl1IOlI01==5'b00000)?3'b001:
(IO01llIO10IlO01==5'b00100)?3'b011:
(IO01llIO10IlO01==5'b01000)?3'b101:
(IO01llIO10IlO01==5'b10000)?3'b111:
3'b001;assign l0IO1IO01lIIO0l[1]
=(OlI01IIO0lOOIl1[4:0]==5'b00010)?1'b1:1'b0;BUF IIlI0OI1lO0OOl1I(IO0lIIlI0OO1lIO,IOIl0OI01lOlI01);assign IlO01IOIl0IO0lI[31:28]
=(O1lIOOOIl1O1lIO&~IOIl0IO01lOI01l)?twr_be_b[31:28]:
((OlI01OlI01lIO10==1'b1)&(IIO0lOlI1OOlI01[3:0]==4'b0111))?4'b1111:
OOl1IIOIl0I01lO[31:28];assign lIO10O1lIOOOIl1
=((~IOIl0IlO01O1lIO&(I1lO0IO01lOOl1I|OIl01l0IO1l10IO))|
(IOIl0IlO01O1lIO&(I1lO0IO01lOOl1I|OIl01l0IO1l10IO)&~IIO0lIIO0lO01Il&~I1lO0l0IO1IlO01));assign OlI1OlIO10O01Il[15:8]
=(IO01lO01IlIO01l)?I01lOIO0lIIO01l[15:8]:I01lOIO0lIIO01l[23:16];assign m_hbar[3]=~O1lIOIlO01O01Il[3];assign OOIl1I01lOOlI01
=(trd_dlysize[4:0]==5'b00001)?1'b1:1'b0;assign IlO01IOIl0IlO01=IlO01O1lIOIO01l;assign IlI0OlIO10l0IO1
=~(O01IllIO10IlI0O&OOl1IlO10IIO0lI)&(O1lIOO1lIOOlI01|OI01ll0IO1IlI0O);assign I01lOI01lOIO01l
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&OOl1IlO10IIO0lI)|
(IO01lIO01lOIl01&OOl1IlO10IIO0lI&OlI01IO01lOOIl1&(IlO01lIO10I01lO|~lIO10lO10IIIO0l))|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&~IIO0lIO0lIl10IO&OOl1IlO10IIO0lI)|
(O01IllIO10IlI0O&OOl1IlO10IIO0lI);assign OIl01I1lO0IOIl0[15]
=O1lIOOOIl1O1lIO?twr_dword_empty[15]:lIO10I01lOlO10I?1'b1:lO10II1lO0IlO01[15];assign O1lIOI1lO0OlI01
=~((OOl1IIlO01I01lO&~IOIl0IO01lOI01l&~lO10IOIl01lO10I[0]&OOl1IlO10IIO0lI)|
(l0IO1l10IOIlO01&~IlI0OO1lIOl10IO&OOl1IlO10IIO0lI)|
(O01IllIO10IlI0O&OOl1IlO10IIO0lI)|
(OOl1IIlO01I01lO&~lO10IOOIl1lIO10&OOl1IlO10IIO0lI));assign OlI1OOI01lIO01l
=(I01lOIO01llIO10&m_hready&~IIO0lIIO0lO01Il&~m_hgrant)|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&~OIl01OlI01OI01l&~m_hgrant)|
(OIl01l0IO1l10IO&OOIl1l10IOIO01l&~m_hready);assign lIO10lO10IIIO0l
=(OI01lIOIl0l0IO1[4:0]==5'b00001)?1'b1:1'b0;assign I01lOlO10IOIl01[4:0]
=(OOl1IIlO01I01lO&~lO10IOOIl1lIO10)?OOl1II1lO0I1lO0[4:0]:
((OOl1IIlO01I01lO&~IOIl0IO01lOI01l)|l0IO1l10IOIlO01)?IlO01I1lO0O1lIO[4:0]:
(O01IllIO10IlI0O)?OI01lIOIl0l0IO1[4:0]:I1lO0OIl01IO01l[4:0];BUF II01lOOOIl1I01lO
(lO10IO01IlOOIl1,lIO10O01Ill0IO1);assign IlI0OOOl1Il0IO1[4:0]
=
IO0lIOIl01l10IO[4:0]+O1lIOOIl01OlI1O[4:0]+OlI1OO01IlOlI01[4:0]+OOIl1OlI01I1lO0[4:0]+
OOl1IOlI01O1lIO[4:0]+IlO01OI01lO01Il[4:0]+IO01lIlI0OI01lO[4:0]+I01lOIlI0OIO0lI[4:0]+
I1lO0IOIl0OIl01[4:0]+l10IOIIO0lIO01l[4:0]+l0IO1IIO0lIIO0l[4:0]+lIO10IO0lIlO10I[4:0]+
lO10IO1lIOIlO01[4:0]+OIl01O1lIOIOIl0[4:0]+O01IlOlI1OlIO10[4:0]+OlI01OlI1OOOl1I[4:0];assign OIl01OI01llIO10[10]
=~l10IOOI01lIlO01&(l0IO1IO01lIIO0l[10]|lO10IOlI01IOIl0[10]);dff3 IlIO10IlO01IO01l
(OIl01I01lOOOIl1,O01IlI1lO0OI01l,clk,reset_b,1'b1);assign l0IO1IO01lIIO0l[9]=(OlI01IIO0lOOIl1[4:0]==5'b01010)?1'b1:1'b0;assign OOl1IOlI1OIIO0l
=(IO0lIIO0lII01lO==1'b1)?1'b1:1'b0;assign OlI01OlI01lIO10
=(OOl1IIlO01I01lO&~IOIl0IO01lOI01l&lO10IOIl01lO10I[0])|(IO01lIO01lOIl01&~IlO01lIO10I01lO)|(l0IO1l10IOIlO01&IlI0OO1lIOl10IO);assign OIl01OIl01l0IO1
=(IlI0OOlI01OlI1O&~IO01lIOIl0IOIl0)|(~IlI0OOlI01OlI1O&O01IlOIl01OOIl1);assign IIO0llO10IOI01l[1]
=(IO01lO01IlIO01l)?O01IlIIO0ll0IO1[1]:O01IlIIO0ll0IO1[2];assign m_haddr[1:0]=l0IO1IOIl0OOl1I;dffe7 IIOIl0O01IlOOl1I
(OlI01IlI0OIlI0O,pci_bar,clk,reset_b,1'b1,O1lIOOOIl1O1lIO);assign m_htrans
=(I01lOIO01llIO10)?2'b10:
(I1lO0IO01lOOl1I&~OIl01OlI01OI01l)?2'b11:
2'b00;dff IlIO10OOIl1OIl01
(IlI0OO1lIOl10IO,IOIl0O1lIOOlI1O,clk,1'b1,reset_b);dff IOIl01IIO0llO10I(lO10Il0IO1lIO10,OIl01l0IO1OOl1I,clk,reset_b,1'b1);assign OIl01I1lO0IOIl0[7]
=O1lIOOOIl1O1lIO?twr_dword_empty[7]:lIO10I01lOlO10I?lO10II1lO0IlO01[8]:lO10II1lO0IlO01[7];dff IO1lIOOOl1IOI01l
(OI01lIlO01l0IO1,IlI0OIlO01OOIl1,clk,reset_b,1'b1);assign O01Ill0IO1OlI1O
=(IlO01IlO01IlO01&IlO01IOIl0IlO01)|
(lO10Il10IOOI01l&~IOIl0IlO01O1lIO)|
(lO10Il10IOOI01l&IOIl0IlO01O1lIO&IIO0lIIO0lO01Il&IlO01IOIl0IlO01&OlI01OlI1Ol10IO)|
(I1lO0IO01lOOl1I&OOIl1l10IOIO01l&m_hready&OIl01OlI01OI01l&IIO0lIIO0lO01Il&IlO01IOIl0IlO01&OlI01OlI1Ol10IO)|
(OIl01l0IO1l10IO&OOIl1l10IOIO01l&m_hready&IIO0lIIO0lO01Il&IlO01IOIl0IlO01&OlI01OlI1Ol10IO)|
OlI1OIIO0lI01lO;
endmodule 
