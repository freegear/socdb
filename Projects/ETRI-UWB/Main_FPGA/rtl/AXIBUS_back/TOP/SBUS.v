// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : BUSTOP.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : BUS TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
//version short name

//`define  ASSERT_ON
`timescale 1 ns/ 10ps
module SBUS(

//Write channel signal
    //_______________________________________________________________
    //For Master 0 :: ARMD
    //Write address channel
//Disable_id_port
    AWADDR_ARMD  ,
    AWLEN_ARMD   ,
    AWSIZE_ARMD  ,
    AWBURST_ARMD ,
    AWLOCK_ARMD  ,
//Disable_cache_port
//Disable_protect_port

    AWVALID_ARMD ,
    AWREADY_2_ARMD ,

    
    //Write data channel
//Disable_id_port
    WDATA_ARMD   ,
    WSTRB_ARMD   ,
    WLAST_ARMD   ,
    WVALID_ARMD  ,
    WREADY_2_ARMD  ,

    //Write response channel
//Disable_id_port
    BRESP_2_ARMD   ,
    BVALID_2_ARMD  ,
    BREADY_ARMD  ,
 
 
 
    //_______________________________________________________________
    //For Master 3 :: DMAC
    //Write address channel
    AWID_DMAC    ,
    AWADDR_DMAC  ,
    AWLEN_DMAC   ,
    AWSIZE_DMAC  ,
    AWBURST_DMAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_DMAC ,
    AWREADY_2_DMAC ,

    
    //Write data channel
    WID_DMAC     ,
    WDATA_DMAC   ,
    WSTRB_DMAC   ,
    WLAST_DMAC   ,
    WVALID_DMAC  ,
    WREADY_2_DMAC  ,

    //Write response channel
    BID_2_DMAC     ,
    BRESP_2_DMAC   ,
    BVALID_2_DMAC  ,
    BREADY_DMAC  ,
 
    //_______________________________________________________________
    //For Master 4 :: DMA2D
    //Write address channel
//Disable_id_port
    AWADDR_DMA2D  ,
    AWLEN_DMA2D   ,
    AWSIZE_DMA2D  ,
    AWBURST_DMA2D ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_DMA2D ,
    AWREADY_2_DMA2D ,

    
    //Write data channel
//Disable_id_port
    WDATA_DMA2D   ,
    WSTRB_DMA2D   ,
    WLAST_DMA2D   ,
    WVALID_DMA2D  ,
    WREADY_2_DMA2D  ,

    //Write response channel
//Disable_id_port
    BRESP_2_DMA2D   ,
    BVALID_2_DMA2D  ,
    BREADY_DMA2D  ,
 
    //_______________________________________________________________
    //For Master 5 :: VIF
    //Write address channel
//Disable_id_port
    AWADDR_VIF  ,
    AWLEN_VIF   ,
    AWSIZE_VIF  ,
    AWBURST_VIF ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_VIF ,
    AWREADY_2_VIF ,

    
    //Write data channel
//Disable_id_port
    WDATA_VIF   ,
    WSTRB_VIF   ,
    WLAST_VIF   ,
    WVALID_VIF  ,
    WREADY_2_VIF  ,

    //Write response channel
//Disable_id_port
    BRESP_2_VIF   ,
    BVALID_2_VIF  ,
    BREADY_VIF  ,
 
    //_______________________________________________________________
    //For Master 6 :: USB
    //Write address channel
//Disable_id_port
    AWADDR_USB  ,
    AWLEN_USB   ,
    AWSIZE_USB  ,
    AWBURST_USB ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALID_USB ,
    AWREADY_2_USB ,

    
    //Write data channel
//Disable_id_port
    WDATA_USB   ,
    WSTRB_USB   ,
    WLAST_USB   ,
    WVALID_USB  ,
    WREADY_2_USB  ,

    //Write response channel
//Disable_id_port
    BRESP_2_USB   ,
    BVALID_2_USB  ,
    BREADY_USB  ,
 

    //_______________________________________________________________
    //For Slave 0 :: DDR
    //Write address channel
    AWID_2_DDR    ,
    AWADDR_2_DDR  ,
    AWLEN_2_DDR   ,
    AWSIZE_2_DDR  ,
    AWBURST_2_DDR ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_DDR ,
    AWREADY_DDR ,

    //Write data channel
    WID_2_DDR     ,
    WDATA_2_DDR   ,
    WSTRB_2_DDR   ,
    WLAST_2_DDR   ,
    WVALID_2_DDR  ,
    WREADY_DDR  ,

    //Write response channel
    BID_DDR     ,
    BRESP_DDR   ,
    BVALID_DDR  ,
    BREADY_2_DDR  ,
 
    //_______________________________________________________________
    //For Slave 1 :: APB0
    //Write address channel
    AWID_2_APB0    ,
    AWADDR_2_APB0  ,
    AWLEN_2_APB0   ,
    AWSIZE_2_APB0  ,
    AWBURST_2_APB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_APB0 ,
    AWREADY_APB0 ,

    //Write data channel
    WID_2_APB0     ,
    WDATA_2_APB0   ,
//Disable_WSTRB_port
    WLAST_2_APB0   ,
    WVALID_2_APB0  ,
    WREADY_APB0  ,

    //Write response channel
    BID_APB0     ,
    BRESP_APB0   ,
    BVALID_APB0  ,
    BREADY_2_APB0  ,
 
    //_______________________________________________________________
    //For Slave 2 :: APB1
    //Write address channel
    AWID_2_APB1    ,
    AWADDR_2_APB1  ,
    AWLEN_2_APB1   ,
    AWSIZE_2_APB1  ,
    AWBURST_2_APB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_APB1 ,
    AWREADY_APB1 ,

    //Write data channel
    WID_2_APB1     ,
    WDATA_2_APB1   ,
//Disable_WSTRB_port
    WLAST_2_APB1   ,
    WVALID_2_APB1  ,
    WREADY_APB1  ,

    //Write response channel
    BID_APB1     ,
    BRESP_APB1   ,
    BVALID_APB1  ,
    BREADY_2_APB1  ,
 
    //_______________________________________________________________
    //For Slave 3 :: SMC
    //Write address channel
    AWID_2_SMC    ,
    AWADDR_2_SMC  ,
    AWLEN_2_SMC   ,
    AWSIZE_2_SMC  ,
    AWBURST_2_SMC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_SMC ,
    AWREADY_SMC ,

    //Write data channel
    WID_2_SMC     ,
    WDATA_2_SMC   ,
    WSTRB_2_SMC   ,
    WLAST_2_SMC   ,
    WVALID_2_SMC  ,
    WREADY_SMC  ,

    //Write response channel
    BID_SMC     ,
    BRESP_SMC   ,
    BVALID_SMC  ,
    BREADY_2_SMC  ,
 
    //_______________________________________________________________
    //For Slave 4 :: SSRAM
    //Write address channel
    AWID_2_SSRAM    ,
    AWADDR_2_SSRAM  ,
    AWLEN_2_SSRAM   ,
    AWSIZE_2_SSRAM  ,
    AWBURST_2_SSRAM ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port
    AWVALID_2_SSRAM ,
    AWREADY_SSRAM ,

    //Write data channel
    WID_2_SSRAM     ,
    WDATA_2_SSRAM   ,
    WSTRB_2_SSRAM   ,
    WLAST_2_SSRAM   ,
    WVALID_2_SSRAM  ,
    WREADY_SSRAM  ,

    //Write response channel
    BID_SSRAM     ,
    BRESP_SSRAM   ,
    BVALID_SSRAM  ,
    BREADY_2_SSRAM  ,
 


//Read channel signal
    //_______________________________________________________________
    //For Master 0 :: ARMD
    //Read address channel
//Disable_id_port
    ARADDR_ARMD  ,
    ARLEN_ARMD   ,
    ARSIZE_ARMD  ,
    ARBURST_ARMD ,
    ARLOCK_ARMD  ,
//Disable_cache_port
//Disable_protect_port

    ARVALID_ARMD ,
    ARREADY_2_ARMD ,

    //Read data channel
//Disable_id_port
    RRESP_2_ARMD   ,
    RDATA_2_ARMD   ,
    RLAST_2_ARMD   ,
    RVALID_2_ARMD  ,
    RREADY_ARMD  ,
    //_______________________________________________________________
    //For Master 1 :: ARMI
    //Read address channel
//Disable_id_port
    ARADDR_ARMI  ,
    ARLEN_ARMI   ,
    ARSIZE_ARMI  ,
    ARBURST_ARMI ,
    ARLOCK_ARMI  ,
//Disable_cache_port
//Disable_protect_port

    ARVALID_ARMI ,
    ARREADY_2_ARMI ,

    //Read data channel
//Disable_id_port
    RRESP_2_ARMI   ,
    RDATA_2_ARMI   ,
    RLAST_2_ARMI   ,
    RVALID_2_ARMI  ,
    RREADY_ARMI  ,
    //_______________________________________________________________
    //For Master 2 :: DM
    //Read address channel
    ARID_DM    ,
    ARADDR_DM  ,
    ARLEN_DM   ,
    ARSIZE_DM  ,
    ARBURST_DM ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_DM ,
    ARREADY_2_DM ,

    //Read data channel
    RID_2_DM     ,
    RRESP_2_DM   ,
    RDATA_2_DM   ,
    RLAST_2_DM   ,
    RVALID_2_DM  ,
    RREADY_DM  ,
    //_______________________________________________________________
    //For Master 3 :: DMAC
    //Read address channel
    ARID_DMAC    ,
    ARADDR_DMAC  ,
    ARLEN_DMAC   ,
    ARSIZE_DMAC  ,
    ARBURST_DMAC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_DMAC ,
    ARREADY_2_DMAC ,

    //Read data channel
    RID_2_DMAC     ,
    RRESP_2_DMAC   ,
    RDATA_2_DMAC   ,
    RLAST_2_DMAC   ,
    RVALID_2_DMAC  ,
    RREADY_DMAC  ,
    //_______________________________________________________________
    //For Master 4 :: DMA2D
    //Read address channel
//Disable_id_port
    ARADDR_DMA2D  ,
    ARLEN_DMA2D   ,
    ARSIZE_DMA2D  ,
    ARBURST_DMA2D ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_DMA2D ,
    ARREADY_2_DMA2D ,

    //Read data channel
//Disable_id_port
    RRESP_2_DMA2D   ,
    RDATA_2_DMA2D   ,
    RLAST_2_DMA2D   ,
    RVALID_2_DMA2D  ,
    RREADY_DMA2D  ,
    //_______________________________________________________________
    //For Master 6 :: USB
    //Read address channel
//Disable_id_port
    ARADDR_USB  ,
    ARLEN_USB   ,
    ARSIZE_USB  ,
    ARBURST_USB ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_USB ,
    ARREADY_2_USB ,

    //Read data channel
//Disable_id_port
    RRESP_2_USB   ,
    RDATA_2_USB   ,
    RLAST_2_USB   ,
    RVALID_2_USB  ,
    RREADY_USB  ,
    
    //_______________________________________________________________
    //For Slave 0 :: DDR
    ARID_2_DDR    ,
    ARADDR_2_DDR  ,
    ARLEN_2_DDR   ,
    ARSIZE_2_DDR  ,
    ARBURST_2_DDR ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_DDR ,
    ARREADY_DDR ,

    //Read data channel
    RID_DDR     ,
    RRESP_DDR   ,
    RDATA_DDR  ,
    RLAST_DDR  ,
    RVALID_DDR  ,
    RREADY_2_DDR  ,
    //_______________________________________________________________
    //For Slave 1 :: APB0
    ARID_2_APB0    ,
    ARADDR_2_APB0  ,
    ARLEN_2_APB0   ,
    ARSIZE_2_APB0  ,
    ARBURST_2_APB0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_APB0 ,
    ARREADY_APB0 ,

    //Read data channel
    RID_APB0     ,
    RRESP_APB0   ,
    RDATA_APB0  ,
    RLAST_APB0  ,
    RVALID_APB0  ,
    RREADY_2_APB0  ,
    //_______________________________________________________________
    //For Slave 2 :: APB1
    ARID_2_APB1    ,
    ARADDR_2_APB1  ,
    ARLEN_2_APB1   ,
    ARSIZE_2_APB1  ,
    ARBURST_2_APB1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_APB1 ,
    ARREADY_APB1 ,

    //Read data channel
    RID_APB1     ,
    RRESP_APB1   ,
    RDATA_APB1  ,
    RLAST_APB1  ,
    RVALID_APB1  ,
    RREADY_2_APB1  ,
    //_______________________________________________________________
    //For Slave 3 :: SMC
    ARID_2_SMC    ,
    ARADDR_2_SMC  ,
    ARLEN_2_SMC   ,
    ARSIZE_2_SMC  ,
    ARBURST_2_SMC ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_SMC ,
    ARREADY_SMC ,

    //Read data channel
    RID_SMC     ,
    RRESP_SMC   ,
    RDATA_SMC  ,
    RLAST_SMC  ,
    RVALID_SMC  ,
    RREADY_2_SMC  ,
    //_______________________________________________________________
    //For Slave 4 :: SSRAM
    ARID_2_SSRAM    ,
    ARADDR_2_SSRAM  ,
    ARLEN_2_SSRAM   ,
    ARSIZE_2_SSRAM  ,
    ARBURST_2_SSRAM ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALID_2_SSRAM ,
    ARREADY_SSRAM ,

    //Read data channel
    RID_SSRAM     ,
    RRESP_SSRAM   ,
    RDATA_SSRAM  ,
    RLAST_SSRAM  ,
    RVALID_SSRAM  ,
    RREADY_2_SSRAM  ,

    ACLK    ,
    ARESETn , 
    SelMAP1
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 2;
parameter SLAVEID_WID= 5;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 7;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter WRITECHID0_WID = 1 ;
parameter WRITECHID1_WID = 1 ;
parameter WRITECHID2_WID = 2 ;
parameter WRITECHID3_WID = 1 ;
parameter WRITECHID4_WID = 1 ;
parameter WRITECHID5_WID = 1 ;
parameter WRITECHID6_WID = 1 ;
parameter READCHID0_WID = 1 ;
parameter READCHID1_WID = 1 ;
parameter READCHID2_WID = 2 ;
parameter READCHID3_WID = 1 ;
parameter READCHID4_WID = 1 ;
parameter READCHID5_WID = 1 ;
parameter READCHID6_WID = 1 ;
parameter WR_SLAVEID0_WID = 4 ;
parameter WR_SLAVEID1_WID = 2 ;
parameter WR_SLAVEID2_WID = 2 ;
parameter WR_SLAVEID3_WID = 4 ;
parameter WR_SLAVEID4_WID = 4 ;
parameter WR_SLAVEID5_WID = 4 ;
parameter RD_SLAVEID0_WID = 5 ;
parameter RD_SLAVEID1_WID = 2 ;
parameter RD_SLAVEID2_WID = 2 ;
parameter RD_SLAVEID3_WID = 5 ;
parameter RD_SLAVEID4_WID = 5 ;
parameter RD_SLAVEID5_WID = 5 ;
parameter SELMASTER0_WID = 3 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 3 ;
parameter SELMASTER4_WID = 3 ;
parameter SELMASTER5_WID = 3 ;
parameter SELWRITE0_WID = 3 ;
parameter SELREAD0_WID = 3 ;
parameter SELWRITE1_WID = 1 ;
parameter SELREAD1_WID = 1 ;
parameter SELWRITE2_WID = 1 ;
parameter SELREAD2_WID = 1 ;
parameter SELWRITE3_WID = 3 ;
parameter SELREAD3_WID = 3 ;
parameter SELWRITE4_WID = 3 ;
parameter SELREAD4_WID = 3 ;
parameter SELWRITE5_WID = 3 ;
parameter SELREAD5_WID = 3 ;
parameter SLAVE_WRITEID0_WID = 1 ;
parameter SLAVE_WRITEID1_WID = 1 ;
parameter SLAVE_WRITEID2_WID = 1 ;
parameter SLAVE_WRITEID3_WID = 1 ;
parameter SLAVE_WRITEID4_WID = 1 ;
parameter SLAVE_WRITEID5_WID = 1 ;
parameter SLAVE_READID0_WID = 2 ;
parameter SLAVE_READID1_WID = 1 ;
parameter SLAVE_READID2_WID = 1 ;
parameter SLAVE_READID3_WID = 2 ;
parameter SLAVE_READID4_WID = 2 ;
parameter SLAVE_READID5_WID = 2 ;

    input   SelMAP1;
    input   ACLK;
    input   ARESETn;

    //Write Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARMD
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_ARMD;
    input   [AWLEN_WID-1:0]         AWLEN_ARMD;
    input   [AWSIZE_WID-1:0]        AWSIZE_ARMD;  
    input   [AWBURST_WID-1:0]       AWBURST_ARMD; 
    input   [AWLOCK_WID-1:0]        AWLOCK_ARMD;  
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_ARMD; 
    output  AWREADY_2_ARMD; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_ARMD;   
    input   [WSTRB_WID-1:0]         WSTRB_ARMD;   
    input   WLAST_ARMD;   
    input   WVALID_ARMD;  
    output  WREADY_2_ARMD;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_ARMD;   
    output   BVALID_2_ARMD;  
    input    BREADY_ARMD;  
 
 
 
    
    //For Master 3 :: DMAC
    //Write address channel
    input   [WRITECHID3_WID-1:0]   AWID_DMAC;    
    input   [ADDR_WID-1:0]          AWADDR_DMAC;
    input   [AWLEN_WID-1:0]         AWLEN_DMAC;
    input   [AWSIZE_WID-1:0]        AWSIZE_DMAC;  
    input   [AWBURST_WID-1:0]       AWBURST_DMAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_DMAC; 
    output  AWREADY_2_DMAC; 

    //Write data channel
    input   [WRITECHID3_WID-1:0]    WID_DMAC;     
    input   [BUS_WID-1:0]           WDATA_DMAC;   
    input   [WSTRB_WID-1:0]         WSTRB_DMAC;   
    input   WLAST_DMAC;   
    input   WVALID_DMAC;  
    output  WREADY_2_DMAC;  

    //Write response channel
    output   [WRITECHID3_WID-1:0]   BID_2_DMAC;     
    output   [BRESP_WID-1:0]        BRESP_2_DMAC;   
    output   BVALID_2_DMAC;  
    input    BREADY_DMAC;  
 
    
    //For Master 4 :: DMA2D
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_DMA2D;
    input   [AWLEN_WID-1:0]         AWLEN_DMA2D;
    input   [AWSIZE_WID-1:0]        AWSIZE_DMA2D;  
    input   [AWBURST_WID-1:0]       AWBURST_DMA2D; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_DMA2D; 
    output  AWREADY_2_DMA2D; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_DMA2D;   
    input   [WSTRB_WID-1:0]         WSTRB_DMA2D;   
    input   WLAST_DMA2D;   
    input   WVALID_DMA2D;  
    output  WREADY_2_DMA2D;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_DMA2D;   
    output   BVALID_2_DMA2D;  
    input    BREADY_DMA2D;  
 
    
    //For Master 5 :: VIF
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_VIF;
    input   [AWLEN_WID-1:0]         AWLEN_VIF;
    input   [AWSIZE_WID-1:0]        AWSIZE_VIF;  
    input   [AWBURST_WID-1:0]       AWBURST_VIF; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_VIF; 
    output  AWREADY_2_VIF; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_VIF;   
    input   [WSTRB_WID-1:0]         WSTRB_VIF;   
    input   WLAST_VIF;   
    input   WVALID_VIF;  
    output  WREADY_2_VIF;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_VIF;   
    output   BVALID_2_VIF;  
    input    BREADY_VIF;  
 
    
    //For Master 6 :: USB
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDR_USB;
    input   [AWLEN_WID-1:0]         AWLEN_USB;
    input   [AWSIZE_WID-1:0]        AWSIZE_USB;  
    input   [AWBURST_WID-1:0]       AWBURST_USB; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   AWVALID_USB; 
    output  AWREADY_2_USB; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATA_USB;   
    input   [WSTRB_WID-1:0]         WSTRB_USB;   
    input   WLAST_USB;   
    input   WVALID_USB;  
    output  WREADY_2_USB;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESP_2_USB;   
    output   BVALID_2_USB;  
    input    BREADY_USB;  
 


    //Write Channel MasterInterface
    //_______________________________________________________________
   
    // For slave 0 :: DDR
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID0_WID-1:0]AWID_2_DDR;    
    output   [ADDR_WID-1:0]     AWADDR_2_DDR;
    output   [AWLEN_WID-1:0]    AWLEN_2_DDR;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_DDR;  
    output   [AWBURST_WID-1:0]  AWBURST_2_DDR; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_DDR; 
    input    AWREADY_DDR; 
    
    //Write data channel
    output   [WR_SLAVEID0_WID-1:0]WID_2_DDR;     
    output   [BUS_WID-1:0]      WDATA_2_DDR;   
    output   [WSTRB_WID-1:0]    WSTRB_2_DDR;   
    output   WLAST_2_DDR;   
    output   WVALID_2_DDR;  
    input    WREADY_DDR; 

    //Write response channel
    input   [WR_SLAVEID0_WID-1:0] BID_DDR;     
    input   [BRESP_WID-1:0]     BRESP_DDR;   
    input   BVALID_DDR;  
    output  BREADY_2_DDR;  
   
    // For slave 1 :: APB0
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID1_WID-1:0]AWID_2_APB0;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB0;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB0;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB0;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_APB0; 
    input    AWREADY_APB0; 
    
    //Write data channel
    output   [WR_SLAVEID1_WID-1:0]WID_2_APB0;     
    output   [BUS_WID-1:0]      WDATA_2_APB0;   
//Disable_WSTRB_port
    output   WLAST_2_APB0;   
    output   WVALID_2_APB0;  
    input    WREADY_APB0; 

    //Write response channel
    input   [WR_SLAVEID1_WID-1:0] BID_APB0;     
    input   [BRESP_WID-1:0]     BRESP_APB0;   
    input   BVALID_APB0;  
    output  BREADY_2_APB0;  
   
    // For slave 2 :: APB1
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID2_WID-1:0]AWID_2_APB1;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB1;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB1;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB1;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_APB1; 
    input    AWREADY_APB1; 
    
    //Write data channel
    output   [WR_SLAVEID2_WID-1:0]WID_2_APB1;     
    output   [BUS_WID-1:0]      WDATA_2_APB1;   
//Disable_WSTRB_port
    output   WLAST_2_APB1;   
    output   WVALID_2_APB1;  
    input    WREADY_APB1; 

    //Write response channel
    input   [WR_SLAVEID2_WID-1:0] BID_APB1;     
    input   [BRESP_WID-1:0]     BRESP_APB1;   
    input   BVALID_APB1;  
    output  BREADY_2_APB1;  
   
    // For slave 3 :: SMC
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID3_WID-1:0]AWID_2_SMC;    
    output   [ADDR_WID-1:0]     AWADDR_2_SMC;
    output   [AWLEN_WID-1:0]    AWLEN_2_SMC;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_SMC;  
    output   [AWBURST_WID-1:0]  AWBURST_2_SMC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_SMC; 
    input    AWREADY_SMC; 
    
    //Write data channel
    output   [WR_SLAVEID3_WID-1:0]WID_2_SMC;     
    output   [BUS_WID-1:0]      WDATA_2_SMC;   
    output   [WSTRB_WID-1:0]    WSTRB_2_SMC;   
    output   WLAST_2_SMC;   
    output   WVALID_2_SMC;  
    input    WREADY_SMC; 

    //Write response channel
    input   [WR_SLAVEID3_WID-1:0] BID_SMC;     
    input   [BRESP_WID-1:0]     BRESP_SMC;   
    input   BVALID_SMC;  
    output  BREADY_2_SMC;  
   
    // For slave 4 :: SSRAM
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID4_WID-1:0]AWID_2_SSRAM;    
    output   [ADDR_WID-1:0]     AWADDR_2_SSRAM;
    output   [AWLEN_WID-1:0]    AWLEN_2_SSRAM;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_SSRAM;  
    output   [AWBURST_WID-1:0]  AWBURST_2_SSRAM; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALID_2_SSRAM; 
    input    AWREADY_SSRAM; 
    
    //Write data channel
    output   [WR_SLAVEID4_WID-1:0]WID_2_SSRAM;     
    output   [BUS_WID-1:0]      WDATA_2_SSRAM;   
    output   [WSTRB_WID-1:0]    WSTRB_2_SSRAM;   
    output   WLAST_2_SSRAM;   
    output   WVALID_2_SSRAM;  
    input    WREADY_SSRAM; 

    //Write response channel
    input   [WR_SLAVEID4_WID-1:0] BID_SSRAM;     
    input   [BRESP_WID-1:0]     BRESP_SSRAM;   
    input   BVALID_SSRAM;  
    output  BREADY_2_SSRAM;  


    //Read Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARMD
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_ARMD;
    input   [ARLEN_WID-1:0]    ARLEN_ARMD;
    input   [ARSIZE_WID-1:0]   ARSIZE_ARMD;  
    input   [ARBURST_WID-1:0]  ARBURST_ARMD; 
    input   [ARLOCK_WID-1:0]   ARLOCK_ARMD;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_ARMD; 
    output  ARREADY_2_ARMD; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_ARMD;   
    output   [BUS_WID-1:0]     RDATA_2_ARMD;
    output   RLAST_2_ARMD;
    output   RVALID_2_ARMD;  
    input    RREADY_ARMD;  
 
    
    //For Master 1 :: ARMI
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_ARMI;
    input   [ARLEN_WID-1:0]    ARLEN_ARMI;
    input   [ARSIZE_WID-1:0]   ARSIZE_ARMI;  
    input   [ARBURST_WID-1:0]  ARBURST_ARMI; 
    input   [ARLOCK_WID-1:0]   ARLOCK_ARMI;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_ARMI; 
    output  ARREADY_2_ARMI; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_ARMI;   
    output   [BUS_WID-1:0]     RDATA_2_ARMI;
    output   RLAST_2_ARMI;
    output   RVALID_2_ARMI;  
    input    RREADY_ARMI;  
 
    
    //For Master 2 :: DM
    //Read address channel
    input   [READCHID2_WID-1:0]ARID_DM;    
    input   [ADDR_WID-1:0]     ARADDR_DM;
    input   [ARLEN_WID-1:0]    ARLEN_DM;
    input   [ARSIZE_WID-1:0]   ARSIZE_DM;  
    input   [ARBURST_WID-1:0]  ARBURST_DM; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_DM; 
    output  ARREADY_2_DM; 

    //Read data channel
    output   [READCHID2_WID-1:0]RID_2_DM;     
    output   [BRESP_WID-1:0]   RRESP_2_DM;   
    output   [BUS_WID-1:0]     RDATA_2_DM;
    output   RLAST_2_DM;
    output   RVALID_2_DM;  
    input    RREADY_DM;  
 
    
    //For Master 3 :: DMAC
    //Read address channel
    input   [READCHID3_WID-1:0]ARID_DMAC;    
    input   [ADDR_WID-1:0]     ARADDR_DMAC;
    input   [ARLEN_WID-1:0]    ARLEN_DMAC;
    input   [ARSIZE_WID-1:0]   ARSIZE_DMAC;  
    input   [ARBURST_WID-1:0]  ARBURST_DMAC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_DMAC; 
    output  ARREADY_2_DMAC; 

    //Read data channel
    output   [READCHID3_WID-1:0]RID_2_DMAC;     
    output   [BRESP_WID-1:0]   RRESP_2_DMAC;   
    output   [BUS_WID-1:0]     RDATA_2_DMAC;
    output   RLAST_2_DMAC;
    output   RVALID_2_DMAC;  
    input    RREADY_DMAC;  
 
    
    //For Master 4 :: DMA2D
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_DMA2D;
    input   [ARLEN_WID-1:0]    ARLEN_DMA2D;
    input   [ARSIZE_WID-1:0]   ARSIZE_DMA2D;  
    input   [ARBURST_WID-1:0]  ARBURST_DMA2D; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_DMA2D; 
    output  ARREADY_2_DMA2D; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_DMA2D;   
    output   [BUS_WID-1:0]     RDATA_2_DMA2D;
    output   RLAST_2_DMA2D;
    output   RVALID_2_DMA2D;  
    input    RREADY_DMA2D;  
 
 
    
    //For Master 6 :: USB
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDR_USB;
    input   [ARLEN_WID-1:0]    ARLEN_USB;
    input   [ARSIZE_WID-1:0]   ARSIZE_USB;  
    input   [ARBURST_WID-1:0]  ARBURST_USB; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALID_USB; 
    output  ARREADY_2_USB; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESP_2_USB;   
    output   [BUS_WID-1:0]     RDATA_2_USB;
    output   RLAST_2_USB;
    output   RVALID_2_USB;  
    input    RREADY_USB;  
 


    //MasterInterface
    //_______________________________________________________________
    
    // For slave 0
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID0_WID-1:0]ARID_2_DDR;    
    output   [ADDR_WID-1:0]     ARADDR_2_DDR;
    output   [ARLEN_WID-1:0]    ARLEN_2_DDR;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_DDR;  
    output   [ARBURST_WID-1:0]  ARBURST_2_DDR; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_DDR; 
    input    ARREADY_DDR; 
    

    //Read data channel
    input   [RD_SLAVEID0_WID-1:0] RID_DDR;     
    input   [RRESP_WID-1:0]     RRESP_DDR;   
    input   [BUS_WID-1:0]       RDATA_DDR;  
    input   RLAST_DDR;  
    input   RVALID_DDR;  
    output  RREADY_2_DDR;  

    
    // For slave 1
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID1_WID-1:0]ARID_2_APB0;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB0;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB0;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB0;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_APB0; 
    input    ARREADY_APB0; 
    

    //Read data channel
    input   [RD_SLAVEID1_WID-1:0] RID_APB0;     
    input   [RRESP_WID-1:0]     RRESP_APB0;   
    input   [BUS_WID-1:0]       RDATA_APB0;  
    input   RLAST_APB0;  
    input   RVALID_APB0;  
    output  RREADY_2_APB0;  

    
    // For slave 2
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID2_WID-1:0]ARID_2_APB1;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB1;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB1;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB1;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_APB1; 
    input    ARREADY_APB1; 
    

    //Read data channel
    input   [RD_SLAVEID2_WID-1:0] RID_APB1;     
    input   [RRESP_WID-1:0]     RRESP_APB1;   
    input   [BUS_WID-1:0]       RDATA_APB1;  
    input   RLAST_APB1;  
    input   RVALID_APB1;  
    output  RREADY_2_APB1;  

    
    // For slave 3
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID3_WID-1:0]ARID_2_SMC;    
    output   [ADDR_WID-1:0]     ARADDR_2_SMC;
    output   [ARLEN_WID-1:0]    ARLEN_2_SMC;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_SMC;  
    output   [ARBURST_WID-1:0]  ARBURST_2_SMC; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_SMC; 
    input    ARREADY_SMC; 
    

    //Read data channel
    input   [RD_SLAVEID3_WID-1:0] RID_SMC;     
    input   [RRESP_WID-1:0]     RRESP_SMC;   
    input   [BUS_WID-1:0]       RDATA_SMC;  
    input   RLAST_SMC;  
    input   RVALID_SMC;  
    output  RREADY_2_SMC;  

    
    // For slave 4
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID4_WID-1:0]ARID_2_SSRAM;    
    output   [ADDR_WID-1:0]     ARADDR_2_SSRAM;
    output   [ARLEN_WID-1:0]    ARLEN_2_SSRAM;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_SSRAM;  
    output   [ARBURST_WID-1:0]  ARBURST_2_SSRAM; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALID_2_SSRAM; 
    input    ARREADY_SSRAM; 
    

    //Read data channel
    input   [RD_SLAVEID4_WID-1:0] RID_SSRAM;     
    input   [RRESP_WID-1:0]     RRESP_SSRAM;   
    input   [BUS_WID-1:0]       RDATA_SSRAM;  
    input   RLAST_SSRAM;  
    input   RVALID_SSRAM;  
    output  RREADY_2_SSRAM;  


//______________________________________________________DEFALUT_SLAVE_START
    // default slave
    // For slave 5 :: default
    //__________________________________________________
    //Write address channel
    wire   [WR_SLAVEID5_WID-1:0]AWID_2_default;    
    wire   [ADDR_WID-1:0]     AWADDR_2_default;
    wire   [AWLEN_WID-1:0]    AWLEN_2_default;
    wire   [AWSIZE_WID-1:0]   AWSIZE_2_default;  
    wire   [AWBURST_WID-1:0]  AWBURST_2_default; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    wire   AWVALID_2_default; 
    wire    AWREADY_default; 
    
    //Write data channel
    wire   [WR_SLAVEID5_WID-1:0]WID_2_default;     
    wire   [BUS_WID-1:0]      WDATA_2_default;   
    wire   [WSTRB_WID-1:0]    WSTRB_2_default;   
    wire   WLAST_2_default;   
    wire   WVALID_2_default;  
    wire    WREADY_default; 

    //Write response channel
    wire   [WR_SLAVEID5_WID-1:0] BID_default;     
    wire   [BRESP_WID-1:0]     BRESP_default;   
    wire   BVALID_default;  
    wire  BREADY_2_default;  

    //__________________________________________________
    // Read address channel
    wire   [RD_SLAVEID5_WID-1:0]ARID_2_default;    
    wire   [ADDR_WID-1:0]     ARADDR_2_default;
    wire   [ARLEN_WID-1:0]    ARLEN_2_default;
    wire   [ARSIZE_WID-1:0]   ARSIZE_2_default;  
    wire   [ARBURST_WID-1:0]  ARBURST_2_default; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    wire   ARVALID_2_default; 
    wire   ARREADY_default; 
    
    //Read data channel
    wire   [RD_SLAVEID5_WID-1:0] RID_default;     
    wire   [RRESP_WID-1:0]     RRESP_default;   
    wire   [BUS_WID-1:0]       RDATA_default;  
    wire   RLAST_default;  
    wire   RVALID_default;  
    wire   RREADY_2_default;  

DefaultSlave #(
	.WID_WIDTH(WR_SLAVEID5_WID),
	.RID_WIDTH(RD_SLAVEID5_WID)
)
DefaultSlave
(
		.ACLK(ACLK),
		.ARESETn(ARESETn),

		.AWID(AWID_2_default),
		.AWADDR(AWADDR_2_default),
		.AWLEN(AWLEN_2_default),
		.AWSIZE(AWSIZE_2_default),
		.AWBURST(AWBURST_2_default),
		.AWVALID(AWVALID_2_default),
		.AWREADY(AWREADY_default),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

		.WID(WID_2_default),
		.WDATA(WDATA_2_default),
		.WLAST(WLAST_2_default),
		.WVALID(WVALID_2_default),
        .WSTRB  (WSTRB_2_default),
		.WREADY (WREADY_default),

		.BID(BID_default),
		.BRESP(BRESP_default),
		.BVALID(BVALID_default),
		.BREADY(BREADY_2_default),

		.ARID(ARID_2_default),
		.ARADDR(ARADDR_2_default),
		.ARLEN(ARLEN_2_default),
		.ARSIZE(ARSIZE_2_default),
		.ARBURST(ARBURST_2_default),
		.ARVALID(ARVALID_2_default),
		.ARREADY(ARREADY_default),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

		// Read Data Channel
		.RID(RID_default),
		.RDATA(RDATA_default),
		.RRESP(RRESP_default),
		.RLAST(RLAST_default),
		.RVALID(RVALID_default),
		.RREADY(RREADY_2_default)
);
//______________________________________________________DEFALUT_SLAVE_END


//version short name
//Slave Lock signals were generated
//Slave module 0  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE0_WID-1:0]CtlDataWrite2Lock0;
    wire   [SELREAD0_WID-1:0]CtlDataRead2Lock0;     
    wire   Lock2wrmi0;
    wire   UnLock2wrmi0;
    wire   UnLock2rdmi0;
    wire   Lock2rdmi0 ;
    //wire   [SELWRITE0_WID:0]LockPort2wrmi0;
    //wire   [SELREAD0_WID:0]LockPort2rdmi0;
    reg   [SELWRITE0_WID:0]LockPort2wrmi0;
    reg   [SELREAD0_WID:0]LockPort2rdmi0;

    //Syn modified
    wire   ReadIntEmptyWrmi02Rdmi0;
    wire   DataCntEmptyRdmi02Wrmi0;

//Slave Lock signals were generated
//Slave module 1  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE1_WID-1:0]CtlDataWrite2Lock1;
    wire   [SELREAD1_WID-1:0]CtlDataRead2Lock1;     
    wire   Lock2wrmi1;
    wire   UnLock2wrmi1;
    wire   UnLock2rdmi1;
    wire   Lock2rdmi1 ;
    //wire   [SELWRITE1_WID:0]LockPort2wrmi1;
    //wire   [SELREAD1_WID:0]LockPort2rdmi1;
    reg   [SELWRITE1_WID:0]LockPort2wrmi1;
    reg   [SELREAD1_WID:0]LockPort2rdmi1;

    //Syn modified
    wire   ReadIntEmptyWrmi12Rdmi1;
    wire   DataCntEmptyRdmi12Wrmi1;

//Slave Lock signals were generated
//Slave module 2  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE2_WID-1:0]CtlDataWrite2Lock2;
    wire   [SELREAD2_WID-1:0]CtlDataRead2Lock2;     
    wire   Lock2wrmi2;
    wire   UnLock2wrmi2;
    wire   UnLock2rdmi2;
    wire   Lock2rdmi2 ;
    //wire   [SELWRITE2_WID:0]LockPort2wrmi2;
    //wire   [SELREAD2_WID:0]LockPort2rdmi2;
    reg   [SELWRITE2_WID:0]LockPort2wrmi2;
    reg   [SELREAD2_WID:0]LockPort2rdmi2;

    //Syn modified
    wire   ReadIntEmptyWrmi22Rdmi2;
    wire   DataCntEmptyRdmi22Wrmi2;

//Slave Lock signals were generated
//Slave module 3  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE3_WID-1:0]CtlDataWrite2Lock3;
    wire   [SELREAD3_WID-1:0]CtlDataRead2Lock3;     
    wire   Lock2wrmi3;
    wire   UnLock2wrmi3;
    wire   UnLock2rdmi3;
    wire   Lock2rdmi3 ;
    //wire   [SELWRITE3_WID:0]LockPort2wrmi3;
    //wire   [SELREAD3_WID:0]LockPort2rdmi3;
    reg   [SELWRITE3_WID:0]LockPort2wrmi3;
    reg   [SELREAD3_WID:0]LockPort2rdmi3;

    //Syn modified
    wire   ReadIntEmptyWrmi32Rdmi3;
    wire   DataCntEmptyRdmi32Wrmi3;

//Slave Lock signals were generated
//Slave module 4  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE4_WID-1:0]CtlDataWrite2Lock4;
    wire   [SELREAD4_WID-1:0]CtlDataRead2Lock4;     
    wire   Lock2wrmi4;
    wire   UnLock2wrmi4;
    wire   UnLock2rdmi4;
    wire   Lock2rdmi4 ;
    //wire   [SELWRITE4_WID:0]LockPort2wrmi4;
    //wire   [SELREAD4_WID:0]LockPort2rdmi4;
    reg   [SELWRITE4_WID:0]LockPort2wrmi4;
    reg   [SELREAD4_WID:0]LockPort2rdmi4;

    //Syn modified
    wire   ReadIntEmptyWrmi42Rdmi4;
    wire   DataCntEmptyRdmi42Wrmi4;

//Slave Lock signals were generated
//Slave module 5  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE5_WID-1:0]CtlDataWrite2Lock5;
    wire   [SELREAD5_WID-1:0]CtlDataRead2Lock5;     
    wire   Lock2wrmi5;
    wire   UnLock2wrmi5;
    wire   UnLock2rdmi5;
    wire   Lock2rdmi5 ;
    //wire   [SELWRITE5_WID:0]LockPort2wrmi5;
    //wire   [SELREAD5_WID:0]LockPort2rdmi5;
    reg   [SELWRITE5_WID:0]LockPort2wrmi5;
    reg   [SELREAD5_WID:0]LockPort2rdmi5;

    //Syn modified
    wire   ReadIntEmptyWrmi52Rdmi5;
    wire   DataCntEmptyRdmi52Wrmi5;

//_____________________________________________________________________



  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

// Protocal Checker for master ARMD
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID0_WID ),
    .RID_WIDTH(READCHID0_WID)
 )
ARMD_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_ARMD  ),
   .AWLEN       (AWLEN_ARMD   ),
   .AWSIZE      (AWSIZE_ARMD  ),
   .AWBURST     (AWBURST_ARMD ),
   .AWLOCK      (AWLOCK_ARMD  ),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_ARMD ),
   .AWREADY     (AWREADY_2_ARMD ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_ARMD   ),
   .WDATA       (WDATA_ARMD   ),
   .WSTRB       (WSTRB_ARMD   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_ARMD  ),
   .WREADY      (WREADY_2_ARMD  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_ARMD   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_ARMD  ),
   .BREADY       (BREADY_ARMD  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_ARMD  ),
   .ARLEN        (ARLEN_ARMD   ),
   .ARSIZE       (ARSIZE_ARMD  ),
   .ARBURST      (ARBURST_ARMD ),
   .ARLOCK       (ARLOCK_ARMD  ),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_ARMD ),
   .ARREADY      (ARREADY_2_ARMD ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_ARMD   ),
   .RDATA        (RDATA_2_ARMD   ),
   .RRESP        (RRESP_2_ARMD   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_ARMD  ),
   .RREADY       (RREADY_ARMD  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master ARMI
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID1_WID ),
    .RID_WIDTH(READCHID1_WID)
 )
ARMI_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),

   // Write Address Channel
   .AWID      ({WRITECHID1_WID{1'b0}}),
   .AWADDR    ({ADDR_WID{1'b0}}  ),
   .AWLEN     ({AWLEN_WID{1'b0}}   ),
   .AWSIZE    ({AWSIZE_WID{1'b0}}  ),
   .AWBURST   ({AWBURST_WID{1'b0}} ),
   .AWLOCK    ({AWLOCK_WID{1'b0}}  ),
   .AWCACHE   ({AWCACHE_WID{1'b0}} ),
   .AWPROT    ({AWPROT_WID{1'b0}}  ),
   .AWUSER    ({32{1'b0}}),
   .AWVALID   (1'b0 ),
   .AWREADY   (1'b0 ),
   // Write Channel
   .WID       ({WRITECHID1_WID{1'b0}}),
   .WLAST       (1'b0   ),
   .WDATA       ({BUS_WID{1'b0}}   ),
   .WSTRB       ({WSTRB_WID{1'b1}}   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (1'b0  ),
   .WREADY      (1'b0  ),
   // Write Response Channel
   .BID         ({WRITECHID1_WID{1'b0}}),
   .BRESP        ({BRESP_WID{1'b0}}   ),
   .BUSER        ({32{1'b0}}),
   .BVALID       (1'b0  ),
   .BREADY       (1'b0  ),

   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_ARMI  ),
   .ARLEN        (ARLEN_ARMI   ),
   .ARSIZE       (ARSIZE_ARMI  ),
   .ARBURST      (ARBURST_ARMI ),
   .ARLOCK       (ARLOCK_ARMI  ),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_ARMI ),
   .ARREADY      (ARREADY_2_ARMI ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_ARMI   ),
   .RDATA        (RDATA_2_ARMI   ),
   .RRESP        (RRESP_2_ARMI   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_ARMI  ),
   .RREADY       (RREADY_ARMI  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DM
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID2_WID ),
    .RID_WIDTH(READCHID2_WID)
 )
DM_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),

   // Write Address Channel
   .AWID      ({WRITECHID2_WID{1'b0}}),
   .AWADDR    ({ADDR_WID{1'b0}}  ),
   .AWLEN     ({AWLEN_WID{1'b0}}   ),
   .AWSIZE    ({AWSIZE_WID{1'b0}}  ),
   .AWBURST   ({AWBURST_WID{1'b0}} ),
   .AWLOCK    ({AWLOCK_WID{1'b0}}  ),
   .AWCACHE   ({AWCACHE_WID{1'b0}} ),
   .AWPROT    ({AWPROT_WID{1'b0}}  ),
   .AWUSER    ({32{1'b0}}),
   .AWVALID   (1'b0 ),
   .AWREADY   (1'b0 ),
   // Write Channel
   .WID       ({WRITECHID2_WID{1'b0}}),
   .WLAST       (1'b0   ),
   .WDATA       ({BUS_WID{1'b0}}   ),
   .WSTRB       ({WSTRB_WID{1'b1}}   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (1'b0  ),
   .WREADY      (1'b0  ),
   // Write Response Channel
   .BID         ({WRITECHID2_WID{1'b0}}),
   .BRESP        ({BRESP_WID{1'b0}}   ),
   .BUSER        ({32{1'b0}}),
   .BVALID       (1'b0  ),
   .BREADY       (1'b0  ),

   // Read Address Channel
   .ARID         (ARID_DM    ),
   .ARADDR       (ARADDR_DM  ),
   .ARLEN        (ARLEN_DM   ),
   .ARSIZE       (ARSIZE_DM  ),
   .ARBURST      (ARBURST_DM ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DM ),
   .ARREADY      (ARREADY_2_DM ),

   // Read Channel
   .RID          (RID_2_DM     ),
   .RLAST        (RLAST_2_DM   ),
   .RDATA        (RDATA_2_DM   ),
   .RRESP        (RRESP_2_DM   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DM  ),
   .RREADY       (RREADY_DM  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DMAC
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID3_WID ),
    .RID_WIDTH(READCHID3_WID)
 )
DMAC_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID        (AWID_DMAC    ),
   .AWADDR      (AWADDR_DMAC  ),
   .AWLEN       (AWLEN_DMAC   ),
   .AWSIZE      (AWSIZE_DMAC  ),
   .AWBURST     (AWBURST_DMAC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_DMAC ),
   .AWREADY     (AWREADY_2_DMAC ),

   // Write Channel
   .WID         (WID_DMAC     ),
   .WLAST       (WLAST_DMAC   ),
   .WDATA       (WDATA_DMAC   ),
   .WSTRB       (WSTRB_DMAC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_DMAC  ),
   .WREADY      (WREADY_2_DMAC  ),

   // Write Response Channel
   .BID          (BID_2_DMAC     ),
   .BRESP        (BRESP_2_DMAC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_DMAC  ),
   .BREADY       (BREADY_DMAC  ),


   // Read Address Channel
   .ARID         (ARID_DMAC    ),
   .ARADDR       (ARADDR_DMAC  ),
   .ARLEN        (ARLEN_DMAC   ),
   .ARSIZE       (ARSIZE_DMAC  ),
   .ARBURST      (ARBURST_DMAC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DMAC ),
   .ARREADY      (ARREADY_2_DMAC ),

   // Read Channel
   .RID          (RID_2_DMAC     ),
   .RLAST        (RLAST_2_DMAC   ),
   .RDATA        (RDATA_2_DMAC   ),
   .RRESP        (RRESP_2_DMAC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DMAC  ),
   .RREADY       (RREADY_DMAC  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DMA2D
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID4_WID ),
    .RID_WIDTH(READCHID4_WID)
 )
DMA2D_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_DMA2D  ),
   .AWLEN       (AWLEN_DMA2D   ),
   .AWSIZE      (AWSIZE_DMA2D  ),
   .AWBURST     (AWBURST_DMA2D ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_DMA2D ),
   .AWREADY     (AWREADY_2_DMA2D ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_DMA2D   ),
   .WDATA       (WDATA_DMA2D   ),
   .WSTRB       (WSTRB_DMA2D   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_DMA2D  ),
   .WREADY      (WREADY_2_DMA2D  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_DMA2D   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_DMA2D  ),
   .BREADY       (BREADY_DMA2D  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_DMA2D  ),
   .ARLEN        (ARLEN_DMA2D   ),
   .ARSIZE       (ARSIZE_DMA2D  ),
   .ARBURST      (ARBURST_DMA2D ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DMA2D ),
   .ARREADY      (ARREADY_2_DMA2D ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_DMA2D   ),
   .RDATA        (RDATA_2_DMA2D   ),
   .RRESP        (RRESP_2_DMA2D   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DMA2D  ),
   .RREADY       (RREADY_DMA2D  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master VIF
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID5_WID ),
    .RID_WIDTH(READCHID5_WID)
 )
VIF_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_VIF  ),
   .AWLEN       (AWLEN_VIF   ),
   .AWSIZE      (AWSIZE_VIF  ),
   .AWBURST     (AWBURST_VIF ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_VIF ),
   .AWREADY     (AWREADY_2_VIF ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_VIF   ),
   .WDATA       (WDATA_VIF   ),
   .WSTRB       (WSTRB_VIF   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_VIF  ),
   .WREADY      (WREADY_2_VIF  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_VIF   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_VIF  ),
   .BREADY       (BREADY_VIF  ),

   .ARID         ({READCHID5_WID{1'b0}}),
   .ARADDR       ({ADDR_WID{1'b0}}),
   .ARLEN        ({AWLEN_WID{1'b0}}),
   .ARSIZE       ({ARSIZE_WID{1'b0}}  ),
   .ARBURST      ({ARBURST_WID{1'b0}} ),
   .ARLOCK       ({ARLOCK_WID{1'b0}}  ),
   .ARCACHE      ({ARCACHE_WID{1'b0}} ),
   .ARPROT       ({ARPROT_WID{1'b0}}  ),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (1'b0 ),
   .ARREADY      (1'b0 ),
   // Read Channel
   .RID         ({READCHID5_WID{1'b0}}),
   .RLAST        (1'b0),
   .RDATA        ({BUS_WID{1'b0}}),
   .RRESP        ({RRESP_WID{1'b0}}),
   .RUSER        ({32{1'b0}}),
   .RVALID       (1'b0),
   .RREADY       (1'b0),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master USB
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID6_WID ),
    .RID_WIDTH(READCHID6_WID)
 )
USB_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_USB  ),
   .AWLEN       (AWLEN_USB   ),
   .AWSIZE      (AWSIZE_USB  ),
   .AWBURST     (AWBURST_USB ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_USB ),
   .AWREADY     (AWREADY_2_USB ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_USB   ),
   .WDATA       (WDATA_USB   ),
   .WSTRB       (WSTRB_USB   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_USB  ),
   .WREADY      (WREADY_2_USB  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_USB   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_USB  ),
   .BREADY       (BREADY_USB  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_USB  ),
   .ARLEN        (ARLEN_USB   ),
   .ARSIZE       (ARSIZE_USB  ),
   .ARBURST      (ARBURST_USB ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_USB ),
   .ARREADY      (ARREADY_2_USB ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_USB   ),
   .RDATA        (RDATA_2_USB   ),
   .RRESP        (RRESP_2_USB   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_USB  ),
   .RREADY       (RREADY_USB  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

// Protocal Checker for slave DDR
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID0_WID ),
    .RID_WIDTH(RD_SLAVEID0_WID)
 )
DDR_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_DDR    ),
   .AWADDR      (AWADDR_2_DDR  ),
   .AWLEN       (AWLEN_2_DDR   ),
   .AWSIZE      (AWSIZE_2_DDR  ),
   .AWBURST     (AWBURST_2_DDR ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_DDR ),
   .AWREADY     (AWREADY_DDR ),

   // Write Channel
   .WID         (WID_2_DDR     ),
   .WLAST       (WLAST_2_DDR   ),
   .WDATA       (WDATA_2_DDR   ),
   .WSTRB       (WSTRB_2_DDR   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_DDR  ),
   .WREADY      (WREADY_DDR  ),

   // Write Response Channel
   .BID          (BID_DDR     ),
   .BRESP        (BRESP_DDR   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_DDR  ),
   .BREADY       (BREADY_2_DDR  ),

   // Read Address Channel
   .ARID         (ARID_2_DDR    ),
   .ARADDR       (ARADDR_2_DDR  ),
   .ARLEN        (ARLEN_2_DDR   ),
   .ARSIZE       (ARSIZE_2_DDR  ),
   .ARBURST      (ARBURST_2_DDR ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_DDR ),
   .ARREADY      (ARREADY_DDR ),

   // Read Channel
   .RID          (RID_DDR     ),
   .RLAST        (RLAST_DDR   ),
   .RDATA        (RDATA_DDR   ),
   .RRESP        (RRESP_DDR   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_DDR  ),
   .RREADY       (RREADY_2_DDR  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB0
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID1_WID ),
    .RID_WIDTH(RD_SLAVEID1_WID)
 )
APB0_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB0    ),
   .AWADDR      (AWADDR_2_APB0  ),
   .AWLEN       (AWLEN_2_APB0   ),
   .AWSIZE      (AWSIZE_2_APB0  ),
   .AWBURST     (AWBURST_2_APB0 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB0 ),
   .AWREADY     (AWREADY_APB0 ),

   // Write Channel
   .WID         (WID_2_APB0     ),
   .WLAST       (WLAST_2_APB0   ),
   .WDATA       (WDATA_2_APB0   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB0  ),
   .WREADY      (WREADY_APB0  ),

   // Write Response Channel
   .BID          (BID_APB0     ),
   .BRESP        (BRESP_APB0   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB0  ),
   .BREADY       (BREADY_2_APB0  ),

   // Read Address Channel
   .ARID         (ARID_2_APB0    ),
   .ARADDR       (ARADDR_2_APB0  ),
   .ARLEN        (ARLEN_2_APB0   ),
   .ARSIZE       (ARSIZE_2_APB0  ),
   .ARBURST      (ARBURST_2_APB0 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB0 ),
   .ARREADY      (ARREADY_APB0 ),

   // Read Channel
   .RID          (RID_APB0     ),
   .RLAST        (RLAST_APB0   ),
   .RDATA        (RDATA_APB0   ),
   .RRESP        (RRESP_APB0   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB0  ),
   .RREADY       (RREADY_2_APB0  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB1
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID2_WID ),
    .RID_WIDTH(RD_SLAVEID2_WID)
 )
APB1_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB1    ),
   .AWADDR      (AWADDR_2_APB1  ),
   .AWLEN       (AWLEN_2_APB1   ),
   .AWSIZE      (AWSIZE_2_APB1  ),
   .AWBURST     (AWBURST_2_APB1 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB1 ),
   .AWREADY     (AWREADY_APB1 ),

   // Write Channel
   .WID         (WID_2_APB1     ),
   .WLAST       (WLAST_2_APB1   ),
   .WDATA       (WDATA_2_APB1   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB1  ),
   .WREADY      (WREADY_APB1  ),

   // Write Response Channel
   .BID          (BID_APB1     ),
   .BRESP        (BRESP_APB1   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB1  ),
   .BREADY       (BREADY_2_APB1  ),

   // Read Address Channel
   .ARID         (ARID_2_APB1    ),
   .ARADDR       (ARADDR_2_APB1  ),
   .ARLEN        (ARLEN_2_APB1   ),
   .ARSIZE       (ARSIZE_2_APB1  ),
   .ARBURST      (ARBURST_2_APB1 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB1 ),
   .ARREADY      (ARREADY_APB1 ),

   // Read Channel
   .RID          (RID_APB1     ),
   .RLAST        (RLAST_APB1   ),
   .RDATA        (RDATA_APB1   ),
   .RRESP        (RRESP_APB1   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB1  ),
   .RREADY       (RREADY_2_APB1  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave SMC
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID3_WID ),
    .RID_WIDTH(RD_SLAVEID3_WID)
 )
SMC_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_SMC    ),
   .AWADDR      (AWADDR_2_SMC  ),
   .AWLEN       (AWLEN_2_SMC   ),
   .AWSIZE      (AWSIZE_2_SMC  ),
   .AWBURST     (AWBURST_2_SMC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_SMC ),
   .AWREADY     (AWREADY_SMC ),

   // Write Channel
   .WID         (WID_2_SMC     ),
   .WLAST       (WLAST_2_SMC   ),
   .WDATA       (WDATA_2_SMC   ),
   .WSTRB       (WSTRB_2_SMC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_SMC  ),
   .WREADY      (WREADY_SMC  ),

   // Write Response Channel
   .BID          (BID_SMC     ),
   .BRESP        (BRESP_SMC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_SMC  ),
   .BREADY       (BREADY_2_SMC  ),

   // Read Address Channel
   .ARID         (ARID_2_SMC    ),
   .ARADDR       (ARADDR_2_SMC  ),
   .ARLEN        (ARLEN_2_SMC   ),
   .ARSIZE       (ARSIZE_2_SMC  ),
   .ARBURST      (ARBURST_2_SMC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_SMC ),
   .ARREADY      (ARREADY_SMC ),

   // Read Channel
   .RID          (RID_SMC     ),
   .RLAST        (RLAST_SMC   ),
   .RDATA        (RDATA_SMC   ),
   .RRESP        (RRESP_SMC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_SMC  ),
   .RREADY       (RREADY_2_SMC  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave SSRAM
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID4_WID ),
    .RID_WIDTH(RD_SLAVEID4_WID)
 )
SSRAM_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_SSRAM    ),
   .AWADDR      (AWADDR_2_SSRAM  ),
   .AWLEN       (AWLEN_2_SSRAM   ),
   .AWSIZE      (AWSIZE_2_SSRAM  ),
   .AWBURST     (AWBURST_2_SSRAM ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_SSRAM ),
   .AWREADY     (AWREADY_SSRAM ),

   // Write Channel
   .WID         (WID_2_SSRAM     ),
   .WLAST       (WLAST_2_SSRAM   ),
   .WDATA       (WDATA_2_SSRAM   ),
   .WSTRB       (WSTRB_2_SSRAM   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_SSRAM  ),
   .WREADY      (WREADY_SSRAM  ),

   // Write Response Channel
   .BID          (BID_SSRAM     ),
   .BRESP        (BRESP_SSRAM   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_SSRAM  ),
   .BREADY       (BREADY_2_SSRAM  ),

   // Read Address Channel
   .ARID         (ARID_2_SSRAM    ),
   .ARADDR       (ARADDR_2_SSRAM  ),
   .ARLEN        (ARLEN_2_SSRAM   ),
   .ARSIZE       (ARSIZE_2_SSRAM  ),
   .ARBURST      (ARBURST_2_SSRAM ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_SSRAM ),
   .ARREADY      (ARREADY_SSRAM ),

   // Read Channel
   .RID          (RID_SSRAM     ),
   .RLAST        (RLAST_SSRAM   ),
   .RDATA        (RDATA_SSRAM   ),
   .RRESP        (RRESP_SSRAM   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_SSRAM  ),
   .RREADY       (RREADY_2_SSRAM  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave default
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID5_WID ),
    .RID_WIDTH(RD_SLAVEID5_WID)
 )
default_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_default    ),
   .AWADDR      (AWADDR_2_default  ),
   .AWLEN       (AWLEN_2_default   ),
   .AWSIZE      (AWSIZE_2_default  ),
   .AWBURST     (AWBURST_2_default ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_default ),
   .AWREADY     (AWREADY_default ),

   // Write Channel
   .WID         (WID_2_default     ),
   .WLAST       (WLAST_2_default   ),
   .WDATA       (WDATA_2_default   ),
   .WSTRB       (WSTRB_2_default   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_default  ),
   .WREADY      (WREADY_default  ),

   // Write Response Channel
   .BID          (BID_default     ),
   .BRESP        (BRESP_default   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_default  ),
   .BREADY       (BREADY_2_default  ),

   // Read Address Channel
   .ARID         (ARID_2_default    ),
   .ARADDR       (ARADDR_2_default  ),
   .ARLEN        (ARLEN_2_default   ),
   .ARSIZE       (ARSIZE_2_default  ),
   .ARBURST      (ARBURST_2_default ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_default ),
   .ARREADY      (ARREADY_default ),

   // Read Channel
   .RID          (RID_default     ),
   .RLAST        (RLAST_default   ),
   .RDATA        (RDATA_default   ),
   .RRESP        (RRESP_default   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_default  ),
   .RREADY       (RREADY_2_default  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

//Write Channel 
//_____________________________________________________________________

WriteChannel 

SBUS_WriteChannel(

    //_______________________________________________________________
    //For Master 0
    //Write address channel
//Disable_id_port
    .AWADDRm02si0  (AWADDR_ARMD  ),
    .AWLENm02si0   (AWLEN_ARMD   ),
    .AWSIZEm02si0  (AWSIZE_ARMD  ),
    .AWBURSTm02si0 (AWBURST_ARMD ),
    .AWLOCKm02si0  (AWLOCK_ARMD  ),
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm02si0 (AWVALID_ARMD ),
    .AWREADYsi02m0 (AWREADY_2_ARMD ),

    //Write data channel
//Disable_id_port
    .WDATAm02si0   (WDATA_ARMD   ),
    .WSTRBm02si0   (WSTRB_ARMD   ),
    .WLASTm02si0   (WLAST_ARMD   ),
    .WVALIDm02si0  (WVALID_ARMD  ),
    .WREADYsi02m0  (WREADY_2_ARMD  ),

    //Write response channel
//Disable_id_port
    .BRESPsi02m0   (BRESP_2_ARMD   ),
    .BVALIDsi02m0  (BVALID_2_ARMD  ),
    .BREADYm02si0  (BREADY_ARMD  ),
    //_______________________________________________________________
    //For Master 3
    //Write address channel
    .AWIDm32si3    (AWID_DMAC    ),
    .AWADDRm32si3  (AWADDR_DMAC  ),
    .AWLENm32si3   (AWLEN_DMAC   ),
    .AWSIZEm32si3  (AWSIZE_DMAC  ),
    .AWBURSTm32si3 (AWBURST_DMAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm32si3 (AWVALID_DMAC ),
    .AWREADYsi32m3 (AWREADY_2_DMAC ),

    //Write data channel
    .WIDm32si3     (WID_DMAC     ),
    .WDATAm32si3   (WDATA_DMAC   ),
    .WSTRBm32si3   (WSTRB_DMAC   ),
    .WLASTm32si3   (WLAST_DMAC   ),
    .WVALIDm32si3  (WVALID_DMAC  ),
    .WREADYsi32m3  (WREADY_2_DMAC  ),

    //Write response channel
    .BIDsi32m3     (BID_2_DMAC     ),
    .BRESPsi32m3   (BRESP_2_DMAC   ),
    .BVALIDsi32m3  (BVALID_2_DMAC  ),
    .BREADYm32si3  (BREADY_DMAC  ),
    //_______________________________________________________________
    //For Master 4
    //Write address channel
//Disable_id_port
    .AWADDRm42si4  (AWADDR_DMA2D  ),
    .AWLENm42si4   (AWLEN_DMA2D   ),
    .AWSIZEm42si4  (AWSIZE_DMA2D  ),
    .AWBURSTm42si4 (AWBURST_DMA2D ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm42si4 (AWVALID_DMA2D ),
    .AWREADYsi42m4 (AWREADY_2_DMA2D ),

    //Write data channel
//Disable_id_port
    .WDATAm42si4   (WDATA_DMA2D   ),
    .WSTRBm42si4   (WSTRB_DMA2D   ),
    .WLASTm42si4   (WLAST_DMA2D   ),
    .WVALIDm42si4  (WVALID_DMA2D  ),
    .WREADYsi42m4  (WREADY_2_DMA2D  ),

    //Write response channel
//Disable_id_port
    .BRESPsi42m4   (BRESP_2_DMA2D   ),
    .BVALIDsi42m4  (BVALID_2_DMA2D  ),
    .BREADYm42si4  (BREADY_DMA2D  ),
    //_______________________________________________________________
    //For Master 5
    //Write address channel
//Disable_id_port
    .AWADDRm52si5  (AWADDR_VIF  ),
    .AWLENm52si5   (AWLEN_VIF   ),
    .AWSIZEm52si5  (AWSIZE_VIF  ),
    .AWBURSTm52si5 (AWBURST_VIF ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm52si5 (AWVALID_VIF ),
    .AWREADYsi52m5 (AWREADY_2_VIF ),

    //Write data channel
//Disable_id_port
    .WDATAm52si5   (WDATA_VIF   ),
    .WSTRBm52si5   (WSTRB_VIF   ),
    .WLASTm52si5   (WLAST_VIF   ),
    .WVALIDm52si5  (WVALID_VIF  ),
    .WREADYsi52m5  (WREADY_2_VIF  ),

    //Write response channel
//Disable_id_port
    .BRESPsi52m5   (BRESP_2_VIF   ),
    .BVALIDsi52m5  (BVALID_2_VIF  ),
    .BREADYm52si5  (BREADY_VIF  ),
    //_______________________________________________________________
    //For Master 6
    //Write address channel
//Disable_id_port
    .AWADDRm62si6  (AWADDR_USB  ),
    .AWLENm62si6   (AWLEN_USB   ),
    .AWSIZEm62si6  (AWSIZE_USB  ),
    .AWBURSTm62si6 (AWBURST_USB ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm62si6 (AWVALID_USB ),
    .AWREADYsi62m6 (AWREADY_2_USB ),

    //Write data channel
//Disable_id_port
    .WDATAm62si6   (WDATA_USB   ),
    .WSTRBm62si6   (WSTRB_USB   ),
    .WLASTm62si6   (WLAST_USB   ),
    .WVALIDm62si6  (WVALID_USB  ),
    .WREADYsi62m6  (WREADY_2_USB  ),

    //Write response channel
//Disable_id_port
    .BRESPsi62m6   (BRESP_2_USB   ),
    .BVALIDsi62m6  (BVALID_2_USB  ),
    .BREADYm62si6  (BREADY_USB  ),

    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    .AWIDmi02s0    (AWID_2_DDR    ),
    .AWADDRmi02s0  (AWADDR_2_DDR  ),
    .AWLENmi02s0   (AWLEN_2_DDR   ),
    .AWSIZEmi02s0  (AWSIZE_2_DDR  ),
    .AWBURSTmi02s0 (AWBURST_2_DDR ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi02s0 (AWVALID_2_DDR ),
    .AWREADYs02mi0 (AWREADY_DDR ),

    //Write data channel
    .WIDmi02s0     (WID_2_DDR     ),
    .WDATAmi02s0   (WDATA_2_DDR   ),
    .WSTRBmi02s0   (WSTRB_2_DDR   ),
    .WLASTmi02s0   (WLAST_2_DDR   ),
    .WVALIDmi02s0  (WVALID_2_DDR  ),
    .WREADYs02mi0  (WREADY_DDR  ),

    //Write response channel
    .BIDs02mi0     (BID_DDR     ),
    .BRESPs02mi0   (BRESP_DDR   ),
    .BVALIDs02mi0  (BVALID_DDR  ),
    .BREADYmi02s0  (BREADY_2_DDR  ),

    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    .AWIDmi12s1    (AWID_2_APB0    ),
    .AWADDRmi12s1  (AWADDR_2_APB0  ),
    .AWLENmi12s1   (AWLEN_2_APB0   ),
    .AWSIZEmi12s1  (AWSIZE_2_APB0  ),
    .AWBURSTmi12s1 (AWBURST_2_APB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi12s1 (AWVALID_2_APB0 ),
    .AWREADYs12mi1 (AWREADY_APB0 ),

    //Write data channel
    .WIDmi12s1     (WID_2_APB0     ),
    .WDATAmi12s1   (WDATA_2_APB0   ),
//Disable_WSTRB_port
    .WLASTmi12s1   (WLAST_2_APB0   ),
    .WVALIDmi12s1  (WVALID_2_APB0  ),
    .WREADYs12mi1  (WREADY_APB0  ),

    //Write response channel
    .BIDs12mi1     (BID_APB0     ),
    .BRESPs12mi1   (BRESP_APB0   ),
    .BVALIDs12mi1  (BVALID_APB0  ),
    .BREADYmi12s1  (BREADY_2_APB0  ),

    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    .AWIDmi22s2    (AWID_2_APB1    ),
    .AWADDRmi22s2  (AWADDR_2_APB1  ),
    .AWLENmi22s2   (AWLEN_2_APB1   ),
    .AWSIZEmi22s2  (AWSIZE_2_APB1  ),
    .AWBURSTmi22s2 (AWBURST_2_APB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi22s2 (AWVALID_2_APB1 ),
    .AWREADYs22mi2 (AWREADY_APB1 ),

    //Write data channel
    .WIDmi22s2     (WID_2_APB1     ),
    .WDATAmi22s2   (WDATA_2_APB1   ),
//Disable_WSTRB_port
    .WLASTmi22s2   (WLAST_2_APB1   ),
    .WVALIDmi22s2  (WVALID_2_APB1  ),
    .WREADYs22mi2  (WREADY_APB1  ),

    //Write response channel
    .BIDs22mi2     (BID_APB1     ),
    .BRESPs22mi2   (BRESP_APB1   ),
    .BVALIDs22mi2  (BVALID_APB1  ),
    .BREADYmi22s2  (BREADY_2_APB1  ),

    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    .AWIDmi32s3    (AWID_2_SMC    ),
    .AWADDRmi32s3  (AWADDR_2_SMC  ),
    .AWLENmi32s3   (AWLEN_2_SMC   ),
    .AWSIZEmi32s3  (AWSIZE_2_SMC  ),
    .AWBURSTmi32s3 (AWBURST_2_SMC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi32s3 (AWVALID_2_SMC ),
    .AWREADYs32mi3 (AWREADY_SMC ),

    //Write data channel
    .WIDmi32s3     (WID_2_SMC     ),
    .WDATAmi32s3   (WDATA_2_SMC   ),
    .WSTRBmi32s3   (WSTRB_2_SMC   ),
    .WLASTmi32s3   (WLAST_2_SMC   ),
    .WVALIDmi32s3  (WVALID_2_SMC  ),
    .WREADYs32mi3  (WREADY_SMC  ),

    //Write response channel
    .BIDs32mi3     (BID_SMC     ),
    .BRESPs32mi3   (BRESP_SMC   ),
    .BVALIDs32mi3  (BVALID_SMC  ),
    .BREADYmi32s3  (BREADY_2_SMC  ),

    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    .AWIDmi42s4    (AWID_2_SSRAM    ),
    .AWADDRmi42s4  (AWADDR_2_SSRAM  ),
    .AWLENmi42s4   (AWLEN_2_SSRAM   ),
    .AWSIZEmi42s4  (AWSIZE_2_SSRAM  ),
    .AWBURSTmi42s4 (AWBURST_2_SSRAM ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi42s4 (AWVALID_2_SSRAM ),
    .AWREADYs42mi4 (AWREADY_SSRAM ),

    //Write data channel
    .WIDmi42s4     (WID_2_SSRAM     ),
    .WDATAmi42s4   (WDATA_2_SSRAM   ),
    .WSTRBmi42s4   (WSTRB_2_SSRAM   ),
    .WLASTmi42s4   (WLAST_2_SSRAM   ),
    .WVALIDmi42s4  (WVALID_2_SSRAM  ),
    .WREADYs42mi4  (WREADY_SSRAM  ),

    //Write response channel
    .BIDs42mi4     (BID_SSRAM     ),
    .BRESPs42mi4   (BRESP_SSRAM   ),
    .BVALIDs42mi4  (BVALID_SSRAM  ),
    .BREADYmi42s4  (BREADY_2_SSRAM  ),

    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    .AWIDmi52s5    (AWID_2_default    ),
    .AWADDRmi52s5  (AWADDR_2_default  ),
    .AWLENmi52s5   (AWLEN_2_default   ),
    .AWSIZEmi52s5  (AWSIZE_2_default  ),
    .AWBURSTmi52s5 (AWBURST_2_default ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi52s5 (AWVALID_2_default ),
    .AWREADYs52mi5 (AWREADY_default ),

    //Write data channel
    .WIDmi52s5     (WID_2_default     ),
    .WDATAmi52s5   (WDATA_2_default   ),
    .WSTRBmi52s5   (WSTRB_2_default   ),
    .WLASTmi52s5   (WLAST_2_default   ),
    .WVALIDmi52s5  (WVALID_2_default  ),
    .WREADYs52mi5  (WREADY_default  ),

    //Write response channel
    .BIDs52mi5     (BID_default     ),
    .BRESPs52mi5   (BRESP_default   ),
    .BVALIDs52mi5  (BVALID_default  ),
    .BREADYmi52s5  (BREADY_2_default  ),


    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2wrmi0          (Lock2wrmi0      ),
    .Lock2rdmi0          (Lock2rdmi0      ),
    .UnLock2wrmi0        (UnLock2wrmi0    ),
    .UnLock2rdmi0        (UnLock2rdmi0    ),
    .ARVALIDmi02s0      (ARVALID_2_DDR   ),
    .LockPort2wrmi0      (LockPort2wrmi0  ),
    .ReadIntEmptyWrmi02Rdmi0     (ReadIntEmptyWrmi02Rdmi0     ),
    .DataCntEmptyRdmi02Wrmi0     (DataCntEmptyRdmi02Wrmi0     ),    
    .CtlDataWrite2Lock0          (CtlDataWrite2Lock0          ),
    
    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2wrmi1          (Lock2wrmi1      ),
    .Lock2rdmi1          (Lock2rdmi1      ),
    .UnLock2wrmi1        (UnLock2wrmi1    ),
    .UnLock2rdmi1        (UnLock2rdmi1    ),
    .ARVALIDmi12s1      (ARVALID_2_APB0   ),
    .LockPort2wrmi1      (LockPort2wrmi1  ),
    .ReadIntEmptyWrmi12Rdmi1     (ReadIntEmptyWrmi12Rdmi1     ),
    .DataCntEmptyRdmi12Wrmi1     (DataCntEmptyRdmi12Wrmi1     ),    
    .CtlDataWrite2Lock1          (CtlDataWrite2Lock1          ),
    
    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2wrmi2          (Lock2wrmi2      ),
    .Lock2rdmi2          (Lock2rdmi2      ),
    .UnLock2wrmi2        (UnLock2wrmi2    ),
    .UnLock2rdmi2        (UnLock2rdmi2    ),
    .ARVALIDmi22s2      (ARVALID_2_APB1   ),
    .LockPort2wrmi2      (LockPort2wrmi2  ),
    .ReadIntEmptyWrmi22Rdmi2     (ReadIntEmptyWrmi22Rdmi2     ),
    .DataCntEmptyRdmi22Wrmi2     (DataCntEmptyRdmi22Wrmi2     ),    
    .CtlDataWrite2Lock2          (CtlDataWrite2Lock2          ),
    
    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2wrmi3          (Lock2wrmi3      ),
    .Lock2rdmi3          (Lock2rdmi3      ),
    .UnLock2wrmi3        (UnLock2wrmi3    ),
    .UnLock2rdmi3        (UnLock2rdmi3    ),
    .ARVALIDmi32s3      (ARVALID_2_SMC   ),
    .LockPort2wrmi3      (LockPort2wrmi3  ),
    .ReadIntEmptyWrmi32Rdmi3     (ReadIntEmptyWrmi32Rdmi3     ),
    .DataCntEmptyRdmi32Wrmi3     (DataCntEmptyRdmi32Wrmi3     ),    
    .CtlDataWrite2Lock3          (CtlDataWrite2Lock3          ),
    
    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2wrmi4          (Lock2wrmi4      ),
    .Lock2rdmi4          (Lock2rdmi4      ),
    .UnLock2wrmi4        (UnLock2wrmi4    ),
    .UnLock2rdmi4        (UnLock2rdmi4    ),
    .ARVALIDmi42s4      (ARVALID_2_SSRAM   ),
    .LockPort2wrmi4      (LockPort2wrmi4  ),
    .ReadIntEmptyWrmi42Rdmi4     (ReadIntEmptyWrmi42Rdmi4     ),
    .DataCntEmptyRdmi42Wrmi4     (DataCntEmptyRdmi42Wrmi4     ),    
    .CtlDataWrite2Lock4          (CtlDataWrite2Lock4          ),
    
    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2wrmi5          (Lock2wrmi5      ),
    .Lock2rdmi5          (Lock2rdmi5      ),
    .UnLock2wrmi5        (UnLock2wrmi5    ),
    .UnLock2rdmi5        (UnLock2rdmi5    ),
    .ARVALIDmi52s5      (ARVALID_2_default   ),
    .LockPort2wrmi5      (LockPort2wrmi5  ),
    .ReadIntEmptyWrmi52Rdmi5     (ReadIntEmptyWrmi52Rdmi5     ),
    .DataCntEmptyRdmi52Wrmi5     (DataCntEmptyRdmi52Wrmi5     ),    
    .CtlDataWrite2Lock5          (CtlDataWrite2Lock5          ),
    
    
    .SelMAP1 (SelMAP1),
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);


//Read Channel 
//_____________________________________________________________________

ReadChannel 
SBUS_ReadChannel (

    //_______________________________________________________________
    //For Master 0
    //Read address channel
//Disable_id_port
    .ARADDRm02si0  (ARADDR_ARMD  ),
    .ARLENm02si0   (ARLEN_ARMD   ),
    .ARSIZEm02si0  (ARSIZE_ARMD  ),
    .ARBURSTm02si0 (ARBURST_ARMD ),
    .ARLOCKm02si0  (ARLOCK_ARMD  ),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm02si0 (ARVALID_ARMD ),
    .ARREADYsi02m0 (ARREADY_2_ARMD ),

    //Read data channel
//Disable_id_port
    .RRESPsi02m0   (RRESP_2_ARMD   ),
    .RDATAsi02m0   (RDATA_2_ARMD   ),
    .RLASTsi02m0   (RLAST_2_ARMD   ),
    .RVALIDsi02m0  (RVALID_2_ARMD  ),
    .RREADYm02si0  (RREADY_ARMD  ),
    //_______________________________________________________________
    //For Master 1
    //Read address channel
//Disable_id_port
    .ARADDRm12si1  (ARADDR_ARMI  ),
    .ARLENm12si1   (ARLEN_ARMI   ),
    .ARSIZEm12si1  (ARSIZE_ARMI  ),
    .ARBURSTm12si1 (ARBURST_ARMI ),
    .ARLOCKm12si1  (ARLOCK_ARMI  ),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm12si1 (ARVALID_ARMI ),
    .ARREADYsi12m1 (ARREADY_2_ARMI ),

    //Read data channel
//Disable_id_port
    .RRESPsi12m1   (RRESP_2_ARMI   ),
    .RDATAsi12m1   (RDATA_2_ARMI   ),
    .RLASTsi12m1   (RLAST_2_ARMI   ),
    .RVALIDsi12m1  (RVALID_2_ARMI  ),
    .RREADYm12si1  (RREADY_ARMI  ),
    //_______________________________________________________________
    //For Master 2
    //Read address channel
    .ARIDm22si2    (ARID_DM    ),
    .ARADDRm22si2  (ARADDR_DM  ),
    .ARLENm22si2   (ARLEN_DM   ),
    .ARSIZEm22si2  (ARSIZE_DM  ),
    .ARBURSTm22si2 (ARBURST_DM ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm22si2 (ARVALID_DM ),
    .ARREADYsi22m2 (ARREADY_2_DM ),

    //Read data channel
    .RIDsi22m2     (RID_2_DM     ),
    .RRESPsi22m2   (RRESP_2_DM   ),
    .RDATAsi22m2   (RDATA_2_DM   ),
    .RLASTsi22m2   (RLAST_2_DM   ),
    .RVALIDsi22m2  (RVALID_2_DM  ),
    .RREADYm22si2  (RREADY_DM  ),
    //_______________________________________________________________
    //For Master 3
    //Read address channel
    .ARIDm32si3    (ARID_DMAC    ),
    .ARADDRm32si3  (ARADDR_DMAC  ),
    .ARLENm32si3   (ARLEN_DMAC   ),
    .ARSIZEm32si3  (ARSIZE_DMAC  ),
    .ARBURSTm32si3 (ARBURST_DMAC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm32si3 (ARVALID_DMAC ),
    .ARREADYsi32m3 (ARREADY_2_DMAC ),

    //Read data channel
    .RIDsi32m3     (RID_2_DMAC     ),
    .RRESPsi32m3   (RRESP_2_DMAC   ),
    .RDATAsi32m3   (RDATA_2_DMAC   ),
    .RLASTsi32m3   (RLAST_2_DMAC   ),
    .RVALIDsi32m3  (RVALID_2_DMAC  ),
    .RREADYm32si3  (RREADY_DMAC  ),
    //_______________________________________________________________
    //For Master 4
    //Read address channel
//Disable_id_port
    .ARADDRm42si4  (ARADDR_DMA2D  ),
    .ARLENm42si4   (ARLEN_DMA2D   ),
    .ARSIZEm42si4  (ARSIZE_DMA2D  ),
    .ARBURSTm42si4 (ARBURST_DMA2D ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm42si4 (ARVALID_DMA2D ),
    .ARREADYsi42m4 (ARREADY_2_DMA2D ),

    //Read data channel
//Disable_id_port
    .RRESPsi42m4   (RRESP_2_DMA2D   ),
    .RDATAsi42m4   (RDATA_2_DMA2D   ),
    .RLASTsi42m4   (RLAST_2_DMA2D   ),
    .RVALIDsi42m4  (RVALID_2_DMA2D  ),
    .RREADYm42si4  (RREADY_DMA2D  ),
    //_______________________________________________________________
    //For Master 6
    //Read address channel
//Disable_id_port
    .ARADDRm62si6  (ARADDR_USB  ),
    .ARLENm62si6   (ARLEN_USB   ),
    .ARSIZEm62si6  (ARSIZE_USB  ),
    .ARBURSTm62si6 (ARBURST_USB ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm62si6 (ARVALID_USB ),
    .ARREADYsi62m6 (ARREADY_2_USB ),

    //Read data channel
//Disable_id_port
    .RRESPsi62m6   (RRESP_2_USB   ),
    .RDATAsi62m6   (RDATA_2_USB   ),
    .RLASTsi62m6   (RLAST_2_USB   ),
    .RVALIDsi62m6  (RVALID_2_USB  ),
    .RREADYm62si6  (RREADY_USB  ),

    //_______________________________________________________________
    //For Slave 0
    //Read address channel
    .ARIDmi02s0    (ARID_2_DDR    ),
    .ARADDRmi02s0  (ARADDR_2_DDR  ),
    .ARLENmi02s0   (ARLEN_2_DDR   ),
    .ARSIZEmi02s0  (ARSIZE_2_DDR  ),
    .ARBURSTmi02s0 (ARBURST_2_DDR ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi02s0 (ARVALID_2_DDR ),
    .ARREADYs02mi0 (ARREADY_DDR ),

    //Read data channel
    .RIDs02mi0     (RID_DDR     ),
    .RRESPs02mi0   (RRESP_DDR   ),
    .RDATAs02mi0   (RDATA_DDR   ),
    .RLASTs02mi0   (RLAST_DDR   ),
    .RVALIDs02mi0  (RVALID_DDR  ),
    .RREADYmi02s0  (RREADY_2_DDR  ),
    //_______________________________________________________________
    //For Slave 1
    //Read address channel
    .ARIDmi12s1    (ARID_2_APB0    ),
    .ARADDRmi12s1  (ARADDR_2_APB0  ),
    .ARLENmi12s1   (ARLEN_2_APB0   ),
    .ARSIZEmi12s1  (ARSIZE_2_APB0  ),
    .ARBURSTmi12s1 (ARBURST_2_APB0 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi12s1 (ARVALID_2_APB0 ),
    .ARREADYs12mi1 (ARREADY_APB0 ),

    //Read data channel
    .RIDs12mi1     (RID_APB0     ),
    .RRESPs12mi1   (RRESP_APB0   ),
    .RDATAs12mi1   (RDATA_APB0   ),
    .RLASTs12mi1   (RLAST_APB0   ),
    .RVALIDs12mi1  (RVALID_APB0  ),
    .RREADYmi12s1  (RREADY_2_APB0  ),
    //_______________________________________________________________
    //For Slave 2
    //Read address channel
    .ARIDmi22s2    (ARID_2_APB1    ),
    .ARADDRmi22s2  (ARADDR_2_APB1  ),
    .ARLENmi22s2   (ARLEN_2_APB1   ),
    .ARSIZEmi22s2  (ARSIZE_2_APB1  ),
    .ARBURSTmi22s2 (ARBURST_2_APB1 ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi22s2 (ARVALID_2_APB1 ),
    .ARREADYs22mi2 (ARREADY_APB1 ),

    //Read data channel
    .RIDs22mi2     (RID_APB1     ),
    .RRESPs22mi2   (RRESP_APB1   ),
    .RDATAs22mi2   (RDATA_APB1   ),
    .RLASTs22mi2   (RLAST_APB1   ),
    .RVALIDs22mi2  (RVALID_APB1  ),
    .RREADYmi22s2  (RREADY_2_APB1  ),
    //_______________________________________________________________
    //For Slave 3
    //Read address channel
    .ARIDmi32s3    (ARID_2_SMC    ),
    .ARADDRmi32s3  (ARADDR_2_SMC  ),
    .ARLENmi32s3   (ARLEN_2_SMC   ),
    .ARSIZEmi32s3  (ARSIZE_2_SMC  ),
    .ARBURSTmi32s3 (ARBURST_2_SMC ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi32s3 (ARVALID_2_SMC ),
    .ARREADYs32mi3 (ARREADY_SMC ),

    //Read data channel
    .RIDs32mi3     (RID_SMC     ),
    .RRESPs32mi3   (RRESP_SMC   ),
    .RDATAs32mi3   (RDATA_SMC   ),
    .RLASTs32mi3   (RLAST_SMC   ),
    .RVALIDs32mi3  (RVALID_SMC  ),
    .RREADYmi32s3  (RREADY_2_SMC  ),
    //_______________________________________________________________
    //For Slave 4
    //Read address channel
    .ARIDmi42s4    (ARID_2_SSRAM    ),
    .ARADDRmi42s4  (ARADDR_2_SSRAM  ),
    .ARLENmi42s4   (ARLEN_2_SSRAM   ),
    .ARSIZEmi42s4  (ARSIZE_2_SSRAM  ),
    .ARBURSTmi42s4 (ARBURST_2_SSRAM ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi42s4 (ARVALID_2_SSRAM ),
    .ARREADYs42mi4 (ARREADY_SSRAM ),

    //Read data channel
    .RIDs42mi4     (RID_SSRAM     ),
    .RRESPs42mi4   (RRESP_SSRAM   ),
    .RDATAs42mi4   (RDATA_SSRAM   ),
    .RLASTs42mi4   (RLAST_SSRAM   ),
    .RVALIDs42mi4  (RVALID_SSRAM  ),
    .RREADYmi42s4  (RREADY_2_SSRAM  ),
    //_______________________________________________________________
    //For Slave 5
    //Read address channel
    .ARIDmi52s5    (ARID_2_default    ),
    .ARADDRmi52s5  (ARADDR_2_default  ),
    .ARLENmi52s5   (ARLEN_2_default   ),
    .ARSIZEmi52s5  (ARSIZE_2_default  ),
    .ARBURSTmi52s5 (ARBURST_2_default ),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi52s5 (ARVALID_2_default ),
    .ARREADYs52mi5 (ARREADY_default ),

    //Read data channel
    .RIDs52mi5     (RID_default     ),
    .RRESPs52mi5   (RRESP_default   ),
    .RDATAs52mi5   (RDATA_default   ),
    .RLASTs52mi5   (RLAST_default   ),
    .RVALIDs52mi5  (RVALID_default  ),
    .RREADYmi52s5  (RREADY_2_default  ),

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2rdmi0          (Lock2rdmi0          ),
    .Lock2wrmi0          (Lock2wrmi0          ),
    .UnLock2rdmi0        (UnLock2rdmi0        ),
    .UnLock2wrmi0        (UnLock2wrmi0        ),
    .AWVALIDmi02s0      (AWVALID_2_DDR  ),
    .LockPort2rdmi0      (LockPort2rdmi0      ),
    .ReadIntEmptyWrmi02Rdmi0    (ReadIntEmptyWrmi02Rdmi0    ),
    .DataCntEmptyRdmi02Wrmi0    (DataCntEmptyRdmi02Wrmi0    ),
    .CtlDataRead2Lock0           (CtlDataRead2Lock0           ),

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2rdmi1          (Lock2rdmi1          ),
    .Lock2wrmi1          (Lock2wrmi1          ),
    .UnLock2rdmi1        (UnLock2rdmi1        ),
    .UnLock2wrmi1        (UnLock2wrmi1        ),
    .AWVALIDmi12s1      (AWVALID_2_APB0  ),
    .LockPort2rdmi1      (LockPort2rdmi1      ),
    .ReadIntEmptyWrmi12Rdmi1    (ReadIntEmptyWrmi12Rdmi1    ),
    .DataCntEmptyRdmi12Wrmi1    (DataCntEmptyRdmi12Wrmi1    ),
    .CtlDataRead2Lock1           (CtlDataRead2Lock1           ),

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2rdmi2          (Lock2rdmi2          ),
    .Lock2wrmi2          (Lock2wrmi2          ),
    .UnLock2rdmi2        (UnLock2rdmi2        ),
    .UnLock2wrmi2        (UnLock2wrmi2        ),
    .AWVALIDmi22s2      (AWVALID_2_APB1  ),
    .LockPort2rdmi2      (LockPort2rdmi2      ),
    .ReadIntEmptyWrmi22Rdmi2    (ReadIntEmptyWrmi22Rdmi2    ),
    .DataCntEmptyRdmi22Wrmi2    (DataCntEmptyRdmi22Wrmi2    ),
    .CtlDataRead2Lock2           (CtlDataRead2Lock2           ),

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2rdmi3          (Lock2rdmi3          ),
    .Lock2wrmi3          (Lock2wrmi3          ),
    .UnLock2rdmi3        (UnLock2rdmi3        ),
    .UnLock2wrmi3        (UnLock2wrmi3        ),
    .AWVALIDmi32s3      (AWVALID_2_SMC  ),
    .LockPort2rdmi3      (LockPort2rdmi3      ),
    .ReadIntEmptyWrmi32Rdmi3    (ReadIntEmptyWrmi32Rdmi3    ),
    .DataCntEmptyRdmi32Wrmi3    (DataCntEmptyRdmi32Wrmi3    ),
    .CtlDataRead2Lock3           (CtlDataRead2Lock3           ),

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2rdmi4          (Lock2rdmi4          ),
    .Lock2wrmi4          (Lock2wrmi4          ),
    .UnLock2rdmi4        (UnLock2rdmi4        ),
    .UnLock2wrmi4        (UnLock2wrmi4        ),
    .AWVALIDmi42s4      (AWVALID_2_SSRAM  ),
    .LockPort2rdmi4      (LockPort2rdmi4      ),
    .ReadIntEmptyWrmi42Rdmi4    (ReadIntEmptyWrmi42Rdmi4    ),
    .DataCntEmptyRdmi42Wrmi4    (DataCntEmptyRdmi42Wrmi4    ),
    .CtlDataRead2Lock4           (CtlDataRead2Lock4           ),

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2rdmi5          (Lock2rdmi5          ),
    .Lock2wrmi5          (Lock2wrmi5          ),
    .UnLock2rdmi5        (UnLock2rdmi5        ),
    .UnLock2wrmi5        (UnLock2wrmi5        ),
    .AWVALIDmi52s5      (AWVALID_2_default  ),
    .LockPort2rdmi5      (LockPort2rdmi5      ),
    .ReadIntEmptyWrmi52Rdmi5    (ReadIntEmptyWrmi52Rdmi5    ),
    .DataCntEmptyRdmi52Wrmi5    (DataCntEmptyRdmi52Wrmi5    ),
    .CtlDataRead2Lock5           (CtlDataRead2Lock5           ),


    .SelMAP1 (SelMAP1),
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

//assign  LockPort2wrmi0 = CtlDataRead2Lock0; 
//assign  LockPort2rdmi0 = CtlDataWrite2Lock0;

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

//assign  LockPort2wrmi1 = CtlDataRead2Lock1; 
//assign  LockPort2rdmi1 = CtlDataWrite2Lock1;

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

//assign  LockPort2wrmi2 = CtlDataRead2Lock2; 
//assign  LockPort2rdmi2 = CtlDataWrite2Lock2;

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

//assign  LockPort2wrmi3 = CtlDataRead2Lock3; 
//assign  LockPort2rdmi3 = CtlDataWrite2Lock3;

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

//assign  LockPort2wrmi4 = CtlDataRead2Lock4; 
//assign  LockPort2rdmi4 = CtlDataWrite2Lock4;

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

//assign  LockPort2wrmi5 = CtlDataRead2Lock5; 
//assign  LockPort2rdmi5 = CtlDataWrite2Lock5;


//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataRead2Lock0 or
         LockPort2wrmi0
        )
begin
    case(CtlDataRead2Lock0)
        3'd0:  LockPort2wrmi0 = 4'd0;
        3'd1:  LockPort2wrmi0 = {1'b1, {3{1'b0}}};
        3'd2:  LockPort2wrmi0 = {1'b1, {3{1'b0}}};
        3'd3:  LockPort2wrmi0 = 4'd1;
        3'd4:  LockPort2wrmi0 = 4'd2;
        3'd5:  LockPort2wrmi0 = 4'd4;
        default:  LockPort2wrmi0 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataRead2Lock1 or
         LockPort2wrmi1
        )
begin
    case(CtlDataRead2Lock1)
        1'd0:  LockPort2wrmi1 = 2'd0;
        1'd1:  LockPort2wrmi1 = 2'd1;
        default:  LockPort2wrmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataRead2Lock2 or
         LockPort2wrmi2
        )
begin
    case(CtlDataRead2Lock2)
        1'd0:  LockPort2wrmi2 = 2'd0;
        1'd1:  LockPort2wrmi2 = 2'd1;
        default:  LockPort2wrmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataRead2Lock3 or
         LockPort2wrmi3
        )
begin
    case(CtlDataRead2Lock3)
        3'd0:  LockPort2wrmi3 = 4'd0;
        3'd1:  LockPort2wrmi3 = {1'b1, {3{1'b0}}};
        3'd2:  LockPort2wrmi3 = {1'b1, {3{1'b0}}};
        3'd3:  LockPort2wrmi3 = 4'd1;
        3'd4:  LockPort2wrmi3 = 4'd2;
        3'd5:  LockPort2wrmi3 = 4'd4;
        default:  LockPort2wrmi3 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataRead2Lock4 or
         LockPort2wrmi4
        )
begin
    case(CtlDataRead2Lock4)
        3'd0:  LockPort2wrmi4 = 4'd0;
        3'd1:  LockPort2wrmi4 = {1'b1, {3{1'b0}}};
        3'd2:  LockPort2wrmi4 = {1'b1, {3{1'b0}}};
        3'd3:  LockPort2wrmi4 = 4'd1;
        3'd4:  LockPort2wrmi4 = 4'd2;
        3'd5:  LockPort2wrmi4 = 4'd4;
        default:  LockPort2wrmi4 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataRead2Lock5 or
         LockPort2wrmi5
        )
begin
    case(CtlDataRead2Lock5)
        3'd0:  LockPort2wrmi5 = 4'd0;
        3'd1:  LockPort2wrmi5 = {1'b1, {3{1'b0}}};
        3'd2:  LockPort2wrmi5 = {1'b1, {3{1'b0}}};
        3'd3:  LockPort2wrmi5 = 4'd1;
        3'd4:  LockPort2wrmi5 = 4'd2;
        3'd5:  LockPort2wrmi5 = 4'd4;
        default:  LockPort2wrmi5 = {1'b1, {3{1'b0}}};
    endcase
end

//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataWrite2Lock0 or 
         LockPort2rdmi0
        )
begin
    case(CtlDataWrite2Lock0)
        3'd0:  LockPort2rdmi0 = 4'd0;
        3'd1:  LockPort2rdmi0 = 4'd3;
        3'd2:  LockPort2rdmi0 = 4'd4;
        3'd3:  LockPort2rdmi0 = {1'b1, {3{1'b0}}};
        3'd4:  LockPort2rdmi0 = 4'd5;
        default:  LockPort2rdmi0 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataWrite2Lock1 or 
         LockPort2rdmi1
        )
begin
    case(CtlDataWrite2Lock1)
        1'd0:  LockPort2rdmi1 = 2'd0;
        1'd1:  LockPort2rdmi1 = 2'd1;
        default:  LockPort2rdmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataWrite2Lock2 or 
         LockPort2rdmi2
        )
begin
    case(CtlDataWrite2Lock2)
        1'd0:  LockPort2rdmi2 = 2'd0;
        1'd1:  LockPort2rdmi2 = 2'd1;
        default:  LockPort2rdmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataWrite2Lock3 or 
         LockPort2rdmi3
        )
begin
    case(CtlDataWrite2Lock3)
        3'd0:  LockPort2rdmi3 = 4'd0;
        3'd1:  LockPort2rdmi3 = 4'd3;
        3'd2:  LockPort2rdmi3 = 4'd4;
        3'd3:  LockPort2rdmi3 = {1'b1, {3{1'b0}}};
        3'd4:  LockPort2rdmi3 = 4'd5;
        default:  LockPort2rdmi3 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataWrite2Lock4 or 
         LockPort2rdmi4
        )
begin
    case(CtlDataWrite2Lock4)
        3'd0:  LockPort2rdmi4 = 4'd0;
        3'd1:  LockPort2rdmi4 = 4'd3;
        3'd2:  LockPort2rdmi4 = 4'd4;
        3'd3:  LockPort2rdmi4 = {1'b1, {3{1'b0}}};
        3'd4:  LockPort2rdmi4 = 4'd5;
        default:  LockPort2rdmi4 = {1'b1, {3{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataWrite2Lock5 or 
         LockPort2rdmi5
        )
begin
    case(CtlDataWrite2Lock5)
        3'd0:  LockPort2rdmi5 = 4'd0;
        3'd1:  LockPort2rdmi5 = 4'd3;
        3'd2:  LockPort2rdmi5 = 4'd4;
        3'd3:  LockPort2rdmi5 = {1'b1, {3{1'b0}}};
        3'd4:  LockPort2rdmi5 = 4'd5;
        default:  LockPort2rdmi5 = {1'b1, {3{1'b0}}};
    endcase
end

endmodule
