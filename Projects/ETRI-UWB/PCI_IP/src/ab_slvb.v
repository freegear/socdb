// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module ab_slvb(
clk,
big_endian,
s_haddr,
s_hburst,
s_hrdata,
s_hreadyin,
s_hreadyout,
s_hresp,
s_hsel,
s_hsize,
s_htrans,
s_hwdata,
s_hwrite,


pci_rdbuf_raddr,
pci_rdbuf_rdata,
pci_rdbuf_waddr,
pci_rdbuf_wdata,
pci_rdbuf_wren,
pci_wrbuf_raddr,
pci_wrbuf_rdata,
pci_wrbuf_waddr,
pci_wrbuf_wdata,
pci_wrbuf_wren,


db01_wea,
h_wb_busy,
hs_fast,
m_swapen,
mack_b,
mrdreq_b,
mrd_abort,
mrd_addrb,
mrd_doutb,
mwrreq_b,
mwr_addra,
mwr_addrb,
mwr_beina,
mwr_dina,
pci_adr,
pci_be_b,
pci_cacheline,
pci_cmd,
pci_mio,
pci_size,
reset_b
);
input big_endian;
input clk;
input[31:0] s_haddr;
input[2:0] s_hburst;
output[31:0] s_hrdata;
input s_hreadyin;
output s_hreadyout;
output[1:0] s_hresp;
input[5:0] s_hsel;
input[2:0] s_hsize;
input[1:0] s_htrans;
input[31:0] s_hwdata;
input s_hwrite;
output[3:0] pci_rdbuf_raddr;
input[31:0] pci_rdbuf_rdata;
output[3:0] pci_rdbuf_waddr;
output[31:0] pci_rdbuf_wdata;
output pci_rdbuf_wren;
output[4:0] pci_wrbuf_raddr;
input[31:0] pci_wrbuf_rdata;
output[4:0] pci_wrbuf_waddr;
output[31:0] pci_wrbuf_wdata;
output[3:0] pci_wrbuf_wren;
output db01_wea;
output h_wb_busy;
input hs_fast;
input m_swapen;
input mack_b;
output mrdreq_b;
input mrd_abort;
output[3:0] mrd_addrb;
input[31:0] mrd_doutb;
output mwrreq_b;
output[6:0] mwr_addra;
output mwr_addrb;
output[3:0] mwr_beina;
output[31:0] mwr_dina;
output[31:0] pci_adr;
output[3:0] pci_be_b;
output pci_cacheline;
output[1:0] pci_cmd;
output pci_mio;
output[6:0] pci_size;
input reset_b;
wire l0IO1I1lO0lO10I;wire[3:0] l0IO1lO10IlO10I;wire[3:0] l0IO1OI01llO10I;wire OlI01IIO0lIIO0l;wire[6:0] l0IO1IO0lIlO10I;wire OlI01OOIl1IIO0l;
wire l0IO1OOl1IlO10I;wire OI01lI01lOIIO0l;wire[3:0] OI01llIO10IIO0l;wire OI01lOlI01IIO0l;wire O1lIOIIO0lIO01l;wire[2:0] OI01lIIO0lIIO0l;
wire O1lIOOOIl1IO01l;wire OI01lOOIl1IIO0l;wire OlI1OI01lOIO01l;wire[3:0] OlI1OlIO10IO01l;wire[5:0] OlI1OOlI01IO01l;wire I01lOIOIl0OIl01;
wire[6:0] OlI1OIIO0lIO01l;wire[1:0] I01lOOlI1OOIl01;wire[5:0] OlI1OOOIl1IO01l;wire I1lO0IO01lOIl01;wire[31:0] I1lO0l0IO1OIl01;wire I1lO0O01IlOIl01;
wire OIl01IlI0OIO0lI;wire[6:0] I1lO0IOIl0OIl01;wire[2:0] OIl01O1lIOIO0lI;wire I1lO0OlI1OOIl01;wire O01IlIlO01IO0lI;wire[3:0] O01Ill10IOIO0lI;
wire[3:0] O01IlOIl01IO0lI;wire IIO0lIlI0OI01lO;wire O01IlIlI0OIO0lI;wire IIO0lO1lIOI01lO;wire[3:0] O01IlO1lIOIO0lI;wire[31:0] IO0lIIlO01I01lO;
wire[2:0] IO0lIl10IOI01lO;wire[3:0] IO0lIOIl01I01lO;wire IlO01OI01lO01Il;wire IO0lIIlI0OI01lO;wire[1:0] IlO01IO0lIO01Il;wire[2:0] IO0lIO1lIOI01lO;
wire IlO01OOl1IO01Il;wire IO01lI1lO0O01Il;wire[3:0] IO01llO10IO01Il;wire IO01lOI01lO01Il;wire[6:0] lIO10IIO0lO1lIO;wire IO01lIO0lIO01Il;
wire[31:0] lIO10OOIl1O1lIO;wire IO01lOOl1IO01Il;wire lO10II01lOO1lIO;wire[3:0] lO10IlIO10O1lIO;wire lO10IOlI01O1lIO;wire IlI0OIIO0lI1lO0;
wire lO10IIIO0lO1lIO;wire IlI0OOOIl1I1lO0;wire lO10IOOIl1O1lIO;wire[3:0] IOIl0I01lOI1lO0;wire[3:0] IOIl0lIO10I1lO0;wire IOIl0OlI01I1lO0;
wire OOIl1IOIl0OlI01;wire[6:0] IOIl0IIO0lI1lO0;wire OOIl1OlI1OOlI01;wire[5:0] IOIl0OOIl1I1lO0;wire OOl1IIO01lOlI01;wire[31:0] OOl1Il0IO1OlI01;
wire[1:0] OOl1IO01IlOlI01;wire l10IOIlI0OOlI1O;wire[5:0] OOl1IIOIl0OlI01;wire l10IOO1lIOOlI1O;wire OOl1IOlI1OOlI01;wire l0IO1IlO01OlI1O;
wire l0IO1l10IOOlI1O;wire[3:0] l0IO1OIl01OlI1O;wire OlI01IlI0Ol10IO;wire[3:0] l0IO1IlI0OOlI1O;wire OlI01O1lIOl10IO;wire l0IO1O1lIOOlI1O;
wire[31:0] OI01lIlO01l10IO;wire OI01ll10IOl10IO;wire OI01lOIl01l10IO;wire O1lIOOI01lOI01l;wire OI01lIlI0Ol10IO;wire O1lIOIO0lIOI01l;
wire OI01lO1lIOl10IO;wire O1lIOOOl1IOI01l;wire OlI1OI1lO0OI01l;wire[3:0] OlI1OlO10IOI01l;wire OlI1OOI01lOI01l;wire[6:0] I01lOIIO0lOOIl1;
wire OlI1OIO0lIOI01l;wire I01lOOOIl1OOIl1;wire OlI1OOOl1IOI01l;wire I1lO0I01lOOOIl1;wire[3:0] I1lO0lIO10OOIl1;wire I1lO0OlI01OOIl1;
wire[5:0] OIl01IIO0ll0IO1;wire[2:0] I1lO0IIO0lOOIl1;wire OIl01OOIl1l0IO1;wire I1lO0OOIl1OOIl1;wire[3:0] O01IlI01lOl0IO1;wire[3:0] O01IllIO10l0IO1;
wire O01IlOlI01l0IO1;wire[31:0] IIO0lIOIl0IlI0O;wire O01IlIIO0ll0IO1;wire IIO0lOlI1OIlI0O;wire O01IlOOIl1l0IO1;wire IO0lIIO01lIlI0O;
wire[3:0] IO0lIl0IO1IlI0O;wire IO0lIO01IlIlI0O;wire IlO01IlI0OOOl1I;wire IO0lIIOIl0IlI0O;wire IlO01O1lIOOOl1I;wire IO0lIOlI1OIlI0O;
wire[4:0] IO01lIlO01OOl1I;wire[4:0] IO01ll10IOOOl1I;wire[3:0] IO01lOIl01OOl1I;wire lIO10IlI0OlIO10;wire IO01lIlI0OOOl1I;wire[3:0] lIO10O1lIOlIO10;
wire IO01lO1lIOOOl1I;wire[1:0] lO10IIlO01lIO10;wire lO10Il10IOlIO10;wire[3:0] lO10IOIl01lIO10;wire IlI0OOI01lIOIl0;wire lO10IIlI0OlIO10;
wire[31:0] IlI0OIO0lIIOIl0;wire lO10IO1lIOlIO10;wire IlI0OOOl1IIOIl0;wire[31:0] IOIl0I1lO0IOIl0;wire[3:0] IOIl0lO10IIOIl0;wire IOIl0OI01lIOIl0;
wire OOIl1IO0lIIlO01;wire IOIl0IO0lIIOIl0;wire OOIl1OOl1IIlO01;wire IOIl0OOl1IIOIl0;wire OOl1II1lO0IlO01;wire[3:0] OOl1IlO10IIlO01;
wire OOl1IOI01lIlO01;wire l10IOIIO0llO10I;wire OOl1IIO0lIIlO01;wire l10IOOOIl1lO10I;wire OOl1IOOl1IIlO01;wire l0IO1I01lOlO10I;wire[3:0] l0IO1lIO10lO10I;
wire l0IO1OlI01lO10I;wire OlI01IOIl0IIO0l;wire l0IO1IIO0llO10I;wire OlI01OlI1OIIO0l;wire l0IO1OOIl1lO10I;wire OI01lIO01lIIO0l;wire[3:0] OI01ll0IO1IIO0l;
wire OI01lO01IlIIO0l;wire O1lIOIOIl0IO01l;wire[6:0] OI01lIOIl0IIO0l;wire[1:0] O1lIOOlI1OIO01l;wire OI01lOlI1OIIO0l;wire[2:0] OlI1OIO01lIO01l;
wire OlI1Ol0IO1IO01l;wire[3:0] OlI1OO01IlIO01l;wire I01lOIlI0OOIl01;wire[6:0] OlI1OIOIl0IO01l;wire I01lOO1lIOOIl01;wire OlI1OOlI1OIO01l;
wire[3:0] I1lO0IlO01OIl01;wire I1lO0l10IOOIl01;wire[3:0] I1lO0OIl01OIl01;wire OIl01OI01lIO0lI;wire I1lO0IlI0OOIl01;wire[31:0] OIl01IO0lIIO0lI;
wire[3:0] I1lO0O1lIOOIl01;wire[31:0] OIl01OOl1IIO0lI;wire O01IlI1lO0IO0lI;wire[3:0] O01IllO10IIO0lI;wire O01IlOI01lIO0lI;wire[31:0] IIO0lIO0lII01lO;
wire O01IlIO0lIIO0lI;wire[31:0] IIO0lOOl1II01lO;wire O01IlOOl1IIO0lI;wire IO0lII1lO0I01lO;wire[3:0] IO0lIlO10II01lO;wire IO0lIOI01lI01lO;
wire IlO01IIO0lO01Il;wire[6:0] IO0lIIO0lII01lO;wire IlO01OOIl1O01Il;wire IO0lIOOl1II01lO;wire IO01lI01lOO01Il;wire[3:0] IO01llIO10O01Il;
wire IO01lOlI01O01Il;wire[6:0] lIO10IOIl0O1lIO;wire IO01lIIO0lO01Il;wire lIO10OlI1OO1lIO;wire IO01lOOIl1O01Il;wire lO10IIO01lO1lIO;
wire[3:0] lO10Il0IO1O1lIO;wire[1:0] lO10IO01IlO1lIO;wire IlI0OIOIl0I1lO0;wire[6:0] lO10IIOIl0O1lIO;wire IlI0OOlI1OI1lO0;wire lO10IOlI1OO1lIO;
wire IOIl0IO01lI1lO0;wire IOIl0l0IO1I1lO0;wire[3:0] IOIl0O01IlI1lO0;wire OOIl1IlI0OOlI01;wire[6:0] IOIl0IOIl0I1lO0;wire[31:0] OOIl1O1lIOOlI01;
wire IOIl0OlI1OI1lO0;wire OOl1IIlO01OlI01;wire OOl1Il10IOOlI01;wire[3:0] OOl1IOIl01OlI01;wire l10IOOI01lOlI1O;wire OOl1IIlI0OOlI01;
wire[2:0] l10IOIO0lIOlI1O;wire[3:0] OOl1IO1lIOOlI01;wire[1:0] l10IOOOl1IOlI1O;wire l0IO1I1lO0OlI1O;wire[3:0] l0IO1lO10IOlI1O;wire OlI01OI01ll10IO;
wire[31:0] l0IO1OI01lOlI1O;wire OlI01IO0lIl10IO;wire l0IO1IO0lIOlI1O;wire[20:0] OlI01OOl1Il10IO;wire l0IO1OOl1IOlI1O;wire OI01lI1lO0l10IO;
wire[3:0] OI01llO10Il10IO;wire OI01lOI01ll10IO;wire O1lIOIIO0lOI01l;wire[6:0] OI01lIO0lIl10IO;wire O1lIOOOIl1OI01l;wire OI01lOOl1Il10IO;
wire OlI1OI01lOOI01l;wire[3:0] OlI1OlIO10OI01l;wire OlI1OOlI01OI01l;wire I01lOIOIl0OOIl1;wire OlI1OIIO0lOI01l;wire I01lOOlI1OOOIl1;
wire OlI1OOOIl1OI01l;wire[5:0] I1lO0IO01lOOIl1;wire[3:0] I1lO0l0IO1OOIl1;wire[5:0] I1lO0O01IlOOIl1;wire OIl01IOIl0l0IO1;wire[6:0] I1lO0IOIl0OOIl1;
wire OIl01OlI1Ol0IO1;wire[5:0] I1lO0OlI1OOOIl1;wire O01IlIO01ll0IO1;wire O01Ill0IO1l0IO1;wire O01IlO01Ill0IO1;wire IIO0lIlI0OIlI0O;
wire O01IlIOIl0l0IO1;wire[2:0] IIO0lO1lIOIlI0O;wire O01IlOlI1Ol0IO1;wire IO0lIIlO01IlI0O;wire IO0lIl10IOIlI0O;wire[3:0] IO0lIOIl01IlI0O;
wire IlO01OI01lOOl1I;wire IO0lIIlI0OIlI0O;wire[1:0] IlO01IO0lIOOl1I;wire IO0lIO1lIOIlI0O;wire[3:0] IlO01OOl1IOOl1I;wire IO01lI1lO0OOl1I;
wire[3:0] IO01llO10IOOl1I;wire lIO10OI01llIO10;wire IO01lOI01lOOl1I;wire lIO10IO0lIlIO10;wire IO01lIO0lIOOl1I;wire[7:0] lIO10OOl1IlIO10;
wire IO01lOOl1IOOl1I;wire lO10II1lO0lIO10;wire[3:0] lO10IlO10IlIO10;wire[3:0] lO10IOI01llIO10;wire IlI0OIIO0lIOIl0;wire[6:0] lO10IIO0lIlIO10;
wire IlI0OOOIl1IOIl0;wire lO10IOOl1IlIO10;wire IOIl0I01lOIOIl0;wire[3:0] IOIl0lIO10IOIl0;wire IOIl0OlI01IOIl0;wire[6:0] OOIl1IIO0lIlO01;
wire IOIl0IIO0lIOIl0;wire[1:0] OOIl1OOIl1IlO01;wire IOIl0OOIl1IOIl0;wire OOl1II01lOIlO01;wire[3:0] OOl1IlIO10IlO01;wire[5:0] OOl1IOlI01IlO01;
wire l10IOIOIl0lO10I;wire[6:0] OOl1IIIO0lIlO01;wire[1:0] l10IOOlI1OlO10I;wire[5:0] OOl1IOOIl1IlO01;wire l0IO1IO01llO10I;wire[31:0] l0IO1l0IO1lO10I;
wire l0IO1O01IllO10I;wire OlI01IlI0OIIO0l;wire[6:0] l0IO1IOIl0lO10I;wire OlI01O1lIOIIO0l;wire l0IO1OlI1OlO10I;wire OI01lIlO01IIO0l;
wire[3:0] OI01ll10IOIIO0l;wire[3:0] OI01lOIl01IIO0l;wire O1lIOIlI0OIO01l;wire OI01lIlI0OIIO0l;wire O1lIOO1lIOIO01l;wire[3:0] OI01lO1lIOIIO0l;
wire[31:0] OlI1OIlO01IO01l;wire[2:0] OlI1Ol10IOIO01l;wire[3:0] OlI1OOIl01IO01l;wire I01lOOI01lOIl01;wire OlI1OIlI0OIO01l;wire I01lOIO0lIOIl01;
wire OlI1OO1lIOIO01l;wire I01lOOOl1IOIl01;wire I1lO0I1lO0OIl01;wire[3:0] I1lO0lO10IOIl01;wire I1lO0OI01lOIl01;wire[6:0] OIl01IIO0lIO0lI;
wire[6:0] I1lO0IO0lIOIl01;wire OIl01OOIl1IO0lI;wire I1lO0OOl1IOIl01;wire O01IlI01lOIO0lI;wire[3:0] O01IllIO10IO0lI;wire O01IlOlI01IO0lI;
wire IIO0lIIO0lI01lO;wire O01IlIIO0lIO0lI;wire IIO0lOOIl1I01lO;wire O01IlOOIl1IO0lI;wire IO0lII01lOI01lO;wire[3:0] IO0lIlIO10I01lO;
wire IO0lIOlI01I01lO;wire[1:0] IlO01IOIl0O01Il;wire[6:0] IO0lIIIO0lI01lO;wire IlO01OlI1OO01Il;wire[5:0] IO0lIOOIl1I01lO;wire IO01lIO01lO01Il;
wire[31:0] IO01ll0IO1O01Il;wire[1:0] IO01lO01IlO01Il;wire lIO10IlI0OO1lIO;wire[6:0] IO01lIOIl0O01Il;wire lIO10O1lIOO1lIO;wire IO01lOlI1OO01Il;
wire lO10IIlO01O1lIO;wire[3:0] lO10Il10IOO1lIO;wire[3:0] lO10IOIl01O1lIO;wire IlI0OIlI0OI1lO0;wire[3:0] lO10IIlI0OO1lIO;wire IlI0OO1lIOI1lO0;
wire[3:0] lO10IO1lIOO1lIO;wire[6:0] IOIl0IlO01I1lO0;wire IOIl0l10IOI1lO0;wire[3:0] IOIl0OIl01I1lO0;wire OOIl1OI01lOlI01;wire IOIl0IlI0OI1lO0;
wire OOIl1IO0lIOlI01;wire IOIl0O1lIOI1lO0;wire[6:0] OOIl1OOl1IOlI01;wire OOl1II1lO0OlI01;wire[3:0] OOl1IlO10IOlI01;wire OOl1IOI01lOlI01;
wire[6:0] l10IOIIO0lOlI1O;wire OOl1IIO0lIOlI01;wire l10IOOOIl1OlI1O;wire OOl1IOOl1IOlI01;wire l0IO1I01lOOlI1O;wire[3:0] l0IO1lIO10OlI1O;
wire l0IO1OlI01OlI1O;wire[5:0] OlI01IIO0ll10IO;wire l0IO1IIO0lOlI1O;wire OlI01OOIl1l10IO;wire l0IO1OOIl1OlI1O;wire OI01lI01lOl10IO;
wire[3:0] OI01llIO10l10IO;wire OI01lOlI01l10IO;wire[3:0] O1lIOIOIl0OI01l;wire[6:0] OI01lIIO0ll10IO;wire O1lIOOlI1OOI01l;wire OI01lOOIl1l10IO;
wire OlI1OIO01lOI01l;wire[3:0] OlI1Ol0IO1OI01l;wire OlI1OO01IlOI01l;wire I01lOIlI0OOOIl1;wire[5:0] OlI1OIOIl0OI01l;wire I01lOO1lIOOOIl1;
wire[2:0] OlI1OOlI1OOI01l;wire[3:0] I1lO0IlO01OOIl1;wire I1lO0l10IOOOIl1;wire[3:0] I1lO0OIl01OOIl1;wire OIl01IlI0Ol0IO1;wire I1lO0IlI0OOOIl1;
wire OIl01O1lIOl0IO1;wire I1lO0O1lIOOOIl1;wire[2:0] O01IlIlO01l0IO1;wire O01Ill10IOl0IO1;wire[3:0] O01IlOIl01l0IO1;wire IIO0lOI01lIlI0O;
wire O01IlIlI0Ol0IO1;wire IIO0lIO0lIIlI0O;wire[31:0] O01IlO1lIOl0IO1;wire IIO0lOOl1IIlI0O;wire IO0lII1lO0IlI0O;wire[3:0] IO0lIlO10IIlI0O;
wire IO0lIOI01lIlI0O;wire[6:0] IlO01IIO0lOOl1I;wire IO0lIIO0lIIlI0O;wire IlO01OOIl1OOl1I;wire IO0lIOOl1IIlI0O;wire IO01lI01lOOOl1I;
wire[3:0] IO01llIO10OOl1I;wire IO01lOlI01OOl1I;wire[6:0] lIO10IIO0llIO10;wire IO01lIIO0lOOl1I;wire lIO10OOIl1lIO10;wire IO01lOOIl1OOl1I;
wire[3:0] lO10II01lOlIO10;wire[3:0] lO10IlIO10lIO10;wire lO10IOlI01lIO10;wire IlI0OIOIl0IOIl0;wire lO10IIIO0llIO10;wire IlI0OOlI1OIOIl0;
wire lO10IOOIl1lIO10;wire IOIl0IO01lIOIl0;wire[3:0] IOIl0l0IO1IOIl0;wire IOIl0O01IlIOIl0;wire OOIl1IOIl0IlO01;wire IOIl0IOIl0IOIl0;
wire[1:0] OOIl1OlI1OIlO01;wire IOIl0OlI1OIOIl0;wire[31:0] OOl1IIO01lIlO01;wire[4:0] OOl1Il0IO1IlO01;wire[3:0] OOl1IO01IlIlO01;wire l10IOIlI0OlO10I;
wire OOl1IIOIl0IlO01;wire[3:0] l10IOO1lIOlO10I;wire OOl1IOlI1OIlO01;wire l0IO1IlO01lO10I;wire l0IO1l10IOlO10I;wire[3:0] l0IO1OIl01lO10I;
wire OlI01OI01lIIO0l;wire l0IO1IlI0OlO10I;wire[31:0] OlI01IO0lIIIO0l;wire[5:0] l0IO1O1lIOlO10I;wire OlI01OOl1IIIO0l;wire[1:0] OI01lI1lO0IIO0l;
wire[3:0] OI01llO10IIIO0l;wire OI01lOI01lIIO0l;wire O1lIOIO0lIIO01l;wire OI01lIO0lIIIO0l;wire O1lIOOOl1IIO01l;wire OI01lOOl1IIIO0l;
wire OlI1OI1lO0IO01l;wire[3:0] OlI1OlO10IIO01l;wire OlI1OOI01lIO01l;wire I01lOIIO0lOIl01;wire[31:0] OlI1OIO0lIIO01l;wire I01lOOOIl1OIl01;
wire OlI1OOOl1IIO01l;wire I1lO0I01lOOIl01;wire I1lO0lIO10OIl01;wire I1lO0OlI01OIl01;wire[6:0] OIl01IOIl0IO0lI;wire I1lO0IIO0lOIl01;
wire OIl01OlI1OIO0lI;wire[31:0] I1lO0OOIl1OIl01;wire O01IlIO01lIO0lI;wire[3:0] O01Ill0IO1IO0lI;wire O01IlO01IlIO0lI;wire IIO0lIOIl0I01lO;
wire[6:0] O01IlIOIl0IO0lI;wire IIO0lOlI1OI01lO;wire[2:0] O01IlOlI1OIO0lI;wire[31:0] IO0lIIO01lI01lO;wire IO0lIl0IO1I01lO;wire[3:0] IO0lIO01IlI01lO;
wire IlO01IlI0OO01Il;wire[6:0] IO0lIIOIl0I01lO;wire[31:0] IlO01O1lIOO01Il;wire IO0lIOlI1OI01lO;wire[31:0] IO01lIlO01O01Il;wire IO01ll10IOO01Il;
wire[3:0] IO01lOIl01O01Il;wire lIO10OI01lO1lIO;wire IO01lIlI0OO01Il;wire[31:0] lIO10IO0lIO1lIO;wire IO01lO1lIOO01Il;wire[2:0] lIO10OOl1IO1lIO;
wire lO10II1lO0O1lIO;wire[3:0] lO10IlO10IO1lIO;wire IlI0OOI01lI1lO0;wire[31:0] lO10IOI01lO1lIO;wire IlI0OIO0lII1lO0;wire lO10IIO0lIO1lIO;
wire[31:0] IlI0OOOl1II1lO0;wire lO10IOOl1IO1lIO;wire IOIl0I1lO0I1lO0;wire[3:0] IOIl0lO10II1lO0;wire IOIl0OI01lI1lO0;wire[6:0] OOIl1IIO0lOlI01;
wire[6:0] IOIl0IO0lII1lO0;wire OOIl1OOIl1OlI01;wire IOIl0OOl1II1lO0;wire OOl1II01lOOlI01;wire[3:0] OOl1IlIO10OlI01;wire OOl1IOlI01OlI01;
wire[6:0] l10IOIOIl0OlI1O;wire OOl1IIIO0lOlI01;wire l10IOOlI1OOlI1O;wire OOl1IOOIl1OlI01;wire l0IO1IO01lOlI1O;wire[3:0] l0IO1l0IO1OlI1O;
wire[1:0] l0IO1O01IlOlI1O;wire OlI01IOIl0l10IO;wire[6:0] l0IO1IOIl0OlI1O;wire OlI01OlI1Ol10IO;wire l0IO1OlI1OOlI1O;wire OI01lIO01ll10IO;
wire OI01ll0IO1l10IO;wire OI01lO01Ill10IO;wire O1lIOIlI0OOI01l;wire[6:0] OI01lIOIl0l10IO;wire[31:0] O1lIOO1lIOOI01l;wire OI01lOlI1Ol10IO;
wire[31:0] OlI1OIlO01OI01l;wire OlI1Ol10IOOI01l;wire[3:0] OlI1OOIl01OI01l;wire I01lOOI01lOOIl1;wire[3:0] OlI1OIlI0OOI01l;wire[1:0] I01lOIO0lIOOIl1;
wire[3:0] OlI1OO1lIOOI01l;wire I01lOOOl1IOOIl1;wire I1lO0I1lO0OOIl1;wire[3:0] I1lO0lO10IOOIl1;wire OIl01OI01ll0IO1;wire I1lO0OI01lOOIl1;
wire OIl01IO0lIl0IO1;wire[2:0] I1lO0IO0lIOOIl1;wire[4:0] OIl01OOl1Il0IO1;wire I1lO0OOl1IOOIl1;wire O01IlI1lO0l0IO1;wire[3:0] O01IllO10Il0IO1;
wire O01IlOI01ll0IO1;wire IIO0lIIO0lIlI0O;wire[6:0] O01IlIO0lIl0IO1;wire IIO0lOOIl1IlI0O;wire O01IlOOl1Il0IO1;wire IO0lII01lOIlI0O;
wire[3:0] IO0lIlIO10IlI0O;wire IO0lIOlI01IlI0O;wire IlO01IOIl0OOl1I;wire IO0lIIIO0lIlI0O;wire[1:0] IlO01OlI1OOOl1I;wire IO0lIOOIl1IlI0O;
wire[5:0] IO01lIO01lOOl1I;wire[3:0] IO01ll0IO1OOl1I;wire[5:0] IO01lO01IlOOl1I;wire[6:0] lIO10IOIl0lIO10;wire[6:0] IO01lIOIl0OOl1I;
wire lIO10OlI1OlIO10;wire IO01lOlI1OOOl1I;wire lO10IIO01llIO10;wire lO10Il0IO1lIO10;wire lO10IO01IllIO10;wire IlI0OIlI0OIOIl0;wire[6:0] lO10IIOIl0lIO10;
wire IlI0OO1lIOIOIl0;wire lO10IOlI1OlIO10;wire IOIl0IlO01IOIl0;wire[3:0] IOIl0l10IOIOIl0;wire[3:0] IOIl0OIl01IOIl0;wire OOIl1IlI0OIlO01;
wire IOIl0IlI0OIOIl0;wire[1:0] OOIl1O1lIOIlO01;wire[3:0] IOIl0O1lIOIOIl0;wire OOl1IIlO01IlO01;wire[5:0] OOl1Il10IOIlO01;wire[3:0] OOl1IOIl01IlO01;
wire l10IOOI01llO10I;wire OOl1IIlI0OIlO01;wire[1:0] l10IOIO0lIlO10I;wire OOl1IO1lIOIlO01;wire l10IOOOl1IlO10I;wire IlO01IlO01IlO01;

dffe IIlO01I1lO0OOl1I(I1lO0OIl01OIl01[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,OlI1OlO10IOI01l[3]);assign lO10IIlI0OO1lIO
=(IO01lIlI0OOOl1I)?4'b1111:
(I1lO0IlI0OOOIl1)?l0IO1IlI0OOlI1O-4'b0001:l0IO1IlI0OOlI1O;assign pci_wrbuf_waddr[4]
=OOl1IIlI0OOlI01;dffe2 IIIO0lOIl01IlI0O(pci_cmd[1:0],IlO01IOIl0O01Il[1:0],clk,reset_b,1'b1,OIl01IOIl0l0IO1);dffe II1lO0OOl1IOlI1O
(IO01llIO10O01Il[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,IO0lIl0IO1IlI0O[2]);assign I01lOO1lIOOIl01
=I01lOIO0lIOIl01&OOIl1IO0lIOlI01;dff2 IOlI01I1lO0l10IO(OOl1IO01IlOlI01,IO01lO01IlO01Il,clk,reset_b,1'b1);assign OlI1OO01IlOI01l
=(l0IO1O01IlOlI1O==2'b10)?1'b1:1'b0;assign OlI1OIIO0lIO01l[6]=(~I1lO0IIO0lOIl01)&IO0lIIIO0lI01lO[6];assign db01_wea
=I01lOIlI0OOOIl1&~IlI0OIIO0lIOIl0;assign I1lO0l10IOOIl01=~IO0lIl10IOI01lO[2]&~IO0lIl10IOI01lO[1]&~IO0lIl10IOI01lO[0];assign O1lIOIO0lIOI01l
=I01lOIlI0OOIl01?hs_fast:OlI01OOl1IIIO0l;assign O01IlI1lO0l0IO1=(OOl1IIlI0OOlI01)?lO10IIO0lIO1lIO:IO0lIIIO0lIlI0O;assign OI01lIOIl0IIO0l
=OI01lIOIl0l10IO+7'b0000011;assign O01IlIOIl0IO0lI[4]
=((OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)|
(OlI1OO1lIOIO01l&OI01lIO0lIIIO0l)|
(OOl1IO1lIOIlO01&O01IlIO0lIIO0lI)|
(OlI1OO1lIOIO01l&IOIl0IO0lIIOIl0)|
(OOl1IO1lIOIlO01&OI01lIO0lIIIO0l)|
(IO01lIO0lIOOl1I&O01IlIO0lIIO0lI))&
O01IlO1lIOl0IO1[4];assign IlO01OOl1IOOl1I
=4'b1111;assign I1lO0I01lOOOIl1=s_htrans[1]&~s_htrans[0];assign OlI01IO0lIIIO0l[31:24]
=(I01lOOOIl1OOIl1|m_swapen)?OIl01IO0lIIO0lI[31:24]:OIl01IO0lIIO0lI[7:0];assign lO10IlIO10lIO10[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OOl1IOIl01IlO01[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;assign IO0lIOOl1II01lO
=(IlO01IlO01IlO01&I1lO0I01lOOOIl1&s_hreadyin&IO0lII01lOI01lO&~OlI1OI1lO0OI01l&~IO0lIIO01lIlI0O)|
(IO01lOOl1IOOl1I&~OlI1OOOl1IIO01l&~IO01lOOIl1OOl1I&OI01lI1lO0l10IO&IO0lII1lO0IlI0O)|
(I1lO0OOl1IOOIl1&I1lO0I01lOOOIl1&IO0lII01lOI01lO&s_hreadyin&~OlI1OI1lO0OI01l)|
(l0IO1OOl1IOlI1O&I1lO0I01lOOOIl1&IO0lII01lOI01lO&s_hreadyin&~OlI1OI1lO0OI01l)|
(IO0lIOOl1IIlI0O&I1lO0I01lOOOIl1&IO0lII01lOI01lO&s_hreadyin&I1lO0IO01lOIl01&~OlI1OI1lO0OI01l&~OI01lIO01ll10IO);assign s_hrdata
=pci_rdbuf_rdata;assign lIO10OOIl1O1lIO[31]=(lIO10OOl1IlIO10==8'b00000000)?OlI01OOl1Il10IO[20]:1'b0;assign IO0lIlIO10I01lO[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;assign lO10IlO10IO1lIO[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;dff IlIO10lO10IO1lIO
(I1lO0OOIl1OOIl1,O01IlOOIl1IO0lI,clk,1'b1,reset_b);assign O01IlI1lO0IO0lI=(I1lO0IO0lIOIl01[5:0]==6'b111111)?1'b1:1'b0;assign O1lIOIlI0OOI01l
=(OlI01IOIl0l10IO&~I01lOO1lIOOIl01&~OlI01IIO0lIIO0l&~l10IOIO0lIOlI1O[1])|(IIO0lIlI0OIlI0O&~l10IOOOl1IlO10I);assign l0IO1l0IO1OlI1O[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign OlI1OlO10IOI01l[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign l0IO1OlI1OlO10I
=(OlI1OOlI1OOI01l==3'b100)?1'b1:1'b0;assign l0IO1OlI01OlI1O
=(l0IO1IIO0llO10I&lO10IIIO0lO1lIO)|
(lO10IIIO0llIO10&l0IO1IIO0lOlI1O);dff II01lOO01IlOOIl1
(l10IOOI01lOlI1O,lIO10OI01lO1lIO,clk,1'b1,reset_b);assign IO0lIl0IO1IlI0O[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;dffe IOIl01lIO10l0IO1
(IO01lOIl01OOl1I[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IO0lIOIl01I01lO[1]);assign I1lO0OlI1OOOIl1[1:0]=I1lO0OOIl1OIl01[1:0];assign IO0lIIlI0OI01lO
=(lO10IIlI0OlIO10==1'b0)?OOl1IIIO0lOlI01:OI01lIO0lIIIO0l;dff2 IIlO01O01IlO01Il
(OOIl1OOIl1IlO01[1:0],IlO01OlI1OOOl1I[1:0],clk,reset_b,1'b1);dffe IIlI0OI01lOI1lO0
(OOl1IlO10IIlO01[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,IOIl0lIO10I1lO0[0]);dffe IlIO10l0IO1lIO10
(OI01lOIl01IIO0l[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,l0IO1lO10IOlI1O[0]);assign IO0lIOlI1OI01lO
=(OlI1OOlI1OOI01l[2:1]==2'b10)?1'b1:1'b0;assign OlI1OIlI0OOI01l[3]
=(lO10IIlI0OlIO10==1'b0)?~l0IO1lO10IlO10I[3]:~OlI1Ol0IO1OI01l[3];assign lIO10OlI1OlIO10=(O1lIOOlI1OIO01l==2'b00)?1'b1:1'b0;dffe IOlI01IO01ll10IO
(lO10IlIO10O1lIO[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,IO01ll0IO1OOl1I[3]);dffe Il10IOl10IOlO10I
(OOl1IOIl01OlI01[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IOIl0lO10IIOIl0[3]);dff32 IO1lIOlO10IIO01l
(IO01ll0IO1O01Il,I1lO0l0IO1OIl01,clk,reset_b,1'b1);assign OOl1IIO01lIlO01=pci_wrbuf_rdata;dffe IOOIl1O01IlIlO01
(OlI01IO0lIl10IO,OIl01IO0lIl0IO1,clk,reset_b,1'b1,IIO0lIIO0lI01lO);dffe IOIl01IlO01l0IO1
(OlI1OlIO10OI01l[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,OI01ll0IO1IIO0l[2]);dff IIlO01OlI01OOl1I
(lIO10IlI0OlIO10,OIl01IlI0Ol0IO1,clk,1'b1,reset_b);dffe II01lOI1lO0OIl01
(O01IlOIl01l0IO1[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,I1lO0lO10IOIl01[2]);dff IlIO10lIO10O1lIO
(IO01lIIO0lOOl1I,OOl1IIO0lIIlO01,clk,reset_b,1'b1);dff7 IO01IlOOl1Il10IO(OI01lIIO0ll10IO,IOIl0IIO0lI1lO0,clk,reset_b,1'b1);assign l10IOIIO0lOlI1O[6:0]
=O1lIOIO0lIOI01l?IlO01IIO0lOOl1I[6:0]:OIl01IOIl0IO0lI[6:0];dff3 IIO0lIOOl1IOI01l(OlI1Ol10IOIO01l,s_hsize,clk,reset_b,1'b1);assign OOIl1OOl1IIlO01
=~l10IOIO0lIOlI1O[2]|~l10IOIO0lIOlI1O[1];assign IO01lIO0lIOOl1I=(IO0lIO1lIOI01lO[2:0]==3'b010)?1'b1:1'b0;assign IO01lIIO0lO01Il
=(OI01lIIO0lIIO0l==3'b110)?1'b1:1'b0;assign lO10IIOIl0O1lIO[2]
=(OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)?IO01lIOIl0OOl1I[2]:
l0IO1IOIl0OlI1O[2];assign O01IlIlO01l0IO1[2:0]=OlI1OIO01lIO01l[2:0];dff4 IOOl1IOOl1IO01Il
(O01IlI01lOl0IO1,lO10II01lOlIO10,clk,reset_b,1'b1);assign lIO10IO0lIO1lIO[7:0]
=(IlO01OOIl1OOl1I|m_swapen)?IlI0OIO0lIIOIl0[7:0]:IlI0OIO0lIIOIl0[31:24];assign lO10IlO10IlIO10[1]
=IOIl0O01IlI1lO0[1]&OOl1IIlI0OOlI01;assign IO0lIOIl01I01lO[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign IO0lIl0IO1I01lO
=lO10IOOl1IO1lIO&lO10IIO01lO1lIO&
~OI01ll0IO1l10IO&O01IlOOIl1l0IO1&lO10IOOIl1lIO10;assign I01lOOOl1IOIl01=1'b1;assign I1lO0I1lO0OIl01
=~s_hsize[2]&~s_hsize[1]&s_hsize[0];dff IIIO0lOlI01IlI0O(OIl01OOIl1IO0lI,OlI01OOIl1IIO0l,clk,reset_b,1'b1);assign OI01llIO10l10IO[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;assign I1lO0lO10IOOIl1[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;dff Il10IOlO10IOlI1O
(IOIl0OOl1IIOIl0,OI01lOOl1IIIO0l,clk,reset_b,1'b1);assign IOIl0IO0lII1lO0[1:0]=s_haddr[1:0];dff IOIl01OlI01l0IO1
(IIO0lIlI0OIlI0O,O1lIOIlI0OOI01l,clk,reset_b,1'b1);assign IO01ll0IO1OOl1I[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;assign IOIl0lO10IIOIl0[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign OI01lOlI1OIIO0l
=~O01IlOlI1OIO0lI[1]&~O01IlOlI1OIO0lI[0];assign OlI1OO1lIOOI01l
=(IO0lIO1lIOIlI0O)?IOIl0l10IOIOIl0:
(IO0lIl10IOIlI0O)?OOl1IO1lIOOlI01-4'b0001:OOl1IO1lIOOlI01;assign I01lOIOIl0OOIl1
=(OOIl1IIO0lIlO01[6:0]==7'b0000001)?1'b1:1'b0;assign OI01ll0IO1IIO0l[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign I1lO0lO10IOIl01[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;assign OI01lO1lIOIIO0l
=
(IO01lO1lIOOOl1I&(OOl1Il10IOIlO01[2]|OOl1Il10IOIlO01[3]|IOIl0l10IOI1lO0))?4'b0001:
(IO01lO1lIOOOl1I)?lO10Il10IOO1lIO:
(l0IO1O1lIOOlI1O)?IOIl0O1lIOIOIl0-4'b0001:IOIl0O1lIOIOIl0;assign OI01ll10IOIIO0l
=(~IO0lIIO0lIIlI0O)?IO0lIIO0lII01lO[5:2]:
(OI01lOlI01IIO0l)?4'b0001:
(IO0lIOlI01IlI0O)?4'b0100:
(OlI1OOlI01OI01l)?4'b1000:
(IOIl0OlI01IOIl0)?4'b0010:
4'b0000;assign I01lOOI01lOIl01
=O1lIOOI01lOI01l|(IlO01OI01lO01Il&~lIO10IO0lIlIO10);dffe IO1lIOI01lOOI01l
(IO0lIlO10II01lO[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,O01IllIO10l0IO1[0]);dffe IOlI01l0IO1IIO0l
(lO10IOIl01O1lIO[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IO01llO10IOOl1I[0]);assign l0IO1O1lIOlO10I[4]
=(OI01lOlI1OIIO0l&O01IlOlI1Ol0IO1)?1'b0:
(IOIl0OlI1OIOIl0&l0IO1OlI1OlO10I)?1'b0:
(IO0lIOlI1OIlI0O&IO01lOlI1OO01Il)?1'b0:
OlI1OIOIl0OI01l[4];assign IO0lIIO01lI01lO[3]
=(I1lO0l10IOOOIl1&~IO01lO1lIOO01Il&I1lO0OOIl1OIl01[3])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[3])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[3])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[3])|
(l0IO1l10IOOlI1O&~OI01lIlI0Ol10IO&l0IO1OI01lOlI1O[3])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[3])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[3])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[3]);assign IlO01OlI1OO01Il
=OlI01OlI1OIIO0l&~lIO10OOIl1lIO10&OOIl1IOIl0IlO01;dffe IIIO0lIO01lIlI0O
(I1lO0lIO10OOIl1[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,OlI1OlIO10IO01l[3]);dffe IOIl01l10IOIO0lI
(IO0lIOIl01IlI0O[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,O01IllO10IIO0lI[3]);assign IOIl0OI01lIOIl0
=(I1lO0OOIl1OIl01[31:4]==IO01ll0IO1O01Il[31:4])?1'b1:1'b0;assign O01IlIlO01IO0lI=~IO01lOOIl1OOl1I;assign OIl01OlI1OIO0lI
=~O1lIOOOIl1OI01l&(IIO0lIlI0OI01lO|lIO10OlI1OO1lIO);dffe IIlI0OIlO01IOIl0
(IOIl0lIO10IOIl0[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,lO10Il0IO1O1lIO[2]);assign IlI0OO1lIOIOIl0
=~IlO01OOIl1O01Il&
(OOIl1IlI0OIlO01|OlI01O1lIOIIO0l);dffe IlIO10I1lO0O1lIO
(l0IO1OIl01lO10I[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,OOl1IlO10IOlI01[2]);assign O01IlIlI0OIO0lI
=(l0IO1IlI0OOlI1O==4'b0000)?1'b1:1'b0;assign IOIl0O01IlI1lO0[0]
=(O01IlOI01ll0IO1)?lO10IO1lIOlIO10:
((~big_endian&OI01lOI01ll10IO&~I1lO0IO0lIOIl01[1])|
(big_endian&OI01lOI01ll10IO&I1lO0IO0lIOIl01[1]))?lO10IO1lIOlIO10:
((~big_endian&IOIl0OI01lI1lO0&~I1lO0IO0lIOIl01[1]&~I1lO0IO0lIOIl01[0])|
(big_endian&IOIl0OI01lI1lO0&I1lO0IO0lIOIl01[1]&I1lO0IO0lIOIl01[0]))?lO10IO1lIOlIO10:
1'b0;dffe IIlO01OIl01O01Il
(pci_cacheline,OOIl1IOIl0OlI01,clk,reset_b,1'b1,OIl01IOIl0l0IO1);dffe6 IlO10IOOl1IIO0lI
(IO01lIO01lOOl1I,I1lO0IO01lOOIl1,clk,reset_b,1'b1,O01IlIO01lIO0lI);assign IlI0OO1lIOI1lO0=1'b0;assign lO10IO01IllIO10
=lO10IIO01lO1lIO&OOl1IIlI0OOlI01&(
(l0IO1OOl1IOlI1O&l0IO1I01lOOlI1O)|
(l0IO1OOl1IOlI1O&I1lO0I01lOOOIl1)|
(l0IO1OOl1IOlI1O&~O01IlI1lO0l0IO1&OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&IO01lI01lOOOl1I&O01IlI1lO0l0IO1&OI01lI01lOl10IO));assign l0IO1IIO0lOlI1O
=(I1lO0IIO0lOOIl1[2:0]==3'b000)?1'b1:1'b0;assign OOl1IIIO0lIlO01[3]
=((l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)|
(l0IO1IIO0lOlI1O&OOl1IIIO0lOlI01)|
(lO10IIIO0lO1lIO&OlI1OIIO0lOI01l))&
OlI1OIO0lIIO01l[3];assign mwr_dina[31:0]
=lIO10IO0lIO1lIO[31:0];assign O01Ill10IOl0IO1=IO0lIl10IOI01lO[2]&~IO0lIl10IOI01lO[1]&~IO0lIl10IOI01lO[0];assign O1lIOIO0lIIO01l
=lIO10IlI0OlIO10?O01IlIlO01IO0lI:O1lIOOOl1IOI01l;assign I1lO0IOIl0OIl01
=
(IOIl0O1lIOI1lO0)?l0IO1IOIl0lO10I+lO10IIOIl0lIO10:
(O01IlIOIl0l0IO1)?IO01lIOIl0O01Il+lO10IIOIl0lIO10:
IO01lIOIl0O01Il;assign IO0lIO01IlI01lO[1]
=IOIl0O01IlI1lO0[1]&~OOl1IIlI0OOlI01;assign OOl1IIO01lOlI01=1'b0;assign lIO10OOl1IO1lIO=3'b111;assign IOIl0I01lOIOIl0
=~s_hburst[2]&s_hburst[1]&~s_hburst[0];assign OlI01IO0lIIIO0l[7:0]
=(I01lOOOIl1OOIl1|m_swapen)?OIl01IO0lIIO0lI[7:0]:OIl01IO0lIIO0lI[31:24];assign lO10IlIO10lIO10[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OOl1IOIl01IlO01[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;dff IOlI01OIl01l10IO
(I1lO0OOl1IOOIl1,l0IO1OOl1IlO10I,clk,reset_b,1'b1);assign l0IO1IO0lIlO10I
=(I1lO0IlI0OOIl01)?IOIl0IO0lII1lO0:
(lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO))?OI01lIO0lIl10IO:
I1lO0IO0lIOIl01;assign lIO10OOIl1O1lIO[1:0]
=(lIO10OOl1IlIO10==8'b00000000)?2'b00:2'b01;assign OlI1OlIO10IO01l[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign O01IllO10IIO0lI[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;dff IIlI0OlO10IIOIl0
(IO01lOOIl1OOl1I,IOIl0OOIl1IOIl0,clk,reset_b,1'b1);assign OI01lI01lOl10IO
=
(lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&IOIl0IOIl0IOIl0)|
IO0lIIOIl0IlI0O;assign OOIl1IO0lIIlO01
=~((OOIl1IOIl0IlO01&IlI0OOI01lI1lO0)|(IIO0lIOIl0I01lO&I01lOO1lIOOOIl1)|lIO10IlI0OO1lIO|OOIl1IlI0OOlI01);assign lO10Il0IO1O1lIO[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign OOl1IlO10IOlI01[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign OI01lOlI1Ol10IO
=(OlI1OOlI1OOI01l==3'b111)?1'b1:1'b0;assign OlI1OIO0lIOI01l=(I1lO0IO0lIOOIl1[2:1]==2'b01)?1'b1:1'b0;dff IOIl01O01IlIO0lI
(O1lIOOI01lOI01l,OOIl1OI01lOlI01,clk,reset_b,1'b1);dffe IIlO01I01lOOOl1I
(OI01llO10Il10IO[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,l0IO1lIO10lO10I[0]);dffe IIIO0llIO10I01lO
(I1lO0OIl01OOIl1[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,OlI1OOIl01IO01l[0]);assign I1lO0OlI1OOOIl1[4]
=(~IO01lO1lIOO01Il)?1'b0:
(OI01lOlI1OIIO0l&IO01lOlI1OO01Il)?1'b0:
(OI01lOlI1OIIO0l&l0IO1OlI1OlO10I)?1'b0:
(OI01lOlI1OIIO0l&O01IlOlI1Ol0IO1)?1'b0:
(IOIl0OlI1OIOIl0&IO01lOlI1OO01Il)?1'b0:
(IOIl0OlI1OIOIl0&l0IO1OlI1OlO10I)?1'b0:
(IO0lIOlI1OIlI0O&IO01lOlI1OO01Il)?1'b0:
I1lO0OOIl1OIl01[4];assign IO01lOI01lOOl1I
=(lO10IIlI0OlIO10==1'b0)?lO10IIIO0lO1lIO:OOl1IO1lIOIlO01;assign IlO01OlI1OOOl1I
=(IlI0OOOIl1I1lO0==1'b1)?2'b00:
(O1lIOOOIl1IO01l==1'b1)?2'b01:
(OlI01OOIl1l10IO==1'b1)?2'b10:
(IIO0lOOIl1I01lO==1'b1)?2'b11:
OOIl1OOIl1IlO01;dffe IOOIl1I01lOIlO01
(OOl1IlO10IIlO01[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,IOIl0lIO10I1lO0[3]);dffe IIlI0Ol0IO1I1lO0
(OI01lOIl01IIO0l[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,l0IO1lO10IOlI1O[3]);assign O01IlOlI01l0IO1
=(IOIl0OlI1OI1lO0&IOIl0OlI1OIOIl0)?1'b1:
(IO0lIOlI1OI01lO&OI01lOlI1OIIO0l)?1'b1:1'b0;assign l0IO1OI01llO10I[2]
=~((~big_endian&(OI01lOlI1OIIO0l|IOIl0OlI1OIOIl0)&
(I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0]))|
(big_endian&IOIl0OlI1OIOIl0&~I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0])|
(big_endian&OI01lOlI1OIIO0l&~I1lO0OOIl1OIl01[1]&I1lO0OOIl1OIl01[0])|
IO0lIOlI1OIlI0O);assign OIl01OlI1Ol0IO1
=(O1lIOOlI1OIO01l==2'b11)?1'b1:1'b0;dffe IO1lIOIO01lIO01l
(O01IllIO10IO0lI[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,I1lO0l0IO1OOIl1[2]);dffe IOlI01l10IOl10IO
(IO01lOIl01O01Il[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IO0lIlO10IIlI0O[2]);assign I1lO0l0IO1OIl01[31:6]
=(I1lO0IlI0OOIl01)?s_haddr[31:6]:
(lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&~OI01lIlI0Ol10IO)?l0IO1l0IO1lO10I[31:6]:
IO01ll0IO1O01Il[31:6];assign pci_rdbuf_wren
=IO01lOOIl1OOl1I;dffe2 Il10IOOIl01OlI1O(I01lOIO0lIOOIl1[1:0],OOIl1O1lIOIlO01[1:0],clk,reset_b,1'b1,O1lIOIIO0lIO01l);dffe IIIO0lIlO01I01lO
(OOl1IlIO10OlI01[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,IOIl0l0IO1IOIl0[1]);assign I01lOOOIl1OIl01
=~OOIl1IO0lIOlI01&(I01lOIO0lIOIl01|I01lOIlI0OOIl01)&OlI01IOIl0l10IO;assign I1lO0IlI0OOIl01
=(IlO01IlO01IlO01&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0)|
(I1lO0OOl1IOOIl1&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0)|
(IO0lIOOl1IIlI0O&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(l0IO1OOl1IOlI1O&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0);assign O01IlO01IlIO0lI
=(lO10IOOIl1O1lIO&O01IlOOIl1IO0lI&~lO10IIlI0OlIO10);assign OlI1OIIO0lIO01l[1:0]=IO0lIIIO0lI01lO[1:0];assign lIO10IOIl0lIO10
=((l10IOOI01lOlI1O&IlO01O1lIOOOl1I&
~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))==1'b1)?IlO01IIO0lOOl1I:
(l10IOOlI1OOlI1O==1'b1)?lIO10IIO0lO1lIO:I01lOIIO0lOOIl1;assign lO10IOlI1OO1lIO
=(OlI1OOlI1OOI01l==IO0lIl10IOI01lO)?1'b1:1'b0;assign IlO01IO0lIO01Il[1:0]
=(~lIO10OOl1IO1lIO[2]&IlI0OOOl1II1lO0[31])?2'b10:
((~lIO10OOl1IO1lIO[2]&~IlI0OOOl1II1lO0[31])|
(~lIO10OOl1IO1lIO[1]&(IlO01OOl1IOOl1I[0]|IlO01OOl1IOOl1I[1]|IlO01OOl1IOOl1I[2]|IlO01OOl1IOOl1I[3])))?2'b00:l10IOOOl1IOlI1O[1:0];assign lO10IIO0lIO1lIO
=(I1lO0IO0lIOOIl1==3'b001)?1'b1:1'b0;assign IO0lIIOIl0I01lO
=(l0IO1IIO0lOlI1O)?7'b0000001:
(lO10IIIO0lO1lIO)?7'b0000010:
7'b0000100;assign lO10IIOIl0O1lIO[5]
=(IO01lIO0lIOOl1I&IOIl0IO0lIIOIl0)?
l0IO1IOIl0OlI1O[5]:
(~IO0lIIO0lIIlI0O)?l0IO1IOIl0OlI1O[5]:
IO01lIOIl0OOl1I[5];assign IOIl0IlO01I1lO0[6:5]
=2'b00;assign IOIl0I01lOI1lO0
=(OI01lI01lOIIO0l)?4'b0001:
(IOIl0I01lOIOIl0)?4'b0100:
(IO0lII01lOIlI0O)?4'b0100:
(OlI1OI01lOOI01l)?4'b1000:
(OOl1II01lOOlI01)?4'b1000:
4'b0000;assign lIO10O1lIOlIO10[1]
=(OOIl1OOl1IIlO01|m_swapen)?l10IOO1lIOlO10I[1]:l10IOO1lIOlO10I[2];assign O01IllO10Il0IO1[3:0]
=(I1lO0lIO10OIl01)?4'b0000:
lO10IlO10IlIO10[3:0];assign IO0lIOIl01I01lO[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OlI1OIO01lOI01l=1'b0;assign l0IO1OOl1IlO10I
=(IO01lOOl1IOOl1I&~OlI1OOOl1IIO01l&~OOl1IOOl1IIlO01&((IO01lO1lIOO01Il&~IO01lOOIl1OOl1I)|~IO01lO1lIOO01Il)&
OI01lI1lO0l10IO&~IO0lII1lO0IlI0O)|
(I1lO0OOl1IOOIl1&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~lO10II1lO0lIO10&~IO0lII1lO0I01lO)|
(I1lO0OOl1IOOIl1&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&lO10II1lO0lIO10&~OlI1OI1lO0IO01l)|
(I1lO0OOl1IOOIl1&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~IO01lI01lOOOl1I&lO10II1lO0lIO10&OlI1OI1lO0IO01l);assign OlI1OI01lOIO01l
=s_hsel[3]|s_hsel[2]|s_hsel[1]|s_hsel[0];assign IlI0OOOl1II1lO0[1:0]=2'b00;assign IOIl0lIO10I1lO0[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;assign l0IO1lO10IOlI1O[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign O01IlOOIl1IO0lI
=(I1lO0OOIl1OOIl1&~IO0lIl0IO1I01lO&~OlI1Ol0IO1IO01l)|
(lO10IOOIl1O1lIO&IO01lOOIl1O01Il)|
(IO01lOOIl1OOl1I&OOl1IOOIl1OlI01)|
(OlI1OOOl1IIO01l&~OOl1IIlO01OlI01);assign IOIl0IO0lII1lO0[4]
=OOl1II1lO0OlI01&s_haddr[4];assign O1lIOIOIl0IO01l
=(OlI01IOIl0l10IO&~I01lOO1lIOOIl01&~OlI01IIO0lIIO0l&~(l10IOIO0lIOlI1O[0]&l10IOIO0lIOlI1O[2]))|
(IIO0lIOIl0I01lO&~I01lOO1lIOOOIl1);assign I1lO0l0IO1OOIl1[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign IO0lIlO10IIlI0O[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;dffe3 Il10IOlO10IlO10I
(OlI1OOlI1OOI01l[2:0],IO0lIl10IOI01lO[2:0],clk,reset_b,1'b1,OI01lOOIl1l10IO);assign IO0lIO1lIOIlI0O=I1lO0OOIl1OOIl1;assign OlI01IOIl0IIO0l
=(lIO10IOIl0O1lIO[6:0]==7'b0000000)?1'b1:1'b0;assign IOIl0l0IO1IOIl0[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;dffe IOOIl1lIO10OlI01
(OOl1IO01IlIlO01[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IOIl0OIl01I1lO0[0]);assign IO01lO1lIOOOl1I=IO01lOlI1OOOl1I;assign O01IlIlI0Ol0IO1
=(lO10IOOIl1O1lIO&~lO10IIlI0OlIO10)?1'b1:
(lO10IOOIl1O1lIO&lO10IIlI0OlIO10)?1'b0:
((OlI1OOOl1IIO01l|IO01lOOIl1OOl1I)&(IO0lIO01IlIlI0O|OlI1OO01IlOI01l))?1'b0:
(I1lO0OOIl1OOIl1&IO0lIO01IlIlI0O)?1'b0:
(I1lO0OOIl1OOIl1&O01IlO01Ill0IO1)?1'b1:
1'b0;dff IO1lIOO01IlOI01l
(mwrreq_b,IlI0OIOIl0IOIl0,clk,1'b1,reset_b);dffe II01lOI01lOOIl01
(IO0lIlO10II01lO[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,O01IllIO10l0IO1[3]);dffe IO1lIOl0IO1OI01l
(lO10IOIl01O1lIO[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IO01llO10IOOl1I[3]);assign OOl1IOOIl1IlO01
=
(IO01lOOl1IOOl1I&l0IO1OOl1IlO10I)?I1lO0OlI1OOOIl1:
(l0IO1OOl1IlO10I&IO01lI01lOOOl1I)?l0IO1O1lIOlO10I:
OlI1OOOIl1IO01l;assign IO0lIIO01lI01lO[31:6]
=(I1lO0l10IOOOIl1)?I1lO0OOIl1OIl01[31:6]:l0IO1OI01lOlI1O[31:6];assign OlI01OlI1Ol10IO=IlO01IIO0lO01Il;dffe IIlO01IO01lO01Il
(l0IO1lIO10OlI1O[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,OOl1IlIO10IlO01[2]);dffe IIIO0ll10IOIlI0O
(OlI1OOIl01OI01l[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,OI01llO10IIIO0l[2]);assign OOl1IOI01lOlI01
=(lO10IOI01lO1lIO[31:5]==IO01ll0IO1O01Il[31:5])?1'b1:1'b0;assign IO01ll10IOOOl1I[3:0]
=(I1lO0O01IlOOIl1[2]|I1lO0O01IlOOIl1[3])?4'b0001:IOIl0l10IOIOIl0;assign l10IOOlI1OOlI1O
=~IIO0lOOIl1IlI0O&(IlI0OIlI0OI1lO0|I01lOOlI1OOOIl1);dffe IOOIl1IlO01OlI01
(IO0lIlIO10IlI0O[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,O01Ill0IO1IO0lI[1]);assign O1lIOIlI0OIO01l
=~OOl1IIlO01IlO01&l10IOIlI0OlO10I;dffe IIlI0OI1lO0IOIl0
(lO10IOIl01lIO10[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IO01llO10IO01Il[1]);assign O01Ill0IO1l0IO1
=
(I1lO0OlI01OIl01)|
(OI01ll0IO1l10IO&O01IlIlI0OIO0lI)|
(I1lO0OOl1IOOIl1&~l0IO1OOl1IlO10I)|
(IO01lOOl1IOOl1I&~OlI1OOOl1IIO01l&~IO01lOOIl1OOl1I&OI01lI1lO0l10IO&IO0lII1lO0IlI0O);assign IOIl0O01IlI1lO0[3]
=(O01IlOI01ll0IO1)?lO10IO1lIOlIO10:
((~big_endian&OI01lOI01ll10IO&I1lO0IO0lIOIl01[1])|
(big_endian&OI01lOI01ll10IO&~I1lO0IO0lIOIl01[1]))?lO10IO1lIOlIO10:
((~big_endian&IOIl0OI01lI1lO0&I1lO0IO0lIOIl01[1]&I1lO0IO0lIOIl01[0])|
(big_endian&IOIl0OI01lI1lO0&~I1lO0IO0lIOIl01[1]&~I1lO0IO0lIOIl01[0]))?lO10IO1lIOlIO10:
1'b0;assign lIO10IO0lIlIO10
=O1lIOIIO0lOI01l;assign l0IO1IO01lOlI1O=1'b0;assign IIO0lO1lIOIlI0O[0]
=~(~O01IlIlO01l0IO1[0]|
(~O01IlIlO01l0IO1[2]&~IlI0OOOl1II1lO0[31])|
(~O01IlIlO01l0IO1[1]&(I1lO0IlO01OIl01[0]|I1lO0IlO01OIl01[1]|I1lO0IlO01OIl01[2]|I1lO0IlO01OIl01[3])));assign OI01lO01Ill10IO
=(OOl1IO01IlOlI01==2'b10)?1'b1:1'b0;dffe3 IIIO0llIO10IlI0O
(OI01lIIO0lIIO0l[2:0],s_hburst[2:0],clk,reset_b,1'b1,OOl1IIO0lIIlO01);assign OOl1IIIO0lIlO01[6]=1'b0;assign mrd_addrb[3:0]
=OlI01IIO0ll10IO[3:0];assign IO01lI1lO0OOl1I=IO0lIl10IOI01lO[2]&IO0lIl10IOI01lO[1]&~IO0lIl10IOI01lO[0];assign OI01lIlO01IIO0l
=~I01lOIlI0OOIl01|OOIl1IO0lIIlO01;assign l0IO1IOIl0lO10I[1:0]=IOIl0I1lO0IOIl0[1:0];assign OlI1OO01IlIO01l[3:0]
=(OI01lOIl01l10IO)?4'b0000:
IO0lIO01IlI01lO[3:0];assign l0IO1IO01llO10I=1'b0;assign IlI0OOOl1IIOIl0=1'b1;assign OOl1II01lOOlI01
=s_hburst[2]&~s_hburst[1]&s_hburst[0];assign IIO0lIO0lII01lO[15:0]
=(~l10IOIO0lIOlI1O[0])?O1lIOO1lIOOI01l[15:0]:
lIO10OOIl1O1lIO[15:0];assign O01IllIO10l0IO1[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign IO01llO10IOOl1I[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;dff IO1lIOOIl01IO01l
(O01IlOOl1IIO0lI,OI01lOOl1Il10IO,clk,reset_b,1'b1);assign OI01lIO0lIl10IO[2]
=(IOIl0OI01lI1lO0&IO0lIOI01lI01lO)?I1lO0IO0lIOIl01[2]:
O01IlIO0lIl0IO1[2];dff IOOIl1OlI01OlI01
(IIO0lIOIl0I01lO,O1lIOIOIl0IO01l,clk,reset_b,1'b1);assign OOl1IlIO10IlO01[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign OI01llO10IIIO0l[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign OI01lOOIl1l10IO
=(IO01lOOl1IOOl1I&O01IlOOl1Il0IO1&O01IlOOIl1IO0lI&~OI01ll0IO1l10IO);assign O01IlOI01ll0IO1
=(OOl1IIlI0OOlI01==1'b0)?O01IlIIO0lIO0lI:IO01lIO0lIOOl1I;dff7 IIIO0lOlI01I01lO
(lIO10IOIl0O1lIO[6:0],OIl01IOIl0IO0lI[6:0],clk,reset_b,1'b1);assign O01Ill0IO1IO0lI[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign IO01llO10IO01Il[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;dff4 IlIO10lO10IlIO10
(O01IlO1lIOIO0lI,lO10IO1lIOO1lIO,clk,reset_b,1'b1);assign OI01lOlI01IIO0l=(l0IO1IO0lIOlI1O)|
(OlI1OIO0lIOI01l&OlI1OO1lIOIO01l);dff IIIO0lO01IlIlI0O
(OIl01OI01ll0IO1,OlI01OI01ll10IO,clk,reset_b,1'b1);dffe IlIO10I01lOO1lIO
(OI01llO10Il10IO[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,l0IO1lIO10lO10I[3]);dffe IIlO01l0IO1OOl1I
(I1lO0OIl01OOIl1[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,OlI1OOIl01IO01l[3]);assign OOl1IIOIl0OlI01
=(OI01lOlI1OIIO0l)?6'b000001:
(IOIl0OlI1OIOIl0)?6'b000010:
6'b000100;assign I1lO0O01IlOOIl1
=(lO10IIlI0OlIO10==1'b0)?OOl1IOlI01IlO01:IO01lO01IlOOl1I;assign IlI0OOOIl1I1lO0
=(~I01lOOlI1OOOIl1&OIl01OI01ll0IO1&lIO10IO0lIlIO10)|
(~lIO10OlI1OO1lIO&I01lOIlI0OOOIl1&~OlI01O1lIOl10IO&IlI0OIIO0lIOIl0&OlI01IOIl0IIO0l);dffe Il10IOIO01lOlI1O
(IO01llIO10OOl1I[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,IO0lIlIO10I01lO[2]);dffe IOOIl1l0IO1IlO01
(IOIl0OIl01IOIl0[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,lO10IlO10IO1lIO[2]);assign IO0lIOlI01I01lO
=(OlI1OOlI1OIO01l&IO0lIOlI1OIlI0O)?1'b1:1'b0;assign I1lO0IlO01OOIl1=lO10IOI01llIO10;assign h_wb_busy=~IlI0OOI01lI1lO0;dffe II01lOIlO01OOIl1
(OI01llIO10IIO0l[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,l0IO1l0IO1OlI1O[1]);dffe IO1lIOl10IOIO01l
(I1lO0OIl01OIl01[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,OlI1OlO10IOI01l[1]);assign IOIl0IlI0OIOIl0
=(OlI1OOOl1IIO01l&~OOl1IIlO01OlI01);assign pci_wrbuf_raddr[4]=lO10IIlI0OlIO10;dffe4 IOlI01OIl01IIO0l
(pci_be_b[3:0],O1lIOIOIl0OI01l[3:0],clk,1'b1,reset_b,l10IOIOIl0lO10I);dffe IOOl1IOOl1IOOl1I
(IO01llIO10O01Il[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,IO0lIl0IO1IlI0O[0]);assign l10IOOOIl1lO10I
=((IIO0lIOIl0I01lO&IlI0OOI01lIOIl0)|(IIO0lIlI0OIlI0O&l10IOOOl1IlO10I))&~IlO01OOl1IO01Il&~I01lOIlI0OOIl01;dff IOIl01I1lO0l0IO1
(IOIl0O1lIOI1lO0,OI01lO1lIOl10IO,clk,reset_b,1'b1);assign O01IlOOIl1l0IO1=(l0IO1O01IlOlI1O==2'b00)?1'b1:1'b0;assign OlI1OIIO0lIO01l[4]
=(O01IlIIO0lIO0lI&OOl1IIIO0lOlI01)?IO0lIIIO0lI01lO[4]:
(lO10IIIO0lO1lIO&IO01lIIO0lO01Il)?IO0lIIIO0lI01lO[4]:
(O01IlIIO0lIO0lI&IO01lIIO0lO01Il)?IO0lIIIO0lI01lO[4]:
(~I1lO0IIO0lOIl01)?IO0lIIIO0lI01lO[4]:
OI01lIIO0ll10IO[4];assign IlO01IOIl0O01Il[1:0]
=((l10IOOI01lOlI1O&IlO01O1lIOOOl1I&
~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))==1'b1)?OOIl1O1lIOIlO01[1:0]:
(l10IOOlI1OOlI1O==1'b1)?I01lOIO0lIOOIl1[1:0]:IlO01IO0lIOOl1I[1:0];assign OOl1Il10IOOlI01
=~OlI1Ol10IOIO01l[1]&OlI1Ol10IOIO01l[0];assign l10IOO1lIOlO10I[3:0]=l10IOIlI0OlO10I?I1lO0IlO01OIl01[3:0]:IlO01OOl1IOOl1I[3:0];assign IOIl0IO0lIIOIl0
=(I1lO0IO0lIOOIl1==3'b110)?1'b1:1'b0;assign OlI1OIOIl0IO01l[6:2]=5'b00000;assign O01IlIOIl0IO0lI[2]
=(OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)&
O01IlO1lIOl0IO1[2];assign OlI1OIlO01IO01l=32'h00000000;assign IO01lIlI0OO01Il
=~O01IlOOIl1l0IO1;assign IlI0OOOIl1IOIl0=IIO0lIOIl0I01lO&IlI0OOI01lIOIl0&l10IOIO0lIOlI1O[2];assign l0IO1lIO10lO10I[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign OlI1OOIl01IO01l[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign OI01lOOl1Il10IO
=
(IO01lOOl1IOOl1I&(OlI1OOOl1IIO01l|OOl1IOOl1IIlO01))|
(IO01lOOl1IOOl1I&IO01lO1lIOO01Il&IO01lOOIl1OOl1I)|
(IlO01IlO01IlO01&OI01lIO01lIIO0l&s_hwrite&~IOIl0I1lO0I1lO0&~IO0lIIO01lIlI0O)|
(IlO01IlO01IlO01&IOIl0IO01lIOIl0&s_hwrite&~l0IO1IO01llO10I&~IO0lIIO01lIlI0O)|
(I1lO0OOl1IOOIl1&IO01lI01lOOOl1I&lO10II1lO0lIO10&OlI1OI1lO0IO01l)|
(IO0lIOOl1IIlI0O&IO01lI01lOOOl1I&OOl1IIO01lOlI01&O01IlIO01ll0IO1&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(I1lO0OOl1IOOIl1&OI01lIO01lIIO0l&s_hwrite&~IOIl0I1lO0I1lO0)|
(I1lO0OOl1IOOIl1&IOIl0IO01lIOIl0&s_hwrite&~l0IO1IO01llO10I)|
(l0IO1OOl1IOlI1O&OI01lIO01lIIO0l&s_hwrite&~IOIl0I1lO0I1lO0)|
(l0IO1OOl1IOlI1O&IOIl0IO01lIOIl0&s_hwrite&~l0IO1IO01llO10I)|
(IO0lIOOl1IIlI0O&OI01lIO01lIIO0l&s_hwrite&~IOIl0I1lO0I1lO0&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&IOIl0IO01lIOIl0&s_hwrite&~l0IO1IO01llO10I&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(l0IO1OOl1IOlI1O&IO01lI01lOOOl1I&lO10IIO01lO1lIO&O01IlI1lO0l0IO1&OI01lI01lOl10IO)|
(l0IO1OOl1IOlI1O&IO01lI01lOOOl1I&l0IO1IO01lOlI1O&IOIl0IO01lI1lO0&lO10IIO01llIO10);assign s_hresp[1]
=lO10IOOl1IO1lIO|IOIl0OOl1IIOIl0|O01IlOOl1IIO0lI;assign OIl01OOl1Il0IO1=IlI0OOOl1II1lO0[15:11];assign IO0lIlIO10I01lO[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;assign lO10IlO10IO1lIO[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign IO0lIOOIl1IlI0O
=(I1lO0OOIl1OOIl1&OlI1Ol0IO1IO01l)|
(l0IO1OOIl1OlI1O&OI01lIlO01IIO0l);assign l0IO1I1lO0OlI1O
=(I1lO0IO0lIOIl01[5:0]==6'b111100)?1'b1:1'b0;assign OIl01IlI0OIO0lI
=OlI01IOIl0l10IO&~I01lOO1lIOOIl01&OlI01IIO0lIIO0l&~l10IOIO0lIOlI1O[1];assign l0IO1l0IO1OlI1O[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign OlI1OlO10IOI01l[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign IO01lOlI1OO01Il
=(OlI1OOlI1OOI01l==3'b010)?1'b1:1'b0;assign O01IlIIO0ll0IO1=(OI01lIIO0lIIO0l[2:1]==2'b11)?1'b1:1'b0;assign IlO01IIO0lO01Il
=(((OIl01OOIl1IO0lI|l10IOIIO0llO10I)&~O1lIOIO0lIIO01l)|
(~OIl01O1lIOl0IO1)|
(I01lOO1lIOOOIl1&mrd_abort))?1'b1:1'b0;assign IOIl0l0IO1IOIl0[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;dffe Il10IOlIO10lO10I
(OOl1IO01IlIlO01[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IOIl0OIl01I1lO0[3]);assign IO0lIOOIl1I01lO
=
(IO01lOlI1OOOl1I)?6'b000000:
(IO01lOOIl1OOl1I)?IOIl0OOIl1I1lO0+6'b000100:
IOIl0OOIl1I1lO0;assign OI01lIlI0Ol10IO
=(lO10IIlI0OlIO10==1'b0)?I1lO0IIO0lOIl01:IO0lIIO0lIIlI0O;assign IlI0OIIO0lI1lO0
=~((OIl01OI01lIO0lI&lIO10IO0lIlIO10&l10IOOOl1IlO10I)|
(IlI0OOI01lIOIl0&(lIO10IO0lIlIO10|(OIl01OlI1Ol0IO1))));dffe IOIl01I01lOl0IO1
(OlI1OlO10IIO01l[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,OI01llIO10l10IO[2]);dffe II01lOl0IO1OIl01
(O01IlOIl01IO0lI[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,I1lO0lO10IOOIl1[2]);assign IO01lOlI01O01Il
=(I1lO0OlI01OIl01)?1'b1:
(l0IO1OlI01lO10I)?1'b0:
OOl1IOlI01OlI01;assign OlI1OIlI0OOI01l[1]
=(lO10IIlI0OlIO10==1'b0)?~l0IO1lO10IlO10I[1]:~OlI1Ol0IO1OI01l[1];assign lIO10OOIl1lIO10=(OOIl1OOIl1IlO01==2'b00)?1'b1:1'b0;dffe IlIO10IO01llIO10
(lO10IlIO10O1lIO[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,IO01ll0IO1OOl1I[1]);dffe IIlO01l10IOO01Il
(OOl1IOIl01OlI01[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IOIl0lO10IIOIl0[1]);assign I1lO0OlI01OIl01
=(~l0IO1OOl1IOlI1O|~lO10IIO01lO1lIO)?1'b0:
(IO0lIOlI01I01lO&(O01IlOI01lIO0lI|OlI1OOI01lOI01l))?1'b1:
(IOIl0OlI01I1lO0&(OI01lOI01lIIO0l|OOl1IOI01lOlI01))?1'b1:
(OI01lOlI01l10IO&(IOIl0OI01lIOIl0|IO01lOI01lO01Il))?1'b1:
(O01IlOlI01l0IO1&(IO0lIOI01lIlI0O|I1lO0OI01lOIl01))?1'b1:
(I1lO0OOIl1OIl01[31:2]==IO01ll0IO1O01Il[31:2])?1'b1:1'b0;assign IOIl0IlO01IOIl0
=(I1lO0OOIl1OOIl1&OlI1Ol0IO1IO01l)|(l0IO1OOIl1OlI1O)|(lO10IOOIl1O1lIO);dffe7 IIIO0lO01IlI01lO
(I01lOIIO0lOOIl1[6:0],l10IOIIO0lOlI1O[6:0],clk,reset_b,1'b1,OlI01OOIl1l10IO);dffe Il10IOIlO01lO10I
(OlI1OlIO10OI01l[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,OI01ll0IO1IIO0l[0]);assign OOIl1IO0lIOlI01
=OOl1IIlO01IlO01&~l10IOO1lIOOlI1O;dffe IOOIl1I1lO0OlI01
(O01IlOIl01l0IO1[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,I1lO0lO10IOIl01[0]);assign OOl1IIO0lIIlO01
=I1lO0IlI0OOIl01&O01IlOOIl1l0IO1;assign pci_wrbuf_wren[2]=IOIl0O01IlI1lO0[2];assign OIl01IOIl0l0IO1
=l10IOOI01lOlI1O&(IlO01O1lIOOOl1I|OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0);dff32 IOI01lOOl1IIOIl0
(IOIl0I1lO0IOIl0,s_haddr,clk,reset_b,1'b1);assign OIl01O1lIOIO0lI[0]
=~(~lIO10OOl1IO1lIO[0]|
(~lIO10OOl1IO1lIO[2]&~IlI0OOOl1II1lO0[31])|
(~lIO10OOl1IO1lIO[1]&(IlO01OOl1IOOl1I[0]|IlO01OOl1IOOl1I[1]|IlO01OOl1IOOl1I[2]|IlO01OOl1IOOl1I[3])));assign OlI1OO1lIOIO01l
=(IO0lIO1lIOI01lO[2:0]==3'b000)?1'b1:1'b0;assign OlI1OIIO0lOI01l=(OI01lIIO0lIIO0l==3'b010)?1'b1:1'b0;assign l0IO1IOIl0OlI1O
=IO01lIOIl0OOl1I+7'b0000100;assign IO01lIlO01O01Il[31:0]=IO0lIIO01lI01lO[31:0];assign O01IlI01lOIO0lI
=OI01lI1lO0IIO0l[1]&~OI01lI1lO0IIO0l[0];assign lIO10IO0lIO1lIO[23:16]
=(IlO01OOIl1OOl1I|m_swapen)?IlI0OIO0lIIOIl0[23:16]:IlI0OIO0lIIOIl0[15:8];assign I1lO0lIO10OIl01=I1lO0O01IlOIl01;assign IOIl0OIl01I1lO0[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign OI01lIO01ll10IO=1'b0;assign OOIl1OOl1IOlI01
=7'b0000000;assign OOl1II1lO0OlI01=IOIl0I01lOIOIl0|OlI1OI01lOOI01l|IO01lI01lOO01Il;dffe8 IOlI01OlI01IIO0l
(IlI0OOOl1II1lO0[15:8],IIO0lOOl1II01lO[15:8],clk,reset_b,1'b1,O1lIOOOl1IIO01l);assign OI01llIO10l10IO[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;assign I1lO0lO10IOOIl1[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;dff II01lOlO10IOOIl1
(OOl1IOOl1IOlI01,OlI1OOOl1IOI01l,clk,reset_b,1'b1);assign OI01lIO0lIl10IO[5]
=(O01IlOI01ll0IO1&OOl1IOI01lIlO01)?O01IlIO0lIl0IO1[5]:
(~IO01lOlI01OOl1I)?O01IlIO0lIl0IO1[5]:
I1lO0IO0lIOIl01[5];dff Il10IOOlI01lO10I
(lIO10IlI0OO1lIO,OIl01IlI0OIO0lI,clk,reset_b,1'b1);assign IO01ll0IO1OOl1I[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;assign IOIl0lO10IIOIl0[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;dffe6 IIlO01lO10IO01Il
(OlI1OOlI01IO01l[5:0],OOl1Il10IOIlO01,clk,reset_b,1'b1,OI01lOOIl1l10IO);assign OOl1IOI01lIlO01
=(OOl1IIlI0OOlI01==1'b0)?IO01lIIO0lO01Il:IOIl0IO0lIIOIl0;dff IIlO01O01IlOOl1I
(I01lOIIO0lOIl01,IlO01IIO0lO01Il,clk,reset_b,1'b1);assign O01Ill0IO1IO0lI[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign IO01llO10IO01Il[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;assign I1lO0O1lIOOIl01
=(OOl1IOlI1OOlI01)?4'b0001:
(IO01lOlI1OO01Il)?4'b0100:
(I1lO0OlI1OOIl01)?4'b0100:
(l0IO1OlI1OlO10I)?4'b1000:
(lO10IOlI1OlIO10)?4'b1000:
4'b0000;assign OlI1OOlI01OI01l
=(OOl1IIO0lIOlI01&IO01lIO0lIOOl1I)|
(IO01lIO0lIO01Il&OOl1IO1lIOIlO01);assign IIO0lOI01lIlI0O
=(l10IOOI01lOlI1O&IlO01O1lIOOOl1I&~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0)&
lIO10IO0lIlIO10&l10IOOOl1IlO10I)|
(OIl01OI01lIO0lI&lIO10IO0lIlIO10&l10IOOOl1IlO10I)|
(IlI0OOI01lIOIl0&(lIO10IO0lIlIO10|(OIl01OlI1Ol0IO1)));dffe IIlI0OI01lOIOIl0
(IOIl0lO10II1lO0[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,lO10IlIO10lIO10[2]);dffe IlIO10l0IO1O1lIO
(l0IO1OIl01OlI1O[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,OOl1IOIl01IlO01[2]);assign l0IO1O1lIOlO10I[2]
=(OI01lOlI1OIIO0l&IO01lOlI1OO01Il)?1'b0:
OlI1OIOIl0OI01l[2];assign l0IO1l10IOOlI1O
=(I1lO0OOIl1OOIl1&OlI1Ol0IO1IO01l)|(l0IO1OOIl1OlI1O)|(lO10IOOIl1O1lIO);assign OOIl1OlI1OOlI01
=I01lOOlI1OOOIl1&l10IOOI01llO10I&~lIO10IO0lIlIO10;dffe IOlI01IO01lIIO0l
(I1lO0lIO10OOIl1[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,OlI1OlIO10IO01l[1]);dffe Il10IOl10IOOlI1O
(IO0lIOIl01IlI0O[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,O01IllO10IIO0lI[1]);assign O01IlOI01lIO0lI
=(I1lO0OOIl1OIl01[31:6]==IO01ll0IO1O01Il[31:6])?1'b1:1'b0;assign OlI1OIO01lIO01l[1]
=(I1lO0l10IOOOIl1)?~(OlI1OOlI01IO01l[2]):~(I1lO0O01IlOOIl1[2]);assign O1lIOOOIl1OI01l
=(IlI0OIOIl0I1lO0|OOIl1IOIl0IlO01)&lIO10OOIl1lIO10;dffe IOIl01IlO01IO0lI
(IOIl0lIO10IOIl0[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,lO10Il0IO1O1lIO[0]);assign OOIl1IlI0OIlO01
=~l0IO1IlO01OlI1O&~l10IOIlI0OlO10I;dffe II01lOI1lO0OOIl1
(l0IO1OIl01lO10I[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,OOl1IlO10IOlI01[0]);dff4 IIlO01lIO10OOl1I
(l0IO1IlI0OOlI1O,lO10IIlI0OO1lIO,clk,reset_b,1'b1);assign pci_wrbuf_wdata=s_hwdata;dffe IO1lIOOIl01OI01l
(IIO0lO1lIOI01lO,IlI0OO1lIOI1lO0,clk,reset_b,1'b1,IIO0lIIO0lI01lO);dffe Il0IO1OOl1IO1lIO
(IO01llIO10O01Il[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,IO0lIl0IO1IlI0O[3]);assign OlI01IIO0lIIO0l
=l10IOIlI0OlO10I?IOIl0IlO01IOIl0:IlO01OOl1IO01Il;assign I1lO0O01IlOIl01=(lO10IOOIl1O1lIO&O01IlOOIl1IO0lI&lO10IIlI0OlIO10);dffe6 IOlI01lIO10IIO0l
(OOl1IOlI01IlO01[5:0],s_hsel,clk,reset_b,1'b1,OOl1IIO0lIIlO01);assign OOl1IIIO0lIlO01[1:0]=2'b00;assign mwr_addra[6]
=lIO10OlI1OO1lIO;assign l0IO1l10IOlO10I=~IO0lIl10IOI01lO[2]&IO0lIl10IOI01lO[1]&~IO0lIl10IOI01lO[0];assign IlI0OIIO0lIOIl0
=I01lOIlI0OOIl01?IO0lIIlO01IlI0O:I01lOOOl1IOIl01;dff7 IOOIl1I1lO0IlO01(IO01lIOIl0O01Il,I1lO0IOIl0OIl01,clk,reset_b,1'b1);assign OI01lOIl01l10IO
=O01IlO01IlIO0lI;assign O01IlIOIl0IO0lI[5]
=((OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)|
(OlI1OO1lIOIO01l&OI01lIO0lIIIO0l)|
(OOl1IO1lIOIlO01&O01IlIO0lIIO0lI)|
(OlI1OO1lIOIO01l&IOIl0IO0lIIOIl0)|
(OOl1IO1lIOIlO01&OI01lIO0lIIIO0l)|
(IO01lIO0lIOOl1I&O01IlIO0lIIO0lI)|
(OOl1IO1lIOIlO01&IOIl0IO0lIIOIl0)|
(IO01lIO0lIOOl1I&OI01lIO0lIIIO0l))&
O01IlO1lIOl0IO1[5];assign I01lOOOl1IOOIl1
=1'b1;assign l0IO1I01lOOlI1O=~s_htrans[1]&~s_htrans[0];assign OlI01IO0lIIIO0l[23:16]
=(I01lOOOIl1OOIl1|m_swapen)?OIl01IO0lIIO0lI[23:16]:OIl01IO0lIIO0lI[15:8];assign lO10IlIO10lIO10[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OOl1IOIl01IlO01[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;dff IlIO10OIl01lIO10
(IlO01IlO01IlO01,IO01lOOl1IO01Il,clk,1'b1,reset_b);dff7 II1lO0OOl1IlO10I(I1lO0IO0lIOIl01,l0IO1IO0lIlO10I,clk,reset_b,1'b1);assign lIO10OOIl1O1lIO[30:11]
=(lIO10OOl1IlIO10==8'b00000000)?OlI01OOl1Il10IO[19:0]:
IlI0OOOl1II1lO0[30:11];assign OlI1OlIO10IO01l[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign O01IllO10IIO0lI[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;dff IOIl01lO10IIO0lI
(OlI1OOOl1IIO01l,OI01lOOIl1IIO0l,clk,reset_b,1'b1);assign IOIl0IOIl0IOIl0
=
(O01IlOI01ll0IO1&&l0IO1I1lO0OlI1O)?1'b1:
(OI01lOI01ll10IO&&lO10II1lO0O1lIO)?1'b1:
(IOIl0OI01lI1lO0&&O01IlI1lO0IO0lI)?1'b1:
1'b0;assign IlO01IlI0OO01Il
=(IIO0lIlI0OIlI0O&l10IOOOl1IlO10I);assign l0IO1l0IO1OlI1O[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign OlI1OlO10IOI01l[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign lO10IOlI1OlIO10
=(OlI1OOlI1OOI01l==3'b101)?1'b1:1'b0;assign lO10IOlI01O1lIO
=(l0IO1IIO0llO10I&O01IlIIO0lIO0lI)|
(lO10IIIO0llIO10&lO10IIIO0lO1lIO)|
(O01IlIIO0ll0IO1&l0IO1IIO0lOlI1O);dff Il10IOO01IlOlI1O
(OIl01OI01lIO0lI,OlI01OI01lIIO0l,clk,reset_b,1'b1);assign IO0lIl0IO1IlI0O[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;dffe IOlI01lIO10l10IO
(IO01lOIl01OOl1I[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IO0lIOIl01I01lO[2]);assign I1lO0OlI1OOOIl1[2]
=(~IO01lO1lIOO01Il)?1'b0:
(OI01lOlI1OIIO0l&IO01lOlI1OO01Il)?1'b0:
I1lO0OOIl1OIl01[2];assign OlI1OIlI0OIO01l
=(lO10IIlI0OlIO10==1'b0)?IO01lIIO0lO01Il:IOIl0IO0lIIOIl0;dff2 II01lOO01IlOIl01
(I01lOOlI1OOIl01[1:0],l10IOOlI1OlO10I[1:0],clk,reset_b,1'b1);dffe IIIO0lI01lOI01lO
(OOl1IlO10IIlO01[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,IOIl0lIO10I1lO0[1]);dffe IOIl01l0IO1l0IO1
(OI01lOIl01IIO0l[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,l0IO1lO10IOlI1O[1]);assign OlI1OOlI1OIO01l
=(OlI1OOlI1OOI01l[2:1]==2'b11)?1'b1:1'b0;assign l0IO1OI01llO10I[0]
=~((~big_endian&(OI01lOlI1OIIO0l|IOIl0OlI1OIOIl0)&
(~I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0]))|
(big_endian&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0])|
(big_endian&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[1]&I1lO0OOIl1OIl01[0])|
IO0lIOlI1OIlI0O);assign OIl01OOIl1l0IO1
=(OOIl1OOIl1IlO01==2'b10)?1'b1:1'b0;dffe IIlI0OIO01lI1lO0
(O01IllIO10IO0lI[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,I1lO0l0IO1OOIl1[0]);dffe IlIO10l10IOlIO10
(IO01lOIl01O01Il[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IO0lIlO10IIlI0O[0]);assign l0IO1l0IO1lO10I
=(OOl1IIlI0OIlO01)?IO01ll0IO1O01Il+32'h0001:
(IO01lOI01lOOl1I)?IO01ll0IO1O01Il+32'h0002:
IO01ll0IO1O01Il+32'h0004;assign pci_rdbuf_raddr[3:0]
=OOl1IOOIl1IlO01[5:2];dffe IIlO01OIl01OOl1I(IlI0OIO0lII1lO0,OIl01IO0lIl0IO1,clk,reset_b,1'b1,O1lIOIIO0lIO01l);dffe IOlI01IlO01l10IO
(OlI1OlIO10OI01l[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,OI01ll0IO1IIO0l[3]);dff II01lOOlI01OOIl1
(IlO01OOIl1OOl1I,OOIl1OOl1IIlO01,clk,reset_b,1'b1);dffe Il10IOI1lO0lO10I
(O01IlOIl01l0IO1[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,I1lO0lO10IOIl01[3]);assign lO10IO01IlO1lIO
=(O01IlO01IlIO0lI==1'b1)?2'b00:
(OI01lO01IlIIO0l==1'b1)?2'b01:
(IOIl0O01IlIOIl0==1'b1)?2'b10:
l0IO1O01IlOlI1O;assign IOIl0IIO0lI1lO0
=(O01IlOOIl1IO0lI)?OOl1IIIO0lIlO01:
(lO10IOOIl1O1lIO)?OlI1OIIO0lIO01l:
OI01lIIO0ll10IO;assign OIl01IIO0lIO0lI[6:0]
=O1lIOIO0lIOI01l?IlO01IIO0lOOl1I[6:0]:OIl01IOIl0IO0lI[6:0];dff6 IOlI1OOOl1IOlI01(OOl1Il10IOIlO01,s_hsel,clk,reset_b,1'b1);assign OIl01IO0lIl0IO1
=l10IOIlI0OlO10I?(lO10IIlO01O1lIO&~O01IlIlO01l0IO1[0]):(IIO0lOOl1IIlI0O&~lIO10OOl1IO1lIO[0]);dffe3 IO1lIOI1lO0IO01l
(I1lO0IO0lIOOIl1[2:0],s_hburst[2:0],clk,reset_b,1'b1,OI01lO1lIOl10IO);assign I1lO0IIO0lOIl01
=OlI1OIIO0lOI01l|OOl1IIIO0lOlI01|IO01lIIO0lO01Il;assign lO10IIOIl0O1lIO[3]
=(OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)?IO01lIOIl0OOl1I[3]:
(OlI1OO1lIOIO01l&OI01lIO0lIIIO0l)?IO01lIOIl0OOl1I[3]:
(OOl1IO1lIOIlO01&O01IlIO0lIIO0lI)?IO01lIOIl0OOl1I[3]:
l0IO1IOIl0OlI1O[3];assign OI01lIlO01l10IO[31:0]
=OOl1IIO01lIlO01[31:0];assign l0IO1I01lOlO10I=(OOl1II1lO0IlO01)?1'b0:
(l0IO1OOl1IOlI1O&lO10II01lOO1lIO);assign lIO10O1lIOlIO10[3]
=(OOIl1OOl1IIlO01|m_swapen)?l10IOO1lIOlO10I[3]:l10IOO1lIOlO10I[0];assign lO10IlO10IlIO10[2]=IOIl0O01IlI1lO0[2]&OOl1IIlI0OOlI01;assign IO0lIOIl01I01lO[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OlI1Ol0IO1IO01l
=OlI1OO01IlOI01l|OI01lO01Ill10IO;assign IO01lOOl1IO01Il
=(IlO01IlO01IlO01&~I1lO0I01lOOOIl1)|
(IlO01IlO01IlO01&~s_hreadyin)|
(IlO01IlO01IlO01&I1lO0I01lOOOIl1&~IO0lII01lOI01lO)|
(I1lO0OOl1IOOIl1&I1lO0I01lOOOIl1&~IO0lII01lOI01lO)|
(I1lO0OOl1IOOIl1&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~lO10II1lO0lIO10&IO0lII1lO0I01lO)|
(I1lO0OOl1IOOIl1&l0IO1I01lOOlI1O)|
(I1lO0OOl1IOOIl1&I1lO0I01lOOOIl1&IO0lII01lOI01lO&~s_hreadyin)|
(l0IO1OOl1IOlI1O&I1lO0I01lOOOIl1&~IO0lII01lOI01lO)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&lO10IIO01lO1lIO&~O01IlI1lO0l0IO1&OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&l0IO1IO01lOlI1O&~IOIl0IO01lI1lO0&OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&l0IO1I01lOOlI1O)|
(l0IO1OOl1IOlI1O&I1lO0I01lOOOIl1&~s_hreadyin&IO0lII01lOI01lO)|
(lO10IOOl1IO1lIO)|
(O01IlOOl1IIO0lI)|
(IO0lIOOl1IIlI0O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~OOl1IIO01lOlI01&IO01lIO01lO01Il&
I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&I1lO0I01lOOOIl1&~IO0lII01lOI01lO&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&l0IO1I01lOOlI1O&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&I1lO0I01lOOOIl1&~s_hreadyin&IO0lII01lOI01lO&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(OlI1OOOl1IOI01l)|
IO0lIIO01lIlI0O;assign l0IO1I1lO0lO10I
=~s_hsize[2]&s_hsize[1]&~s_hsize[0];assign IIO0lOOl1II01lO[31:0]=IlI0OIO0lIIOIl0[31:0];assign IOIl0lIO10I1lO0[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;assign l0IO1lO10IOlI1O[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign OI01lIO01lIIO0l
=I1lO0I01lOOOIl1&OlI1OI01lOIO01l&s_hreadyin&OlI1OI1lO0OI01l;assign IOIl0IO0lII1lO0[2]=OOl1II1lO0OlI01&s_haddr[2];dff IOlI01OlI01l10IO
(OOIl1IlI0OOlI01,IlO01IlI0OO01Il,clk,reset_b,1'b1);assign IO01ll0IO1OOl1I[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;assign IOIl0lO10IIOIl0[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign IOIl0OlI1OIOIl0
=~O01IlOlI1OIO0lI[1]&O01IlOlI1OIO0lI[0];dff4 Il0IO1OOl1IlIO10(OOl1IO1lIOOlI01,OlI1OO1lIOOI01l,clk,reset_b,1'b1);assign IlO01IOIl0OOl1I
=((I01lOIOIl0OOIl1&~IlI0OIIO0lIOIl0)|~OlI01O1lIOl10IO)?1'b1:1'b0;assign OI01ll0IO1IIO0l[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign I1lO0lO10IOIl01[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;dff4 IOIl01lO10Il0IO1
(IOIl0O1lIOIOIl0,OI01lO1lIOIIO0l,clk,reset_b,1'b1);assign IOIl0l10IOIOIl0
=(lO10IIlI0OlIO10==1'b0)?O01Ill10IOIO0lI:OI01ll10IOIIO0l;assign lIO10OI01llIO10
=(l10IOOI01lOlI1O&(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))|(l10IOOI01llO10I&lIO10IO0lIlIO10);dffe IOOIl1I01lOOlI01
(IO0lIlO10II01lO[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,O01IllIO10l0IO1[1]);dffe IIlI0Ol0IO1IOIl0
(lO10IOIl01O1lIO[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IO01llO10IOOl1I[1]);assign l0IO1O1lIOlO10I[5]
=(IOIl0OlI1OIOIl0&O01IlOlI1Ol0IO1)?1'b0:
(IO0lIOlI1OIlI0O&l0IO1OlI1OlO10I)?1'b0:
OlI1OIOIl0OI01l[5];assign IO0lIIO01lI01lO[4]
=(I1lO0l10IOOOIl1&~IO01lO1lIOO01Il&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&IO0lIOlI1OIlI0O&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[4])|
(I1lO0l10IOOOIl1&O01IlOlI1Ol0IO1&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[4])|
(l0IO1l10IOOlI1O&~OI01lIlI0Ol10IO&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&I1lO0OI01lOOIl1&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[4])|
(l0IO1l10IOOlI1O&OlI1OIlI0OIO01l&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[4]);assign OlI01OOIl1l10IO
=~lIO10OlI1OO1lIO&I01lOIlI0OOOIl1&
((~OlI01O1lIOl10IO&~OlI01IOIl0IIO0l)|
((O1lIOIO0lIOI01l|I01lOIOIl0OOIl1|~OlI01O1lIOl10IO)&~IlI0OIIO0lIOIl0));dffe IO1lIOIO01lOI01l
(l0IO1lIO10OlI1O[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,OOl1IlIO10IlO01[0]);dffe IOlI01l10IOIIO0l
(OlI1OOIl01OI01l[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,OI01llO10IIIO0l[0]);assign IO0lIOI01lIlI0O
=(I1lO0OOIl1OIl01[31:3]==IO01ll0IO1O01Il[31:3])?1'b1:1'b0;assign OOl1Il0IO1IlO01[3:0]
=(OlI1OOlI01IO01l[2]|OlI1OOlI01IO01l[3])?4'b0001:IOIl0O1lIOIOIl0[3:0];assign IIO0lOOIl1IlI0O=l10IOOI01lOlI1O&OIl01OOIl1l0IO1;dffe IIIO0lIlO01IlI0O
(IOIl0lIO10IOIl0[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,lO10Il0IO1O1lIO[3]);assign I01lOIO0lIOIl01
=~IlI0OOOl1IIOIl0|(l0IO1IlO01OlI1O&~OlI01O1lIOIIO0l);dffe IOIl01I1lO0IO0lI
(l0IO1OIl01lO10I[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,OOl1IlO10IOlI01[3]);assign IO01lIlI0OOOl1I
=(IO01lO1lIOO01Il&IO01lOOIl1OOl1I&OOl1IOOIl1OlI01)|
(~IO01lO1lIOO01Il&IO01lOOIl1OOl1I&OOl1IOOl1IIlO01)|
(IOIl0IlI0OIOIl0);assign IOIl0O01IlI1lO0[1]
=(O01IlOI01ll0IO1)?lO10IO1lIOlIO10:
((~big_endian&OI01lOI01ll10IO&~I1lO0IO0lIOIl01[1])|
(big_endian&OI01lOI01ll10IO&I1lO0IO0lIOIl01[1]))?lO10IO1lIOlIO10:
((~big_endian&IOIl0OI01lI1lO0&~I1lO0IO0lIOIl01[1]&I1lO0IO0lIOIl01[0])|
(big_endian&IOIl0OI01lI1lO0&I1lO0IO0lIOIl01[1]&~I1lO0IO0lIOIl01[0]))?lO10IO1lIOlIO10:
1'b0;dff II01lOOIl01OIl01
(IIO0lIIO0lIlI0O,mack_b,clk,1'b1,reset_b);assign I1lO0IO01lOOIl1=(OI01lOOIl1l10IO)?OOl1Il10IOIlO01:s_hsel;assign IIO0lO1lIOIlI0O[2]
=~(~O01IlIlO01l0IO1[2]&IlI0OOOl1II1lO0[31]);assign lO10IOOIl1lIO10=(OOl1IO01IlOlI01==2'b00)?1'b1:1'b0;assign lO10IIIO0lO1lIO
=(I1lO0IIO0lOOIl1[2:0]==3'b001)?1'b1:1'b0;assign OOl1IIIO0lIlO01[4]
=((l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)|
(l0IO1IIO0lOlI1O&OOl1IIIO0lOlI01)|
(lO10IIIO0lO1lIO&OlI1OIIO0lOI01l)|
(l0IO1IIO0lOlI1O&IO01lIIO0lO01Il)|
(lO10IIIO0lO1lIO&OOl1IIIO0lOlI01)|
(O01IlIIO0lIO0lI&OlI1OIIO0lOI01l))&
OlI1OIO0lIIO01l[4];assign mwr_beina[3:0]
=lIO10O1lIOlIO10[3:0];assign OI01ll10IOl10IO=IO0lIl10IOI01lO[2]&~IO0lIl10IOI01lO[1]&IO0lIl10IOI01lO[0];assign OIl01O1lIOl0IO1
=lIO10IlI0OlIO10?l0IO1IlO01lO10I:I01lOOOl1IOOIl1;assign O01IlIOIl0l0IO1
=lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&OOl1IIlI0OOlI01;assign IO0lIO01IlI01lO[2]
=IOIl0O01IlI1lO0[2]&~OOl1IIlI0OOlI01;assign IO01lIO01lO01Il=1'b0;assign OIl01OOl1IIO0lI=32'h00000000;assign IO0lII01lOIlI0O
=~s_hburst[2]&s_hburst[1]&s_hburst[0];assign IO0lIIlO01I01lO[31:0]=OIl01OOIl1IO0lI?IlI0OOOl1II1lO0[31:0]:OlI01IO0lIIIO0l[31:0];assign O01IllIO10l0IO1[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign IO01llO10IOOl1I[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;dff IIlI0OOIl01I1lO0
(l0IO1OOl1IOlI1O,lO10IOOl1IlIO10,clk,reset_b,1'b1);assign O01IlIO0lIl0IO1=I1lO0IO0lIOIl01+lO10IIO0lIlIO10;assign OlI01OOIl1IIO0l
=(IIO0lIlI0OIlI0O&l10IOOOl1IlO10I)|(~(IIO0lIOIl0I01lO&IlI0OOI01lIOIl0)&OIl01OOIl1IO0lI);assign OlI1OlIO10IO01l[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign O01IllO10IIO0lI[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;dff IIIO0llO10IIlI0O
(l0IO1OOIl1OlI1O,IO0lIOOIl1IlI0O,clk,reset_b,1'b1);assign IOIl0OI01lI1lO0
=(OOl1IIlI0OOlI01==1'b0)?l0IO1IIO0lOlI1O:OlI1OO1lIOIO01l;assign IlO01O1lIOOOl1I
=(OlI01IOIl0l10IO&~I01lOO1lIOOIl01&~OlI01IIO0lIIO0l&~(l10IOIO0lIOlI1O[0]&l10IOIO0lIOlI1O[2]))|
(IIO0lIOIl0I01lO&~I01lOO1lIOOOIl1);assign lO10Il0IO1O1lIO[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign OOl1IlO10IOlI01[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign IO01lO1lIOO01Il
=IO01lOlI1OO01Il|l0IO1OlI1OlO10I|O01IlOlI1Ol0IO1;assign OOl1IIO0lIOlI01=(I1lO0IO0lIOOIl1[2:1]==2'b10)?1'b1:1'b0;dff IOlI01O01IlIIO0l
(IlO01OI01lO01Il,I01lOOI01lOIl01,clk,reset_b,1'b1);dffe II01lOI01lOOOIl1
(OI01llO10Il10IO[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,l0IO1lIO10lO10I[1]);dffe IO1lIOlIO10IO01l
(I1lO0OIl01OOIl1[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,OlI1OOIl01IO01l[1]);assign I1lO0OlI1OOOIl1[5]
=(IO0lIOlI1OIlI0O&O01IlOlI1Ol0IO1)?I1lO0OOIl1OIl01[5]:
1'b0;assign I1lO0OI01lOOIl1
=(lO10IIlI0OlIO10==1'b0)?O01IlIIO0lIO0lI:IO01lIO0lIOOl1I;assign l10IOOlI1OlO10I
=(O1lIOOlI1OOI01l==1'b1)?2'b00:
(IlO01OlI1OO01Il==1'b1)?2'b01:
(IIO0lOlI1OIlI0O==1'b1)?2'b10:
(OOIl1OlI1OOlI01==1'b1)?2'b11:
I01lOOlI1OOIl01;dffe IIlO01IO01lOOl1I
(IO01llIO10OOl1I[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,IO0lIlIO10I01lO[0]);dffe IIIO0ll0IO1I01lO
(IOIl0OIl01IOIl0[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,lO10IlO10IO1lIO[0]);assign OI01lOlI01l10IO
=(IOIl0OlI1OI1lO0&IO0lIOlI1OIlI0O)?1'b1:
(IO0lIOlI1OI01lO&IOIl0OlI1OIOIl0)?1'b1:
(OlI1OOlI1OIO01l&OI01lOlI1OIIO0l)?1'b1:1'b0;assign l0IO1OI01llO10I[3]
=~((~big_endian&OI01lOlI1OIIO0l&(I1lO0OOIl1OIl01[1]&I1lO0OOIl1OIl01[0]))|
(~big_endian&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[1])|
(big_endian&(OI01lOlI1OIIO0l|IOIl0OlI1OIOIl0)&(~I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0]))|
IO0lIOlI1OIlI0O);dff IlIO10O01IllIO10
(lIO10OlI1OO1lIO,OIl01OlI1OIO0lI,clk,reset_b,1'b1);dffe IOOIl1IO01lIlO01
(O01IllIO10IO0lI[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,I1lO0l0IO1OOIl1[3]);dffe IIlI0Ol10IOI1lO0
(IO01lOIl01O01Il[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IO0lIlO10IIlI0O[3]);dff IOOIl1lO10IIlO01
(IO0lII1lO0IlI0O,OI01lIlI0OIIO0l,clk,reset_b,1'b1);assign pci_rdbuf_wdata=OlI1OIlO01OI01l;dffe32 IlIO10OIl01O1lIO
(pci_adr[31:0],IIO0lIOIl0IlI0O[31:0],clk,reset_b,1'b1,OIl01IOIl0l0IO1);dffe IO1lIOIlO01IO01l
(OOl1IlIO10OlI01[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,IOIl0l0IO1IOIl0[2]);assign l10IOIlI0OlO10I
=IlO01OI01lOOl1I|(~I01lOOOIl1OIl01&I01lOIlI0OOIl01);assign OI01lO1lIOl10IO=I1lO0IlI0OOIl01&~O01IlOOIl1l0IO1;assign OI01lO01IlIIO0l
=(OOl1IIO0lIIlO01);assign OlI1OIIO0lIO01l[2]=(l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)?OI01lIIO0ll10IO[2]:
IO0lIIIO0lI01lO[2];assign O1lIOIOIl0OI01l
=lIO10O1lIOlIO10;assign l0IO1OlI1OOlI1O=(O01IlOlI1OIO0lI==OlI1Ol10IOIO01l)?1'b1:1'b0;assign OOIl1O1lIOIlO01[1:0]
=l10IOIlI0OlO10I?l10IOIO0lIlO10I[1:0]:IlO01IO0lIO01Il[1:0];assign O01IlIO0lIIO0lI=(I1lO0IO0lIOOIl1==3'b010)?1'b1:1'b0;assign IOIl0IOIl0I1lO0
=
(IO01lIIO0lOOl1I)?OlI1OIOIl0IO01l+IO0lIIOIl0I01lO:
(OOl1IIOIl0IlO01)?OI01lIOIl0l10IO+IO0lIIOIl0I01lO:
OI01lIOIl0l10IO;assign lO10IIOIl0O1lIO[6]
=(~IO0lIIO0lIIlI0O)&l0IO1IOIl0OlI1O[6];assign lO10IIlO01lIO10=2'b00;assign OOl1II1lO0IlO01
=(O01IlI01lOl0IO1==4'b0001)?1'b1:1'b0;assign lIO10O1lIOlIO10[0]
=(OOIl1OOl1IIlO01|m_swapen)?l10IOO1lIOlO10I[0]:l10IOO1lIOlO10I[3];assign l0IO1lIO10lO10I[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign OlI1OOIl01IO01l[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign lO10IOOl1IlIO10
=(IlO01IlO01IlO01&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0&~IO0lIIO01lIlI0O)|
(IlO01IlO01IlO01&IOIl0IO01lIOIl0&s_hwrite&l0IO1IO01llO10I&~IO0lIIO01lIlI0O)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&lO10IIO01lO1lIO&~O01IlI1lO0l0IO1&~OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&lO10IIO01lO1lIO&O01IlI1lO0l0IO1&~OI01lI01lOl10IO)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&lO10IIO01lO1lIO&~IO01lI01lOOOl1I&O01IlI1lO0l0IO1&OI01lI01lOl10IO)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&l0IO1IO01lOlI1O&~IOIl0IO01lI1lO0&~OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&l0IO1IO01lOlI1O&IOIl0IO01lI1lO0&~lO10IIO01llIO10)|
(l0IO1OOl1IOlI1O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&l0IO1IO01lOlI1O&~IO01lI01lOOOl1I&IOIl0IO01lI1lO0&lO10IIO01llIO10)|
(l0IO1OOl1IOlI1O&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0)|
(l0IO1OOl1IOlI1O&IOIl0IO01lIOIl0&s_hwrite&l0IO1IO01llO10I)|
(I1lO0OOl1IOOIl1&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0)|
(I1lO0OOl1IOOIl1&IOIl0IO01lIOIl0&s_hwrite&l0IO1IO01llO10I)|
(IO0lIOOl1IIlI0O&OI01lIO01lIIO0l&s_hwrite&IOIl0I1lO0I1lO0&I1lO0IO01lOIl01&~OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&IOIl0IO01lIOIl0&s_hwrite&l0IO1IO01llO10I&I1lO0IO01lOIl01&~OI01lIO01ll10IO);assign OOl1II01lOIlO01
=1'b0;assign O1lIOOOl1IIO01l=OlI01IlI0OIIO0l&~IlI0OIIO0lIOIl0;assign IOIl0lIO10I1lO0[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;assign l0IO1lO10IOlI1O[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign OI01lOOIl1IIO0l
=(I1lO0OOIl1OOIl1&IO0lIl0IO1I01lO)|
(OlI1OOOl1IIO01l&OI01lIlO01IIO0l&OOl1IIlO01OlI01);assign IOIl0IO0lII1lO0[5]
=OOl1II1lO0OlI01&s_haddr[5];assign IlO01IlI0OOOl1I
=(OlI01IOIl0l10IO&~I01lOO1lIOOIl01&OlI01IIO0lIIO0l&~(l10IOIO0lIOlI1O[0]&l10IOIO0lIOlI1O[2]))|
(OOIl1IOIl0IlO01&~IlI0OOI01lI1lO0);assign I1lO0l0IO1OOIl1[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign IO0lIlO10IIlI0O[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign OOl1IOlI1OOlI01
=(OlI1OOlI1OOI01l==3'b000)?1'b1:1'b0;assign l0IO1IIO0llO10I=(OI01lIIO0lIIO0l[2:1]==2'b01)?1'b1:1'b0;assign lIO10IIO0llIO10[6:0]
=(IIO0lIOIl0I01lO&IlI0OOI01lIOIl0)?IlO01IIO0lOOl1I[6:0]:
(~O1lIOIO0lIIO01l)?OOIl1IIO0lOlI01[6:0]-7'b0000001:
OOIl1IIO0lOlI01[6:0];assign IOIl0l0IO1IOIl0[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;dffe IIlO01lIO10O01Il
(OOl1IO01IlIlO01[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IOIl0OIl01I1lO0[1]);assign lO10Il10IOO1lIO
=
((I1lO0l10IOOIl01)|
(l0IO1l10IOlO10I&OlI1Ol10IOOI01l)|
(lO10Il10IOlIO10&OlI1Ol10IOOI01l&~IOIl0I1lO0IOIl0[0]&~IOIl0I1lO0IOIl0[1]))?4'b0001:
((l0IO1l10IOlO10I&IO01ll10IOO01Il)|
(O01Ill10IOl0IO1&OOl1Il10IOOlI01)|
(lO10Il10IOlIO10&IO01ll10IOO01Il)|
(OI01ll10IOl10IO&OOl1Il10IOOlI01&~IOIl0I1lO0IOIl0[1]))?4'b0100:
((O01Ill10IOl0IO1&IO01ll10IOO01Il)|
(OI01ll10IOl10IO&IO01ll10IOO01Il))?4'b1000:
((l0IO1l10IOlO10I&OOl1Il10IOOlI01)|
(O01Ill10IOl0IO1&OlI1Ol10IOOI01l)|
(lO10Il10IOlIO10&OOl1Il10IOOlI01&~IOIl0I1lO0IOIl0[1])|
(OI01ll10IOl10IO&OlI1Ol10IOOI01l&~IOIl0I1lO0IOIl0[0]&~IOIl0I1lO0IOIl0[1])|
(lO10Il10IOlIO10&OlI1Ol10IOOI01l&(IOIl0I1lO0IOIl0[0]|IOIl0I1lO0IOIl0[1])))?4'b0010:
((lO10Il10IOlIO10&OOl1Il10IOOlI01&IOIl0I1lO0IOIl0[1])|
(OI01ll10IOl10IO&OlI1Ol10IOOI01l&(IOIl0I1lO0IOIl0[0]|IOIl0I1lO0IOIl0[1])))?4'b0011:
(OI01ll10IOl10IO&OOl1Il10IOOlI01&IOIl0I1lO0IOIl0[1])?4'b0101:
((IO01lI1lO0OOl1I&OOl1Il10IOOlI01)|
(I1lO0I1lO0OOIl1&OOl1Il10IOOlI01&~IOIl0I1lO0IOIl0[1]))?4'b1000:
((IO01lI1lO0OOl1I&OlI1Ol10IOOI01l)|
(I1lO0I1lO0OOIl1&OlI1Ol10IOOI01l&~IOIl0I1lO0IOIl0[0]&~IOIl0I1lO0IOIl0[1]))?4'b0100:
(I1lO0I1lO0OOIl1&OOl1Il10IOOlI01&IOIl0I1lO0IOIl0[1])?4'b1001:
(I1lO0I1lO0OOIl1&OlI1Ol10IOOI01l&(IOIl0I1lO0IOIl0[0]|IOIl0I1lO0IOIl0[1]))?4'b0101:
4'b0000;assign l0IO1IlI0OlO10I
=O01IlOOIl1IO0lI;dff IOOIl1O01IlOlI01(mrdreq_b,IlI0OIIO0lI1lO0,clk,1'b1,reset_b);dffe Il10IOI01lOlO10I
(OlI1OlO10IIO01l[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,OI01llIO10l10IO[0]);dffe IOOIl1l0IO1OlI01
(O01IlOIl01IO0lI[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,I1lO0lO10IOOIl1[0]);dff6 IIlI0OlO10II1lO0
(OlI1OOOIl1IO01l,OOl1IOOIl1IlO01,clk,reset_b,1'b1);assign l0IO1IlO01OlI1O
=(I1lO0OOIl1OOIl1&(IO0lIl0IO1I01lO|OlI1Ol0IO1IO01l))?1'b0:1'b1;assign IIO0lOlI1OI01lO
=IlI0OOI01lIOIl0&(lIO10IO0lIlIO10|OIl01OlI1Ol0IO1);dffe II01lOIO01lOIl01
(l0IO1lIO10OlI1O[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,OOl1IlIO10IlO01[3]);dffe IO1lIOl10IOOI01l
(OlI1OOIl01OI01l[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,OI01llO10IIIO0l[3]);assign IO01lOI01lO01Il
=(lO10IOI01lO1lIO[31:4]==IO01ll0IO1O01Il[31:4])?1'b1:1'b0;assign IO01ll10IOOOl1I[4]
=(I1lO0O01IlOOIl1[2]|I1lO0O01IlOOIl1[3])?1'b0:
(IOIl0l10IOIOIl0==4'b0000)?1'b1:1'b0;dffe32 IOlI01O01Ill10IO
(OOIl1O1lIOOlI01[31:0],IIO0lIO0lII01lO[31:0],clk,reset_b,1'b1,IIO0lIIO0lI01lO);dffe IIlO01IlO01O01Il
(IO0lIlIO10IlI0O[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,O01Ill0IO1IO0lI[2]);assign OOIl1OOIl1OlI01=~l10IOIlI0OlO10I;dffe IIIO0lI1lO0IlI0O
(lO10IOIl01lIO10[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IO01llO10IO01Il[2]);assign IOIl0l0IO1I1lO0
=~O01Ill0IO1l0IO1&
(lO10Il0IO1lIO10|OI01ll0IO1l10IO);assign pci_wrbuf_wren[0]=IOIl0O01IlI1lO0[0];assign IIO0lIIO0lI01lO
=O1lIOOOIl1IO01l;assign lO10IIO01lO1lIO=IO01lIO01lOOl1I[3]|IO01lIO01lOOl1I[2]|IO01lIO01lOOl1I[1]|IO01lIO01lOOl1I[0];assign OIl01O1lIOIO0lI[2]
=~(~lIO10OOl1IO1lIO[2]&IlI0OOOl1II1lO0[31]);dffe6 IIlI0OI1lO0I1lO0
(IO01lO01IlOOl1I[5:0],s_hsel,clk,reset_b,1'b1,OI01lO1lIOl10IO);assign IOIl0IIO0lIOIl0=(OI01lIIO0lIIO0l==3'b000)?1'b1:1'b0;dff7 IOI01lOOl1II1lO0
(IO01lIOIl0OOl1I,I1lO0IOIl0OOIl1,clk,reset_b,1'b1);assign OIl01IO0lIIO0lI[31:0]=mrd_doutb[31:0];assign I1lO0I1lO0OOIl1
=IO0lIl10IOI01lO[2]&IO0lIl10IOI01lO[1]&IO0lIl10IOI01lO[0];dff Il10IOOlI01OlI1O
(I01lOOOIl1OOIl1,l10IOOOIl1OlI1O,clk,reset_b,1'b1);assign IO0lIIO0lII01lO=IO01lIOIl0O01Il+7'b0000011;assign IOIl0OIl01I1lO0[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign lO10IIO01llIO10=1'b0;assign IIO0lOOl1IIlI0O
=1'b0;assign IO01lI01lOO01Il=s_hburst[2]&s_hburst[1]&~s_hburst[0];dffe IlIO10OlI01O1lIO
(IlI0OOOl1II1lO0[31],IIO0lOOl1II01lO[31],clk,reset_b,1'b1,O1lIOOOl1IIO01l);assign O01IllIO10l0IO1[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign IO01llO10IOOl1I[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;dff IOOIl1OIl01IlO01
(IO0lIOOl1IIlI0O,IOIl0OOl1II1lO0,clk,reset_b,1'b1);assign OI01lIO0lIl10IO[3]
=(IOIl0OI01lI1lO0&IO0lIOI01lI01lO)?I1lO0IO0lIOIl01[3]:
(IOIl0OI01lI1lO0&OlI1OOI01lIO01l)?I1lO0IO0lIOIl01[3]:
(OI01lOI01ll10IO&IO0lIOI01lI01lO)?I1lO0IO0lIOIl01[3]:
O01IlIO0lIl0IO1[3];dff IIlO01OlI01O01Il
(OOIl1IOIl0IlO01,IlO01IlI0OOOl1I,clk,reset_b,1'b1);assign OOl1IlIO10IlO01[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign OI01llO10IIIO0l[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;dffe32 IOOIl1lO10IOlI01
(I1lO0OOIl1OIl01[31:0],IOIl0I1lO0IOIl0[31:0],clk,reset_b,1'b1,OI01lOOIl1l10IO);assign IO0lIOI01lI01lO
=(OOl1IIlI0OOlI01==1'b0)?OlI1OIIO0lOI01l:O01IlIO0lIIO0lI;dff7 IO1lIOOlI01IO01l
(OOIl1IIO0lOlI01[6:0],lIO10IIO0llIO10[6:0],clk,reset_b,1'b1);assign O01Ill0IO1IO0lI[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign IO01llO10IO01Il[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;assign I1lO0O1lIOOOIl1
=(IO0lII1lO0I01lO)?1'b0:
(l0IO1OOl1IlO10I&IO01lI01lOOOl1I)?1'b1:
1'b0;assign IOIl0OlI01IOIl0
=(OlI1OIO0lIOI01l&OOl1IO1lIOIlO01)|
(OOl1IIO0lIOlI01&OlI1OO1lIOIO01l);assign lIO10OI01lO1lIO
=(l10IOOI01lOlI1O&~IlO01O1lIOOOl1I&~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))|
(IlO01OI01lO01Il&lIO10IO0lIlIO10)|(OIl01OI01ll0IO1&lIO10IO0lIlIO10);dffe IOIl01I01lOIO0lI
(IOIl0lO10II1lO0[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,lO10IlIO10lIO10[0]);dffe II01lOl0IO1OOIl1
(l0IO1OIl01OlI1O[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,OOl1IOIl01IlO01[0]);assign OlI1OIOIl0OI01l
=OlI1OOOIl1IO01l+OOl1IIOIl0OlI01;assign IO0lIIO01lI01lO[1:0]
=(((big_endian==1'b0)&&(lO10IOI01llIO10[0]==1'b0))||
((big_endian==1'b1)&&(lO10IOI01llIO10[3]==1'b0)))?2'b00:
(((big_endian==1'b0)&&(lO10IOI01llIO10[1:0]==2'b01))||
((big_endian==1'b1)&&(lO10IOI01llIO10[3:2]==2'b10)))?2'b01:
(((big_endian==1'b0)&&(lO10IOI01llIO10[2:0]==3'b011))||
((big_endian==1'b1)&&(lO10IOI01llIO10[3:1]==3'b110)))?2'b10:
2'b11;assign O1lIOOlI1OOI01l
=(I01lOOlI1OOOIl1&OIl01OI01ll0IO1&lIO10IO0lIlIO10)|
(lIO10OlI1OO1lIO&I01lOIlI0OOOIl1&~OlI01O1lIOl10IO&IlI0OIIO0lIOIl0&OlI01IOIl0IIO0l);dffe IlIO10IO01lO1lIO
(IO01llIO10OOl1I[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,IO0lIlIO10I01lO[3]);dffe IIlO01l10IOOOl1I
(IOIl0OIl01IOIl0[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,lO10IlO10IO1lIO[3]);assign OOl1Il0IO1OlI01
=(lO10IOlI01lIO10)?32'h00000000:
(O01IlOlI01l0IO1)?32'h00000004:
(OI01lOlI01l10IO)?32'h0000000c:
(IOIl0OlI01I1lO0)?32'h0000001c:
32'h0000003c;assign OlI1OIO01lIO01l[0]
=(I1lO0l10IOOOIl1)?~(OlI1OOlI01IO01l[0]|OlI1OOlI01IO01l[1]):
~(I1lO0O01IlOOIl1[0]|I1lO0O01IlOOIl1[1]);assign IlI0OOI01lI1lO0
=lIO10OOIl1lIO10|OlI01OlI1OIIO0l;dffe Il10IOIlO01OlI1O
(OI01llIO10IIO0l[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,l0IO1l0IO1OlI1O[2]);dffe IOOIl1l10IOIlO01
(I1lO0OIl01OIl01[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,OlI1OlO10IOI01l[2]);assign IO0lIIlI0OIlI0O=IO01lIlI0OOOl1I;assign pci_wrbuf_waddr[3:0]
=I1lO0IO0lIOIl01[5:2];dffe IIlI0OOIl01IOIl0(pci_mio,I01lOIOIl0OIl01,clk,reset_b,1'b1,OIl01IOIl0l0IO1);dffe IIO01lOOl1IOOIl1
(IO01llIO10O01Il[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,IO0lIl0IO1IlI0O[1]);assign OIl01IlI0Ol0IO1
=I01lOOI01lOOIl1|(~l10IOOOIl1lO10I&lIO10IlI0OlIO10);assign IO01lO01IlO01Il
=(I1lO0O01IlOIl01==1'b1)?2'b00:
(l0IO1O01IllO10I==1'b1)?2'b01:
(lO10IO01IllIO10==1'b1)?2'b10:
OOl1IO01IlOlI01;assign IO0lIO01IlIlI0O
=(l0IO1O01IlOlI1O==2'b01)?1'b1:1'b0;assign OlI1OIIO0lIO01l[5]
=(O01IlIIO0lIO0lI&IO01lIIO0lO01Il)?IO0lIIIO0lI01lO[5]:
(~I1lO0IIO0lOIl01)?IO0lIIIO0lI01lO[5]:
OI01lIIO0ll10IO[5];assign OOIl1IOIl0OlI01
=((l10IOOI01lOlI1O&IlO01O1lIOOOl1I&
~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))==1'b1)?IlI0OO1lIOI1lO0:
(l10IOOlI1OOlI1O==1'b1)?O1lIOO1lIOIO01l:IIO0lO1lIOI01lO;assign IO01ll10IOO01Il
=OlI1Ol10IOIO01l[1]&~OlI1Ol10IOIO01l[0];assign IlI0OIO0lIIOIl0[31:0]
=I01lOIlI0OOIl01?OI01lIlO01l10IO[31:0]:OIl01OOl1IIO0lI[31:0];assign IO0lIIO0lIIlI0O
=O01IlIO0lIIO0lI|OI01lIO0lIIIO0l|IOIl0IO0lIIOIl0;assign OlI1OIOIl0IO01l[1:0]=IOIl0I1lO0IOIl0[1:0];assign O01IlIOIl0IO0lI[3]
=((OlI1OO1lIOIO01l&O01IlIO0lIIO0lI)|
(OlI1OO1lIOIO01l&OI01lIO0lIIIO0l)|
(OOl1IO1lIOIlO01&O01IlIO0lIIO0lI))&
O01IlO1lIOl0IO1[3];assign OOl1IIlO01IlO01
=1'b1;assign IO01lI01lOOOl1I=s_htrans[1]&s_htrans[0];assign l10IOOOIl1OlI1O=~IlI0OOOIl1IOIl0&(OlI01IlI0Ol10IO|I01lOOOIl1OOIl1);assign l0IO1lIO10lO10I[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign OlI1OOIl01IO01l[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign IOIl0OOl1II1lO0
=
(IlO01IlO01IlO01&IOIl0IO01lIOIl0&~s_hwrite&~IO0lIIO01lIlI0O)|
(I1lO0OOl1IOOIl1&IOIl0IO01lIOIl0&~s_hwrite)|
(l0IO1OOl1IOlI1O&IOIl0IO01lIOIl0&~s_hwrite)|
(IO0lIOOl1IIlI0O&IOIl0IO01lIOIl0&~s_hwrite)|
(IO0lIOOl1IIlI0O&OI01lIO01ll10IO)|
(IO0lIOOl1IIlI0O&~I1lO0IO01lOIl01)|
(IO0lIOOl1IIlI0O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~OOl1IIO01lOlI01&~IO01lIO01lO01Il)|
(IO0lIOOl1IIlI0O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&OOl1IIO01lOlI01&~O01IlIO01ll0IO1)|
(IO0lIOOl1IIlI0O&~I1lO0I01lOOOIl1&~l0IO1I01lOOlI1O&~IO01lI01lOOOl1I&OOl1IIO01lOlI01&O01IlIO01ll0IO1);assign s_hresp[0]
=OlI1OOOl1IOI01l|OOl1IOOl1IOlI01;assign OlI01OOl1Il10IO[20:0]
=
(OIl01OOl1Il0IO1==5'b00000)?21'b000000000000000000001:
(OIl01OOl1Il0IO1==5'b00001)?21'b000000000000000000010:
(OIl01OOl1Il0IO1==5'b00010)?21'b000000000000000000100:
(OIl01OOl1Il0IO1==5'b00011)?21'b000000000000000001000:
(OIl01OOl1Il0IO1==5'b00100)?21'b000000000000000010000:
(OIl01OOl1Il0IO1==5'b00101)?21'b000000000000000100000:
(OIl01OOl1Il0IO1==5'b00110)?21'b000000000000001000000:
(OIl01OOl1Il0IO1==5'b00111)?21'b000000000000010000000:
(OIl01OOl1Il0IO1==5'b01000)?21'b000000000000100000000:
(OIl01OOl1Il0IO1==5'b01001)?21'b000000000001000000000:
(OIl01OOl1Il0IO1==5'b01010)?21'b000000000010000000000:
(OIl01OOl1Il0IO1==5'b01011)?21'b000000000100000000000:
(OIl01OOl1Il0IO1==5'b01100)?21'b000000001000000000000:
(OIl01OOl1Il0IO1==5'b01101)?21'b000000010000000000000:
(OIl01OOl1Il0IO1==5'b01110)?21'b000000100000000000000:
(OIl01OOl1Il0IO1==5'b01111)?21'b000001000000000000000:
(OIl01OOl1Il0IO1==5'b10000)?21'b000010000000000000000:
(OIl01OOl1Il0IO1==5'b10001)?21'b000100000000000000000:
(OIl01OOl1Il0IO1==5'b10010)?21'b001000000000000000000:
(OIl01OOl1Il0IO1==5'b10011)?21'b010000000000000000000:
(OIl01OOl1Il0IO1==5'b10100)?21'b100000000000000000000:
21'b000000000000000000000;assign IO0lIlIO10I01lO[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;assign lO10IlO10IO1lIO[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign OlI1OOOIl1OI01l
=(l0IO1OOIl1OlI1O&~OI01lIlO01IIO0l)|
(lO10IOOIl1O1lIO&~IO01lOOIl1O01Il);assign lO10II1lO0O1lIO
=(I1lO0IO0lIOIl01[5:0]==6'b111110)?1'b1:1'b0;assign IlI0OIlI0OIOIl0
=lIO10IlI0OO1lIO|(OlI01IlI0OIIO0l&IlI0OIIO0lIOIl0&OlI01O1lIOl10IO);assign l0IO1l0IO1OlI1O[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;assign OlI1OlO10IOI01l[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign I1lO0OlI1OOIl01
=(OlI1OOlI1OOI01l==3'b011)?1'b1:1'b0;assign I1lO0OlI01OOIl1=(IOIl0IIO0lIOIl0)|
(l0IO1IIO0llO10I&l0IO1IIO0lOlI1O);assign OlI01IIO0ll10IO[5:0]
=((IIO0lIOIl0I01lO&IlI0OOI01lIOIl0)|I01lOIIO0lOIl01)?6'b000000:
(~O1lIOIO0lIIO01l)?OIl01IIO0ll0IO1[5:0]+6'b000001:
OIl01IIO0ll0IO1[5:0];assign IO0lIl0IO1IlI0O[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;dffe IlIO10lIO10lIO10
(IO01lOIl01OOl1I[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IO0lIOIl01I01lO[0]);dff6 IOlI01lO10Il10IO
(IOIl0OOIl1I1lO0,IO0lIOOIl1I01lO,clk,reset_b,1'b1);assign IOIl0IlI0OI1lO0
=(lO10IIlI0OlIO10==1'b0)?OlI1OIIO0lOI01l:O01IlIO0lIIO0lI;assign I01lOO1lIOOOIl1=O1lIOOI01lOI01l;dffe IOlI01I01lOl10IO
(OlI1OlO10IIO01l[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,OI01llIO10l10IO[3]);dffe Il10IOl0IO1lO10I
(O01IlOIl01IO0lI[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,I1lO0lO10IOOIl1[3]);assign IOIl0OlI1OI1lO0
=(OlI1OOlI1OOI01l[2:1]==2'b01)?1'b1:1'b0;assign OlI1OIlI0OOI01l[2]
=(lO10IIlI0OlIO10==1'b0)?~l0IO1lO10IlO10I[2]:~OlI1Ol0IO1OI01l[2];assign OlI01OlI1OIIO0l=(I01lOOlI1OOIl01==2'b00)?1'b1:1'b0;dffe IOIl01IO01ll0IO1
(lO10IlIO10O1lIO[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,IO01ll0IO1OOl1I[2]);dffe II01lOl10IOOIl01
(OOl1IOIl01OlI01[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IOIl0lO10IIOIl0[2]);assign l0IO1OlI01lO10I
=I1lO0OOIl1OOIl1&IO0lIl0IO1I01lO;assign IO0lIIlO01IlI0O=~lO10IOOIl1O1lIO;dffe7 IO1lIOO01IlIO01l
(lIO10IIO0lO1lIO[6:0],OIl01IIO0lIO0lI[6:0],clk,reset_b,1'b1,IIO0lOlI1OIlI0O);dffe IlIO10IlO01lIO10
(OlI1OlIO10OI01l[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,OI01ll0IO1IIO0l[1]);dff IOOIl1OI01lIlO01
(I01lOIlI0OOIl01,l10IOIlI0OlO10I,clk,1'b1,reset_b);dffe IIlO01I1lO0O01Il
(O01IlOIl01l0IO1[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,I1lO0lO10IOIl01[1]);dffe32 Il10IOlIO10OlI1O
(OlI1OIO0lIIO01l[31:0],s_haddr[31:0],clk,reset_b,1'b1,OOl1IIO0lIIlO01);assign pci_wrbuf_wren[3]=IOIl0O01IlI1lO0[3];assign l10IOIOIl0lO10I
=l10IOOI01lOlI1O&IlO01O1lIOOOl1I;dff3 IIOIl0OOl1IIlI0O(IO0lIl10IOI01lO,s_hburst,clk,reset_b,1'b1);assign l10IOIO0lIOlI1O[2:0]
=l10IOIlI0OlO10I?IIO0lO1lIOIlI0O[2:0]:OIl01O1lIOIO0lI[2:0];assign OOl1IO1lIOIlO01=(IO0lIO1lIOI01lO[2:0]==3'b001)?1'b1:1'b0;assign OOl1IIIO0lOlI01
=(OI01lIIO0lIIO0l==3'b100)?1'b1:1'b0;assign lO10IIOIl0O1lIO[1:0]=l0IO1IOIl0OlI1O[1:0];assign I1lO0IlO01OIl01[3:0]
=I1lO0IlO01OOIl1[3:0];assign lO10II01lOlIO10
=(I1lO0I01lOOIl01)?IOIl0I01lOI1lO0:
(l0IO1I01lOlO10I)?O01IlI01lOl0IO1-4'b0001:O01IlI01lOl0IO1;assign lIO10IO0lIO1lIO[15:8]
=(IlO01OOIl1OOl1I|m_swapen)?IlI0OIO0lIIOIl0[15:8]:IlI0OIO0lIIOIl0[23:16];assign lO10IlO10IlIO10[0]
=IOIl0O01IlI1lO0[0]&OOl1IIlI0OOlI01;assign IOIl0OIl01I1lO0[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign IOIl0IO01lI1lO0=1'b0;assign IlO01OOl1IO01Il
=1'b0;assign IO01lI1lO0O01Il=~s_hsize[2]&~s_hsize[1]&~s_hsize[0];dffe6 IIlI0OOlI01IOIl0
(IlI0OOOl1II1lO0[7:2],IIO0lOOl1II01lO[7:2],clk,reset_b,1'b1,O1lIOOOl1IIO01l);assign OI01llIO10l10IO[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;assign I1lO0lO10IOOIl1[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;assign OI01lOOl1IIIO0l
=lO10IOOl1IO1lIO|O01IlOOl1IIO0lI;assign OI01lIO0lIl10IO[6]=(~IO01lOlI01OOl1I)&O01IlIO0lIl0IO1[6];dff IlIO10OlI01lIO10
(OlI01IlI0OIIO0l,IlI0OIlI0OIOIl0,clk,reset_b,1'b1);assign IO01ll0IO1OOl1I[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;assign IOIl0lO10IIOIl0[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1010)))?1'b1:1'b0;dffe3 II01lOlO10IOIl01
(O01IlOlI1OIO0lI[2:0],OlI1Ol10IOIO01l[2:0],clk,reset_b,1'b1,OI01lOOIl1l10IO);assign IO01lOlI01OOl1I
=(OOl1IIlI0OOlI01==1'b0)?I1lO0IIO0lOIl01:IO0lIIO0lIIlI0O;assign l10IOIOIl0OlI1O[6:0]
=(OOIl1IOIl0IlO01)?IlO01IIO0lOOl1I[6:0]:
(I01lOIlI0OOOIl1&~IlI0OIIO0lIOIl0)?OOIl1IIO0lIlO01[6:0]-7'b0000001:
OOIl1IIO0lIlO01[6:0];assign OI01ll0IO1IIO0l[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign I1lO0lO10IOIl01[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;assign IO0lII1lO0I01lO
=(O01IlO1lIOIO0lI==4'b0001)?1'b1:1'b0;assign O01Ill10IOIO0lI
=(~I1lO0IIO0lOIl01)?OI01lIOIl0IIO0l[5:2]:
(I1lO0OlI01OOIl1)?4'b0001:
(l0IO1OlI01OlI1O)?4'b0010:
(lO10IOlI01O1lIO)?4'b0100:
(O01IlOlI01IO0lI)?4'b1000:
4'b0000;assign OOIl1OI01lOlI01
=IlI0OOI01lIOIl0&~(lIO10IO0lIlIO10|(OIl01OlI1Ol0IO1));dffe IIIO0lI01lOIlI0O
(IOIl0lO10II1lO0[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,lO10IlIO10lIO10[3]);dffe IOIl01l0IO1IO0lI
(l0IO1OIl01OlI1O[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,OOl1IOIl01IlO01[3]);assign l0IO1O1lIOlO10I[3]
=(OI01lOlI1OIIO0l&l0IO1OlI1OlO10I)?1'b0:
(IOIl0OlI1OIOIl0&IO01lOlI1OO01Il)?1'b0:
OlI1OIOIl0OI01l[3];assign IO0lIIO01lI01lO[2]
=(I1lO0l10IOOOIl1&~IO01lO1lIOO01Il&I1lO0OOIl1OIl01[2])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[2])|
(l0IO1l10IOOlI1O&~OI01lIlI0Ol10IO&l0IO1OI01lOlI1O[2])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[2]);assign O1lIOOOIl1IO01l
=lIO10OOIl1lIO10&OOIl1IOIl0IlO01;dffe IIlI0OIO01lIOIl0
(I1lO0lIO10OOIl1[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,OlI1OlIO10IO01l[2]);dffe IlIO10l10IOO1lIO
(IO0lIOIl01IlI0O[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,O01IllO10IIO0lI[2]);assign OI01lOI01lIIO0l
=(I1lO0OOIl1OIl01[31:5]==IO01ll0IO1O01Il[31:5])?1'b1:1'b0;assign OlI1OIO01lIO01l[2]
=(I1lO0l10IOOOIl1)?~(OlI1OOlI01IO01l[3]):~(I1lO0O01IlOOIl1[3]);assign IIO0lIlI0OI01lO
=(IlI0OIOIl0I1lO0|OOIl1IOIl0IlO01)&OlI01OlI1OIIO0l;dffe IOlI01IlO01IIO0l
(IOIl0lIO10IOIl0[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,lO10Il0IO1O1lIO[1]);assign IlO01OOIl1O01Il=l10IOIlI0OlO10I;dffe Il10IOI1lO0OlI1O
(l0IO1OIl01lO10I[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,OOl1IlO10IOlI01[1]);assign I1lO0IlI0OOOIl1
=(O01IlIlI0OIO0lI)?1'b0:
(lO10IOOl1IO1lIO)?1'b1:
1'b0;assign lO10IO1lIOlIO10
=lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO);dffe IOOIl1OIl01OlI01
(O1lIOO1lIOIO01l,IlI0OO1lIOI1lO0,clk,reset_b,1'b1,O1lIOIIO0lIO01l);assign OlI1Ol0IO1OI01l
=(IO01lIOIl0OOl1I[5:2]==4'b0000)?OI01llO10Il10IO:
(IO01lIOIl0OOl1I[5:2]==4'b0001)?IOIl0lO10II1lO0:
(IO01lIOIl0OOl1I[5:2]==4'b0010)?IO0lIlO10II01lO:
(IO01lIOIl0OOl1I[5:2]==4'b0011)?OlI1OlO10IIO01l:
(IO01lIOIl0OOl1I[5:2]==4'b0100)?OOl1IlO10IIlO01:
(IO01lIOIl0OOl1I[5:2]==4'b0101)?IO01llIO10OOl1I:
(IO01lIOIl0OOl1I[5:2]==4'b0110)?I1lO0lIO10OOIl1:
(IO01lIOIl0OOl1I[5:2]==4'b0111)?l0IO1lIO10OlI1O:
(IO01lIOIl0OOl1I[5:2]==4'b1000)?lO10IlIO10O1lIO:
(IO01lIOIl0OOl1I[5:2]==4'b1001)?O01IllIO10IO0lI:
(IO01lIOIl0OOl1I[5:2]==4'b1010)?OI01llIO10IIO0l:
(IO01lIOIl0OOl1I[5:2]==4'b1011)?IOIl0lIO10IOIl0:
(IO01lIOIl0OOl1I[5:2]==4'b1100)?IO0lIlIO10IlI0O:
(IO01lIOIl0OOl1I[5:2]==4'b1101)?OlI1OlIO10OI01l:
(IO01lIOIl0OOl1I[5:2]==4'b1110)?OOl1IlIO10OlI01:
IO01llIO10O01Il;assign O1lIOO1lIOOI01l[31:0]
=l10IOIlI0OlO10I?IO01lIlO01O01Il[31:0]:OlI1OIlO01IO01l[31:0];assign l0IO1O01IllO10I=(OI01lO1lIOl10IO);dffe3 IIlI0OlIO10IOIl0
(I1lO0IIO0lOOIl1[2:0],s_hsize[2:0],clk,reset_b,1'b1,OOl1IIO0lIIlO01);assign OOl1IIIO0lIlO01[2]
=(l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)&
OlI1OIO0lIIO01l[2];assign mwr_addra[5:0]=lIO10IOIl0O1lIO[5:0];assign lO10Il10IOlIO10
=~IO0lIl10IOI01lO[2]&IO0lIl10IOI01lO[1]&IO0lIl10IOI01lO[0];assign OlI01O1lIOl10IO
=I01lOIlI0OOIl01?l0IO1IlO01lO10I:I01lOOOl1IOOIl1;assign lO10IIOIl0lIO10
=(OlI1OO1lIOIO01l)?7'b0000001:
(OOl1IO1lIOIlO01)?7'b0000010:
7'b0000100;assign IO0lIO01IlI01lO[0]
=IOIl0O01IlI1lO0[0]&~OOl1IIlI0OOlI01;assign O01IlIOIl0IO0lI[6]=1'b0;assign l10IOOOl1IOlI1O=2'b00;assign OI01lI01lOIIO0l
=~s_hburst[2]&~s_hburst[1]&~s_hburst[0];assign OlI01IO0lIIIO0l[15:8]
=(I01lOOOIl1OOIl1|m_swapen)?OIl01IO0lIIO0lI[15:8]:OIl01IO0lIIO0lI[23:16];assign lO10IlIO10lIO10[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign OOl1IOIl01IlO01[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;dff IOIl01OIl01l0IO1
(IO01lOOl1IOOl1I,I1lO0OOl1IOIl01,clk,reset_b,1'b1);assign lO10IIO0lIlIO10
=(IOIl0OI01lI1lO0)?7'b0000001:
(OI01lOI01ll10IO)?7'b0000010:
7'b0000100;assign lIO10OOIl1O1lIO[10:2]=IlI0OOOl1II1lO0[10:2];assign OlI1OlIO10IO01l[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign O01IllO10IIO0lI[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1000)))?1'b1:1'b0;dff IOlI01lO10IIIO0l
(OOl1IOOl1IIlO01,OlI1OOOl1IIO01l,clk,reset_b,1'b1);assign IO0lIIOIl0IlI0O=(I1lO0IO0lIOIl01==7'b1000000)?1'b1:1'b0;assign IIO0lIO0lIIlI0O
=~(IIO0lIOIl0I01lO&I01lOO1lIOOOIl1&mrd_abort);assign lO10Il0IO1O1lIO[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign OOl1IlO10IOlI01[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign O01IlOlI1Ol0IO1
=(OlI1OOlI1OOI01l==3'b110)?1'b1:1'b0;assign O01IlOlI01IO0lI
=(lO10IIIO0llIO10&O01IlIIO0lIO0lI)|
(O01IlIIO0ll0IO1&lO10IIIO0lO1lIO);dff IlIO10O01IlO1lIO
(IlI0OOI01lIOIl0,IIO0lOI01lIlI0O,clk,reset_b,1'b1);assign IO0lIl0IO1IlI0O[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;dffe IIlI0OlIO10I1lO0
(IO01lOIl01OOl1I[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IO0lIOIl01I01lO[3]);assign I1lO0OlI1OOOIl1[3]
=(~IO01lO1lIOO01Il)?1'b0:
(OI01lOlI1OIIO0l&IO01lOlI1OO01Il)?1'b0:
(OI01lOlI1OIIO0l&l0IO1OlI1OlO10I)?1'b0:
(IOIl0OlI1OIOIl0&IO01lOlI1OO01Il)?1'b0:
I1lO0OOIl1OIl01[3];assign OOl1IIlI0OIlO01
=(lO10IIlI0OlIO10==1'b0)?l0IO1IIO0lOlI1O:OlI1OO1lIOIO01l;dff2 Il10IOO01IllO10I
(O1lIOOlI1OIO01l[1:0],OOIl1OlI1OIlO01[1:0],clk,reset_b,1'b1);dffe IO1lIOI01lOIO01l
(OOl1IlO10IIlO01[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,IOIl0lIO10I1lO0[2]);dffe IOlI01l0IO1l10IO
(OI01lOIl01IIO0l[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,l0IO1lO10IOlI1O[2]);assign lO10IOlI01lIO10
=(OlI1OOlI1OOI01l[2:1]==2'b00)?1'b1:
(IOIl0OlI1OI1lO0&OI01lOlI1OIIO0l)?1'b1:1'b0;assign l0IO1OI01llO10I[1]
=~((~big_endian&OI01lOlI1OIIO0l&(~I1lO0OOIl1OIl01[1]&I1lO0OOIl1OIl01[0]))|
(~big_endian&IOIl0OlI1OIOIl0&~I1lO0OOIl1OIl01[1])|
(big_endian&(OI01lOlI1OIIO0l|IOIl0OlI1OIOIl0)&I1lO0OOIl1OIl01[1]&~I1lO0OOIl1OIl01[0])|
IO0lIOlI1OIlI0O);assign IlI0OOlI1OIOIl0
=(I01lOOlI1OOIl01==2'b10)?1'b1:1'b0;dffe IIIO0lIO01lI01lO
(O01IllIO10IO0lI[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,I1lO0l0IO1OOIl1[1]);dffe IOIl01l10IOl0IO1
(IO01lOIl01O01Il[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,IO0lIlO10IIlI0O[1]);assign I1lO0l0IO1OIl01[5:0]
=(I1lO0IlI0OOIl01)?s_haddr[5:0]:
(lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&OI01lIlI0Ol10IO)?I1lO0IO0lIOIl01[5:0]:
(lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&~OI01lIlI0Ol10IO)?l0IO1l0IO1lO10I[5:0]:
IO01ll0IO1O01Il[5:0];assign pci_rdbuf_waddr[3:0]
=IOIl0OOIl1I1lO0[5:2];dffe2 II01lOOIl01OOIl1(IlO01IO0lIOOl1I[1:0],OOIl1O1lIOIlO01[1:0],clk,reset_b,1'b1,IIO0lIIO0lI01lO);dffe IIlI0OIlO01I1lO0
(OOl1IlIO10OlI01[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,IOIl0l0IO1IOIl0[0]);assign IlO01OI01lOOl1I
=~I01lOIO0lIOIl01&(OOIl1IO0lIOlI01|~I01lOIlI0OOIl01)&OlI01IOIl0l10IO;assign l0IO1lO10IlO10I
=(OI01lIIO0ll10IO[5:2]==4'b0000)?OOl1IO01IlIlO01:
(OI01lIIO0ll10IO[5:2]==4'b0001)?IO01lOIl01OOl1I:
(OI01lIIO0ll10IO[5:2]==4'b0010)?I1lO0OIl01OOIl1:
(OI01lIIO0ll10IO[5:2]==4'b0011)?l0IO1OIl01OlI1O:
(OI01lIIO0ll10IO[5:2]==4'b0100)?lO10IOIl01O1lIO:
(OI01lIIO0ll10IO[5:2]==4'b0101)?O01IlOIl01IO0lI:
(OI01lIIO0ll10IO[5:2]==4'b0110)?OI01lOIl01IIO0l:
(OI01lIIO0ll10IO[5:2]==4'b0111)?IOIl0OIl01IOIl0:
(OI01lIIO0ll10IO[5:2]==4'b1000)?IO0lIOIl01IlI0O:
(OI01lIIO0ll10IO[5:2]==4'b1001)?OlI1OOIl01OI01l:
(OI01lIIO0ll10IO[5:2]==4'b1010)?OOl1IOIl01OlI01:
(OI01lIIO0ll10IO[5:2]==4'b1011)?IO01lOIl01O01Il:
(OI01lIIO0ll10IO[5:2]==4'b1100)?I1lO0OIl01OIl01:
(OI01lIIO0ll10IO[5:2]==4'b1101)?l0IO1OIl01lO10I:
(OI01lIIO0ll10IO[5:2]==4'b1110)?lO10IOIl01lIO10:
O01IlOIl01l0IO1;dff2 IOIl01lIO10IO0lI
(l0IO1O01IlOlI1O,lO10IO01IlO1lIO,clk,reset_b,1'b1);assign IO0lIIIO0lI01lO=OI01lIIO0ll10IO+7'b0000100;assign IIO0lIOIl0IlI0O
=((l10IOOI01lOlI1O&IlO01O1lIOOOl1I&
~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))==1'b1)?IIO0lIO0lII01lO:
(l10IOOlI1OOlI1O==1'b1)?IlO01O1lIOO01Il:OOIl1O1lIOOlI01;assign l0IO1OOIl1lO10I
=(I1lO0OOIl1OIl01==IOIl0I1lO0IOIl0)?1'b1:1'b0;assign l10IOIO0lIlO10I[1:0]
=(~O01IlIlO01l0IO1[2]&IlI0OOOl1II1lO0[31])?2'b10:
((~O01IlIlO01l0IO1[2]&~IlI0OOOl1II1lO0[31])|
(~O01IlIlO01l0IO1[1]&(I1lO0IlO01OIl01[0]|I1lO0IlO01OIl01[1]|I1lO0IlO01OIl01[2]|I1lO0IlO01OIl01[3])))?2'b00:lO10IIlO01lIO10[1:0];assign l0IO1IO0lIOlI1O
=(I1lO0IO0lIOOIl1==3'b000)?1'b1:1'b0;dff7 IO1lIOlIO10OI01l(OI01lIOIl0l10IO,IOIl0IOIl0I1lO0,clk,reset_b,1'b1);assign lO10IIOIl0O1lIO[4]
=(IO01lIO0lIOOl1I&OI01lIO0lIIIO0l)?
l0IO1IOIl0OlI1O[4]:
(OOl1IO1lIOIlO01&IOIl0IO0lIIOIl0)?l0IO1IOIl0OlI1O[4]:
(IO01lIO0lIOOl1I&IOIl0IO0lIIOIl0)?l0IO1IOIl0OlI1O[4]:
(~IO0lIIO0lIIlI0O)?l0IO1IOIl0OlI1O[4]:
IO01lIOIl0OOl1I[4];assign IOIl0IlO01I1lO0[4:0]
=IO01lIlO01OOl1I[4:0];assign I1lO0I01lOOIl01=I1lO0IlI0OOIl01;assign lIO10O1lIOlIO10[2]
=(OOIl1OOl1IIlO01|m_swapen)?l10IOO1lIOlO10I[2]:l10IOO1lIOlO10I[1];assign lO10IlO10IlIO10[3]=IOIl0O01IlI1lO0[3]&OOl1IIlI0OOlI01;assign IO0lIOIl01I01lO[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0001)))?1'b1:1'b0;assign IO0lIIO01lIlI0O=1'b0;assign I1lO0OOl1IOIl01
=(IlO01IlO01IlO01&OI01lIO01lIIO0l&~s_hwrite&~IO0lIIO01lIlI0O)|
(I1lO0OOl1IOOIl1&OI01lIO01lIIO0l&~s_hwrite)|
(l0IO1OOl1IOlI1O&OI01lIO01lIIO0l&~s_hwrite)|
(IO0lIOOl1IIlI0O&OI01lIO01lIIO0l&~s_hwrite&I1lO0IO01lOIl01&~OI01lIO01ll10IO);assign IO0lII01lOI01lO
=s_hsel[3]|s_hsel[2]|s_hsel[1]|s_hsel[0];assign IlI0OOOl1II1lO0[30:24]=7'b0000000;assign IOIl0lIO10I1lO0[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;assign l0IO1lO10IOlI1O[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0110)))?1'b1:1'b0;assign IOIl0IO01lIOIl0
=I1lO0I01lOOOIl1&OOl1II01lOIlO01&s_hreadyin&OlI1OI1lO0OI01l;assign IOIl0IO0lII1lO0[3]=OOl1II1lO0OlI01&s_haddr[3];assign IlI0OIOIl0I1lO0
=(OlI01IOIl0l10IO&I01lOO1lIOOIl01)|(IIO0lIOIl0I01lO&I01lOO1lIOOOIl1)|(I01lOIlI0OOOIl1&IlO01IOIl0OOl1I)|
(OlI01IlI0OIIO0l&(~IlI0OIIO0lIOIl0|~OlI01O1lIOl10IO))|(OOIl1IlI0OOlI01);assign I1lO0l0IO1OOIl1[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign IO0lIlO10IIlI0O[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign IO0lIOlI1OIlI0O
=O01IlOlI1OIO0lI[1]&~O01IlOlI1OIO0lI[0];assign IO0lIl10IOIlI0O=(IO01lOOIl1O01Il)?1'b0:lO10IOOIl1O1lIO;assign OIl01IOIl0IO0lI[6:0]
=(OOIl1IOIl0IlO01)?7'b0000000:
(I01lOIlI0OOOIl1&~IlI0OIIO0lIOIl0)?lIO10IOIl0O1lIO[6:0]+7'b0000001:
lIO10IOIl0O1lIO[6:0];assign OI01ll0IO1IIO0l[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign I1lO0lO10IOIl01[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1111)))?1'b1:1'b0;assign l0IO1O1lIOOlI1O
=(OOl1IOOIl1OlI01)?1'b0:
(IO01lOOIl1OOl1I)?1'b1:
1'b0;assign IO01lOOIl1O01Il=(OOl1IO1lIOOlI01==4'b0001)?1'b1:1'b0;assign OlI01OI01ll10IO
=(l10IOOI01llO10I&~lIO10IO0lIlIO10)|(OIl01OI01ll0IO1&~lIO10IO0lIlIO10);dffe IIlO01I01lOO01Il
(IO0lIlO10II01lO[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,O01IllIO10l0IO1[2]);dffe IIIO0ll0IO1IlI0O
(lO10IOIl01O1lIO[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IO01llO10IOOl1I[2]);assign OlI1OI1lO0IO01l=1'b1;assign IO0lIIO01lI01lO[5]
=(I1lO0l10IOOOIl1&~IO01lO1lIOO01Il&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&IO01lOlI1OO01Il&IO0lIOlI1OIlI0O&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&l0IO1OlI1OlO10I&IO0lIOlI1OIlI0O&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&O01IlOlI1Ol0IO1&OI01lOlI1OIIO0l&I1lO0OOIl1OIl01[5])|
(I1lO0l10IOOOIl1&O01IlOlI1Ol0IO1&IOIl0OlI1OIOIl0&I1lO0OOIl1OIl01[5])|
(l0IO1l10IOOlI1O&~OI01lIlI0Ol10IO&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IOIl0IlI0OI1lO0&I1lO0OI01lOOIl1&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&IO0lIIlI0OI01lO&I1lO0OI01lOOIl1&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&OlI1OIlI0OIO01l&OOl1IIlI0OIlO01&l0IO1OI01lOlI1O[5])|
(l0IO1l10IOOlI1O&OlI1OIlI0OIO01l&IO01lOI01lOOl1I&l0IO1OI01lOlI1O[5]);assign IIO0lOlI1OIlI0O
=lIO10OlI1OO1lIO&I01lOIlI0OOOIl1&
((~OlI01O1lIOl10IO&~OlI01IOIl0IIO0l)|
((O1lIOIO0lIOI01l|I01lOIOIl0OOIl1|~OlI01O1lIOl10IO)&~IlI0OIIO0lIOIl0));dffe IOOIl1IO01lOlI01
(l0IO1lIO10OlI1O[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,OOl1IlIO10IlO01[1]);dffe IIlI0Ol10IOIOIl0
(OlI1OOIl01OI01l[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,OI01llO10IIIO0l[1]);assign OlI1OOI01lOI01l
=(lO10IOI01lO1lIO[31:6]==IO01ll0IO1O01Il[31:6])?1'b1:1'b0;assign OOl1Il0IO1IlO01[4]
=(OlI1OOlI01IO01l[2]|OlI1OOlI01IO01l[3])?1'b0:
(IOIl0O1lIOIOIl0==4'b0000)?1'b1:1'b0;assign IlI0OIlI0OI1lO0
=l10IOOI01lOlI1O&IlI0OOlI1OIOIl0;dffe IO1lIOIlO01OI01l
(IO0lIlIO10IlI0O[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,O01Ill0IO1IO0lI[0]);dff IO1lIOOI01lIO01l
(l10IOO1lIOOlI1O,lIO10O1lIOO1lIO,clk,reset_b,1'b1);dffe IOlI01I1lO0IIO0l
(lO10IOIl01lIO10[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IO01llO10IO01Il[0]);assign lO10Il0IO1lIO10
=
(~OOl1IOlI01OlI01&((IO01lO1lIOO01Il&IO01lOOIl1OOl1I&OOl1IOOIl1OlI01)|
(~IO01lO1lIOO01Il&IO01lOOIl1OOl1I&OOl1IOOl1IIlO01)|
(IOIl0IlI0OIOIl0)));assign IOIl0O01IlI1lO0[2]
=(O01IlOI01ll0IO1)?lO10IO1lIOlIO10:
((~big_endian&OI01lOI01ll10IO&I1lO0IO0lIOIl01[1])|
(big_endian&OI01lOI01ll10IO&~I1lO0IO0lIOIl01[1]))?lO10IO1lIOlIO10:
((~big_endian&IOIl0OI01lI1lO0&I1lO0IO0lIOIl01[1]&~I1lO0IO0lIOIl01[0])|
(big_endian&IOIl0OI01lI1lO0&~I1lO0IO0lIOIl01[1]&I1lO0IO0lIOIl01[0]))?lO10IO1lIOlIO10:
1'b0;dff Il10IOOIl01lO10I
(O1lIOIIO0lOI01l,IIO0lIIO0lIlI0O,clk,1'b1,reset_b);assign O01IlIO01lIO0lI=OI01lOOIl1l10IO|OOl1IIO0lIIlO01|OI01lO1lIOl10IO;assign IIO0lO1lIOIlI0O[1]
=~(~O01IlIlO01l0IO1[1]&~I1lO0IlO01OIl01[0]&~I1lO0IlO01OIl01[1]&~I1lO0IlO01OIl01[2]&~I1lO0IlO01OIl01[3]);assign O01IlO01Ill0IO1
=(OOl1IO01IlOlI01==2'b01)?1'b1:1'b0;assign O01IlIIO0lIO0lI=(I1lO0IIO0lOOIl1[2:0]==3'b010)?1'b1:1'b0;assign OOl1IIIO0lIlO01[5]
=((l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)|
(l0IO1IIO0lOlI1O&OOl1IIIO0lOlI01)|
(lO10IIIO0lO1lIO&OlI1OIIO0lOI01l)|
(l0IO1IIO0lOlI1O&IO01lIIO0lO01Il)|
(lO10IIIO0lO1lIO&OOl1IIIO0lOlI01)|
(O01IlIIO0lIO0lI&OlI1OIIO0lOI01l)|
(lO10IIIO0lO1lIO&IO01lIIO0lO01Il)|
(O01IlIIO0lIO0lI&OOl1IIIO0lOlI01))&
OlI1OIO0lIIO01l[5];assign mwr_addrb
=I01lOOlI1OOOIl1;assign IOIl0l10IOI1lO0=~IO0lIl10IOI01lO[2]&~IO0lIl10IOI01lO[1]&IO0lIl10IOI01lO[0];assign OOl1IIlO01OlI01
=~I01lOIlI0OOIl01|IIO0lIO0lIIlI0O;assign l0IO1IOIl0lO10I[6:2]=5'b00000;assign IO0lIO01IlI01lO[3]
=IOIl0O01IlI1lO0[3]&~OOl1IIlI0OOlI01;assign I1lO0IO01lOIl01=1'b0;assign OlI01OOl1IIIO0l=1'b0;assign OlI1OI01lOOI01l
=s_hburst[2]&~s_hburst[1]&~s_hburst[0];assign IIO0lIO0lII01lO[31:16]
=(~l10IOIO0lIOlI1O[0])?O1lIOO1lIOOI01l[31:16]:
lIO10OOIl1O1lIO[31:16];assign O01IllIO10l0IO1[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign IO01llO10IOOl1I[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0100)))?1'b1:1'b0;dff IIIO0lOIl01I01lO
(lO10IOOl1IO1lIO,O01IlOOl1Il0IO1,clk,reset_b,1'b1);assign OI01lIO0lIl10IO[1:0]=O01IlIO0lIl0IO1[1:0];dff IO1lIOOlI01OI01l
(OlI01IOIl0l10IO,IlI0OIOIl0I1lO0,clk,1'b1,reset_b);assign OOl1IlIO10IlO01[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign OI01llO10IIIO0l[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;dff IO1lIOlO10IOI01l
(lO10IOOIl1O1lIO,OlI1OOOIl1OI01l,clk,reset_b,1'b1);assign OI01lOI01ll10IO
=(OOl1IIlI0OOlI01==1'b0)?lO10IIIO0lO1lIO:OOl1IO1lIOIlO01;dff7 IIlI0OOlI01I1lO0
(OOIl1IIO0lIlO01[6:0],l10IOIOIl0OlI1O[6:0],clk,reset_b,1'b1);assign lO10Il0IO1O1lIO[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign OOl1IlO10IOlI01[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1101)))?1'b1:1'b0;assign lO10IO1lIOO1lIO
=(OOl1IOlI1OIlO01)?I1lO0O1lIOOIl01:
(I1lO0O1lIOOOIl1)?O01IlO1lIOIO0lI-4'b0001:O01IlO1lIOIO0lI;assign IO01lIO0lIO01Il
=(I1lO0IO0lIOOIl1[2:1]==2'b11)?1'b1:1'b0;dff IIlI0OO01IlIOIl0(l10IOOI01llO10I,lIO10OI01llIO10,clk,reset_b,1'b1);dffe Il10IOI01lOOlI1O
(OI01llO10Il10IO[2],O01IllO10Il0IO1[2],clk,reset_b,1'b1,l0IO1lIO10lO10I[2]);dffe IOOIl1lIO10IlO01
(I1lO0OIl01OOIl1[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,OlI1OOIl01IO01l[2]);assign IO01lOlI1OOOl1I
=(IO01lOOl1IOOl1I&~OlI1OOOl1IIO01l&
(~IO01lOOIl1OOl1I|(IO01lOOIl1OOl1I&OOl1IOOIl1OlI01))&~OI01lI1lO0l10IO);assign l0IO1OI01lOlI1O
=(lO10IIlI0OlIO10==1'b0)?OlI1OIO0lIIO01l:O01IlO1lIOl0IO1;assign OOIl1OlI1OIlO01
=(OlI01OlI1Ol10IO==1'b1)?2'b00:
(IIO0lOlI1OI01lO==1'b1)?2'b01:
(IlI0OOlI1OI1lO0==1'b1)?2'b11:
O1lIOOlI1OIO01l;dffe II01lOIO01lOOIl1
(IO01llIO10OOl1I[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,IO0lIlIO10I01lO[1]);dffe IO1lIOl0IO1IO01l
(IOIl0OIl01IOIl0[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,lO10IlO10IO1lIO[1]);assign IOIl0OlI01I1lO0
=(IO0lIOlI1OI01lO&IO0lIOlI1OIlI0O)?1'b1:
(OlI1OOlI1OIO01l&IOIl0OlI1OIOIl0)?1'b1:1'b0;assign lO10IOI01llIO10
=((I1lO0OOIl1OOIl1&OlI1Ol0IO1IO01l)|lO10IOOIl1O1lIO|l0IO1OOIl1OlI1O)?OlI1OIlI0OOI01l:
(OOl1IOlI1OOlI01|lO10II1lO0lIO10)?l0IO1OI01llO10I:
4'b0000;dff IOIl01O01Ill0IO1
(I01lOOlI1OOOIl1,l10IOOlI1OOlI1O,clk,reset_b,1'b1);dffe IIlO01IlO01OOl1I
(OI01llIO10IIO0l[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,l0IO1l0IO1OlI1O[0]);dffe IIIO0ll10IOI01lO
(I1lO0OIl01OIl01[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,OlI1OlO10IOI01l[0]);assign OI01lIlI0OIIO0l
=(IOIl0IlI0OIOIl0)?1'b1:
(IO0lIIlI0OIlI0O)?1'b0:
IO0lII1lO0IlI0O;assign pci_wrbuf_raddr[3:0]
=(lO10IIlI0OlIO10==1'b0)?IOIl0IIO0lI1lO0[5:2]:I1lO0IOIl0OOIl1[5:2];dffe7 IOIl01OIl01IO0lI
(pci_size[6:0],lIO10IOIl0lIO10[6:0],clk,reset_b,1'b1,OIl01IOIl0l0IO1);dffe IOOIl1IlO01IlO01
(OOl1IlIO10OlI01[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,IOIl0l0IO1IOIl0[3]);assign I01lOOI01lOOIl1
=((IIO0lIOIl0I01lO&IlI0OOI01lIOIl0)|(IIO0lIlI0OIlI0O&l10IOOOl1IlO10I))&~IOIl0IlO01IOIl0&I01lOIlI0OOIl01;dffe32 IlIO10I1lO0lIO10
(O01IlO1lIOl0IO1[31:0],s_haddr[31:0],clk,reset_b,1'b1,OI01lO1lIOl10IO);assign IOIl0O01IlIOIl0
=lO10IIO01lO1lIO&~OOl1IIlI0OOlI01&(
(l0IO1OOl1IOlI1O&l0IO1I01lOOlI1O)|
(l0IO1OOl1IOlI1O&I1lO0I01lOOOIl1)|
(l0IO1OOl1IOlI1O&~O01IlI1lO0l0IO1&OOl1II1lO0IlO01)|
(l0IO1OOl1IOlI1O&IO01lI01lOOOl1I&O01IlI1lO0l0IO1&OI01lI01lOl10IO));assign OlI1OIIO0lIO01l[3]
=(l0IO1IIO0lOlI1O&OlI1OIIO0lOI01l)?OI01lIIO0ll10IO[3]:
(l0IO1IIO0lOlI1O&OOl1IIIO0lOlI01)?OI01lIIO0ll10IO[3]:
(lO10IIIO0lO1lIO&OlI1OIIO0lOI01l)?OI01lIIO0ll10IO[3]:
IO0lIIIO0lI01lO[3];assign I01lOIOIl0OIl01
=((l10IOOI01lOlI1O&IlO01O1lIOOOl1I&
~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0))==1'b1)?OIl01IO0lIl0IO1:
(l10IOOlI1OOlI1O==1'b1)?IlI0OIO0lII1lO0:OlI01IO0lIl10IO;assign OlI1Ol10IOOI01l
=~OlI1Ol10IOIO01l[1]&~OlI1Ol10IOIO01l[0];assign IlO01IIO0lOOl1I[6:0]=l10IOIlI0OlO10I?IOIl0IlO01I1lO0[6:0]:OOIl1OOl1IOlI01[6:0];assign OI01lIO0lIIIO0l
=(I1lO0IO0lIOOIl1==3'b100)?1'b1:1'b0;assign OOl1IIOIl0IlO01
=lO10IIO01lO1lIO&l0IO1OOl1IOlI1O&(O01IlI01lOIO0lI|lO10II01lOO1lIO)&~OOl1IIlI0OOlI01;assign O01IlIOIl0IO0lI[1:0]=2'b00;assign l0IO1IlO01lO10I
=1'b1;dffe IIO01lOOl1IOIl01(OOl1IIlI0OOlI01,IO01lIlI0OO01Il,clk,reset_b,1'b1,I1lO0IlI0OOIl01);assign OlI01IlI0Ol10IO
=IIO0lIOIl0I01lO&IlI0OOI01lIOIl0&~l10IOIO0lIOlI1O[2];assign l0IO1lIO10lO10I[1]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign OlI1OOIl01IO01l[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0010)))?1'b1:1'b0;assign O01IlOOl1Il0IO1
=(IO01lOOl1IOOl1I&~OlI1OOOl1IIO01l&~OOl1IOOl1IIlO01&
((IO01lO1lIOO01Il&~IO01lOOIl1OOl1I)|~IO01lO1lIOO01Il)&~OI01lI1lO0l10IO);assign s_hreadyout
=IlO01IlO01IlO01|
I1lO0OOl1IOOIl1|
l0IO1OOl1IOlI1O|
IOIl0OOl1IIOIl0|
(IO0lIOOl1IIlI0O&I1lO0IO01lOIl01);assign lIO10OOl1IlIO10
=IlI0OOOl1II1lO0[23:16];assign IO0lIlIO10I01lO[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;assign lO10IlO10IO1lIO[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign IOIl0OOIl1IOIl0
=(OlI1OOOl1IIO01l&~OI01lIlO01IIO0l&OOl1IIlO01OlI01)|
(IO01lOOIl1OOl1I&~OOl1IOOIl1OlI01);assign IOIl0IO0lII1lO0[6]=1'b0;assign l10IOIlI0OOlI1O
=(OOIl1IOIl0IlO01&IlI0OOI01lI1lO0)|(I01lOIlI0OOOIl1&~IlO01IOIl0OOl1I);assign I1lO0l0IO1OOIl1[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign IO0lIlO10IIlI0O[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1011)))?1'b1:1'b0;assign lO10II1lO0lIO10
=(OlI1OOlI1OOI01l==3'b001)?1'b1:1'b0;assign lO10IIIO0llIO10=(OI01lIIO0lIIO0l[2:1]==2'b10)?1'b1:1'b0;assign l10IOIIO0llO10I
=(OOIl1IIO0lOlI01[6:0]==7'b0000001)?1'b1:1'b0;assign IOIl0l0IO1IOIl0[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;dffe II01lOlIO10OIl01
(OOl1IO01IlIlO01[2],OlI1OO01IlIO01l[2],clk,reset_b,1'b1,IOIl0OIl01I1lO0[2]);assign OOl1IOOIl1OlI01
=(IOIl0O1lIOIOIl0==4'b0001)?1'b1:1'b0;dffe IlO10IOOl1Il0IO1(lO10IIlI0OlIO10,O01IlIlI0Ol0IO1,clk,reset_b,1'b1,l0IO1IlI0OlO10I);assign IlI0OIOIl0IOIl0
=~(l10IOOI01llO10I&lIO10IO0lIlIO10);dffe IlIO10I01lOlIO10
(OlI1OlO10IIO01l[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,OI01llIO10l10IO[1]);dffe IIlO01l0IO1O01Il
(O01IlOIl01IO0lI[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,I1lO0lO10IOOIl1[1]);dff IIIO0llO10II01lO
(OOl1IOlI01OlI01,IO01lOlI01O01Il,clk,reset_b,1'b1);assign OlI1OIlI0OOI01l[0]
=(lO10IIlI0OlIO10==1'b0)?~l0IO1lO10IlO10I[0]:~OlI1Ol0IO1OI01l[0];assign IlI0OOlI1OI1lO0
=OOIl1OI01lOlI01|(IIO0lIlI0OIlI0O&l10IOOOl1IlO10I);dffe Il10IOIO01llO10I
(lO10IlIO10O1lIO[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,IO01ll0IO1OOl1I[0]);dffe IOOIl1l10IOOlI01
(OOl1IOIl01OlI01[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,IOIl0lO10IIOIl0[0]);assign I1lO0OI01lOIl01
=(lO10IOI01lO1lIO[31:3]==IO01ll0IO1O01Il[31:3])?1'b1:1'b0;assign IO01lIlO01OOl1I
=(I1lO0OOIl1OOIl1&IO0lIl0IO1I01lO)?OOl1Il0IO1IlO01:
(OlI1OOOl1IIO01l)?OOl1Il0IO1IlO01:
IO01ll10IOOOl1I;dffe32 IIlI0OO01IlI1lO0
(IlO01O1lIOO01Il[31:0],IIO0lIO0lII01lO[31:0],clk,reset_b,1'b1,O1lIOIIO0lIO01l);dffe II01lOIlO01OIl01
(IO0lIlIO10IlI0O[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,O01Ill0IO1IO0lI[3]);assign lIO10O1lIOO1lIO
=~OOIl1OOIl1OlI01&
(O1lIOIlI0OIO01l|l10IOO1lIOOlI1O);dffe IO1lIOI1lO0OI01l
(lO10IOIl01lIO10[3],OlI1OO01IlIO01l[3],clk,reset_b,1'b1,IO01llO10IO01Il[3]);dff II01lOlIO10OOIl1
(OI01ll0IO1l10IO,IOIl0l0IO1I1lO0,clk,reset_b,1'b1);assign pci_wrbuf_wren[1]=IOIl0O01IlI1lO0[1];assign O1lIOIIO0lIO01l
=IlO01OlI1OO01Il;dff2 IO01IlOOl1IIIO0l(OI01lI1lO0IIO0l,s_htrans,clk,reset_b,1'b1);assign OIl01O1lIOIO0lI[1]
=~(~lIO10OOl1IO1lIO[1]&~IlO01OOl1IOOl1I[0]&~IlO01OOl1IOOl1I[1]&~IlO01OOl1IOOl1I[2]&~IlO01OOl1IOOl1I[3]);dffe3 IIIO0lI1lO0I01lO
(IO0lIO1lIOI01lO[2:0],s_hsize[2:0],clk,reset_b,1'b1,OI01lO1lIOl10IO);assign IO0lIIIO0lIlI0O
=(OI01lIIO0lIIO0l==3'b001)?1'b1:1'b0;assign I1lO0IOIl0OOIl1
=(O01IlOOIl1IO0lI)?O01IlIOIl0IO0lI:
(lO10IOOIl1O1lIO)?lO10IIOIl0O1lIO:
IO01lIOIl0OOl1I;assign OlI1OIlO01OI01l[31:0]
=IO0lIIlO01I01lO[31:0];assign lO10II01lOO1lIO=OI01lI1lO0IIO0l[1]&OI01lI1lO0IIO0l[0];assign lIO10IO0lIO1lIO[31:24]
=(IlO01OOIl1OOl1I|m_swapen)?IlI0OIO0lIIOIl0[31:24]:IlI0OIO0lIIOIl0[7:0];assign IOIl0I1lO0I1lO0=O01IlOOIl1l0IO1|lO10IOOIl1lIO10;assign IOIl0OIl01I1lO0[1]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[1]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0000)))?1'b1:1'b0;assign O01IlIO01ll0IO1=1'b0;assign O1lIOOOl1IOI01l
=1'b1;assign OlI1OI1lO0OI01l=IO01lI1lO0O01Il|I1lO0I1lO0OIl01|l0IO1I1lO0lO10I;dffe8 IOIl01OlI01IO0lI
(IlI0OOOl1II1lO0[23:16],IIO0lOOl1II01lO[23:16],clk,reset_b,1'b1,O1lIOOOl1IIO01l);assign OI01llIO10l10IO[0]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0011)))?1'b1:1'b0;assign I1lO0lO10IOOIl1[0]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[0]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0101)))?1'b1:1'b0;dff IIlO01lO10IOOl1I
(OlI1OOOl1IOI01l,IO0lIOOl1II01lO,clk,reset_b,1'b1);assign OI01lIO0lIl10IO[4]
=(O01IlOI01ll0IO1&OlI1OOI01lIO01l)?O01IlIO0lIl0IO1[4]:
(OI01lOI01ll10IO&OOl1IOI01lIlO01)?O01IlIO0lIl0IO1[4]:
(O01IlOI01ll0IO1&OOl1IOI01lIlO01)?O01IlIO0lIl0IO1[4]:
(~IO01lOlI01OOl1I)?O01IlIO0lIl0IO1[4]:
I1lO0IO0lIOIl01[4];dff II01lOOlI01OIl01
(I01lOIlI0OOOIl1,l10IOIlI0OOlI1O,clk,reset_b,1'b1);assign OOl1IlIO10IlO01[3]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b0111)))?1'b1:1'b0;assign OI01llO10IIIO0l[3]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[3]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1001)))?1'b1:1'b0;assign OI01lI1lO0l10IO
=l0IO1OOIl1lO10I&l0IO1OlI1OOlI1O&lO10IOlI1OO1lIO&
OI01ll0IO1l10IO&~OlI1OIO01lOI01l;assign OlI1OOI01lIO01l
=(OOl1IIlI0OOlI01==1'b0)?OOl1IIIO0lOlI01:OI01lIO0lIIIO0l;dff6 IOOIl1OlI01IlO01
(OIl01IIO0ll0IO1[5:0],OlI01IIO0ll10IO[5:0],clk,reset_b,1'b1);assign O01Ill0IO1IO0lI[2]
=((I1lO0lIO10OIl01==1'b1)|
((lO10IlO10IlIO10[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1100)))?1'b1:1'b0;assign IO01llO10IO01Il[2]
=((OI01lOIl01l10IO==1'b1)|
((IO0lIO01IlI01lO[2]==1'b1)&(I1lO0IO0lIOIl01[5:2]==4'b1110)))?1'b1:1'b0;assign OOl1IOlI1OIlO01
=IO01lOOl1IOOl1I&l0IO1OOl1IlO10I;assign IO0lIOlI01IlI0O
=(OlI1OIO0lIOI01l&IO01lIO0lIOOl1I)|
(OOl1IIO0lIOlI01&OOl1IO1lIOIlO01)|
(IO01lIO0lIO01Il&OlI1OO1lIOIO01l);assign OlI01OI01lIIO0l
=(l10IOOI01lOlI1O&IlO01O1lIOOOl1I&~(OIl01OOIl1l0IO1|IlI0OOlI1OIOIl0)&
~(lIO10IO0lIlIO10&l10IOOOl1IlO10I))|
(OIl01OI01lIO0lI&~(lIO10IO0lIlIO10&l10IOOOl1IlO10I));dffe IOlI01I01lOIIO0l
(IOIl0lO10II1lO0[1],O01IllO10Il0IO1[1],clk,reset_b,1'b1,lO10IlIO10lIO10[1]);dffe Il10IOl0IO1OlI1O
(l0IO1OIl01OlI1O[1],OlI1OO01IlIO01l[1],clk,reset_b,1'b1,OOl1IOIl01IlO01[1]);assign l0IO1O1lIOlO10I[1:0]=OlI1OIOIl0OI01l[1:0];assign I1lO0l10IOOOIl1
=(I1lO0OOIl1OOIl1&IO0lIl0IO1I01lO)|OlI1OOOl1IIO01l|IO01lOOIl1OOl1I;assign IIO0lOOIl1I01lO
=~I01lOOlI1OOOIl1&l10IOOI01llO10I&~lIO10IO0lIlIO10;dffe IOIl01IO01lIO0lI
(I1lO0lIO10OOIl1[0],O01IllO10Il0IO1[0],clk,reset_b,1'b1,OlI1OlIO10IO01l[0]);dffe II01lOl10IOOOIl1
(IO0lIOIl01IlI0O[0],OlI1OO01IlIO01l[0],clk,reset_b,1'b1,O01IllO10IIO0lI[0]);assign lO10IOI01lO1lIO
=(I1lO0OlI1OOIl01|lO10IOlI1OlIO10|OI01lOlI1Ol10IO|lO10II1lO0lIO10)?
(I1lO0OOIl1OIl01+OOl1Il0IO1OlI01):I1lO0OOIl1OIl01;assign lO10IIlO01O1lIO
=(I1lO0l10IOOOIl1)?OlI1OOlI01IO01l[0]:I1lO0O01IlOOIl1[0];assign l10IOOOl1IlO10I=lIO10OlI1OlIO10;dffe IlIO10IlO01O1lIO
(OI01llIO10IIO0l[3],O01IllO10Il0IO1[3],clk,reset_b,1'b1,l0IO1l0IO1OlI1O[3]);dff IIIO0lOI01lI01lO
(OlI01O1lIOIIO0l,IlI0OO1lIOIOIl0,clk,reset_b,1'b1);
endmodule 
