// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module ab_mas_m(
big_endian,
clk,
m_haddr,
m_hburst,
m_hrdata,
m_hready,
m_hresp,
m_hsize,
m_htrans,
m_hwdata,
m_hwrite,
m_hgrant,
m_hbusreq,
m_hlock,
m_hprot,

t_adr,
t_ads_b,
t_be_b,
t_busy,
t_dwr,
t_err_b,
t_hsize,
t_rdy_b,
t_trans,
t_wr,
t_drd,
t_wrap,

reset_b
);
input big_endian;
input clk;
output[31:0] m_haddr;
output[2:0] m_hburst;
input[31:0] m_hrdata;
input m_hready;
input[1:0] m_hresp;
output[2:0] m_hsize;
output[1:0] m_htrans;
output[31:0] m_hwdata;
output m_hwrite;
input m_hgrant;
output m_hbusreq;
output m_hlock;
output[3:0] m_hprot;
input[31:0] t_adr;
input t_ads_b;
input[3:0] t_be_b;
input t_busy;
input[31:0] t_dwr;
output t_err_b;
input[1:0] t_hsize;
output t_rdy_b;
input[4:0] t_trans;
input t_wr;
output[31:0] t_drd;
input t_wrap;
input reset_b;
wire[31:0] OIl01IO01lIOIl0;wire OI01lOlI1OIOIl0;wire OOl1IOOl1IlIO10;wire[4:0] I1lO0IO0lIlIO10;wire IO0lIIlI0OOOl1I;wire[2:0] lO10IOlI01IlI0O;
wire OOl1IOIl01l0IO1;wire OI01ll0IO1OOIl1;wire[31:0] I1lO0I1lO0OI01l;wire lIO10OOl1IOI01l;wire[3:0] IO0lIIO01ll10IO;wire OOIl1OlI1Ol10IO;
wire OlI01IIO0lOlI1O;wire I01lOIlI0OOlI01;wire IIO0lOlI01I1lO0;wire lIO10lO10IO1lIO;wire[31:0] OOIl1l0IO1O01Il;wire I01lOIO01lO01Il;
wire OlI01I1lO0I01lO;wire IOIl0OOl1II01lO;wire l0IO1O1lIOIO0lI;wire OlI1OIIO0lOIl01;wire O01IlIlI0OIO01l;wire IO01lO01IlIIO0l;wire[1:0] IOIl0lO10IlO10I;
wire OlI1OI1lO0lO10I;wire[31:0] l0IO1l0IO1IlO01;wire O01IlIO01lIlO01;wire[4:0] IlO01OOIl1IOIl0;wire[31:0] IlI0OO1lIOlIO10;wire[2:0] l10IOIOIl0OOl1I;
wire[4:0] O1lIOOI01lIlI0O;wire OIl01O01Ill0IO1;wire IlI0Ol0IO1l0IO1;wire[31:0] IlO01lIO10OOIl1;wire l10IOI01lOOOIl1;wire O1lIOIlO01OI01l;
wire[31:0] lO10IOOIl1l10IO;wire[2:0] OOl1IIO0lIOlI1O;wire[3:0] OI01lIOIl0OlI01;wire I1lO0OI01lI1lO0;wire lO10IlO10II1lO0;wire[31:0] IO0lIOIl01O1lIO;
wire OOl1Il10IOO1lIO;wire[1:0] lO10IlIO10O01Il;wire[4:0] OI01lI01lOO01Il;wire I1lO0IlO01I01lO;wire[2:0] IIO0lOlI1OIO0lI;wire lIO10IO0lIOIl01;
wire OOIl1IOIl0IO01l;wire I01lOO01IlIO01l;wire[31:0] OlI01OlI01IIO0l;wire IIO0llIO10IIO0l;wire I01lOOIl01lO10I;wire[4:0] lIO10l10IOlO10I;
wire OOIl1I01lOIlO01;wire[2:0] O01IlOOl1IIOIl0;wire[31:0] IO01lOlI1OlIO10;wire IOIl0IIO0lOOl1I;wire[31:0] l0IO1IlI0OIlI0O;wire O01IlOIl01IlI0O;
wire OlI1OOlI01l0IO1;wire IO01llIO10l0IO1;wire IOIl0I1lO0OOIl1;wire[2:0] l0IO1IO01lOI01l;wire[1:0] O1lIOOOl1Il10IO;wire OIl01O1lIOOlI1O;
wire[31:0] IlO01IIO0lOlI01;wire l10IOOlI01OlI01;wire[3:0] IlI0OIlI0OI1lO0;wire O1lIOOIl01I1lO0;wire[4:0] OIl01l0IO1O1lIO;wire IlO01I1lO0O01Il;
wire IlI0OIO01lI01lO;wire I1lO0OOIl1IO0lI;wire[1:0] IO0lIO1lIOOIl01;wire OOl1IIlI0OOIl01;wire lO10IIIO0lIO01l;wire OI01lOlI01IO01l;
wire[4:0] I1lO0lO10IIIO0l;wire IO0lIl0IO1lO10I;wire lO10II1lO0IlO01;wire[4:0] OOl1IIlO01IOIl0;wire[2:0] OlI01OOIl1lIO10;wire IIO0lIIO0llIO10;
wire[31:0] I01lOIO0lIOOl1I;wire lIO10OI01lOOl1I;wire OOIl1O01IlIlI0O;wire[31:0] OlI01lO10Il0IO1;wire[2:0] I01lOl10IOOOIl1;wire[3:0] IIO0lI01lOOI01l;
wire lIO10IlO01l10IO;wire O01IlO1lIOl10IO;wire[31:0] OlI1OOlI1OOlI1O;wire IO01lIOIl0OlI1O;wire IOIl0OI01lOlI01;wire l0IO1O01IlI1lO0;
wire[2:0] OlI1OlIO10O1lIO;wire O01Ill10IOO01Il;wire IO01lI01lOI01lO;wire l10IOOOIl1I01lO;wire[31:0] IlI0OOOl1IIO0lI;wire O1lIOIO0lIIO0lI;
wire l10IOOlI1OOIl01;wire[4:0] OIl01IOIl0OIl01;wire IlO01OI01lIO01l;wire IlI0OOIl01IIO0l;wire l10IOlIO10lO10I;wire O1lIOl10IOIlO01;
wire IlO01IlO01IlO01;
dff IO01IllO10IOOIl1(OlI1OI1lO0lO10I,IO01lIOIl0OlI1O,clk,reset_b,1'b1);assign OlI01IIO0lOlI1O
=(IOIl0I1lO0OOIl1)?1'b0:
((O1lIOl10IOIlO01&m_hready&IO01llIO10l0IO1)|
OOl1IIlI0OOIl01);assign l0IO1l0IO1IlO01[5:2]
=(IO0lIl0IO1lO10I)?t_adr[5:2]:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{I01lOIO0lIOOl1I[5:4],I01lOIO0lIOOl1I[3:2]+2'b01}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{I01lOIO0lIOOl1I[5],I01lOIO0lIOOl1I[4:2]+3'b001}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?I01lOIO0lIOOl1I[5:2]+4'b0001:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{I01lOIO0lIOOl1I[5:4],I01lOIO0lIOOl1I[3:2]-2'b01}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{I01lOIO0lIOOl1I[5],I01lOIO0lIOOl1I[4:2]-3'b001}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?I01lOIO0lIOOl1I[5:2]-4'b0001:
I01lOIO0lIOOl1I[5:2];assign IlI0OIO01lI01lO
=
((O01IlO1lIOl10IO|lIO10lO10IO1lIO)
&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&O1lIOl10IOIlO01)|
((O01IlO1lIOl10IO|lIO10lO10IO1lIO)&OI01lOlI1OIOIl0);assign I01lOOIl01lO10I
=((IlO01IlO01IlO01==1'b1)&&(t_hsize==2'b10)&&
(t_trans==5'b00001)&&(t_wr==1'b1)&&
(t_be_b!=4'b0000)&&(t_be_b!=4'b0011)&&
(t_be_b!=4'b0111)&&(t_be_b!=4'b1011)&&
(t_be_b!=4'b1100)&&(t_be_b!=4'b1101)&&
(t_be_b!=4'b1110))?1'b1:1'b0;assign IOIl0OOl1II01lO
=m_hresp[0]&m_hresp[1];dff IO01IlIO0lIOlI01(IlO01IlO01IlO01,l10IOOlI01OlI01,clk,1'b1,reset_b);assign I01lOIlI0OOlI01
=(OOIl1O01IlIlI0O)?1'b0:
(O1lIOl10IOIlO01&m_hready&IO01llIO10l0IO1&~IOIl0I1lO0OOIl1);assign IO0lIOIl01O1lIO[31:4]
=(IO0lIl0IO1lO10I)?t_adr[31:4]:
IlI0OOOl1IIO0lI[31:4];assign OlI01OOIl1lIO10
=
((IIO0lOlI01I1lO0==1'b1)&&((IO0lIIO01ll10IO==4'b0111)||(IO0lIIO01ll10IO==4'b1011)||(IO0lIIO01ll10IO==4'b1101)||(IO0lIIO01ll10IO==4'b1110)))?3'b000:
((IIO0lOlI01I1lO0==1'b1)&&((IO0lIIO01ll10IO==4'b0011)||(IO0lIIO01ll10IO==4'b1100)))?3'b001:
3'b010;assign IIO0lOlI01I1lO0
=(OOl1IIlO01IOIl0==5'b00001)?1'b1:1'b0;assign IOIl0IIO0lOOl1I=m_hready;assign m_hwdata=IO01lOlI1OlIO10;assign OI01lOlI1OIOIl0
=(l10IOOOIl1I01lO&m_hgrant&m_hready)|
(I01lOO01IlIO01l&m_hgrant&m_hready)|
(IlO01IlO01IlO01&~l10IOlIO10lO10I&IO01lI01lOI01lO&m_hgrant&m_hready)|

(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&m_hgrant&O1lIOl10IOIlO01)|

(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&m_hgrant)|
(OlI1OI1lO0lO10I&m_hgrant&m_hready)|
(lO10IlO10II1lO0&~m_hready);assign OI01lOlI01IO01l
=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign IOIl0I1lO0OOIl1=(I1lO0lO10IIIO0l==5'b00001)?1'b1:1'b0;assign OlI01lO10Il0IO1
=(IOIl0lO10IlO10I==2'b00)?IlI0OOOl1IIO0lI:
(IOIl0lO10IlO10I==2'b01)?OlI1OOlI1OOlI1O:
I01lOIO0lIOOl1I;dff IlIO10I1lO0IOIl0
(IO0lIIlI0OOOl1I,OOIl1I01lOIlO01,clk,reset_b,1'b1);assign IO0lIIO01ll10IO
=
((IlO01IlO01IlO01==1'b1)&&((t_be_b==4'b0000)||(t_be_b==4'b0011)||(t_be_b==4'b1100)||
(t_be_b==4'b0111)||(t_be_b==4'b1011)||(t_be_b==4'b1101)||(t_be_b==4'b1110)))?
t_be_b:
(IlO01IlO01IlO01&~t_wr)?4'b0000:
(IlO01IlO01IlO01)?{2'b11,t_be_b[1:0]}:
{OI01lIOIl0OlI01[3:2],2'b11};assign m_haddr[1:0]
=(IO0lIl0IO1lO10I)?t_adr[1:0]:
(OOl1IOOl1IlIO10)?O1lIOOOl1Il10IO:
IlI0OO1lIOlIO10[1:0];dff IOlI1OI01lOIOIl0
(lO10IlO10II1lO0,OI01lOlI1OIOIl0,clk,reset_b,1'b1);assign O1lIOIlO01OI01l
=
((O01IlO1lIOl10IO|lIO10lO10IO1lIO|I01lOIO01lO01Il)
&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&O1lIOl10IOIlO01)|
((O01IlO1lIOl10IO|lIO10lO10IO1lIO)&OI01lOlI1OIOIl0);assign IlO01lIO10OOIl1[31:5]
=(IO0lIl0IO1lO10I)?t_adr[31:5]:
OlI1OOlI1OOlI1O[31:5];dff3 II1lO0IIO0lIlI0O(IIO0lOlI1OIO0lI,OlI1OlIO10O1lIO,clk,reset_b,1'b1);assign lIO10IO0lIOIl01
=(~t_ads_b)?t_ads_b:
(O01Ill10IOO01Il)?1'b1:
l10IOlIO10lO10I;assign t_rdy_b
=(IOIl0OI01lOlI01)?~t_wr:
~(O01IlIO01lIlO01&OOl1IOIl01l0IO1&~OOl1IOOl1IlIO10)&
~(~O01IlIO01lIlO01&IO01lI01lOI01lO&O1lIOl10IOIlO01&m_hready&IO01llIO10l0IO1)&
~(O01IlIO01lIlO01&OOl1IIlI0OOIl01&~IOIl0I1lO0OOIl1&~OOl1IOOl1IlIO10);assign O1lIOIO0lIIO0lI
=(O01IlO1lIOl10IO&IOIl0OOl1II01lO)|
(O01IlO1lIOl10IO&O1lIOOIl01I1lO0)|
(I01lOIO01lO01Il&IOIl0OOl1II01lO)|
(I01lOIO01lO01Il&O1lIOOIl01I1lO0)|
(IlI0Ol0IO1l0IO1&~m_hready)|
(lIO10lO10IO1lIO&(O1lIOOIl01I1lO0|IOIl0OOl1II01lO));assign OIl01O01Ill0IO1
=(l10IOOlI1OOIl01&OI01ll0IO1OOIl1);assign l0IO1IlI0OIlI0O
=(IO0lIl0IO1lO10I)?t_adr[31:0]:
(OlI1OIIO0lOIl01)?I1lO0I1lO0OI01l+32'h00000002:
(IlO01I1lO0O01Il)?I1lO0I1lO0OI01l-32'h00000002:
I1lO0I1lO0OI01l;assign IlO01I1lO0O01Il
=IlI0Ol0IO1l0IO1&~OOl1IOOl1IlIO10;assign l0IO1O01IlI1lO0=(IO0lIIlI0OOOl1I==1'b1)?1'b1:1'b0;dff Il0IO1O1lIOIO01l
(IO01lO01IlIIO0l,I1lO0OOIl1IO0lI,clk,reset_b,1'b1);assign l10IOOlI1OOIl01=(OI01lOlI01IO01l)?t_wr:
O01IlIO01lIlO01;dff Il10IOO01IlO1lIO
(IlI0Ol0IO1l0IO1,O1lIOIO0lIIO0lI,clk,reset_b,1'b1);assign IlO01OOIl1IOIl0
=(l0IO1O1lIOIO0lI)?OIl01l0IO1O1lIO:
(OlI01IIO0lOlI1O)?I1lO0lO10IIIO0l-5'b00001:I1lO0lO10IIIO0l;dff32 IO1lIOlO10IO01Il
(OlI1OOlI1OOlI1O,IlO01lIO10OOIl1,clk,reset_b,1'b1);assign O01IlIlI0OIO01l=(OlI1OI1lO0lO10I);assign IIO0lI01lOOI01l
=(IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I)?t_be_b:
OI01lIOIl0OlI01;assign OOIl1OlI1Ol10IO=m_hresp[0]&~m_hresp[1];assign l10IOI01lOOOIl1
=(O01IlO1lIOl10IO&OOIl1OlI1Ol10IO)|
(lIO10lO10IO1lIO&OOIl1OlI1Ol10IO)|
(I01lOIO01lO01Il&OOIl1OlI1Ol10IO)|
(OOl1IIlI0OOIl01&O01IlIO01lIlO01&~IOIl0I1lO0OOIl1);assign lIO10l10IOlO10I
=(IOIl0OI01lOlI01)?OIl01IOIl0OIl01:
(O1lIOIlO01OI01l)?OI01lI01lOO01Il:
(I01lOIlI0OOlI01)?I1lO0IO0lIlIO10-5'b00001:I1lO0IO0lIlIO10;dff32 IOI01lO01IllO10I
(OIl01IO01lIOIl0,OlI01OlI01IIO0l,clk,reset_b,1'b1);dff3 IIO01ll0IO1OI01l(l0IO1IO01lOI01l,lO10IOlI01IlI0O,clk,reset_b,1'b1);dff5 IOI01lIO01lIO0lI
(O1lIOOI01lIlI0O,OOl1IIlO01IOIl0,clk,reset_b,1'b1);assign t_err_b=~(~O01IlIO01lIlO01&OOl1IIlI0OOIl01);assign m_hlock=0;assign lIO10OOl1IOI01l
=(IlO01IlO01IlO01&~l10IOlIO10lO10I&IO01lI01lOI01lO&~m_hgrant)|
(OlI1OI1lO0lO10I&~m_hgrant)|
(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&~m_hgrant&O1lIOl10IOIlO01)|
(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~IOIl0I1lO0OOIl1&~m_hgrant)|
(I01lOO01IlIO01l&~m_hgrant);dff IOI01lO1lIOOOl1I
(OOl1IIlI0OOIl01,l10IOI01lOOOIl1,clk,reset_b,1'b1);assign l0IO1O1lIOIO0lI=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign l0IO1l0IO1IlO01[1:0]
=(IO0lIl0IO1lO10I)?t_adr[1:0]:I01lOIO0lIOOl1I[1:0];assign l10IOIOIl0OOl1I
=
(OlI01I1lO0I01lO)?OOl1IIO0lIOlI1O:
(I1lO0lO10IIIO0l==5'b00010)?3'b000:
(I1lO0lO10IIIO0l==5'b00101)?3'b011:
(I1lO0lO10IIIO0l==5'b01001)?3'b101:
(I1lO0lO10IIIO0l==5'b10001)?3'b111:
3'b001;dffe IIlO01OlI1OOOl1I
(OOl1IOOl1IlIO10,I01lOOIl01lO10I,clk,reset_b,1'b1,IlO01IlO01IlO01);assign O1lIOOOl1Il10IO
=(((big_endian==1'b0)&&(IlI0OIlI0OI1lO0==4'b0111))||
((big_endian==1'b1)&&(IlI0OIlI0OI1lO0==4'b1110)))?2'b11:
(((big_endian==1'b0)&&(IlI0OIlI0OI1lO0==4'b1011))||
((big_endian==1'b1)&&(IlI0OIlI0OI1lO0==4'b1101)))?2'b10:
(((big_endian==1'b0)&&(IlI0OIlI0OI1lO0==4'b1101))||
((big_endian==1'b1)&&(IlI0OIlI0OI1lO0==4'b1011)))?2'b01:
(((big_endian==1'b0)&&(IlI0OIlI0OI1lO0==4'b1110))||
((big_endian==1'b1)&&(IlI0OIlI0OI1lO0==4'b0111)))?2'b00:
(((big_endian==1'b0)&&(IlI0OIlI0OI1lO0==4'b0011))||
((big_endian==1'b1)&&(IlI0OIlI0OI1lO0==4'b1100)))?2'b10:
2'b00;dff IIlI0Ol10IOOI01l
(I01lOO01IlIO01l,lIO10OOl1IOI01l,clk,reset_b,1'b1);assign IOIl0OI01lOlI01=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign IO0lIOIl01O1lIO[3:0]
=(IO0lIl0IO1lO10I)?t_adr[3:0]:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{IlI0OOOl1IIO0lI[3:2],IlI0OOOl1IIO0lI[1:0]+2'b01}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{IlI0OOOl1IIO0lI[3],IlI0OOOl1IIO0lI[2:0]+3'b001}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?IlI0OOOl1IIO0lI[3:0]+4'b0001:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{IlI0OOOl1IIO0lI[3:2],IlI0OOOl1IIO0lI[1:0]-2'b01}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{IlI0OOOl1IIO0lI[3],IlI0OOOl1IIO0lI[2:0]-3'b001}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?IlI0OOOl1IIO0lI[3:0]-4'b0001:
IlI0OOOl1IIO0lI[3:0];assign O01IlOOl1IIOIl0
=(IOIl0lO10IlO10I==2'b00)?3'b000:
(IOIl0lO10IlO10I==2'b01)?3'b001:
OlI01OOIl1lIO10;dff2 IIOIl0OlI01O1lIO
(IO0lIO1lIOOIl01,IOIl0lO10IlO10I,clk,reset_b,1'b1);assign OOIl1IOIl0IO01l=OI01ll0IO1OOIl1|(~IOIl0IIO0lOOl1I&O1lIOl10IOIlO01);assign lO10IlIO10O01Il
=(lO10IlO10II1lO0)?2'b10:
(O01IlO1lIOl10IO&~(OOIl1O01IlIlI0O&O1lIOl10IOIlO01))?2'b11:
(lIO10lO10IO1lIO)?2'b01:
2'b00;assign IIO0llIO10IIO0l
=(lO10IlO10II1lO0&m_hready&m_hgrant&~IO01lO01IlIIO0l)|
(lO10IlO10II1lO0&m_hready&m_hgrant&~IOIl0I1lO0OOIl1&OOIl1O01IlIlI0O&IO01lO01IlIIO0l)|
(lO10IlO10II1lO0&m_hready&IOIl0I1lO0OOIl1)|
(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&~OOIl1O01IlIlI0O&m_hgrant&~IO01lO01IlIIO0l)|
(O01IlO1lIOl10IO&IO01llIO10l0IO1&~m_hready)|

(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&~O1lIOl10IOIlO01)|

(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&~m_hready&~t_busy)|
(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&~OOIl1O01IlIlI0O&m_hgrant&~t_busy)|
(lIO10lO10IO1lIO&~O1lIOl10IOIlO01&m_hgrant&~t_busy&IO01llIO10l0IO1);dffe IO1lIOIO0lIIO01l
(O01IlIO01lIlO01,t_wr,clk,reset_b,1'b1,OI01lOlI01IO01l);assign IlO01IIO0lOlI01
=(IO0lIl0IO1lO10I)?t_adr[31:0]:
(OlI1OIIO0lOIl01)?OOIl1l0IO1O01Il+32'h00000001:
(IlO01I1lO0O01Il)?OOIl1l0IO1O01Il-32'h00000001:
OOIl1l0IO1O01Il;assign IlI0OO1lIOlIO10
=(OlI01I1lO0I01lO)?OlI01lO10Il0IO1:lO10IOOIl1l10IO;assign I1lO0IlO01I01lO=IIO0lIIO0llIO10;dffe4 II1lO0lO10IIlO01
(IlI0OIlI0OI1lO0,IO0lIIO01ll10IO,clk,1'b1,reset_b,OlI1OOlI01l0IO1);assign m_hburst
=(lO10II1lO0IlO01)?OOl1IIO0lIOlI1O:
IIO0lOlI1OIO0lI;dff IOOl1IOI01lIIO0l(O01IlO1lIOl10IO,IIO0llIO10IIO0l,clk,reset_b,1'b1);assign OI01lI01lOO01Il
=IlO01OOIl1IOIl0;assign IlO01lIO10OOIl1[4:1]
=(IO0lIl0IO1lO10I)?t_adr[4:1]:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{OlI1OOlI1OOlI1O[4:3],OlI1OOlI1OOlI1O[2:1]+2'b01}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{OlI1OOlI1OOlI1O[4],OlI1OOlI1OOlI1O[3:1]+3'b001}:
((OlI1OIIO0lOIl01==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?OlI1OOlI1OOlI1O[4:1]+4'b0001:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b00100))?{OlI1OOlI1OOlI1O[4:3],OlI1OOlI1OOlI1O[2:1]-2'b01}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b01000))?{OlI1OOlI1OOlI1O[4],OlI1OOlI1OOlI1O[3:1]-3'b001}:
((IlO01I1lO0O01Il==1'b1)&(OOl1IIlO01IOIl0<=5'b10000))?OlI1OOlI1OOlI1O[4:1]-4'b0001:
OlI1OOlI1OOlI1O[4:1];assign lO10II1lO0IlO01
=IlI0OOIl01IIO0l;dff IIO0lIOOl1IOlI1O(l10IOlIO10lO10I,lIO10IO0lIOIl01,clk,1'b1,reset_b);assign t_drd=m_hrdata;assign OOl1Il10IOO1lIO
=(IlI0Ol0IO1l0IO1&m_hready)|
(IIO0lIIO0llIO10&~l0IO1O01IlI1lO0)|
(I01lOIO01lO01Il&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&~IOIl0I1lO0OOIl1)|
(I01lOIO01lO01Il&~O1lIOl10IOIlO01&IO01llIO10l0IO1);assign I1lO0OI01lI1lO0
=~OIl01O01Ill0IO1&(lIO10IlO01l10IO|IO01lI01lOI01lO);dff32 IO01IlIlO01lIO10(I1lO0I1lO0OI01l,l0IO1IlI0OIlI0O,clk,reset_b,1'b1);assign IO0lIl0IO1lO10I
=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign OOl1IOIl01l0IO1
=(IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I)|
(O01IlIO01lIlO01&O1lIOl10IOIlO01&m_hready&IO01llIO10l0IO1&~IOIl0I1lO0OOIl1&~OOl1IOOl1IlIO10);dff IOIl01l0IO1I01lO
(lO10IIIO0lIO01l,OlI01I1lO0I01lO,clk,reset_b,1'b1);assign m_hwrite=l10IOOlI1OOIl01;dff IlIO10OOIl1OlI1O
(IIO0lIIO0llIO10,OOl1Il10IOO1lIO,clk,reset_b,1'b1);dff5 Il10IOI01lOl10IO(I1lO0lO10IIIO0l,IlO01OOIl1IOIl0,clk,reset_b,1'b1);assign l0IO1l0IO1IlO01[31:6]
=(IO0lIl0IO1lO10I)?t_adr[31:6]:
I01lOIO0lIOOl1I[31:6];assign I01lOl10IOOOIl1
=
(OlI01I1lO0I01lO)?OOl1IIO0lIOlI1O:
((OlI01I1lO0I01lO==1'b0)&&(IlO01OOIl1IOIl0==5'b00001))?3'b000:
((OlI01I1lO0I01lO==1'b0)&&(IlO01OOIl1IOIl0==5'b00100))?3'b011:
((OlI01I1lO0I01lO==1'b0)&&(IlO01OOIl1IOIl0==5'b01000))?3'b101:
((OlI01I1lO0I01lO==1'b0)&&(IlO01OOIl1IOIl0==5'b10000))?3'b111:
3'b001;dff4 IOOIl1OIl01OOIl1
(OI01lIOIl0OlI01,IIO0lI01lOOI01l,clk,1'b1,reset_b);assign O1lIOOIl01I1lO0=~m_hresp[0]&m_hresp[1];assign lIO10OI01lOOl1I
=(lO10IlO10II1lO0&m_hready&~IOIl0I1lO0OOIl1&~m_hgrant)|
(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&~OOIl1O01IlIlI0O&~m_hgrant)|
(I01lOIO01lO01Il&O1lIOl10IOIlO01&IO01llIO10l0IO1&~m_hready)|
(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&~m_hgrant&~OOIl1O01IlIlI0O)|
(lIO10lO10IO1lIO&~O1lIOl10IOIlO01&~m_hgrant);dff5 IIO01lIOIl0I1lO0
(I1lO0IO0lIlIO10,lIO10l10IOlO10I,clk,reset_b,1'b1);assign lO10IOOIl1l10IO
=(IOIl0lO10IlO10I==2'b00)?OOIl1l0IO1O01Il:
(IOIl0lO10IlO10I==2'b01)?I1lO0I1lO0OI01l:
OIl01IO01lIOIl0;assign IlI0OOIl01IIO0l
=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign OOl1IIlO01IOIl0
=(IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I)?t_trans:O1lIOOI01lIlI0O;assign OI01ll0IO1OOIl1=lO10IlIO10O01Il[1]&m_hready;assign m_hprot
=4'b0011;assign O01IlOIl01IlI0O
=(I01lOO01IlIO01l&m_hgrant&~m_hready)|
(IlO01IlO01IlO01&~l10IOlIO10lO10I&IO01lI01lOI01lO&m_hgrant&~m_hready)|
(OlI1OI1lO0lO10I&m_hgrant&~m_hready)|
(l10IOOOIl1I01lO&~m_hready)|
(l10IOOOIl1I01lO&~m_hgrant);dff IIIO0llIO10IlO01
(I01lOIO01lO01Il,lIO10OI01lOOl1I,clk,reset_b,1'b1);assign OIl01l0IO1O1lIO
=
((t_hsize==2'b10)&&(IIO0lOlI01I1lO0==1'b1)&&(t_wr==1'b1)&&((t_be_b==4'b0000)||(t_be_b==4'b0011)||(t_be_b==4'b0111)||
(t_be_b==4'b1011)||(t_be_b==4'b1101)||(t_be_b==4'b1110)||(t_be_b==4'b1100)))?
5'b00001:
((t_hsize==2'b10)&&(IIO0lOlI01I1lO0==1'b1)&&(t_wr==1'b0))?5'b00001:
((t_hsize==2'b10)&&(IIO0lOlI01I1lO0==1'b1))?5'b00010:
t_trans;dff32 IOOIl1O1lIOOlI01
(I01lOIO0lIOOl1I,l0IO1l0IO1IlO01,clk,reset_b,1'b1);assign OOIl1I01lOIlO01
=(IlO01OI01lIO01l)?1'b0:
(I1lO0IlO01I01lO)?~IO0lIIlI0OOOl1I:IO0lIIlI0OOOl1I;assign OlI1OOlI01l0IO1
=IlO01IlO01IlO01|((O01IlO1lIOl10IO|I01lOIO01lO01Il)&IO01llIO10l0IO1&m_hready);assign m_haddr[31:2]
=(IO0lIl0IO1lO10I)?t_adr[31:2]:
IlI0OO1lIOlIO10[31:2];dff IIIO0lIOIl0IlI0O(l10IOOOIl1I01lO,O01IlOIl01IlI0O,clk,reset_b,1'b1);assign OIl01IOIl0OIl01
=t_trans;dff32 IIOIl0OOIl1OIl01(IlI0OOOl1IIO0lI,IO0lIOIl01O1lIO,clk,reset_b,1'b1);assign OlI1OlIO10O1lIO
=(lO10II1lO0IlO01)?OOl1IIO0lIOlI1O:
(IlI0OIO01lI01lO)?l10IOIOIl0OOl1I:
(O01IlIlI0OIO01l)?I01lOl10IOOOIl1:
IIO0lOlI1OIO0lI;assign IOIl0lO10IlO10I
=(IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I)?t_hsize:IO0lIO1lIOOIl01;dff IOlI01IIO0lI1lO0
(O1lIOl10IOIlO01,OOIl1IOIl0IO01l,clk,reset_b,1'b1);assign m_htrans=lO10IlIO10O01Il;assign OIl01O1lIOOlI1O
=
(lO10IlO10II1lO0&m_hready&m_hgrant&~IOIl0I1lO0OOIl1&~OOIl1O01IlIlI0O&IO01lO01IlIIO0l)|
(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&m_hgrant&~OOIl1O01IlIlI0O&IO01lO01IlIIO0l)|
(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&~m_hready&t_busy)|
(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&~OOIl1O01IlIlI0O&m_hgrant&t_busy)|
(lIO10lO10IO1lIO&~O1lIOl10IOIlO01&m_hgrant&t_busy&IO01llIO10l0IO1);assign lIO10IlO01l10IO
=(IOIl0I1lO0OOIl1&O1lIOl10IOIlO01&m_hready)|
(OOl1IIlI0OOIl01&O01IlIO01lIlO01&IOIl0I1lO0OOIl1);dff32 IlIO10OI01ll0IO1
(OOIl1l0IO1O01Il,IlO01IIO0lOlI01,clk,reset_b,1'b1);assign OlI1OIIO0lOIl01=OI01ll0IO1OOIl1&~OOl1IOOl1IlIO10;assign IlO01OI01lIO01l
=IlI0Ol0IO1l0IO1&OOl1Il10IOO1lIO;assign I1lO0OOIl1IO0lI=(IlO01IlO01IlO01)?t_busy:
IO01lO01IlIIO0l;assign m_hsize
=(IlI0OOIl01IIO0l)?O01IlOOl1IIOIl0:
l0IO1IO01lOI01l;dff II01lOIlO01IO0lI(lIO10lO10IO1lIO,OIl01O1lIOOlI1O,clk,reset_b,1'b1);assign OOIl1O01IlIlI0O
=(I1lO0IO0lIlIO10==5'b00001)?1'b1:1'b0;assign IlO01lIO10OOIl1[0]=(IO0lIl0IO1lO10I)?t_adr[0]:I01lOIO0lIOOl1I[0];assign OOl1IIO0lIOlI1O
=
((OlI01I1lO0I01lO==1'b1)&&(OOl1IIlO01IOIl0==5'b00001))?3'b000:
((OlI01I1lO0I01lO==1'b1)&&(OOl1IIlO01IOIl0<=5'b00100))?3'b010:
((OlI01I1lO0I01lO==1'b1)&&(OOl1IIlO01IOIl0<=5'b01000))?3'b100:
((OlI01I1lO0I01lO==1'b1)&&(OOl1IIlO01IOIl0<=5'b10000))?3'b110:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0==5'b00001))?3'b000:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0<5'b00100))?3'b001:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0==5'b00100))?3'b011:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0<5'b01000))?3'b001:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0==5'b01000))?3'b101:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0<5'b10000))?3'b001:
((OlI01I1lO0I01lO==1'b0)&&(OOl1IIlO01IOIl0==5'b10000))?3'b111:
3'b001;assign O01Ill10IOO01Il
=IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I;assign IO01llIO10l0IO1=~m_hresp[0]&~m_hresp[1];assign IO01lIOIl0OlI1O
=(IIO0lIIO0llIO10&l0IO1O01IlI1lO0);dff IOOl1Il10IOI01lO(IO01lI01lOI01lO,I1lO0OI01lI1lO0,clk,1'b1,reset_b);assign OlI01OlI01IIO0l
=(IO0lIl0IO1lO10I)?t_adr[31:0]:
(OlI1OIIO0lOIl01)?OIl01IO01lIOIl0+32'h00000004:
(IlO01I1lO0O01Il)?OIl01IO01lIOIl0-32'h00000004:
OIl01IO01lIOIl0;assign lO10IOlI01IlI0O
=(IlI0OOIl01IIO0l|O1lIOIlO01OI01l)?O01IlOOl1IIOIl0:
l0IO1IO01lOI01l;dffe32 IOIl01IlI0OIIO0l
(IO01lOlI1OlIO10,t_dwr,clk,reset_b,1'b1,OOl1IOIl01l0IO1);assign OlI01I1lO0I01lO
=(IlO01IlO01IlO01&IO01lI01lOI01lO&~l10IOlIO10lO10I)?t_wrap:lO10IIIO0lIO01l;assign m_hbusreq
=(~IlO01IlO01IlO01&~IIO0lIIO0llIO10&~OOl1IIlI0OOIl01)|(lO10II1lO0IlO01);assign l10IOOlI01OlI01
=(IlO01IlO01IlO01&l10IOlIO10lO10I)|
(IlO01IlO01IlO01&~l10IOlIO10lO10I&~IO01lI01lOI01lO)|
(OOl1IIlI0OOIl01&~O01IlIO01lIlO01)|
(OOl1IIlI0OOIl01&O01IlIO01lIlO01&IOIl0I1lO0OOIl1)|

(O01IlO1lIOl10IO&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&IOIl0I1lO0OOIl1&O1lIOl10IOIlO01)|

(lIO10lO10IO1lIO&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&OOIl1O01IlIlI0O&IOIl0I1lO0OOIl1)|
(I01lOIO01lO01Il&O1lIOl10IOIlO01&IO01llIO10l0IO1&m_hready&IOIl0I1lO0OOIl1);
endmodule 
