// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module pcimodel(
adin,
adout,
cbein_b,
cbeout_b,
clk,
devselin_b,
devselout_b,
framein_b,
frameout_b,
gnt_b,
idsel,
intaout_b,
irdyin_b,
irdyout_b,
parin,
parout,
perrin_b,
perrout_b,
reqout_b,
reset_b,
serrout_b,
stopin_b,
stopout_b,
trdyin_b,
trdyout_b,

h_abort_b,
h_adsh_b,
h_adsm_b,
h_ain,
h_aout,
h_bein_b,
h_beout_b,
h_bii_b,
h_blast_b,
h_boff_b,
h_cacheline,
h_cache_size,
h_cmd,
h_cs_b,
h_din,
h_done_b,
h_dout,
h_inta_b,
h_mio,
h_rdyh_b,
h_rdym_b,
h_retry_b,
h_size,
h_wait_b,
h_wrin,
h_wrout,

oe_ad,
oe_cbe,
oe_devsel,
oe_frame,
oe_irdy,
oe_par,
oe_perr,
oe_req,
oe_stop,
oe_trdy,

device_id,
vendor_id,
class_code,
revision_id,
interrupt_pin,
subsystem_id,
subvendor_id,
run_66mhz
);
input[31:0] adin;
output[31:0] adout;
input[3:0] cbein_b;
output[3:0] cbeout_b;
input clk;
input devselin_b;
output devselout_b;
input framein_b;
output frameout_b;
input gnt_b;
input idsel;
output intaout_b;
input irdyin_b;
output irdyout_b;
input parin;
output parout;
input perrin_b;
output perrout_b;
output reqout_b;
input reset_b;
output serrout_b;
input stopin_b;
output stopout_b;
input trdyin_b;
output trdyout_b;
input h_abort_b;
input h_adsh_b;
output h_adsm_b;
input[31:0] h_ain;
output[31:0] h_aout;
input[3:0] h_bein_b;
output[3:0] h_beout_b;
input h_bii_b;
input h_blast_b;
output h_boff_b;
input h_cacheline;
output[7:0] h_cache_size;
input[1:0] h_cmd;
output[1:0] h_cs_b;
input[31:0] h_din;
output h_done_b;
output[31:0] h_dout;
input h_inta_b;
input h_mio;
input h_rdyh_b;
output h_rdym_b;
input h_retry_b;
input[15:0] h_size;
input h_wait_b;
input h_wrin;
output h_wrout;
output oe_ad;
output oe_cbe;
output oe_devsel;
output oe_frame;
output oe_irdy;
output oe_par;
output oe_perr;
output oe_req;
output oe_stop;
output oe_trdy;
input[15:0] device_id;
input[15:0] vendor_id;
input[23:0] class_code;
input[7:0] revision_id;
input[7:0] interrupt_pin;
input[15:0] subsystem_id;
input[15:0] subvendor_id;
input run_66mhz;
wire OI01lIOIl0lO10I;wire OI01lOlI1OlO10I;wire I1lO0OlI01IIO0l;wire IlI0OIO01llO10I;wire I1lO0IIO0lIIO0l;wire[31:0] IlI0Ol0IO1lO10I;
wire[7:0] I1lO0OOIl1IIO0l;wire[3:0] IlI0OO01IllO10I;wire l10IOI01lOIIO0l;wire l10IOlIO10IIO0l;wire O1lIOIlO01IO01l;wire l10IOOlI01IIO0l;
wire[31:0] O1lIOl10IOIO01l;wire l10IOIIO0lIIO0l;wire O1lIOOIl01IO01l;wire[3:0] l10IOOOIl1IIO0l;wire O1lIOIlI0OIO01l;wire O1lIOO1lIOIO01l;
wire OlI1OIlO01IO01l;wire[31:0] OIl01IOIl0OIl01;wire OlI1Ol10IOIO01l;wire OIl01OlI1OOIl01;wire OlI1OOIl01IO01l;wire O01IlIO01lOIl01;
wire O01Ill0IO1OIl01;wire O01IlO01IlOIl01;wire[31:0] IO01lI01lOIO0lI;wire[15:0] O01IlIOIl0OIl01;wire[7:0] IO01llIO10IO0lI;wire O01IlOlI1OOIl01;
wire IO01lOlI01IO0lI;wire[31:0] IO01lIIO0lIO0lI;wire IO01lOOIl1IO0lI;wire[31:0] IOIl0IlI0OI01lO;wire I01lOI01lOIO0lI;wire IOIl0O1lIOI01lO;
wire I01lOlIO10IO0lI;wire[31:2] IIO0lIlO01I01lO;wire[2:0] IIO0ll10IOI01lO;wire IIO0lOIl01I01lO;wire[31:0] lIO10IO01lO01Il;wire IIO0lIlI0OI01lO;
wire lIO10l0IO1O01Il;wire IIO0lO1lIOI01lO;wire lIO10O01IlO01Il;wire lIO10IOIl0O01Il;wire lIO10OlI1OO01Il;wire OOIl1OlI01O1lIO;wire lO10IIO01lO01Il;
wire OOIl1IIO0lO1lIO;wire lO10Il0IO1O01Il;wire[7:0] OOIl1OOIl1O1lIO;wire lO10IO01IlO01Il;wire OOl1II01lOO1lIO;wire OOl1IlIO10O1lIO;
wire OI01lIlO01I1lO0;wire OOl1IOlI01O1lIO;wire[31:0] OI01ll10IOI1lO0;wire OOl1IIIO0lO1lIO;wire OI01lOIl01I1lO0;wire[35:0] OOl1IOOIl1O1lIO;
wire OI01lIlI0OI1lO0;wire OI01lO1lIOI1lO0;wire IlI0OIlO01I1lO0;wire[31:0] I1lO0IOIl0OlI01;wire IlI0Ol10IOI1lO0;wire[3:0] I1lO0OlI1OOlI01;
wire IlI0OOIl01I1lO0;wire l10IOIO01lOlI01;wire l10IOl0IO1OlI01;wire l10IOO01IlOlI01;wire[31:0] O1lIOI01lOOlI1O;wire l10IOIOIl0OlI01;
wire O1lIOlIO10OlI1O;wire l10IOOlI1OOlI01;wire O1lIOOlI01OlI1O;wire[3:0] O1lIOIIO0lOlI1O;wire O1lIOOOIl1OlI1O;wire[31:0] OIl01IlI0Ol10IO;
wire OlI1OI01lOOlI1O;wire[1:0] OIl01O1lIOl10IO;wire OlI1OlIO10OlI1O;wire O01IlIlO01l10IO;wire O01Ill10IOl10IO;wire O01IlOIl01l10IO;
wire[31:0] IO01lIO01lOI01l;wire O01IlIlI0Ol10IO;wire IO01ll0IO1OI01l;wire O01IlO1lIOl10IO;wire IO01lO01IlOI01l;wire IO01lIOIl0OI01l;
wire[31:0] IO01lOlI1OOI01l;wire IOIl0OlI01OOIl1;wire I01lOIO01lOI01l;wire IOIl0IIO0lOOIl1;wire I01lOl0IO1OI01l;wire IOIl0OOIl1OOIl1;
wire I01lOO01IlOI01l;wire IIO0lI01lOOOIl1;wire IIO0llIO10OOIl1;wire lIO10IlO01l0IO1;wire IIO0lOlI01OOIl1;wire[31:0] lIO10l10IOl0IO1;
wire IIO0lIIO0lOOIl1;wire lIO10OIl01l0IO1;wire IIO0lOOIl1OOIl1;wire lIO10IlI0Ol0IO1;wire lIO10O1lIOl0IO1;wire lO10IIlO01l0IO1;wire[31:0] OOIl1IOIl0IlI0O;
wire lO10Il10IOl0IO1;wire[31:0] OOIl1OlI1OIlI0O;wire lO10IOIl01l0IO1;wire OOl1IIO01lIlI0O;wire OOl1Il0IO1IlI0O;wire OOl1IO01IlIlI0O;
wire[31:0] OI01lI01lOOOl1I;wire OOl1IIOIl0IlI0O;wire OI01llIO10OOl1I;wire[31:13] OOl1IOlI1OIlI0O;wire[35:0] OI01lOlI01OOl1I;wire OI01lIIO0lOOl1I;
wire OI01lOOIl1OOl1I;wire[31:0] I1lO0IlI0OlIO10;wire IlI0OI01lOOOl1I;wire[1:0] I1lO0O1lIOlIO10;wire IlI0OlIO10OOl1I;wire l10IOIlO01lIO10;
wire[3:0] l10IOl10IOlIO10;wire[7:0] l10IOOIl01lIO10;wire[31:0] O1lIOIO01lIOIl0;wire l10IOIlI0OlIO10;wire O1lIOl0IO1IOIl0;wire l10IOO1lIOlIO10;
wire O1lIOO01IlIOIl0;wire O1lIOIOIl0IOIl0;wire O1lIOOlI1OIOIl0;wire OIl01OI01lIlO01;wire OlI1OIO01lIOIl0;wire OIl01IO0lIIlO01;wire OlI1Ol0IO1IOIl0;
wire OIl01OOl1IIlO01;wire OlI1OO01IlIOIl0;wire O01IlI1lO0IlO01;wire O01IllO10IIlO01;wire IO01lIlO01lO10I;wire O01IlOI01lIlO01;wire[31:0] IO01ll10IOlO10I;
wire O01IlIO0lIIlO01;wire IO01lOIl01lO10I;wire[31:13] O01IlOOl1IIlO01;wire IO01lIlI0OlO10I;wire IO01lO1lIOlO10I;wire I01lOIlO01lO10I;
wire[31:0] IOIl0IOIl0IIO0l;wire I01lOl10IOlO10I;wire IOIl0OlI1OIIO0l;wire I01lOOIl01lO10I;wire IIO0lIO01lIIO0l;wire IIO0ll0IO1IIO0l;
wire IIO0lO01IlIIO0l;wire[31:0] lIO10I1lO0IO01l;wire IIO0lIOIl0IIO0l;wire lIO10lO10IIO01l;wire IIO0lOlI1OIIO0l;wire lIO10OI01lIO01l;
wire[7:0] lIO10IO0lIIO01l;wire lIO10OOl1IIO01l;wire[31:0] OOIl1IlI0OOIl01;wire lO10II1lO0IO01l;wire OOIl1O1lIOOIl01;wire lO10IlO10IIO01l;
wire OOl1IIlO01OIl01;wire OOl1Il10IOOIl01;wire[7:0] OOl1IOIl01OIl01;wire[31:0] OI01lIO01lIO0lI;wire OOl1IIlI0OOIl01;wire OI01ll0IO1IO0lI;
wire OOl1IO1lIOOIl01;wire OI01lO01IlIO0lI;wire OI01lIOIl0IO0lI;wire OI01lOlI1OIO0lI;wire I1lO0OI01lI01lO;wire IlI0OIO01lIO0lI;wire I1lO0IO0lII01lO;
wire IlI0Ol0IO1IO0lI;wire[31:2] I1lO0OOl1II01lO;wire IlI0OO01IlIO0lI;wire l10IOI1lO0I01lO;wire l10IOlO10II01lO;wire O1lIOIlO01O01Il;
wire l10IOOI01lI01lO;wire[31:0] O1lIOl10IOO01Il;wire l10IOIO0lII01lO;wire O1lIOOIl01O01Il;wire l10IOOOl1II01lO;wire O1lIOIlI0OO01Il;
wire O1lIOO1lIOO01Il;wire OlI1OIlO01O01Il;wire[31:0] OIl01IOIl0O1lIO;wire OlI1Ol10IOO01Il;wire OIl01OlI1OO1lIO;wire OlI1OOIl01O01Il;
wire O01IlIO01lO1lIO;wire O01Ill0IO1O1lIO;wire O01IlO01IlO1lIO;wire[31:0] IO01lI1lO0I1lO0;wire O01IlIOIl0O1lIO;wire IO01llO10II1lO0;
wire[3:0] O01IlOlI1OO1lIO;wire IO01lOI01lI1lO0;wire IO01lIO0lII1lO0;wire IO01lOOl1II1lO0;wire[31:0] IOIl0IlI0OOlI01;wire I01lOI1lO0I1lO0;
wire IOIl0O1lIOOlI01;wire[31:0] I01lOlO10II1lO0;wire IIO0lIlO01OlI01;wire IIO0ll10IOOlI01;wire IIO0lOIl01OlI01;wire[31:0] lIO10IO01lOlI1O;
wire[15:0] IIO0lIlI0OOlI01;wire lIO10l0IO1OlI1O;wire IIO0lO1lIOOlI01;wire lIO10O01IlOlI1O;wire lIO10IOIl0OlI1O;wire lIO10OlI1OOlI1O;
wire OOIl1OI01ll10IO;wire lO10IIO01lOlI1O;wire OOIl1IO0lIl10IO;wire lO10Il0IO1OlI1O;wire OOIl1OOl1Il10IO;wire lO10IO01IlOlI1O;wire OOl1II1lO0l10IO;
wire OOl1IlO10Il10IO;wire OI01lIlO01OI01l;wire OOl1IOI01ll10IO;wire[31:0] OI01ll10IOOI01l;wire[31:0] OOl1IIO0lIl10IO;wire OI01lOIl01OI01l;
wire OOl1IOOl1Il10IO;wire OI01lIlI0OOI01l;wire OI01lO1lIOOI01l;wire I1lO0O01IlOOIl1;wire IlI0OIlO01OI01l;wire[31:0] I1lO0IOIl0OOIl1;
wire IlI0Ol10IOOI01l;wire I1lO0OlI1OOOIl1;wire IlI0OOIl01OI01l;wire l10IOIO01lOOIl1;wire l10IOl0IO1OOIl1;wire l10IOO01IlOOIl1;wire[31:0] O1lIOI1lO0l0IO1;
wire l10IOIOIl0OOIl1;wire O1lIOlO10Il0IO1;wire l10IOOlI1OOOIl1;wire O1lIOOI01ll0IO1;wire O1lIOIO0lIl0IO1;wire O1lIOOOl1Il0IO1;wire[31:0] OIl01IlI0OIlI0O;
wire OlI1OI1lO0l0IO1;wire OIl01O1lIOIlI0O;wire[15:0] OlI1OlO10Il0IO1;wire O01IlIlO01IlI0O;wire[31:2] O01Ill10IOIlI0O;wire O01IlOIl01IlI0O;
wire[31:0] IO01lIO01lOOl1I;wire O01IlIlI0OIlI0O;wire IO01ll0IO1OOl1I;wire O01IlO1lIOIlI0O;wire IO01lO01IlOOl1I;wire IO01lIOIl0OOl1I;
wire IO01lOlI1OOOl1I;wire IOIl0OI01llIO10;wire I01lOIO01lOOl1I;wire[1:0] IOIl0IO0lIlIO10;wire I01lOl0IO1OOl1I;wire IOIl0OOl1IlIO10;
wire I01lOO01IlOOl1I;wire IIO0lI1lO0lIO10;wire IIO0llO10IlIO10;wire lIO10IlO01IOIl0;wire IIO0lOI01llIO10;wire lIO10l10IOIOIl0;wire[31:0] IIO0lIO0lIlIO10;
wire lIO10OIl01IOIl0;wire IIO0lOOl1IlIO10;wire lIO10IlI0OIOIl0;wire lIO10O1lIOIOIl0;wire OOIl1OlI01IlO01;wire lO10IIlO01IOIl0;wire[31:0] OOIl1IIO0lIlO01;
wire lO10Il10IOIOIl0;wire OOIl1OOIl1IlO01;wire lO10IOIl01IOIl0;wire OOl1II01lOIlO01;wire OOl1IlIO10IlO01;wire OOl1IOlI01IlO01;wire[31:0] OI01lI1lO0lO10I;
wire OOl1IIIO0lIlO01;wire[1:0] OI01llO10IlO10I;wire OOl1IOOIl1IlO01;wire OI01lOI01llO10I;wire OI01lIO0lIlO10I;wire OI01lOOl1IlO10I;
wire[31:0] I1lO0IlI0OIIO0l;wire[15:0] IlI0OI1lO0lO10I;wire[7:0] I1lO0O1lIOIIO0l;wire[3:0] IlI0OlO10IlO10I;wire l10IOIlO01IIO0l;wire[31:0] l10IOl10IOIIO0l;
wire l10IOOIl01IIO0l;wire[31:0] O1lIOI01lOIO01l;wire l10IOIlI0OIIO0l;wire O1lIOlIO10IO01l;wire l10IOO1lIOIIO0l;wire[31:2] O1lIOOlI01IO01l;
wire[2:0] O1lIOIIO0lIO01l;wire O1lIOOOIl1IO01l;wire OIl01OI01lOIl01;wire OlI1OI01lOIO01l;wire OIl01IO0lIOIl01;wire OlI1OlIO10IO01l;
wire OIl01OOl1IOIl01;wire O01IlI1lO0OIl01;wire O01IllO10IOIl01;wire IO01lIlO01IO0lI;wire O01IlOI01lOIl01;wire IO01ll10IOIO0lI;wire[31:0] O01IlIO0lIOIl01;
wire[7:0] IO01lOIl01IO0lI;wire[3:0] O01IlOOl1IOIl01;wire IO01lIlI0OIO0lI;wire IO01lO1lIOIO0lI;wire IOIl0OlI01I01lO;wire I01lOIlO01IO0lI;
wire[31:0] IOIl0IIO0lI01lO;wire I01lOl10IOIO0lI;wire IOIl0OOIl1I01lO;wire[31:0] I01lOOIl01IO0lI;wire IIO0lI01lOI01lO;wire IIO0llIO10I01lO;
wire IIO0lOlI01I01lO;wire[31:0] lIO10I1lO0O01Il;wire IIO0lIIO0lI01lO;wire[31:0] lIO10lO10IO01Il;wire IIO0lOOIl1I01lO;wire lIO10OI01lO01Il;
wire lIO10IO0lIO01Il;wire lIO10OOl1IO01Il;wire[31:0] OOIl1IlI0OO1lIO;wire[15:0] lO10II1lO0O01Il;wire[3:0] OOIl1O1lIOO1lIO;wire lO10IlO10IO01Il;
wire OOl1IIlO01O1lIO;wire[3:0] OOl1Il10IOO1lIO;wire OOl1IOIl01O1lIO;wire[31:0] OI01lI01lOI1lO0;wire OOl1IIlI0OO1lIO;wire[31:0] OI01llIO10I1lO0;
wire OOl1IO1lIOO1lIO;wire[3:0] OI01lOlI01I1lO0;wire OI01lIIO0lI1lO0;wire OI01lOOIl1I1lO0;wire[31:0] I1lO0OI01lOlI01;wire IlI0OI01lOI1lO0;
wire I1lO0IO0lIOlI01;wire IlI0OlIO10I1lO0;wire I1lO0OOl1IOlI01;wire l10IOI1lO0OlI01;wire l10IOlO10IOlI01;wire O1lIOIlO01OlI1O;wire l10IOOI01lOlI01;
wire O1lIOl10IOOlI1O;wire l10IOIO0lIOlI01;wire[7:0] O1lIOOIl01OlI1O;wire l10IOOOl1IOlI01;wire O1lIOIlI0OOlI1O;wire O1lIOO1lIOOlI1O;
wire OIl01OlI01l10IO;wire OlI1OIlO01OlI1O;wire[31:0] OIl01IIO0ll10IO;wire OlI1Ol10IOOlI1O;wire OIl01OOIl1l10IO;wire[35:0] OlI1OOIl01OlI1O;
wire O01IlI01lOl10IO;wire O01IllIO10l10IO;wire O01IlOlI01l10IO;wire[31:0] IO01lI1lO0OI01l;wire O01IlIIO0ll10IO;wire IO01llO10IOI01l;
wire O01IlOOIl1l10IO;wire IO01lOI01lOI01l;wire IO01lIO0lIOI01l;wire IO01lOOl1IOI01l;wire[31:0] IOIl0IlI0OOOIl1;wire I01lOI1lO0OI01l;
wire IOIl0O1lIOOOIl1;wire[31:13] I01lOlO10IOI01l;wire IIO0lIlO01OOIl1;wire IIO0ll10IOOOIl1;wire IIO0lOIl01OOIl1;wire[31:0] lIO10I01lOl0IO1;
wire IIO0lIlI0OOOIl1;wire[1:0] lIO10lIO10l0IO1;wire IIO0lO1lIOOOIl1;wire[1:0] lIO10OlI01l0IO1;wire[3:0] lIO10IIO0ll0IO1;wire lIO10OOIl1l0IO1;
wire[31:0] OOIl1OI01lIlI0O;wire lO10II01lOl0IO1;wire OOIl1IO0lIIlI0O;wire lO10IlIO10l0IO1;wire OOIl1OOl1IIlI0O;wire OOl1II1lO0IlI0O;
wire[31:0] OOl1IlO10IIlI0O;wire OI01lIlO01OOl1I;wire OOl1IOI01lIlI0O;wire OI01ll10IOOOl1I;wire OOl1IIO0lIIlI0O;wire OI01lOIl01OOl1I;
wire OOl1IOOl1IIlI0O;wire OI01lIlI0OOOl1I;wire OI01lO1lIOOOl1I;wire I1lO0OlI01lIO10;wire IlI0OIlO01OOl1I;wire[31:0] I1lO0IIO0llIO10;
wire IlI0Ol10IOOOl1I;wire I1lO0OOIl1lIO10;wire IlI0OOIl01OOl1I;wire l10IOI01lOlIO10;wire l10IOlIO10lIO10;wire l10IOOlI01lIO10;wire[31:0] O1lIOI1lO0IOIl0;
wire l10IOIIO0llIO10;wire O1lIOlO10IIOIl0;wire l10IOOOIl1lIO10;wire O1lIOOI01lIOIl0;wire O1lIOIO0lIIOIl0;wire O1lIOOOl1IIOIl0;wire[31:0] OIl01IOIl0IlO01;
wire OlI1OI1lO0IOIl0;wire OIl01OlI1OIlO01;wire OlI1OlO10IIOIl0;wire[31:0] O01IlIO01lIlO01;wire[7:0] O01Ill0IO1IlO01;wire O01IlO01IlIlO01;
wire[31:0] IO01lI01lOlO10I;wire O01IlIOIl0IlO01;wire IO01llIO10lO10I;wire O01IlOlI1OIlO01;wire[35:0] IO01lOlI01lO10I;wire[3:0] IO01lIIO0llO10I;
wire[7:0] IO01lOOIl1lO10I;wire[31:0] IOIl0OI01lIIO0l;wire I01lOI01lOlO10I;wire IOIl0IO0lIIIO0l;wire I01lOlIO10lO10I;wire IOIl0OOl1IIIO0l;
wire IIO0lI1lO0IIO0l;wire IIO0llO10IIIO0l;wire lIO10IO01lIO01l;wire IIO0lOI01lIIO0l;wire lIO10l0IO1IO01l;wire IIO0lIO0lIIIO0l;wire lIO10O01IlIO01l;
wire IIO0lOOl1IIIO0l;wire lIO10IOIl0IO01l;wire lIO10OlI1OIO01l;wire OOIl1OlI01OIl01;wire lO10IIO01lIO01l;wire[31:0] OOIl1IIO0lOIl01;
wire lO10Il0IO1IO01l;wire OOIl1OOIl1OIl01;wire[31:13] lO10IO01IlIO01l;wire OOl1II01lOOIl01;wire OOl1IlIO10OIl01;wire OOl1IOlI01OIl01;
wire[31:0] OI01lI1lO0IO0lI;wire OOl1IIIO0lOIl01;wire OI01llO10IIO0lI;wire OOl1IOOIl1OIl01;wire OI01lOI01lIO0lI;wire OI01lIO0lIIO0lI;
wire OI01lOOl1IIO0lI;wire[31:0] I1lO0IOIl0I01lO;wire IlI0OI1lO0IO0lI;wire I1lO0OlI1OI01lO;wire IlI0OlO10IIO0lI;wire l10IOIO01lI01lO;
wire l10IOl0IO1I01lO;wire l10IOO01IlI01lO;wire[31:0] O1lIOI01lOO01Il;wire l10IOIOIl0I01lO;wire O1lIOlIO10O01Il;wire l10IOOlI1OI01lO;
wire O1lIOOlI01O01Il;wire O1lIOIIO0lO01Il;wire[7:0] O1lIOOOIl1O01Il;wire[31:0] OIl01OI01lO1lIO;wire[15:0] OlI1OI01lOO01Il;wire OIl01IO0lIO1lIO;
wire OlI1OlIO10O01Il;wire OIl01OOl1IO1lIO;wire O01IlI1lO0O1lIO;wire O01IllO10IO1lIO;wire IO01lIO01lI1lO0;wire O01IlOI01lO1lIO;wire IO01ll0IO1I1lO0;
wire O01IlIO0lIO1lIO;wire IO01lO01IlI1lO0;wire O01IlOOl1IO1lIO;wire IO01lIOIl0I1lO0;wire IO01lOlI1OI1lO0;wire IOIl0OlI01OlI01;wire I01lOIO01lI1lO0;
wire[31:0] IOIl0IIO0lOlI01;wire[31:0] I01lOl0IO1I1lO0;wire IOIl0OOIl1OlI01;wire I01lOO01IlI1lO0;wire IIO0lI01lOOlI01;wire IIO0llIO10OlI01;
wire l0IO1OOl1IOlI1O;wire IIO0lOlI01OlI01;wire[31:0] lIO10I1lO0OlI1O;wire IIO0lIIO0lOlI01;wire[3:0] lIO10lO10IOlI1O;wire IIO0lOOIl1OlI01;
wire lIO10OI01lOlI1O;wire lIO10IO0lIOlI1O;wire lIO10OOl1IOlI1O;wire[31:0] OOIl1IOIl0l10IO;wire lO10II1lO0OlI1O;wire OOIl1OlI1Ol10IO;
wire lO10IlO10IOlI1O;wire OOl1IIO01ll10IO;wire OOl1Il0IO1l10IO;wire OOl1IO01Ill10IO;wire[31:0] OI01lI01lOOI01l;wire OOl1IIOIl0l10IO;
wire OI01llIO10OI01l;wire[31:0] OOl1IOlI1Ol10IO;wire OI01lOlI01OI01l;wire[31:0] OI01lIIO0lOI01l;wire OI01lOOIl1OI01l;wire[31:0] I1lO0OI01lOOIl1;
wire[15:0] IlI0OI01lOOI01l;wire I1lO0IO0lIOOIl1;wire IlI0OlIO10OI01l;wire I1lO0OOl1IOOIl1;wire l10IOI1lO0OOIl1;wire l10IOlO10IOOIl1;
wire O1lIOIO01ll0IO1;wire l10IOOI01lOOIl1;wire O1lIOl0IO1l0IO1;wire l10IOIO0lIOOIl1;wire O1lIOO01Ill0IO1;wire l10IOOOl1IOOIl1;wire O1lIOIOIl0l0IO1;
wire O1lIOOlI1Ol0IO1;wire OIl01OlI01IlI0O;wire OlI1OIO01ll0IO1;wire[31:0] OIl01IIO0lIlI0O;wire[31:0] OlI1Ol0IO1l0IO1;wire OIl01OOIl1IlI0O;
wire OlI1OO01Ill0IO1;wire O01IlI01lOIlI0O;wire O01IllIO10IlI0O;wire IlO01OOl1IOOl1I;wire O01IlOlI01IlI0O;wire[31:0] IO01lI1lO0OOl1I;
wire O01IlIIO0lIlI0O;wire IO01llO10IOOl1I;wire[3:0] O01IlOOIl1IlI0O;wire IO01lOI01lOOl1I;wire IO01lIO0lIOOl1I;wire IO01lOOl1IOOl1I;
wire[31:0] IOIl0IOIl0lIO10;wire I01lOI1lO0OOl1I;wire IOIl0OlI1OlIO10;wire I01lOlO10IOOl1I;wire IIO0lIO01llIO10;wire IIO0ll0IO1lIO10;
wire IIO0lO01IllIO10;wire[31:0] lIO10I01lOIOIl0;wire IIO0lIOIl0lIO10;wire lIO10lIO10IOIl0;wire[15:0] IIO0lOlI1OlIO10;wire lIO10OlI01IOIl0;
wire[31:2] lIO10IIO0lIOIl0;wire lIO10OOIl1IOIl0;wire[31:0] OOIl1IlI0OIlO01;wire lO10II01lOIOIl0;wire OOIl1O1lIOIlO01;wire lO10IlIO10IOIl0;
wire[31:0] OOl1IIlO01IlO01;wire[2:0] OOl1Il10IOIlO01;wire OOl1IOIl01IlO01;wire OI01lIO01llO10I;wire OOl1IIlI0OIlO01;wire OI01ll0IO1lO10I;
wire OOl1IO1lIOIlO01;wire OI01lO01IllO10I;wire[31:0] IlO01IlO01IlO01;
assign h_adsm_b=O1lIOlO10IIOIl0;assign lIO10lO10IO01Il[9]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[9])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff8 Il0IO1OIl01IOIl0
(l10IOOIl01lIO10,IO01lOOIl1lO10I,clk,reset_b,1'b1);assign OI01lOlI01I1lO0[3]=(OI01llO10IlO10I[1]|(OI01llO10IlO10I[0]&h_mio));assign OI01lI1lO0IO0lI[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lIlO01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IOIl0O1lIO[23:16];dff IIlO01OOl1IOI01l
(OOl1IIIO0lOIl01,IIO0lIIO0lOOIl1,clk,reset_b,1'b1);assign l10IOO1lIOIIO0l
=LCELL((lO10IO01IlOlI1O&IIO0lO1lIOI01lO&(OOl1IIlO01OIl01|~h_bii_b))|
(IIO0lOOl1IIIO0l&(OI01lOIl01OOl1I|OOl1IIlO01OIl01))|
(lO10IO01IlO01Il)|
(~I01lOO01IlI1lO0))|
(I01lOlIO10lO10I&LCELL((lO10IO01IlOlI1O&IIO0lO1lIOI01lO&OI01lOIl01OOl1I)|
(O01IlOOl1IO1lIO)|
(OlI1OO01IlIOIl0&OI01lOIl01OOl1I&~OlI1OO01Ill0IO1)));assign lIO10O01IlOlI1O
=(IIO0lOIl01I01lO&IIO0lIIO0lOlI01)|OIl01OOl1IO1lIO|OI01lO01IlIO0lI;dffe IIlO01OIl01lO10I
(IO01ll0IO1I1lO0,IO01lIlI0OlO10I,clk,reset_b,1'b1,O1lIOl0IO1l0IO1);assign cbeout_b=O1lIOIIO0lOlI1O;assign O1lIOI1lO0l0IO1[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01IO0lI&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IOIl0lIO10[31:24];assign OlI1Ol10IOOlI1O
=(OOl1IIIO0lOIl01&~IIO0lIIO0lI01lO);assign IO01lO1lIOlO10I=~I01lOO01IlI1lO0&OOl1IOOl1Il10IO&I01lOlIO10lO10I;dff IIO0lIIIO0lOlI1O
(serrout_b,OOl1Il0IO1l10IO,clk,1'b1,reset_b);assign l10IOOI01lI01lO
=(OOl1IIlI0OIlO01|I01lOIO01lOOl1I|l10IOOI01lOOIl1)|(IlI0Ol10IOI1lO0&~OOl1IIlI0OOIl01);assign O1lIOI01lOOlI1O[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OI01l&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IlI0OOOIl1[7:0];assign OOl1IIlI0OO1lIO
=~O01IlIOIl0OIl01[7]&~O01IlIOIl0OIl01[6]&~O01IlIOIl0OIl01[5]&~O01IlIOIl0OIl01[4];assign OOl1IIlO01IlO01[1:0]=2'b00;dff II1lO0I1lO0OOIl1
(OOl1IlIO10IlO01,IO01lIO0lIOOl1I,clk,reset_b,1'b1);assign lO10IIlO01IOIl0=(OlI1OO01IlIOIl0|OOl1IOOl1IIlI0O)&~IIO0lIlO01OOIl1;assign IO01lI01lOlO10I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01lIO10&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IlI0OOIl01[15:8];assign IIO0lIO01lIIO0l
=lO10II01lOIOIl0&IIO0lIO01llIO10&~l10IOIO01lOlI01;dff32 IIOIl0IlO01OOIl1(I1lO0IIO0llIO10,lIO10l10IOl0IO1,clk,reset_b,1'b1);assign OI01lO1lIOOOl1I
=(O01IllO10IOIl01|OI01lOlI1OlO10I|IIO0llO10IlIO10);dffe8 IOOIl1lIO10IlO01
(OlI1OOIl01OlI1O[23:16],OOl1IOOIl1O1lIO[23:16],clk,reset_b,1'b1,OOl1IOI01ll10IO);assign lIO10IO01lOlI1O[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01IO01l&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0OI01lOOIl1[23:16];assign l10IOlO10IOOIl1
=~IIO0lOIl01I01lO&OI01lOOIl1I1lO0&~l10IOlO10IOlI01;dff32 IIlO01O01IlOOl1I(OOIl1IlI0OOIl01,IO01lI01lOlO10I,clk,reset_b,1'b1);dff IOlI01IOIl0lO10I
(I01lOO01IlOI01l,OOl1IOOIl1IlO01,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[12]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[12])|
(IlI0OIlO01OOl1I&h_din[12])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[12]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[12])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[12]);assign OlI1OlO10Il0IO1[15:9]
=7'b0000000;assign h_rdym_b=O01IlI01lOl10IO;assign OIl01OI01lOIl01=(IlO01IlO01IlO01[7:2]==6'b100000)?1'b1:1'b0;assign lO10IlO10IOlI1O
=l10IOOOl1IOlI01;assign OOl1IOOIl1O1lIO[31]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[31])|
(IlI0OIlO01OOl1I&h_din[31])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[31]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[31])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[31]);assign IIO0lOlI1OlIO10[4:0]
=5'b00000;BUF Il0IO1OlI1OO01Il(OOl1II1lO0l10IO,O1lIOIOIl0l0IO1);assign O1lIOIlO01O01Il
=(IlO01IlO01IlO01[7:2]==6'b110011)?1'b1:1'b0;assign OI01lO01IllO10I
=(I01lOlIO10lO10I&I1lO0OOIl1lIO10)|(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe8 IOlI01IO0lIlO10I
(OI01lIIO0lOI01l[31:24],O01IlIO01lIlO01[31:24],clk,reset_b,1'b1,lO10IIlO01l0IO1);assign lIO10IlI0OIOIl0
=(IlO01IlO01IlO01[7:2]==6'b000001)?1'b1:1'b0;assign oe_req=reset_b;assign O1lIOl10IOO01Il[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIO01llO10I&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IIO0lOlI01[15:8];assign O01IlOlI1OIlO01
=O01IlOOl1IOIl01[3]&~O01IlOOl1IOIl01[2]&O01IlOOl1IOIl01[1]&~O01IlOOl1IOIl01[0]&
IIO0lOOl1IlIO10&~IlO01IlO01IlO01[0]&~IlO01IlO01IlO01[1];assign lIO10lO10IO01Il[17]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[17])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign OOl1Il0IO1IlI0O
=
CASCADE(~(l10IOl0IO1OOIl1&OOIl1OlI1OIlI0O[24]))&(IIO0llIO10I01lO|OOl1IlIO10IlO01|(OI01lIO0lIlO10I));dff IOlI01O1lIOOOl1I
(oe_cbe,OIl01OlI1OO1lIO,clk,reset_b,1'b1);assign IO01lI1lO0OOl1I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OI01lI01lO&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IIO0lIlO01[23:16];assign I01lOlIO10lO10I
=~irdyin_b;dff IOlI01IlI0OI1lO0(oe_devsel,OOIl1O1lIOIlO01,clk,reset_b,1'b1);assign O01IlIO01lIlO01
=(OIl01OlI1OOIl01)?adin:lIO10lO10IO01Il;assign O1lIOIlI0OO01Il=(IlO01IlO01IlO01[7:2]==6'b000101)?1'b1:1'b0;assign I1lO0OlI1OOlI01[3]
=CASCADE(~((OlI1Ol10IOO01Il&IIO0lOIl01I01lO)|IO01llO10IOI01l)&
~(O01IlIIO0lIlI0O))&
~(I01lOl10IOlO10I)&
LCELL(~((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0]))&
O1lIOIIO0lOlI1O[3];assign lIO10I1lO0O01Il[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01OlI1O&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IOIl0OlI01[31:24];assign l10IOIO0lII01lO
=CASCADE((O01IlIIO0lIlI0O&~O1lIOOOIl1IO01l)|
(OOl1IIIO0lOIl01&IIO0lIIO0lI01lO&~(OI01lOlI1OIO0lI&IIO0lI01lOI01lO)))|
((IIO0lIIO0lOlI01|OlI1Ol10IOO01Il)&~OI01lIIO0lI1lO0&IIO0lOIl01I01lO&IIO0lIOIl0lIO10)|
(OIl01O1lIOIlI0O)|
(IlI0Ol10IOI1lO0&I01lOI01lOlO10I);assign I1lO0IO0lIOOIl1
=(l10IOOOl1IOOIl1&lO10IlIO10l0IO1)|
(OI01ll0IO1IO0lI)|
(~OOl1IOOl1Il10IO|~I01lOO01IlI1lO0);assign IIO0lIO0lIIIO0l
=OlI1OOIl01OlI1O[28]^OlI1OOIl01OlI1O[29]^OlI1OOIl01OlI1O[30]^OlI1OOIl01OlI1O[31];assign l10IOOI01lOlI01
=LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO);assign lIO10I1lO0IO01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01IOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IOIl0I01lO[7:0];BUF IIlO01OOIl1IO0lI
(lO10II1lO0IO01l,l10IOIOIl0I01lO);assign OOIl1IIO0lO1lIO=(IO01llIO10IO0lI[7:0]==8'h10)?1'b1:1'b0;dff II1lO0l10IOlIO10
(OI01lIOIl0IO0lI,O01IlI1lO0O1lIO,clk,reset_b,1'b1);BUF IIlO01O1lIOlO10I(lIO10l0IO1O01Il,IlI0OIlO01OI01l);assign OI01lI01lOOI01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01OIl01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IlI0OIlI0O[15:8];BUF IOlI01OOIl1OI01l
(O1lIOOI01lIOIl0,IIO0lIO01lIIO0l);dff IIlO01OI01lI1lO0(O1lIOO01IlIOIl0,I1lO0OOl1IOOIl1,clk,1'b1,reset_b);assign O1lIOOOl1Il0IO1
=(cbein_b[0]^cbein_b[1]^cbein_b[2]^cbein_b[3]);assign IIO0lI1lO0IIO0l
=LCELL(
LCELL(lO10IO01IlOlI1O&OlI1OO01Ill0IO1&I01lOO01IlI1lO0&h_abort_b)|
(LCELL(lO10IO01IlOlI1O|O01IlOOl1IO1lIO)&~OOl1IOOl1Il10IO&~I01lOlIO10lO10I)|
LCELL((l10IOOOl1IOlI01&O01IlOlI1OIlO01)|
(lO10IO01IlO01Il&O01IlOlI1OIlO01)|
((IlI0Ol10IOOI01l|lO10Il10IOl0IO1)&l10IOl10IOlIO10[0])));assign O1lIOI01lOIO01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01I1lO0&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IlI0OI01lO[23:16];assign lO10II01lOl0IO1
=~IIO0lIlI0OOlI01[11]&~IIO0lIlI0OOlI01[10]&~IIO0lIlI0OOlI01[9]&~IIO0lIlI0OOlI01[8];dff32 IIlO01OlI01lO10I
(OOIl1IOIl0l10IO,IO01lI1lO0I1lO0,clk,reset_b,1'b1);dff IOlI01IOIl0IO0lI(I01lOO01IlOOl1I,IlI0OOIl01OI01l,clk,1'b1,reset_b);assign OOl1IOOIl1O1lIO[4]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[4])|
(IlI0OIlO01OOl1I&h_din[4])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[4]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[4])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[4]);assign IO01lIO01lOI01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0O01IlOOIl1&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1OI01lIlI0O[31:24];dff IOOIl1OIl01IlO01
(IO01lO01IlI1lO0,OOIl1OOl1Il10IO,clk,reset_b,1'b1);assign OlI1Ol0IO1l0IO1[15:0]=vendor_id;assign lO10IOIl01l0IO1
=
(lO10IO01IlOlI1O&l10IOO1lIOlIO10&I01lOlIO10lO10I&(OOl1IIlO01OIl01|~h_bii_b)&IIO0lO1lIOI01lO)|
(lO10IO01IlOlI1O&l10IOO1lIOlIO10&I01lOlIO10lO10I&(~h_retry_b|~h_abort_b))|
(lO10IO01IlOlI1O&l10IOO1lIOlIO10&I01lOlIO10lO10I&OI01lOIl01OOl1I&IIO0lO1lIOI01lO)|
(lO10IO01IlOlI1O&~I01lOlIO10lO10I&OlI1OO01Ill0IO1)|
(O01IlOOl1IO1lIO&I01lOlIO10lO10I&l10IOO1lIOlIO10)|
(IlI0OO01IlIO0lI&l10IOO1lIOlIO10);assign OOl1IOOIl1O1lIO[23]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[23])|
(IlI0OIlO01OOl1I&h_din[23])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[23]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[23])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[23]);assign IIO0lOlI1OlIO10[14]
=l10IOl0IO1OlI01;assign O1lIOOIl01IO01l=IO01llO10IOOl1I;assign O1lIOIlO01OlI1O=(IlO01IlO01IlO01[7:2]==6'b101011)?1'b1:1'b0;assign lIO10OIl01IOIl0
=((OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
~OlI1OO01Ill0IO1&IIO0lIlO01OOIl1&~(IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1&IO01lOI01lI1lO0));assign l10IOl10IOIIO0l[31:2]
=(IO01lIlI0OIO0lI)?lIO10IIO0lIOIl0[31:2]:O01Ill10IOIlI0O[31:2];dff Il0IO1O01IlO01Il
(IIO0lOOIl1OOIl1,lO10IlO10IO01Il,clk,reset_b,1'b1);assign OOl1IIOIl0IlI0O
=IIO0lI1lO0lIO10|OOl1II1lO0l10IO|l10IOI1lO0I01lO|O01IlI1lO0IlO01;assign I1lO0O01IlOOIl1
=(IlO01IlO01IlO01[7:2]==6'b111110)?1'b1:1'b0;assign l10IOIO01lI01lO
=(OOl1IIO01ll10IO&~O1lIOOlI01O01Il)|
(OOl1IIO01ll10IO&~h_abort_b&~I1lO0OOl1IOOIl1)|
(IO01lOI01lI1lO0&IIO0lO1lIOI01lO&~O1lIOOlI01O01Il&~I1lO0OOl1IOOIl1)|
(IO01lOI01lI1lO0&~h_abort_b&~I1lO0OOl1IOOIl1);assign lIO10lO10IO01Il[25]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[25])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff IIO0lIOIl01OlI1O
(l10IOl0IO1OlI01,O01Ill0IO1O1lIO,clk,reset_b,1'b1);assign OOl1Il10IOIlO01=O1lIOIIO0lIO01l+3'b001;assign OI01ll10IOI1lO0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OI01ll10IO&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IIO0ll10IO[23:16];dff IOIl01O01IlO1lIO
(I1lO0IIO0lIIO0l,lIO10l10IOIOIl0,clk,reset_b,1'b1);assign IO01lO01IlOOl1I
=
CASCADE(~(I01lOlIO10lO10I&l10IOO1lIOlIO10&LCELL(lO10IO01IlOlI1O&h_abort_b&h_retry_b)&
LCELL(~((OOl1IIlO01OIl01|~h_bii_b|OI01lOIl01OOl1I)&IIO0lO1lIOI01lO))))&
(~(~l10IOO1lIOlIO10&LCELL(lO10IO01IlOlI1O&~IIO0lO1lIOI01lO&OlI1OO01Ill0IO1&h_abort_b&h_retry_b))&
O01IlOlI1OOIl01&
~(((OOl1IIO01ll10IO&O1lIOOlI01O01Il&(h_abort_b|I1lO0OOl1IOOIl1))|
(IO01lOI01lI1lO0&I1lO0OOl1IOOIl1)|
(IO01lOI01lI1lO0&~IIO0lO1lIOI01lO&h_abort_b)|
(IO01lOI01lI1lO0&IIO0lO1lIOI01lO&O1lIOOlI01O01Il&h_abort_b))&
~(~h_bii_b&IIO0lO1lIOI01lO)&h_retry_b));assign lIO10lO10IO01Il[6]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[6])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign I1lO0O1lIOIIO0l
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O01IlI01lOIlI0O&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IO01llIO10IO0lI;assign OI01lOlI01I1lO0[0]
=h_wrin;assign O1lIOI1lO0IOIl0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OOl1I&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IOIl0IIO0l[31:24];dff IOIl01O01IlOIl01
(lO10Il10IOl0IO1,I01lOl10IOIO0lI,clk,reset_b,1'b1);assign stopout_b=I01lOO01IlI1lO0;dff IOIl01l0IO1IlO01
(l10IOIO0lIOlI01,lO10Il0IO1O01Il,clk,reset_b,1'b1);assign IO01llIO10lO10I
=(IlO01IlO01IlO01[31:13]==O01IlOOl1IIlO01[31:13])?1'b1:1'b0;assign OOl1Il10IOOIl01=O01IlIIO0lIlI0O&O1lIOOOIl1IO01l;assign O1lIOI1lO0l0IO1[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01IO0lI&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IOIl0lIO10[7:0];assign l10IOIIO0lIIO0l
=((O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0))|
(O01IlIIO0ll10IO))&(~OlI1Ol10IOIO01l|lO10IOIl01IOIl0);dffe24 IIOIl0IO01lIIO0l
(I1lO0OOl1II01lO[31:8],OOl1IIlO01IlO01[31:8],clk,reset_b,1'b1,IOIl0OlI1OIIO0l);dff II1lO0l10IOIIO0l
(OlI1OIlO01IO01l,OOl1IO01IlIlI0O,clk,reset_b,1'b1);assign IlI0OIlO01OOl1I
=LCELL(IlI0Ol10IOOI01l|(OlI1Ol10IOO01Il&(OOl1IOIl01IlO01|O1lIOIIO0lO01Il))|(lO10IO01IlOlI1O));assign IO01lI01lOIO0lI[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OlI01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IlI0OO1lIO[15:8];assign IIO0lIOIl0lIO10
=IIO0lIlI0OOOIl1&OlI1OI01lOOlI1O&OOl1IIlI0OO1lIO&I01lOI01lOIO0lI;dff2 IOlI01OI01llO10I
(OIl01O1lIOl10IO[1:0],lIO10lIO10l0IO1[1:0],clk,reset_b,1'b1);assign O1lIOOOl1IIOIl0=(adin[0]^adin[1]^adin[2]^adin[3]);assign IIO0lOlI01OlI01
=(IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)|IIO0ll10IOOlI01|l10IOIlO01lIO10;assign lIO10I01lOl0IO1[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01l0IO1&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IlI0OlIO10[23:16];assign O01IlIO01lO1lIO
=O01IlIlI0OIlI0O&(~OOIl1OOl1IIlI0O|O1lIOOI01ll0IO1)&~l10IOIO01lOlI01&IIO0lIO01llIO10;dff32 IIlO01OlI01IO0lI
(OOIl1IIO0lIlO01,IO01lI1lO0OOl1I,clk,reset_b,1'b1);assign OOl1Il0IO1l10IO=~O1lIOIO0lIl0IO1;dffe32 Il0IO1IO0lIOlI1O
(I01lOOIl01IO0lI,h_din,clk,reset_b,1'b1,l10IOOI01lI01lO);assign OI01lIO01lIO0lI[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01IlO01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01OI01lO1lIO[31:24];assign O01IllIO10l10IO
=OOl1IIIO0lOIl01&OI01lOlI1OIO0lI;dff32 IlO10IOOl1IO1lIO(IOIl0IlI0OI01lO,O1lIOI01lOIO01l,clk,reset_b,1'b1);dff IOOIl1I1lO0l10IO
(l10IOl0IO1I01lO,I01lOO01IlOOl1I,clk,1'b1,reset_b);assign OOl1IOOIl1O1lIO[15]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[15])|
(IlI0OIlO01OOl1I&h_din[15])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[15]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[15])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[15]);assign OlI1OlO10Il0IO1[6]
=IO01lOOIl1IO0lI;dff IOlI01OlI1OIO0lI(IO01llO10IOOl1I,l10IOO01IlI01lO,clk,reset_b,1'b1);assign O1lIOIO01ll0IO1
=(IlO01IlO01IlO01[7:2]==6'b100011)?1'b1:1'b0;dff IOIl01I1lO0IlO01(O1lIOOlI01OlI1O,IO01lOlI01IO0lI,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[34]
=(IlI0OIlO01OOl1I&h_bein_b[2])|
(O01IlOI01lIlO01&l10IOOOIl1IIO0l[2])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[34]);assign IlI0Ol0IO1lO10I[7:0]
=IO01llIO10IO0lI;assign lIO10IlI0Ol0IO1=IIO0lIlI0OOOIl1&OlI1OI01lOOlI1O&OOl1IIlI0OO1lIO&l10IOIlI0OIIO0l;assign I1lO0OlI01lIO10
=(IlO01IlO01IlO01[7:2]==6'b110110)?1'b1:1'b0;assign l10IOIlO01IIO0l=O1lIOOlI01O01Il&(h_abort_b|I1lO0OOl1IOOIl1);dffe8 IOOIl1l0IO1l10IO
(OI01lOlI01OOl1I[23:16],adin[23:16],clk,reset_b,1'b1,OIl01OOl1IOIl01);assign OOl1IOIl01O1lIO
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[2]:O1lIOOOIl1OlI1O;assign irdyout_b
=l10IOIOIl0OOIl1;assign IO01ll10IOlO10I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OI01llIO10&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IIO0lOIl01[23:16];assign IlI0OlIO10I1lO0
=((O01IlOOl1IOIl01==4'b0010)|(O01IlOOl1IOIl01==4'b0011))?1'b1:1'b0;assign lIO10lO10IO01Il[14]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[14])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign IIO0ll0IO1IIO0l
=(~(OI01lO1lIOI1lO0&OOIl1OlI1OIlI0O[29]))&(O01IllIO10l10IO|(O01Ill0IO1OIl01));dff IOOIl1lIO10O1lIO
(I1lO0OlI1OI01lO,lIO10lO10IIO01l,clk,reset_b,1'b1);assign lIO10I1lO0OlI1O[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IO01lIO01l&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IOIl0OOIl1[31:24];assign h_cache_size[7:0]
=IO01llIO10IO0lI[7:0];dff IOOIl1I01lOIlO01(l10IOlIO10lIO10,IO01lO1lIOlO10I,clk,reset_b,1'b1);assign h_aout[1:0]=2'b00;assign OOl1IOlI1OIlI0O[15:13]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IIO0lI01lOOlI01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:13]:lO10IO01IlIO01l[15:13];assign OOl1Il10IOO1lIO[2]
=
(IIO0lOIl01I01lO&LCELL(OlI1Ol10IOO01Il&OOl1IOOIl1O1lIO[34]))|
LCELL((IO01llO10IOI01l&OOl1IOOIl1O1lIO[34])|
((O01IlIIO0lIlI0O)&OI01lOlI01I1lO0[2])|
((I01lOl10IOlO10I)&OOIl1O1lIOO1lIO[2])|
(((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0])&IO01lIIO0llO10I[2]))|
I1lO0OlI1OOlI01[2];assign lIO10I1lO0O01Il[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01OlI1O&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IOIl0OlI01[7:0];assign lIO10IOIl0O01Il
=LCELL(OlI1Ol10IOO01Il&~OI01lIIO0lI1lO0);assign OOl1IO1lIOO1lIO
=~OOl1IOOl1Il10IO&(l10IOO1lIOlIO10|(OlI1OO01Ill0IO1&I01lOO01IlI1lO0))&
~(((lO10IO01IlOlI1O|OlI1OO01IlIOIl0)&~h_abort_b&~I1lO0OOl1IOOIl1)|((O01IlOOl1IO1lIO|OOl1IOOl1IIlI0O)&lIO10O01IlIO01l));assign I01lOl0IO1OI01l
=LCELL(lO10Il0IO1OlI1O^O01IlIO0lIO1lIO^IlI0Ol0IO1IO0lI^IIO0lIO0lIIIO0l);assign IlI0OIO01llO10I
=LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO);assign OI01lI01lOOOl1I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01IlI0O&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IOIl0IlO01[15:8];assign IOIl0O1lIOOlI01
=(O01IlIIO0lIlI0O&(h_size==16'h0001))?1'b1:
(O01IlIIO0lIlI0O&(h_size!=16'h0001))?1'b0:O1lIOlIO10O01Il;assign IO01lOIl01IO0lI[7:0]
=(IOIl0OOIl1OOIl1)?(O1lIOOIl01OlI1O[7:0]+8'b00000001):I1lO0OOIl1IIO0l[7:0];dff IOlI01IIO0lI1lO0
(O1lIOO1lIOOlI1O,IIO0llIO10OOIl1,clk,reset_b,1'b1);assign IIO0ll10IOOlI01
=LCELL(I01lOO01IlOOl1I&(~lO10IOIl01IOIl0|(~O1lIOOlI01OlI1O&IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1))&~IIO0lIIO0lOlI01);assign O1lIOI01lOO01Il[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01lO10I&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IlI0OOlI01[23:16];assign lIO10OI01lO01Il
=IIO0lIO01llIO10|(~O01IlIIO0lIlI0O&l10IOIO01lOlI01);assign I1lO0O1lIOlIO10
=(I1lO0OOl1IOOIl1&~O1lIOO01IlIOIl0)?lIO10OlI01l0IO1:2'b00;assign IlI0OIlO01I1lO0
=LCELL(OOl1IO01Ill10IO^IO01lOOl1II1lO0^IIO0lO01IlIIO0l);assign IO01lIOIl0OI01l
=LCELL((LCELL(OlI1Ol10IOO01Il&~OI01lIIO0lI1lO0)&~OI01lOOIl1I1lO0&~IIO0lOIl01I01lO)|
LCELL(OlI1Ol10IOO01Il&~I01lOI1lO0OI01l&~OI01lIIO0lI1lO0&~IIO0lIOIl0lIO10));assign IO01lIO01lOOl1I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01I01lO&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IlI0OIlO01[31:24];assign I01lOI01lOlO10I
=l10IOIlI0OlIO10&lO10II01lOl0IO1&O01IlIlI0Ol10IO&IlI0OI01lOI1lO0;dff32 IOIl01IlO01l10IO
(IOIl0IlI0OOOIl1,O1lIOI01lOOlI1O,clk,reset_b,1'b1);dff IOOIl1I1lO0IlI0O(O01IlOOl1IO1lIO,l10IOOOIl1lIO10,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[7]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[7])|
(IlI0OIlO01OOl1I&h_din[7])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[7]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[7])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[7]);assign IO01lIO01lOI01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0O01IlOOIl1&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1OI01lIlI0O[7:0];assign OOIl1OOl1Il10IO
=OlI1Ol10IOO01Il&IIO0lOIl01I01lO;assign OOl1IIO0lIl10IO[31:8]=class_code;assign IlI0OOIl01I1lO0
=(IIO0lOOl1IIIO0l&h_retry_b)|(OlI1OO01IlIOIl0&IIO0lOOIl1I01lO);assign OOl1IOOIl1O1lIO[26]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[26])|
(IlI0OIlO01OOl1I&h_din[26])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[26]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[26])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[26]);assign IIO0lOlI1OlIO10[11]
=IIO0ll0IO1lIO10;assign oe_irdy=OI01lOIl01I1lO0;assign I1lO0OlI01IIO0l=(IlO01IlO01IlO01[7:2]==6'b101110)?1'b1:1'b0;assign IO01lOIl01lO10I
=((OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
~OlI1OO01Ill0IO1&IIO0lIlO01OOIl1&~(IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1&IO01lOI01lI1lO0));assign l10IOl10IOIIO0l[0]
=(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l)?(h_ain[0]&~h_mio):
(l10IOIIO0llIO10)?IOIl0IO0lIlIO10[0]:IO01lIIO0lIO0lI[0];dff IIlI0OOOl1IlIO10
(IOIl0OlI1OlIO10,O1lIOlO10Il0IO1,clk,reset_b,1'b1);assign lO10II1lO0OlI1O
=(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0)&~lO10IOIl01IOIl0)|
(O01IlIIO0ll10IO&~(lIO10lIO10IOIl0&O1lIOOOIl1IO01l)&~lO10IOIl01IOIl0)|
(l10IOIIO0llIO10&~lO10IOIl01IOIl0)|
(I01lOl10IOlO10I&~OI01lOIl01I1lO0);assign OI01ll10IOOI01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lOIl01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IIO0lIlI0O[23:16];dff IOlI01IlI0OOI01l
(IIO0lOOl1IlIO10,IlI0OlO10IIO0lI,clk,reset_b,1'b1);assign lIO10lO10IO01Il[22]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[22])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign lIO10O1lIOl0IO1
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);dff Il0IO1OlI1OIO01l
(OI01lIIO0lOOl1I,IIO0ll10IOOOIl1,clk,reset_b,1'b1);assign O1lIOl10IOIO01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIO01lI1lO0&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IIO0lI01lO[31:24];assign OI01lOOIl1I1lO0
=~stopin_b&~I1lO0IIO0lIIO0l;dff IOOIl1I01lOOIl01(I01lOO01IlI1lO0,l10IOOOl1II01lO,clk,1'b1,reset_b);assign lIO10lO10IO01Il[3]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[3])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff16 IlO10IOOIl1IlI0O
(lO10IO01IlIO01l[31:16],OOl1IOlI1OIlI0O[31:16],clk,1'b1,reset_b);assign OIl01OlI1OIlO01
=IO01llO10II1lO0&OOl1IOIl01IlO01&l10IOl10IOlIO10[3]&l10IOl10IOlIO10[2]&~l10IOl10IOlIO10[0];assign O1lIOI1lO0IOIl0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OOl1I&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IOIl0IIO0l[7:0];dff IIO0lIOOl1Il0IO1
(IlI0Ol10IOI1lO0,lO10Il10IOIOIl0,clk,reset_b,1'b1);assign OlI1OlIO10O01Il
=((LCELL(OlI1OO01IlIOIl0&IO01lO01IlOI01l&~OOl1IIlO01OIl01&~OI01lOIl01OOl1I)&l10IOO1lIOlIO10)|
(LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO)&I01lOlIO10lO10I&l10IOO1lIOlIO10));assign I01lOl0IO1OOl1I
=OlI1OOIl01OlI1O[8]^OlI1OOIl01OlI1O[9]^OlI1OOIl01OlI1O[10]^OlI1OOIl01OlI1O[11];assign lO10IlIO10l0IO1
=(OOl1II01lOOIl01|IO01lIlI0OlO10I|O01IlOlI1OIlO01|IlI0OlIO10OOl1I);assign l10IOI01lOIIO0l
=(IlI0Ol10IOOI01l&OOIl1OOl1IIlI0O)|(l10IOOOl1IOlI01&O01IlOlI1OIlO01)|lO10Il10IOl0IO1|l10IOIIO0llIO10|(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~lO10IOIl01IOIl0);assign IO01lI1lO0I1lO0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01IIO0l&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IOIl0l10IO[15:8];dffe IOIl01O01IlIlO01
(O01IlIO01lOIl01,OI01lOI01llO10I,clk,reset_b,1'b1,O01IlIIO0lIlI0O);dff IIlO01OI01lOI01l
(O1lIOl10IOOlI1O,IOIl0IIO0lOOIl1,clk,reset_b,1'b1);dff IOlI01IIO0lOI01l(l10IOO01IlOOIl1,lIO10OOl1IO01Il,clk,reset_b,1'b1);BUF IOIl01lIO10IlI0O
(IOIl0IO0lIIIO0l,OOl1IOlI01O1lIO);assign lIO10I01lOIOIl0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01O01Il&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IlI0OIIO0l[23:16];assign l10IOIOIl0I01lO
=OI01lOI01lIO0lI|lIO10IOIl0OlI1O;assign IlO01IlO01IlO01[31:0]
=(l10IOl0IO1I01lO&l10IOOOl1IOOIl1)?OOIl1OlI1OIlI0O[31:0]:OI01llIO10I1lO0[31:0];assign l10IOO01IlOlI01
=(adin[12]^adin[13]^adin[14]^adin[15]);assign I01lOIlO01lO10I
=(IIO0lOIl01I01lO&IIO0lIIO0lOlI01)|O1lIOl0IO1IOIl0|lIO10l0IO1O01Il;assign OI01lI01lOI1lO0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01l10IO&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IlI0Ol10IO[31:24];dff IIlO01OOIl1lO10I
(OOl1IIlI0OOIl01,O1lIOO01Ill0IO1,clk,reset_b,1'b1);dff32 IOIl01IlO01IlI0O(IOIl0IOIl0IIO0l,O1lIOI1lO0IOIl0,clk,reset_b,1'b1);assign O1lIOO1lIOIO01l
=(IO01lOOIl1IO0lI&OOl1IlIO10O1lIO&~perrin_b);dffe4 IIOIl0l0IO1IIO0l
(IO01lOlI01lO10I[35:32],OlI1OOIl01OlI1O[35:32],clk,reset_b,1'b1,OOl1IIIO0lOIl01);assign OI01lIO01lIO0lI[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01IlO01&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01OI01lO1lIO[7:0];assign h_done_b
=~lIO10OlI1OO01Il;dff32 IIO0lIO01IlIOIl0(OIl01OI01lO1lIO,OI01lIO01lIO0lI,clk,reset_b,1'b1);assign IIO0lOOIl1OlI01
=
(I01lOO01IlOOl1I&l10IOO1lIOlIO10)|
(~I01lOlIO10lO10I&LCELL((l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO)|
(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&lO10IlIO10l0IO1&lO10IlO10IIO01l)|
(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&(O01IlOlI1OIlO01|IlI0OlIO10OOl1I))));assign OOl1IOOIl1O1lIO[18]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[18])|
(IlI0OIlO01OOl1I&h_din[18])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[18]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[18])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[18]);assign OlI1OlO10Il0IO1[3]
=1'b0;assign lIO10OOl1IIO01l=O01IlO01IlIlO01|OI01lOOIl1OOl1I;assign I1lO0OI01lI01lO
=(IlO01IlO01IlO01[7:2]==6'b100110)?1'b1:1'b0;BUF IIO0lIIlI0OOlI1O(OOIl1OOIl1OIl01,O1lIOOIl01O01Il);dff32 IIO0lIIO0lIIOIl0
(IO01lIIO0lIO0lI[31:0],l10IOl10IOIIO0l[31:0],clk,reset_b,1'b1);assign IIO0lIO0lIlIO10[7:0]=l10IOOIl01lIO10;assign OI01lIOIl0lO10I
=(OI01lOOIl1I1lO0&lIO10IOIl0OlI1O&~lIO10l10IOIOIl0)|IIO0lI01lOOOIl1;assign OI01lIlO01I1lO0
=(IlO01IlO01IlO01[7:2]==6'b111001)?1'b1:1'b0;assign OI01lOlI01OI01l
=IIO0lIlO01OlI01|IIO0lOOl1IIIO0l|(~h_abort_b&~I1lO0OOl1IOOIl1);assign lIO10lO10IO01Il[30]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[30])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign IIO0lOIl01OlI01
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[8]:OI01lOOIl1OI01l;assign IO01lIOIl0OOl1I
=(~IlI0Ol10IOOI01l&~lO10Il10IOl0IO1&~O1lIOIIO0lIO01l[2]);assign lIO10l10IOl0IO1[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIO01ll0IO1&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IIO0llIO10[31:24];assign O01IlOlI1OOIl01
=~(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO&I01lOlIO10lO10I)&
~(IIO0lOOl1IIIO0l&h_retry_b)&
~(OOl1IIO01ll10IO&O1lIOOlI01O01Il&O1lIOlO10IIOIl0)&
~(IO01lOI01lI1lO0&I1lO0OOl1IOOIl1&h_retry_b);assign lIO10lO10IO01Il[11]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[11])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff8 IIlO01OIl01IO0lI
(IO01llIO10IO0lI,I1lO0O1lIOIIO0l,clk,reset_b,1'b1);assign OI01llO10IlO10I[1]
=(h_mio&h_wrin)?(h_cmd[1]&IOIl0OlI1OlIO10):h_cmd[1];assign lIO10I1lO0OlI1O[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IO01lIO01l&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IOIl0OOIl1[7:0];dff IIO0lIOOl1IIOIl0
(IIO0lIIO0lOlI01,O01IlIO0lIIlO01,clk,reset_b,1'b1);BUF Il0IO1OI01lOlI1O(OI01ll0IO1IO0lI,lIO10OOIl1l0IO1);assign OIl01OOl1IO1lIO
=LCELL(((OlI1OO01IlIOIl0|OOl1IOOl1IIlI0O)&~IIO0lIlO01OOIl1)|(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0));assign I01lOlO10IOI01l[15:13]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlI0OO01Il&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:13]:O01IlOOl1IIlO01[15:13];assign I1lO0OlI1OOlI01[0]
=CASCADE(~((OlI1Ol10IOO01Il&IIO0lOIl01I01lO)|IO01llO10IOI01l)&
~(O01IlIIO0lIlI0O))&
~(I01lOl10IOlO10I)&
LCELL(~((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0]))&
O1lIOIIO0lOlI1O[0];assign OI01lI1lO0lO10I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01O1lIO&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IOIl0OIl01[15:8];assign IlI0Ol10IOOOl1I
=(LCELL(IlI0Ol10IOOI01l&OOIl1OOl1IIlI0O&h_wait_b)|
(OlI1Ol10IOO01Il&IIO0lOIl01I01lO&OI01lOOIl1I1lO0&~IIO0lIOIl0lIO10&~(h_wait_b|I01lOI1lO0OI01l))|
LCELL(lIO10IOIl0O01Il&~OI01lOOIl1I1lO0&(~IIO0lOIl01I01lO|l10IOI1lO0OlI01))|
(lO10Il10IOl0IO1&l10IOl10IOlIO10[0]));assign devselout_b
=OOl1IOOl1Il10IO;dff IOlI01IIO0lOOl1I(lIO10OlI1OIO01l,O01IllO10IIlO01,clk,1'b1,reset_b);assign OOl1IOI01ll10IO
=CASCADE(OlI1Ol10IOO01Il|
(I01lOlIO10lO10I&O01IlOI01lOIl01)|
OOl1IOI01lIlI0O)&
(IIO0lOIl01I01lO|(I01lOlIO10lO10I&O01IlOI01lOIl01)|OOl1IOI01lIlI0O);assign O1lIOI01lOOlI1O[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OI01l&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IlI0OOOIl1[23:16];assign IIO0lIlI0OOOIl1
=~O01IlIOIl0OIl01[15]&~O01IlIOIl0OIl01[14]&~O01IlIOIl0OIl01[13]&~O01IlIOIl0OIl01[12];assign O1lIOOlI01IO01l[9:2]
=
(IO01lOI01lI1lO0&IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1)?(OOl1IIlO01IlO01[9:2]+8'b00000001):OOl1IIlO01IlO01[9:2];dff IOOIl1l10IOIlO01
(OOl1IlO10Il10IO,O1lIOOlI1Ol0IO1,clk,reset_b,1'b1);assign I01lOIlO01IO0lI=(OlI1OO01IlIOIl0|OOl1IOOl1IIlI0O)&~IIO0lIlO01OOIl1;assign IO01lI01lOlO10I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01lIO10&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IlI0OOIl01[31:24];assign l10IOIO01lOOIl1
=~l10IOIO01lOlI01&IIO0lIO01llIO10&OOIl1OOl1IIlI0O&~O1lIOOI01ll0IO1&lO10II01lOIOIl0;dff32 IOIl01IO01lIlO01
(IOIl0IIO0lOlI01,O1lIOl10IOO01Il,clk,reset_b,1'b1);assign O01IllO10IIlO01
=~(OI01lOlI1OlO10I&((IlI0OIlO01I1lO0&~parin)|(~IlI0OIlO01I1lO0&parin)));dffe8 IIOIl0lIO10I01lO
(OlI1OOIl01OlI1O[7:0],OOl1IOOIl1O1lIO[7:0],clk,reset_b,1'b1,IIO0lOI01llIO10);assign IO01lIO01lOOl1I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01I01lO&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IlI0OIlO01[7:0];dff IOIl01OIl01l10IO
(OI01lOlI1OIO0lI,lIO10OlI1OOlI1O,clk,reset_b,1'b1);dff32 IIO0lIOlI01IO01l(OIl01IlI0OIlI0O,OI01lI01lOOI01l,clk,reset_b,1'b1);dff Il0IO1IOIl0O01Il
(OlI1OO01IlIOIl0,IlI0OOIl01I1lO0,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[10]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[10])|
(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[10])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[10]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[10])|
(IlI0OIlO01OOl1I&h_din[10]);assign lIO10IO01lO01Il[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&l0IO1OOl1IOlI1O&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0OI01lOlI01[15:8];assign OlI1OI01lOIO01l
=IIO0lIIO0lOlI01&IIO0lOIl01I01lO&~OOl1IIlI0OOIl01&~(IIO0lIO01llIO10&O1lIOOI01ll0IO1)&~OI01lIIO0lI1lO0;assign I01lOl0IO1I1lO0[15:0]
=subvendor_id;assign OOl1IOOIl1IlO01=(OOl1IOOl1IIlI0O&I01lOlIO10lO10I)|(I01lOO01IlOI01l&l10IOO1lIOlIO10)|I01lOlO10IOOl1I;assign OOl1IOOIl1O1lIO[29]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[29])|
(IlI0OIlO01OOl1I&h_din[29])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[29]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[29])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[29]);assign IIO0lOlI1OlIO10[7:6]
=2'b00;BUF IIlO01OlI1OOI01l(OOl1II01lOO1lIO,O1lIOIlI0OOlI1O);assign OI01lIlO01OI01l
=(IlO01IlO01IlO01[7:2]==6'b110001)?1'b1:1'b0;assign lIO10O01IlO01Il
=(I01lOlIO10lO10I&IOIl0OOIl1OlI01)|(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe8 Il0IO1IO0lIO01Il
(OI01lIIO0lOI01l[15:8],O01IlIO01lIlO01[15:8],clk,reset_b,1'b1,I01lOIlO01lO10I);dff IIlO01O01IlI1lO0
(IO01lOOIl1IO0lI,l10IOOIl01IIO0l,clk,reset_b,1'b1);assign IIO0lIOIl0IIO0l=~IlI0OI1lO0IO0lI;assign O1lIOl10IOO01Il[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIO01llO10I&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IIO0lOlI01[31:24];assign l10IOOlI1OI01lO
=((O01IlOOl1IOIl01==4'b0110)|
(O01IlOOl1IOIl01==4'b1100)|
(O01IlOOl1IOIl01==4'b1110)|
(O01IlOOl1IOIl01==4'b0010))?1'b1:1'b0;assign lIO10lO10IO01Il[19]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[19])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign IIO0llIO10OlI01
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);assign IIO0ll10IOOOIl1
=l10IOI01lOlIO10&gnt_b&~IlI0Ol10IOOI01l&~lO10Il10IOl0IO1&~(l10IOl10IOlIO10[3]&l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0]);assign O1lIOl10IOIO01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIO01lI1lO0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IIO0lI01lO[7:0];assign O1lIOOI01ll0IO1
=~O01IlI01lOl10IO;dff Il0IO1IlI0Ol0IO1(oe_trdy,I1lO0IO0lIOOIl1,clk,reset_b,1'b1);assign lIO10lO10IO01Il[0]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[0])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff3 IIO0lIOIl01O01Il
(O01IlOOl1IIlO01[15:13],I01lOlO10IOI01l[15:13],clk,1'b1,reset_b);assign lIO10IIO0ll0IO1[3:0]
=(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l)?OI01lOlI01I1lO0[3:0]:
(I01lOl10IOlO10I)?OOIl1O1lIOO1lIO[3:0]:l10IOl10IOlIO10[3:0];assign IO01lI1lO0OI01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OOIl1&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IOIl0IlI0O[15:8];dff II1lO0O01IlI01lO
(IO01llO10II1lO0,IIO0lIIO0lOlI01,clk,reset_b,1'b1);assign IIO0lOlI1OIIO0l=~IlI0OlIO10OI01l;assign O01IlIO0lIO1lIO
=OlI1OOIl01OlI1O[20]^OlI1OOIl01OlI1O[21]^OlI1OOIl01OlI1O[22]^OlI1OOIl01OlI1O[23];assign OOl1IOI01lIlI0O
=LCELL(l10IOI01lOIIO0l|(O01IlOI01lOIl01&OlI1OO01Ill0IO1));assign lIO10I1lO0IO01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01IOIl0&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IOIl0I01lO[23:16];dffe16 IIO0lIOOIl1OlI1O
(O01IlIOIl0OIl01[15:0],lO10II1lO0O01Il[15:0],clk,1'b1,reset_b,OlI1OI1lO0l0IO1);assign OIl01IO0lIIlO01
=(IO01llIO10IO0lI[7:0]==8'h04)?1'b1:1'b0;dff IOOIl1l10IOOIl01(OI01lOOl1IIO0lI,IIO0lO01IllIO10,clk,reset_b,1'b1);BUF IIO0lIO1lIOO01Il
(IO01ll0IO1OI01l,lO10IIlO01IOIl0);assign OI01lI01lOOI01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01OIl01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IlI0OIlI0O[31:24];dff Il0IO1OOIl1IOIl0
(l10IOIO01lOlI01,lIO10OI01lO01Il,clk,reset_b,1'b1);assign OOl1IIlO01OIl01=OIl01O1lIOl10IO[0]&O1lIOlIO10IO01l;assign OI01lOOl1IlO10I
=(adin[24]^adin[25]^adin[26]^adin[27]);dff IOIl01lIO10l10IO(OI01llO10IIO0lI,O01IlOlI01l10IO,clk,reset_b,1'b1);assign OI01lI01lOI1lO0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01l10IO&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IlI0Ol10IO[7:0];assign O1lIOO01Ill0IO1
=((~l10IOIO01lOlI01&IIO0lIO01llIO10&O1lIOOI01ll0IO1)|(OOl1IIlI0OOIl01)|
(O1lIOOI01ll0IO1&I01lOI01lOlO10I&IIO0lIlI0OOlI01[0]))&~O01IlIIO0lIlI0O;dff32 IIO0lIOlI01O01Il
(OIl01IOIl0OIl01,OI01lI1lO0lO10I,clk,reset_b,1'b1);assign O1lIOOlI1Ol0IO1
=((IIO0lIIO0lOlI01&IIO0lOIl01I01lO)|
LCELL((IIO0lOOl1IIIO0l&h_retry_b)|
(OlI1OO01IlIOIl0&I01lOlIO10lO10I))|
LCELL((l10IOOOl1IOlI01&IlI0OlIO10OOl1I)|
(lO10IO01IlO01Il&IlI0OlIO10OOl1I)|
(OI01lIOIl0IO0lI)));assign OOl1IOOIl1O1lIO[2]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[2])|
(IlI0OIlO01OOl1I&h_din[2])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[2]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[2])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[2]);assign O1lIOIO01lIOIl0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IlO01OOl1IOOl1I&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0OI01lIIO0l[15:8];assign h_boff_b
=~(IlI0OIO01lIO0lI|(l10IOOOl1IOOIl1&lO10IlIO10l0IO1&l10IOOlI1OI01lO));dff32 II01lOOOl1IOlI01
(I1lO0OI01lOlI01,lIO10IO01lO01Il,clk,reset_b,1'b1);assign OlI1OOIl01O01Il=OOl1IOOIl1OIl01|I01lOOIl01lO10I;assign OOl1IOOIl1O1lIO[21]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[21])|
(IlI0OIlO01OOl1I&h_din[21])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[21]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[21])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[21]);assign OlI1OlO10Il0IO1[0]
=IIO0lOOIl1OOIl1;assign l10IOO01IlI01lO
=(framein_b&~gnt_b&irdyin_b)&
LCELL((O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~lO10IOIl01IOIl0)|((l10IOIIO0llIO10|(O01IlIIO0ll10IO&~(lIO10lIO10IOIl0&O1lIOOOIl1IO01l)))&~lO10IOIl01IOIl0));assign OI01lIlO01OOl1I
=(IlO01IlO01IlO01[7:2]==6'b101001)?1'b1:1'b0;assign OIl01OOl1IIlO01
=~I01lOlIO10lO10I&((~h_abort_b&~I1lO0OOl1IOOIl1)|lIO10O01IlIO01l);assign IO01lIlI0OIO0lI
=LCELL(lIO10IOIl0OlI1O&IIO0lOIl01I01lO);assign IO01lOlI1OOI01l[31:13]=O01IlOOl1IIlO01[31:13];assign IO01lIOIl0I1lO0
=~l10IOlO10IOlI01&O1lIOIIO0lIO01l[1]&O1lIOIIO0lIO01l[0]&lIO10IOIl0OlI1O;assign OOIl1OlI01IlO01
=(IlO01IlO01IlO01[7:2]==6'b111100)?1'b1:1'b0;dff II1lO0I01lOIIO0l(OOl1IIO01ll10IO,l10IOIO01lI01lO,clk,1'b1,reset_b);assign lIO10lO10IO01Il[27]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[27])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff IOlI01OIl01OOl1I
(lIO10IO0lIO01Il,OI01lIO0lIIO0lI,clk,reset_b,1'b1);assign IIO0ll10IOI01lO[1]
=~l10IOlO10IOlI01&
CASCADE((IO01lIOIl0OOl1I&OOl1Il10IOIlO01[1])|(l10IOI1lO0OOIl1&O1lIOIIO0lIO01l[1]));assign lIO10l10IOl0IO1[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIO01ll0IO1&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IIO0llIO10[7:0];assign O1lIOOOIl1IO01l
=~h_adsh_b;assign lO10IOIl01IOIl0=IO01lOI01lI1lO0|OlI1OO01IlIOIl0;assign lIO10lO10IO01Il[8]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[8])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign O01IlI01lOIlI0O
=(IlO01IlO01IlO01[7:2]==6'b000011)?1'b1:1'b0;assign OI01lOlI01I1lO0[2]=h_mio;assign OI01lI1lO0IO0lI[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lIlO01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IOIl0O1lIO[15:8];dff II1lO0O01IlOlI01
(I01lOl10IOlO10I,OlI1Ol10IOOlI1O,clk,reset_b,1'b1);assign I01lOlIO10IO0lI
=(l10IOO1lIOlIO10&l10IOO1lIOIIO0l)|
(O01IlO1lIOIlI0O)|
(IIO0lOOl1IIIO0l&~h_retry_b)|
(lO10IO01IlOlI1O&(~h_retry_b|~h_abort_b)&I01lOlIO10lO10I&(l10IOO1lIOlIO10|(OlI1OO01Ill0IO1&I01lOO01IlI1lO0)))|
(OlI1OO01IlIOIl0&~h_retry_b&(I01lOlIO10lO10I|OlI1OO01Ill0IO1)&(l10IOO1lIOlIO10|(OlI1OO01Ill0IO1&I01lOO01IlI1lO0)))|
(OlI1OO01IlIOIl0&~h_abort_b&~I1lO0OOl1IOOIl1&I01lOlIO10lO10I&(l10IOO1lIOlIO10|(OlI1OO01Ill0IO1&I01lOO01IlI1lO0)))|
LCELL((I01lOlIO10lO10I&LCELL((OlI1OO01IlIOIl0&~h_bii_b&IIO0lO1lIOI01lO&I01lOO01IlI1lO0)|
(O01IlOOl1IO1lIO&lIO10O01IlIO01l&OlI1OO01Ill0IO1&I01lOO01IlI1lO0)|
(OOl1IOOl1IIlI0O&(l10IOO1lIOlIO10|(OlI1OO01Ill0IO1&I01lOO01IlI1lO0)))))|
(lO10IO01IlOlI1O&OlI1OO01Ill0IO1&~I01lOlIO10lO10I));assign IlI0OlO10IlO10I
=(IIO0lIlO01OlI01)?OI01lOlI01OOl1I[35:32]:cbein_b;assign O1lIOl0IO1l0IO1=l10IOl0IO1I01lO&l10IOOOl1IOOIl1&~lO10IOIl01IOIl0;assign OIl01OlI1OO1lIO
=lIO10OOl1IIO01l|((O01IlIIO0lIlI0O|O01IlIIO0ll10IO|l10IOIIO0llIO10)&OlI1Ol10IOIO01l);assign O1lIOI1lO0l0IO1[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01IO0lI&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IOIl0lIO10[23:16];assign OOl1IIIO0lO1lIO
=I01lOl10IOlO10I|
((lO10IOIl01IOIl0|~(~gnt_b&framein_b&irdyin_b))&l10IOIIO0llIO10);dff8 IOIl01IO01lO1lIO
(O1lIOOIl01OlI1O[7:0],IO01lOIl01IO0lI[7:0],clk,reset_b,1'b1);dff IOOIl1l10IOO1lIO
(I1lO0OlI1OOOIl1,O1lIOIO0lIl0IO1,clk,reset_b,1'b1);assign lO10IIO01lIO01l=l10IOOOl1IOlI01;assign IO01lI01lOIO0lI[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OlI01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IlI0OO1lIO[31:24];assign I01lOI01lOIO0lI
=~O01IlIOIl0OIl01[3]&~O01IlIOIl0OIl01[2]&~O01IlIOIl0OIl01[1]&O01IlIOIl0OIl01[0];dff32 Il0IO1OI01lO01Il
(OOIl1OlI1OIlI0O[31:0],adin[31:0],clk,reset_b,1'b1);dff Il0IO1IOIl0OlI1O(O01IllIO10IlI0O,OI01lO1lIOOI01l,clk,reset_b,1'b1);assign O01IlOlI01IlI0O
=(IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)|IIO0ll10IOOlI01|l10IOIlO01lIO10;assign IO01lI01lOlO10I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01lIO10&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IlI0OOIl01[7:0];assign OOl1IIO01lIlI0O
=~O1lIOOI01ll0IO1&OOIl1OOl1IIlI0O;dff32 IIO0lIOlI01OlI1O(OIl01IIO0ll10IO,OI01ll10IOI1lO0,clk,reset_b,1'b1);assign IO01lIO0lII1lO0
=(l10IOl0IO1I01lO&l10IOOOl1IOOIl1&~lO10IOIl01IOIl0);dffe8 IIlO01IO0lIOOl1I
(OlI1OOIl01OlI1O[31:24],OOl1IOOIl1O1lIO[31:24],clk,reset_b,1'b1,I01lOIO01lI1lO0);assign lIO10IO01lOlI1O[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01IO01l&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0OI01lOOIl1[15:8];assign lIO10OlI1OOlI1O
=OI01lIIO0lI1lO0;dff32 II01lOOOl1IOOIl1(I1lO0IlI0OlIO10,lIO10I01lOl0IO1,clk,reset_b,1'b1);dff IIOIl0I1lO0lIO10
(l10IOOOl1IOlI01,l10IOOlI1OOOIl1,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[13]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[13])|
(IlI0OIlO01OOl1I&h_din[13])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[13]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[13])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[13]);assign OlI1OlO10Il0IO1[8]
=OI01lOOIl1OI01l;dff Il0IO1OlI1OOlI1O(IIO0lOIl01OOIl1,lIO10OOl1IIO01l,clk,reset_b,1'b1);assign OI01lIO01llO10I
=(IlO01IlO01IlO01[7:2]==6'b100001)?1'b1:1'b0;dff II1lO0I1lO0I01lO(lIO10O01IlIO01l,OIl01OOl1IIlO01,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[32]
=(IlI0OIlO01OOl1I&h_bein_b[0])|
(O01IlOI01lIlO01&l10IOOOIl1IIO0l[0])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[32]);assign IlI0Ol0IO1lO10I[31:16]
=16'b0000000000000000;BUF IOIl01lO10IOIl01(l10IOI1lO0I01lO,IO01lIOIl0I1lO0);assign OOIl1OlI01OIl01
=(IlO01IlO01IlO01[7:2]==6'b110100)?1'b1:1'b0;assign IOIl0OOl1IlIO10
=(I01lOlIO10lO10I&OIl01OOIl1l10IO)|(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe8 IIOIl0l0IO1lIO10
(OI01lOlI01OOl1I[7:0],adin[7:0],clk,reset_b,1'b1,I1lO0OOl1IOlI01);assign lO10IlO10IO01Il
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[0]:IIO0lOOIl1OOIl1;dff IIO0lIOlI1Ol0IO1
(l10IOIOIl0OOIl1,I01lOI1lO0OOl1I,clk,1'b1,reset_b);assign O1lIOl10IOO01Il[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIO01llO10I&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IIO0lOlI01[7:0];assign IlI0OlIO10OOl1I
=O01IlOOl1IOIl01[3]&~O01IlOOl1IOIl01[2]&O01IlOOl1IOIl01[1]&O01IlOOl1IOIl01[0]&
IIO0lOOl1IlIO10&~IlO01IlO01IlO01[0]&~IlO01IlO01IlO01[1];assign lIO10lO10IO01Il[16]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[16])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign O1lIOIO0lIIOIl0
=~(lIO10O1lIOl0IO1&OOIl1OlI1OIlI0O[27])&(l10IOlIO10lIO10|(IIO0ll0IO1lIO10));dffe IIOIl0lIO10OOIl1
(IIO0lI01lOI01lO,OI01lIlI0OI1lO0,clk,reset_b,1'b1,OOl1Il10IOOIl01);assign IO01lI1lO0OOl1I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OI01lI01lO&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IIO0lIlO01[15:8];assign l10IOO1lIOlIO10
=~framein_b;dff IIOIl0I01lOI01lO(O01IlO1lIOIlI0O,lO10IlIO10IOIl0,clk,reset_b,1'b1);assign h_dout=OI01lIIO0lOI01l;assign OOl1IOlI1OIlI0O[31:24]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IIO0lI01lOOlI01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:lO10IO01IlIO01l[31:24];assign OOl1Il10IOO1lIO[3]
=
(IIO0lOIl01I01lO&LCELL(OlI1Ol10IOO01Il&OOl1IOOIl1O1lIO[35]))|
LCELL((IO01llO10IOI01l&OOl1IOOIl1O1lIO[35])|
((O01IlIIO0lIlI0O)&OI01lOlI01I1lO0[3])|
((I01lOl10IOlO10I)&OOIl1O1lIOO1lIO[3])|
(((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0])&IO01lIIO0llO10I[3]))|
I1lO0OlI1OOlI01[3];assign lIO10I1lO0O01Il[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01OlI1O&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IOIl0OlI01[23:16];assign lO10Il0IO1IO01l
=(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&(framein_b&~gnt_b&irdyin_b)&(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0)&~lO10IOIl01IOIl0)|
(O01IlIIO0ll10IO&(framein_b&~gnt_b&irdyin_b)&~lO10IOIl01IOIl0)|
(IlI0Ol10IOOI01l&~h_wait_b);assign O01IlOIl01l10IO
=(l10IOOOl1IOOIl1&lO10IlIO10l0IO1);assign OlI1Ol0IO1IOIl0=LCELL(cbein_b[0]^cbein_b[1]^cbein_b[2]^cbein_b[3]);assign lO10IIO01lO01Il
=LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO);assign OI01lI01lOOOl1I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01IlI0O&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IOIl0IlO01[31:24];BUF II1lO0OIl01IIO0l
(IlI0OI01lOOOl1I,O01IlIOIl0IlO01);assign OOIl1OOIl1O1lIO[7:0]
=(IlI0OlIO10I1lO0|~OOIl1OlI1OIlI0O[1])?OOIl1OlI1OIlI0O[9:2]:
(OOIl1OlI1OIlI0O[1]&IO01ll10IOIO0lI)?{4'b1111,OOIl1OlI1OIlI0O[5:2]}:
(OOIl1OlI1OIlI0O[1]&O1lIOl10IOOlI1O)?{5'b11111,OOIl1OlI1OIlI0O[4:2]}:
(OOIl1OlI1OIlI0O[1]&OI01ll10IOOOl1I)?{6'b111111,OOIl1OlI1OIlI0O[3:2]}:8'b11111111;dff Il0IO1IIO0ll0IO1
(OI01lOlI1OlO10I,O01IllO10IOIl01,clk,reset_b,1'b1);BUF II1lO0lIO10lIO10(OIl01IO0lIOIl01,IIO0lOlI01OlI01);assign OI01lI01lOOI01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01OIl01&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IlI0OIlI0O[7:0];BUF IIOIl0OIl01OlI01
(IO01lOI01lOI01l,OOl1IIO01lIlI0O);assign O01IlIlO01l10IO
=(lO10IO01IlOlI1O&~OlI1OO01Ill0IO1&~I01lOlIO10lO10I&IIO0lO1lIOI01lO)?1'b1:
(lO10IO01IlOlI1O&IIO0lO1lIOI01lO&~OlI1OO01Ill0IO1&~l10IOO1lIOlIO10)?1'b1:1'b0;assign OOl1IO01Ill10IO
=LCELL(IIO0lOlI01I01lO^OlI1OIlO01IO01l^OOl1IOlI01IlO01^IO01lOOl1IOOl1I);assign O1lIOIOIl0IOIl0
=LCELL(
(LCELL((O01IlOOl1IO1lIO|IlI0OO01IlIO0lI)&~OOl1IOOl1Il10IO&~lIO10O01IlIO01l)&l10IOO1lIOlIO10)|
(LCELL(lO10IO01IlOlI1O&h_abort_b)&l10IOO1lIOlIO10)|
(LCELL(I01lOO01IlOI01l&OI01llO10IIO0lI&l10IOOlI1OI01lO)&l10IOO1lIOlIO10));assign O1lIOI01lOIO01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01I1lO0&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IlI0OI01lO[15:8];assign O01IlIlI0Ol10IO
=~IIO0lIlI0OOlI01[7]&~IIO0lIlI0OOlI01[6]&~IIO0lIlI0OOlI01[5]&~IIO0lIlI0OOlI01[4];dff32 II1lO0IlO01lIO10
(I1lO0IOIl0I01lO,lIO10I1lO0IO01l,clk,reset_b,1'b1);dff IIOIl0I1lO0IIO0l(l10IOOOl1IOOIl1,IIO0lOOIl1OlI01,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[5]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[5])|
(IlI0OIlO01OOl1I&h_din[5])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[5]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[5])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[5]);assign IO01lIO01lOI01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0O01IlOOIl1&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1OI01lIlI0O[23:16];dff IIlO01OlI1OOOl1I
(I01lOIO01lOOl1I,IIO0lIlI0OI01lO,clk,reset_b,1'b1);assign O01IlIO0lIOIl01[31:16]=IIO0lOlI1OlIO10;assign O01IlOOIl1l10IO
=(LCELL(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&lO10IlIO10l0IO1&lO10IlO10IIO01l)&I01lOlIO10lO10I);assign OOl1IOOIl1O1lIO[24]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[24])|
(IlI0OIlO01OOl1I&h_din[24])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[24]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[24])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[24]);assign IIO0lOlI1OlIO10[13]
=O01Ill0IO1OIl01;assign OOIl1OOIl1IlO01=~(OOl1IIIO0lOIl01&l10IOIOIl0OOIl1)&
~(I01lOl10IOlO10I)&
~(IIO0llO10IIIO0l);assign OOIl1OlI01O1lIO
=(IlO01IlO01IlO01[7:2]==6'b101100)?1'b1:1'b0;assign OI01lOIl01OI01l
=((OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
~OlI1OO01Ill0IO1&IIO0lIlO01OOIl1&~(IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1&IO01lOI01lI1lO0));assign lIO10IIO0lIOIl0[31:2]
=
(lIO10l0IO1IO01l&I1lO0IO0lII01lO&IO01ll10IOIO0lI)?{IO01lIIO0lIO0lI[31:6],(IO01lIIO0lIO0lI[5:2]+4'b0001)}:
(lIO10l0IO1IO01l&I1lO0IO0lII01lO&O1lIOl10IOOlI1O)?{IO01lIIO0lIO0lI[31:5],(IO01lIIO0lIO0lI[4:2]+3'b001)}:
(lIO10l0IO1IO01l&I1lO0IO0lII01lO&OI01ll10IOOOl1I)?{IO01lIIO0lIO0lI[31:4],(IO01lIIO0lIO0lI[3:2]+2'b01)}:
(IO01lIIO0lIO0lI[31:2]+30'h00000001);dff IlO10IOOl1IOIl01
(IlI0OOIl01OOl1I,l10IOOlI1OOlI01,clk,reset_b,1'b1);assign frameout_b=I01lOI1lO0OI01l;assign l0IO1OOl1IOlI1O
=(IlO01IlO01IlO01[7:2]==6'b111111)?1'b1:1'b0;assign lIO10OI01lIO01l
=(OOl1IIO01ll10IO&O1lIOOlI01O01Il&(h_abort_b|I1lO0OOl1IOOIl1))|
(IO01lOI01lI1lO0&I1lO0OOl1IOOIl1)|
(IO01lOI01lI1lO0&~IIO0lO1lIOI01lO&h_abort_b)|
(IO01lOI01lI1lO0&IIO0lO1lIOI01lO&O1lIOOlI01O01Il&h_abort_b);assign lIO10lO10IO01Il[24]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[24])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff IOlI1OOOIl1O1lIO
(IO01lIO0lIOI01l,lIO10IO0lIOlI1O,clk,reset_b,1'b1);assign O01Ill10IOl10IO
=O1lIOIIO0lIO01l[1]&O1lIOIIO0lIO01l[0]&~l10IOlO10IOlI01&~IlI0Ol10IOOI01l&~lO10Il10IOl0IO1;assign OI01ll10IOI1lO0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OI01ll10IO&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IIO0ll10IO[15:8];assign lIO10l10IOIOIl0
=~h_wait_b&(IlI0Ol10IOOI01l|(lIO10IOIl0OlI1O&IIO0lOIl01I01lO&~IIO0lIOIl0lIO10&~I01lOI1lO0OI01l)|I1lO0IIO0lIIO0l);assign h_cs_b[0]
=I1lO0OOl1IOOIl1|~OOIl1IO0lIl10IO;assign lIO10lO10IO01Il[5]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[5])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign O1lIOOOIl1O01Il
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O01IlI01lOIlI0O&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOl1IOIl01OIl01;assign O1lIOlIO10OlI1O
=OOIl1OlI1Ol10IO&OOl1IOIl01IlO01&l10IOl10IOlIO10[3]&l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0];assign O1lIOI1lO0IOIl0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OOl1I&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IOIl0IIO0l[23:16];dff IOlI01OOl1IlO10I
(O01IlIIO0ll10IO,l10IOIIO0lIIO0l,clk,reset_b,1'b1);assign IO01ll0IO1OOl1I
=(l10IOOOl1IOOIl1&lO10IlIO10l0IO1)|
(OIl01IO0lIO1lIO)|
(~OOl1IOOl1Il10IO|~I01lOO01IlI1lO0);assign OlI1OlIO10IO01l
=OlI1OOIl01OlI1O[0]^OlI1OOIl01OlI1O[1]^OlI1OOIl01OlI1O[2]^OlI1OOIl01OlI1O[3];assign OOl1II01lOOIl01
=(OOIl1O1lIOOIl01&IlI0OOIl01OOl1I&O01IlO1lIOl10IO)?1'b1:1'b0;assign lIO10lO10IOlI1O
=(~h_wrin&~(IIO0lIO01llIO10|l10IOIO01lOlI01|IOIl0O1lIOOlI01))?4'b0000:h_bein_b;assign IO01lI1lO0I1lO0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01IIO0l&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IOIl0l10IO[31:24];assign OI01llIO10OI01l
=O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0);dffe6 IIO0lIOI01lIOIl0
(I1lO0OOl1II01lO[7:2],OOl1IIlO01IlO01[7:2],clk,reset_b,1'b1,IOIl0OlI1OIIO0l);dff Il0IO1IIO0lIOIl0
(OOl1IOlI01IlO01,IO01lOOl1IOI01l,clk,reset_b,1'b1);assign IIO0lOlI01OOIl1=l10IOIIO0llIO10|O01IlIIO0lIlI0O;assign IO01lI01lOIO0lI[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OlI01&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IlI0OO1lIO[7:0];assign IlI0OI1lO0lO10I
=O01IlIOIl0OIl01-16'h0001;dff4 IIOIl0IO01llIO10(IlI0OO01IllO10I,cbein_b,clk,reset_b,1'b1);assign OOl1IO01IlIlI0O
=(adin[4]^adin[5]^adin[6]^adin[7]);assign OlI1OIlO01O01Il
=(IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)|IIO0ll10IOOlI01|l10IOIlO01lIO10;assign lIO10I01lOl0IO1[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01l0IO1&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IlI0OlIO10[15:8];assign IO01lOI01lOOl1I
=OI01lOI01lIO0lI&IIO0lOIl01I01lO;dff32 II1lO0IlO01IIO0l(I1lO0IOIl0OOIl1,lIO10I1lO0OlI1O,clk,reset_b,1'b1);assign IIO0llIO10OOIl1
=OlI1Ol10IOO01Il;dffe4 IOIl01l0IO1O1lIO(l10IOOOIl1IIO0l,h_bein_b,clk,reset_b,1'b1,l10IOOI01lI01lO);assign OI01lIO01lIO0lI[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01IlO01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01OI01lO1lIO[23:16];dff IOlI01OOIl1I1lO0
(lIO10OlI1OO01Il,lO10IIO01lOlI1O,clk,reset_b,1'b1);dff32 IOlI01O01IlIO0lI(OOIl1IlI0OIlO01,IO01lIO01lOOl1I,clk,reset_b,1'b1);dff IIlO01IOIl0I1lO0
(IO01lO01IlOI01l,IIO0lOOl1IIIO0l,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[16]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[16])|
(IlI0OIlO01OOl1I&h_din[16])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[16]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[16])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[16]);assign OlI1OlO10Il0IO1[5]
=1'b0;assign O01IlO01IlIlO01
=framein_b&irdyin_b&~gnt_b&
((O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~lO10IOIl01IOIl0)|((l10IOIIO0llIO10|O01IlIIO0ll10IO)&~lO10IOIl01IOIl0));assign OOIl1OI01ll10IO
=(IlO01IlO01IlO01[7:2]==6'b100100)?1'b1:1'b0;BUF IOlI01IlI0OOOl1I(OIl01OOIl1IlI0O,lIO10OIl01IOIl0);assign OOl1IOOIl1O1lIO[35]
=(IlI0OIlO01OOl1I&h_bein_b[3])|
(O01IlOI01lIlO01&l10IOOOIl1IIO0l[3])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[35]);assign IIO0lIO0lIlIO10[31:16]
=16'b0000000000000000;assign lIO10IOIl0OlI1O=LCELL(IIO0lIIO0lOlI01|OlI1Ol10IOO01Il);assign lIO10IlO01l0IO1
=(IlO01IlO01IlO01[7:2]==6'b110111)?1'b1:1'b0;assign O01IlIlO01IlI0O
=((IIO0lO1lIOI01lO|~h_abort_b)&~I1lO0OOl1IOOIl1)|IIO0lOOl1IIIO0l;dffe8 IIlO01IO0lII1lO0
(OI01lOlI01OOl1I[31:24],adin[31:24],clk,reset_b,1'b1,OI01lO01IllO10I);assign O1lIOlO10Il0IO1
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[4]:IOIl0OlI1OlIO10;dff3 IOOIl1lO10Il10IO
(O1lIOIIO0lIO01l,IIO0ll10IOI01lO,clk,reset_b,1'b1);assign IO01ll10IOlO10I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OI01llIO10&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IIO0lOIl01[15:8];dff IIOIl0I01lOOlI01
(O1lIOlO10IIOIl0,O01IlOlI1OOIl01,clk,1'b1,reset_b);assign lIO10lO10IO01Il[13]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[13])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign O01Ill0IO1O1lIO
=(~(IIO0llIO10OlI01&OOIl1OlI1OIlI0O[30]))&(O01IllIO10IlI0O|(l10IOl0IO1OlI01));dff4 IIlO01O1lIOIO0lI
(l10IOl10IOlIO10,lIO10IIO0ll0IO1,clk,reset_b,1'b1);assign lIO10I1lO0OlI1O[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IO01lIO01l&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IOIl0OOIl1[23:16];dff IOlI01OOl1IIO0lI
(O01IlIIO0lIlI0O,l10IOIO0lII01lO,clk,1'b1,reset_b);BUF IIlO01OI01lOOl1I(lIO10l0IO1OlI1O,lIO10OOIl1l0IO1);dffe4 II1lO0l0IO1I01lO
(OI01lOlI01OOl1I[35:32],cbein_b,clk,reset_b,1'b1,IOIl0OOl1IlIO10);assign I01lOlO10IOI01l[31:24]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlI0OO01Il&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:O01IlOOl1IIlO01[31:24];assign I1lO0OlI1OOlI01[1]
=CASCADE(~((OlI1Ol10IOO01Il&IIO0lOIl01I01lO)|IO01llO10IOI01l)&
~(O01IlIIO0lIlI0O))&
~(I01lOl10IOlO10I)&
LCELL(~((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0]))&
O1lIOIIO0lOlI1O[1];assign OI01lI1lO0lO10I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01O1lIO&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IOIl0OIl01[31:24];assign O01IlI1lO0OIl01
=LCELL(IIO0lIIO0lOlI01&~OI01lIIO0lI1lO0);assign IIO0lO1lIOOOIl1=OlI1OlIO10OlI1O|OOl1IO1lIOO1lIO|lIO10OOIl1l0IO1;assign lO10Il0IO1O01Il
=(OOl1IIO0lIIlI0O^I01lOl0IO1OI01l^OlI1Ol0IO1IOIl0);assign IIO0lOI01llIO10
=CASCADE(OlI1Ol10IOO01Il|
(I01lOlIO10lO10I&l10IOOI01lOlI01)|
IIO0lOI01lIIO0l)&
(IIO0lOIl01I01lO|(I01lOlIO10lO10I&l10IOOI01lOlI01)|IIO0lOI01lIIO0l);assign OI01lI01lOOOl1I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01IlI0O&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IOIl0IlO01[7:0];assign IOIl0OOl1IIIO0l
=((~(IIO0lIO01llIO10&((O1lIOOOIl1IO01l&O01IlIIO0lIlI0O&~lO10IOIl01IOIl0)|O01IlIIO0ll10IO|IlI0Ol10IOOI01l)))&
~(l10IOIO01lOlI01&(O01IlIIO0ll10IO|IlI0Ol10IOOI01l))&
(~(~l10IOIO01lOlI01&IOIl0O1lIOOlI01))&
((~l10IOIO01lOlI01&~IOIl0O1lIOOlI01)|l10IOIOIl0OlI01))?1'b1:1'b0;assign OI01lOIl01OOl1I
=O1lIOOIl01OlI1O[7]&O1lIOOIl01OlI1O[6]&O1lIOOIl01OlI1O[5]&O1lIOOIl01OlI1O[4]&
O1lIOOIl01OlI1O[3]&O1lIOOIl01OlI1O[2]&O1lIOOIl01OlI1O[1]&O1lIOOIl01OlI1O[0];dff IIOIl0l10IOI01lO
(OOl1IlIO10O1lIO,O1lIOO1lIOOlI1O,clk,reset_b,1'b1);assign l10IOIlO01lIO10
=((OOl1IIIO0lOIl01&OI01lOlI1OIO0lI)|IlI0Ol10IOI1lO0)&IIO0lI01lOI01lO;assign O1lIOI01lOO01Il[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01lO10I&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IlI0OOlI01[15:8];assign lO10II01lOIOIl0
=~IIO0lIlI0OOOIl1|~OlI1OI01lOOlI1O|~OOl1IIlI0OO1lIO|O01IlIOIl0OIl01[3]|
O01IlIOIl0OIl01[2]|(O01IlIOIl0OIl01[1]&O01IlIOIl0OIl01[0]);dff32 II1lO0IO01lI01lO
(OOl1IOlI1Ol10IO,I01lOlO10II1lO0,clk,reset_b,1'b1);assign O01IlI1lO0O1lIO=lO10IO01IlO01Il&IlI0OlIO10OOl1I;assign O01IlOlI01l10IO
=IIO0lI1lO0IIO0l|O1lIOIOIl0IOIl0|OOl1II1lO0IlI0O|IO01lIOIl0OI01l;assign IO01lIO01lOOl1I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01I01lO&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IlI0OIlO01[23:16];dff II1lO0OIl01lIO10
(IIO0lIIO0lI01lO,IO01lOlI1OOOl1I,clk,reset_b,1'b1);dff32 IOlI01OlI01I1lO0(OOIl1IlI0OO1lIO,IO01lI01lOIO0lI,clk,reset_b,1'b1);dff IIlO01IOIl0OI01l
(IlI0OO01IlIO0lI,lO10IOIl01l0IO1,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[8]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[8])|
(IlI0OIlO01OOl1I&h_din[8])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[8]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[8])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[8]);assign lIO10IO01lO01Il[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&l0IO1OOl1IOlI1O&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0OI01lOlI01[31:24];assign OOl1IIlI0OIlO01
=(IlI0Ol10IOOI01l&OOIl1OOl1IIlI0O&h_wait_b)|(IO01lO01IlI1lO0&~OOl1IIlI0OOIl01);assign OOl1IIO0lIl10IO[7:0]=revision_id;assign OlI1OOIl01IO01l
=
(OlI1OO01IlIOIl0&(~h_retry_b|(~h_abort_b&~I1lO0OOl1IOOIl1)|(~h_bii_b&IIO0lO1lIOI01lO))&~I01lOlIO10lO10I&l10IOO1lIOlIO10)|
(OOl1IOOl1IIlI0O&~I01lOlIO10lO10I);assign OOl1IOOIl1O1lIO[27]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[27])|
(IlI0OIlO01OOl1I&h_din[27])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[27]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[27])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[27]);assign IIO0lOlI1OlIO10[10:9]
=2'b10;dff IIO0lIOlI1OIOIl0(I01lOI1lO0OI01l,OOl1IIOIl0IlI0O,clk,1'b1,reset_b);assign lIO10IlO01IOIl0
=(IlO01IlO01IlO01[7:2]==6'b101111)?1'b1:1'b0;assign lIO10OIl01l0IO1
=((OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
~OlI1OO01Ill0IO1&IIO0lIlO01OOIl1&~(IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1&IO01lOI01lI1lO0));assign l10IOl10IOIIO0l[1]
=(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l)?((h_ain[1]&~h_mio)|(h_cacheline&h_mio)):
(l10IOIIO0llIO10)?IOIl0IO0lIlIO10[1]:IO01lIIO0lIO0lI[1];dff IIO0lIO01Ill0IO1
(lIO10OOIl1IOIl0,O01IlOIl01IlI0O,clk,reset_b,1'b1);assign O01IlIOIl0O1lIO
=
CASCADE(~((O01IlIIO0lIlI0O&~O1lIOOOIl1IO01l)|
(lIO10IOIl0OlI1O&OI01lIIO0lI1lO0)|
(IlI0Ol10IOOI01l&(~l10IOIOIl0OlI01|IIO0lIO01llIO10|l10IOIO01lOlI01)&h_wait_b)|
(O01IlIIO0ll10IO&lO10IOIl01IOIl0)|
(l10IOIIO0llIO10&lO10IOIl01IOIl0)|
(lO10Il10IOl0IO1&IIO0lIOIl0lIO10)))&
~(lIO10IOIl0OlI1O&OI01lOOIl1I1lO0&~lIO10l10IOIOIl0)&
~(lIO10IOIl0OlI1O&IIO0lOIl01I01lO&LCELL(((OI01lIIO0lOOl1I|lIO10IlI0Ol0IO1)&h_wait_b)|
((~OOIl1OOl1IIlI0O|O1lIOOI01ll0IO1)&IIO0lIO01llIO10&~l10IOIO01lOlI01)))&
~(lIO10IOIl0OlI1O&(OI01lIIO0lOOl1I|IIO0lIOIl0lIO10)&I1lO0IIO0lIIO0l&h_wait_b);assign OI01ll10IOOI01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lOIl01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IIO0lIlI0O[15:8];assign O01IlOlI1OO1lIO
=(I01lOO01IlOOl1I)?cbein_b:O01IlOOl1IOIl01;assign lIO10lO10IO01Il[21]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[21])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign OOl1IlIO10OIl01
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);assign O01Ill0IO1IlO01
=(I01lOI1lO0OI01l)?OOl1IOIl01OIl01:
(~I01lOI1lO0OI01l&~l10IOI01lOlIO10)?lIO10IO0lIIO01l-8'b00000001:8'b00000000;assign O1lIOl10IOIO01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIO01lI1lO0&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IIO0lI01lO[23:16];assign OlI1Ol10IOIO01l
=~gnt_b&framein_b&irdyin_b;dff IIlO01IlI0OlO10I(oe_stop,IO01ll0IO1OOl1I,clk,reset_b,1'b1);assign lIO10lO10IO01Il[2]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[2])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff3 IOlI01OIl01OI01l
(lO10IO01IlIO01l[15:13],OOl1IOlI1OIlI0O[15:13],clk,1'b1,reset_b);assign lIO10lO10IIO01l
=~O01IlIIO0lIlI0O&(OIl01OlI1OIlO01|I1lO0OlI1OI01lO);assign IO01lI1lO0OI01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OOIl1&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IOIl0IlI0O[31:24];dff IOOIl1O01Ill10IO
(lIO10lIO10IOIl0,O01IlIIO0lIlI0O,clk,1'b1,reset_b);assign OOl1IO1lIOOIl01
=(CASCADE(LCELL(OlI1OO01IlIOIl0&~IO01lO01IlOI01l&h_bii_b&I01lOO01IlI1lO0&
(h_abort_b|I1lO0OOl1IOOIl1))&
((l10IOO1lIOlIO10&~OI01lOIl01OOl1I)|OlI1OO01Ill0IO1))&
((~I01lOlIO10lO10I&~O1lIOOlI01OlI1O)|LCELL((OlI1OO01Ill0IO1|~IIO0lIlO01OOIl1)&~O1lIOOlI01OlI1O)|LCELL(IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)));assign l10IOIO0lIOOIl1
=OlI1OOIl01OlI1O[12]^OlI1OOIl01OlI1O[13]^OlI1OOIl01OlI1O[14]^OlI1OOIl01OlI1O[15];assign IIO0lOI01lIIO0l
=LCELL(l10IOI01lOIIO0l|(l10IOOI01lOlI01&OlI1OO01Ill0IO1));assign IO01lI1lO0I1lO0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01IIO0l&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IOIl0l10IO[7:0];dff IOlI01OOIl1OOl1I
(O1lIOlIO10O01Il,IOIl0O1lIOOlI01,clk,reset_b,1'b1);dff II1lO0IO01lOlI01(IO01ll10IOIO0lI,OOIl1IIO0lO1lIO,clk,reset_b,1'b1);dff IIOIl0l10IOOlI01
(lIO10OOl1IOlI1O,O01IlO01IlOIl01,clk,reset_b,1'b1);BUF IOlI01O1lIOOI01l(O1lIOl0IO1IOIl0,I01lOIlO01IO0lI);assign lIO10I01lOIOIl0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01O01Il&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IlI0OIIO0l[15:8];assign O01IlIOIl0IlO01
=(O1lIOOI01lIOIl0&IO01lOI01lOI01l)|IlI0Ol10IOOI01l;assign lIO10lIO10l0IO1[1:0]
=(l10IOl0IO1I01lO&~lO10IOIl01IOIl0)?OOIl1OlI1OIlI0O[1:0]:OIl01O1lIOl10IO[1:0];assign lIO10OOl1IO01Il
=(adin[16]^adin[17]^adin[18]^adin[19]);assign l10IOOlI01lIO10
=(IIO0lOIl01I01lO&IIO0lIIO0lOlI01)|OOIl1IO0lIIlI0O|OIl01IO0lIOIl01;assign OI01lI01lOI1lO0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01l10IO&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IlI0Ol10IO[23:16];assign IlI0OI01lOOI01l
=(IIO0lIO01llIO10&(O01IlIIO0lIlI0O|O01IlIIO0ll10IO))?16'h0001:
(O01IlIIO0lIlI0O&~OI01lOI01llO10I)?h_size:
(~l10IOIO01lOlI01&O01IlIO01lOIl01&~IIO0lIO01llIO10)?16'hffff:
(~l10IOIO01lOlI01&IIO0lIO01llIO10&O1lIOOI01ll0IO1)?16'h0000:
(~l10IOIO01lOlI01&IIO0lIO01llIO10)?16'h0001:
(OOl1IIlI0OOIl01)?16'h0000:
(O1lIOOI01ll0IO1)?OlI1OI01lOO01Il:
IIO0lIlI0OOlI01;dff32 IOlI01OlI01OI01l
(OOIl1IOIl0IlI0O,IO01lI1lO0OI01l,clk,reset_b,1'b1);assign IO01lIO0lIOOl1I
=(IO01lOOIl1IO0lI&l10IOlO10II01lO&((IlI0OIlO01I1lO0&~parin)|(~IlI0OIlO01I1lO0&parin)));assign OOl1IOOIl1O1lIO[0]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[0])|
(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[0])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[0]))|
((O01IlOI01lIlO01&I01lOOIl01IO0lI[0])|
(IlI0OIlO01OOl1I&h_din[0]));assign O1lIOIO01lIOIl0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IlO01OOl1IOOl1I&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0OI01lIIO0l[31:24];dff IIOIl0OIl01I01lO
(IlI0OIO01lIO0lI,O01IlOI01lO1lIO,clk,reset_b,1'b1);dff32 IOlI1OOOl1IIlI0O(IOIl0OI01lIIO0l,O1lIOIO01lIOIl0,clk,reset_b,1'b1);assign OOl1IOOIl1OIl01
=
(LCELL(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO)&I01lOlIO10lO10I)|
(I01lOlIO10lO10I&l10IOO1lIOlIO10&LCELL(~((OOl1IIlO01OIl01|~h_bii_b|OI01lOIl01OOl1I)&IIO0lO1lIOI01lO)&(lO10IO01IlOlI1O&h_retry_b&h_abort_b)));assign OOl1IOOIl1O1lIO[19]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[19])|
(IlI0OIlO01OOl1I&h_din[19])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[19]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[19])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[19]);assign OlI1OlO10Il0IO1[2]
=O1lIOOOIl1OlI1O;assign oe_frame=IIO0lOIl01OOIl1;assign lIO10IO01lIO01l=(IlO01IlO01IlO01[7:2]==6'b100111)?1'b1:1'b0;BUF IOOIl1I01lOO1lIO
(I1lO0OOIl1lIO10,IO01lOIl01lO10I);dffe IOOIl1l0IO1IlI0O(I1lO0IO0lII01lO,h_cacheline,clk,reset_b,1'b1,IlI0Ol10IOOI01l);assign OOl1IlO10IIlI0O[31:13]
=lO10IO01IlIO01l[31:13];assign O1lIOIlI0OOlI1O
=(lIO10IOIl0OlI1O&IIO0lIO01llIO10&~l10IOIO01lOlI01&(~OOIl1OOl1IIlI0O|O1lIOOI01ll0IO1))|
(lIO10IOIl0OlI1O&(OI01lIIO0lOOl1I|lIO10IlI0Ol0IO1)&h_wait_b);assign IOIl0OlI01I01lO
=(IlO01IlO01IlO01[7:2]==6'b111010)?1'b1:1'b0;assign OOl1IIlO01O1lIO=l10IOIlO01IIO0l|(~O01IlIlO01IlI0O&IIO0lIlO01OOIl1);assign lIO10lO10IO01Il[29]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[29])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff Il0IO1O01IlIO01l
(OI01lIO0lIlO10I,OOl1Il0IO1IlI0O,clk,reset_b,1'b1);assign l10IOI1lO0OOIl1
=(~IlI0Ol10IOOI01l&~lO10Il10IOl0IO1&O1lIOIIO0lIO01l[2]);assign lIO10l10IOl0IO1[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIO01ll0IO1&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0IIO0llIO10[23:16];assign IOIl0OlI1OIIO0l
=~O1lIOlO10IIOIl0;assign lIO10lO10IO01Il[10]=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[10])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff8 II01lOOOIl1IIO0l
(OOl1IOIl01OIl01,O1lIOOOIl1O01Il,clk,reset_b,1'b1);assign OI01llO10IlO10I[0]=h_cmd[0];assign OI01lI1lO0IO0lI[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lIlO01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IOIl0O1lIO[31:24];dff IOOIl1O01IlIlI0O
(OlI1Ol10IOO01Il,IlI0Ol10IOOOl1I,clk,reset_b,1'b1);assign lO10IlIO10IOIl0
=(l10IOOOl1IOOIl1&lO10IOIl01IOIl0&lO10IlIO10l0IO1)|
(l10IOOOl1IOOIl1&~h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO);assign OI01lO01IlIO0lI
=LCELL((IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)|IIO0ll10IOOlI01|l10IOIlO01lIO10);dffe IOlI1OOOIl1OIl01
(OOIl1IO0lIl10IO,OOl1II01lOOIl01,clk,reset_b,1'b1,O1lIOl0IO1l0IO1);assign OOl1Il10IOO1lIO[0]
=
(IIO0lOIl01I01lO&LCELL(OlI1Ol10IOO01Il&OOl1IOOIl1O1lIO[32]))|
LCELL((IO01llO10IOI01l&OOl1IOOIl1O1lIO[32])|
((O01IlIIO0lIlI0O)&OI01lOlI01I1lO0[0])|
((I01lOl10IOlO10I)&OOIl1O1lIOO1lIO[0])|
(((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0])&IO01lIIO0llO10I[0]))|
I1lO0OlI1OOlI01[0];assign OI01lI1lO0lO10I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01O1lIO&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IOIl0OIl01[7:0];assign IIO0lIIO0lOOIl1
=lIO10IOIl0OlI1O&
((~IIO0lOIl01I01lO&OI01lOOIl1I1lO0)|
(OI01lIIO0lI1lO0)|
(IIO0lOIl01I01lO&~OI01lOOIl1I1lO0&~IIO0lIOIl0lIO10&I01lOI1lO0OI01l)|
(IIO0lOIl01I01lO&OI01lOOIl1I1lO0&~IIO0lIOIl0lIO10&(h_wait_b|I01lOI1lO0OI01l)));assign OOIl1O1lIOIlO01
=(l10IOOOl1IOOIl1&lO10IlIO10l0IO1)|
(lIO10l0IO1OlI1O)|
(~OOl1IOOl1Il10IO|~I01lOO01IlI1lO0);dff IIOIl0l10IOOOIl1
(oe_perr,OI01lO1lIOOOl1I,clk,reset_b,1'b1);assign I01lOIO01lI1lO0
=CASCADE(OlI1Ol10IOO01Il|
(I01lOlIO10lO10I&IlI0OIO01llO10I)|
I01lOIO01lOI01l)&
(IIO0lOIl01I01lO|(I01lOlIO10lO10I&IlI0OIO01llO10I)|I01lOIO01lOI01l);assign O1lIOI01lOOlI1O[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OI01l&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IlI0OOOIl1[15:8];assign OlI1OI01lOOlI1O
=~O01IlIOIl0OIl01[11]&~O01IlIOIl0OIl01[10]&~O01IlIOIl0OIl01[9]&~O01IlIOIl0OIl01[8];assign OOl1IIlO01IlO01[31:2]
=(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0)?IlO01IlO01IlO01[31:2]:IIO0lIlO01I01lO[31:2];dff IIlO01IOIl0OOl1I
(IIO0llIO10I01lO,O1lIOO1lIOIO01l,clk,reset_b,1'b1);assign l10IOOlI01IIO0l=(OlI1OO01IlIOIl0|OOl1IOOl1IIlI0O)&~IIO0lIlO01OOIl1;assign IO01lI01lOlO10I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01lIO10&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IlI0OOIl01[23:16];assign O1lIOIlI0OIO01l
=~IIO0lOIl01I01lO&lIO10OI01lOlI1O;dff32 IOlI01OlI01OOl1I(OOIl1IIO0lOIl01,IO01ll10IOlO10I,clk,reset_b,1'b1);assign perrout_b
=lIO10OlI1OIO01l;dffe8 IIO0lIO1lIOIO01l(OlI1OOIl01OlI1O[15:8],OOl1IOOIl1O1lIO[15:8],clk,reset_b,1'b1,OlI1OIO01ll0IO1);assign lIO10IO01lOlI1O[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01IO01l&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0OI01lOOIl1[31:24];assign IO01lOlI1OOOl1I
=l10IOlO10IOOIl1|lIO10OlI1OOlI1O;dff32 IOOIl1IlO01IlO01(IOIl0IlI0OOlI01,O1lIOI01lOO01Il,clk,reset_b,1'b1);dff IOIl01I1lO0OIl01
(OOl1IOOl1IIlI0O,OlI1OOIl01IO01l,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[11]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[11])|
(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[11])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[11]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[11])|
(IlI0OIlO01OOl1I&h_din[11]);assign lIO10IO01lO01Il[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&l0IO1OOl1IOlI1O&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0OI01lOlI01[7:0];assign O01IlI01lOl10IO
=CASCADE(~(OOl1IIlI0OIlO01|I01lOIO01lOOl1I|l10IOOI01lOOIl1))&~(IlI0Ol10IOI1lO0&~OOl1IIlI0OOIl01);assign I01lOlO10II1lO0
=(IlO01IlO01IlO01[7:2]==6'b000000)?OlI1Ol0IO1l0IO1:
(IlO01IlO01IlO01[7:2]==6'b000001)?O01IlIO0lIOIl01:
(IlO01IlO01IlO01[7:2]==6'b000010)?OOl1IIO0lIl10IO:
(IlO01IlO01IlO01[7:2]==6'b000011)?IlI0Ol0IO1lO10I:
(IlO01IlO01IlO01[7:2]==6'b000100)?OOl1IlO10IIlI0O:
(IlO01IlO01IlO01[7:2]==6'b000101)?IO01lOlI1OOI01l:
(IlO01IlO01IlO01[7:2]==6'b001011)?I01lOl0IO1I1lO0:
(IlO01IlO01IlO01[7:2]==6'b001111)?IIO0lIO0lIlIO10:
(IlO01IlO01IlO01[7:2]==6'b100000)?OIl01IIO0lIlI0O:
(IlO01IlO01IlO01[7:2]==6'b100001)?IOIl0IIO0lOlI01:
(IlO01IlO01IlO01[7:2]==6'b100010)?OOIl1IIO0lOIl01:
(IlO01IlO01IlO01[7:2]==6'b100011)?I1lO0IIO0llIO10:
(IlO01IlO01IlO01[7:2]==6'b100100)?OIl01IIO0ll10IO:
(IlO01IlO01IlO01[7:2]==6'b100101)?IOIl0IIO0lI01lO:
(IlO01IlO01IlO01[7:2]==6'b100110)?OOIl1IIO0lIlO01:
(IlO01IlO01IlO01[7:2]==6'b100111)?I1lO0IOIl0OOIl1:
(IlO01IlO01IlO01[7:2]==6'b101000)?OIl01IOIl0O1lIO:
(IlO01IlO01IlO01[7:2]==6'b101001)?IOIl0IOIl0IIO0l:
(IlO01IlO01IlO01[7:2]==6'b101010)?OOIl1IOIl0IlI0O:
(IlO01IlO01IlO01[7:2]==6'b101011)?I1lO0IOIl0OlI01:
(IlO01IlO01IlO01[7:2]==6'b101100)?OIl01IOIl0OIl01:
(IlO01IlO01IlO01[7:2]==6'b101101)?IOIl0IOIl0lIO10:
(IlO01IlO01IlO01[7:2]==6'b101110)?OOIl1IOIl0l10IO:
(IlO01IlO01IlO01[7:2]==6'b101111)?I1lO0IOIl0I01lO:
(IlO01IlO01IlO01[7:2]==6'b110000)?OIl01IOIl0IlO01:
(IlO01IlO01IlO01[7:2]==6'b110001)?IOIl0IlI0OOOIl1:
(IlO01IlO01IlO01[7:2]==6'b110010)?OOIl1IlI0OO1lIO:
(IlO01IlO01IlO01[7:2]==6'b110011)?I1lO0IlI0OIIO0l:
(IlO01IlO01IlO01[7:2]==6'b110100)?OIl01IlI0OIlI0O:
(IlO01IlO01IlO01[7:2]==6'b110101)?IOIl0IlI0OOlI01:
(IlO01IlO01IlO01[7:2]==6'b110110)?OOIl1IlI0OOIl01:
(IlO01IlO01IlO01[7:2]==6'b110111)?I1lO0IlI0OlIO10:
(IlO01IlO01IlO01[7:2]==6'b111000)?OIl01IlI0Ol10IO:
(IlO01IlO01IlO01[7:2]==6'b111001)?IOIl0IlI0OI01lO:
(IlO01IlO01IlO01[7:2]==6'b111010)?OOIl1IlI0OIlO01:
(IlO01IlO01IlO01[7:2]==6'b111011)?I1lO0OI01lOOIl1:
(IlO01IlO01IlO01[7:2]==6'b111100)?OIl01OI01lO1lIO:
(IlO01IlO01IlO01[7:2]==6'b111101)?IOIl0OI01lIIO0l:
(IlO01IlO01IlO01[7:2]==6'b111110)?OOIl1OI01lIlI0O:
(IlO01IlO01IlO01[7:2]==6'b111111)?I1lO0OI01lOlI01:
32'h00000000;assign l10IOOlI1OOOIl1
=LCELL(l10IOOOl1IOOIl1&(IlI0OlIO10OOl1I|O01IlOlI1OIlO01))&~lO10IOIl01IOIl0&I01lOlIO10lO10I;assign OOl1IOOIl1O1lIO[30]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[30])|
(IlI0OIlO01OOl1I&h_din[30])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[30]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[30])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[30]);assign IIO0lOlI1OlIO10[5]
=run_66mhz;BUF II1lO0lO10IOlI01(IIO0lI1lO0lIO10,OI01lIOIl0lO10I);assign IOIl0OlI01OlI01
=(IlO01IlO01IlO01[7:2]==6'b110010)?1'b1:1'b0;assign OIl01OOl1IOIl01
=(I01lOlIO10lO10I&OOIl1OOIl1OIl01)|(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe8 IOIl01l0IO1OIl01
(OI01lIIO0lOI01l[23:16],O01IlIO01lIlO01[23:16],clk,reset_b,1'b1,l10IOOlI01lIO10);dff II01lOOOl1II01lO
(OI01lOOIl1OI01l,IIO0lOIl01OlI01,clk,reset_b,1'b1);assign reqout_b=OlI1OI1lO0IOIl0;assign O1lIOl10IOO01Il[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIO01llO10I&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0IIO0lOlI01[23:16];assign lO10IlO10IIO01l
=((O01IlOOl1IOIl01==4'b0111)|
(O01IlOOl1IOIl01==4'b1111)|
(O01IlOOl1IOIl01==4'b0011))?1'b1:1'b0;assign lIO10lO10IO01Il[18]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[18])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign lIO10O1lIOIOIl0
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);dff4 IOIl01lO10IIlO01
(O1lIOIIO0lOlI1O,OOl1Il10IOO1lIO,clk,reset_b,1'b1);assign IO01lI1lO0OOl1I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OI01lI01lO&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IIO0lIlO01[31:24];assign IIO0lIO01llIO10
=~h_blast_b;dff IOIl01I01lOl10IO(OOl1IOOl1Il10IO,OlI1OlO10IIOIl0,clk,1'b1,reset_b);assign OIl01OlI1OOIl01
=~IIO0lIlO01OlI01&~l10IOIlO01lIO10;assign IIO0lI01lOOlI01=(IlO01IlO01IlO01[7:2]==6'b000100)?1'b1:1'b0;assign IO01llO10IOI01l
=LCELL((IlI0Ol10IOOI01l|lO10Il10IOl0IO1)&l10IOl10IOlIO10[0]);assign IO01lI1lO0OI01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OOIl1&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IOIl0IlI0O[7:0];dff Il0IO1OOl1IIO01l
(OOIl1OlI1Ol10IO,OlI1Ol10IOO01Il,clk,reset_b,1'b1);assign trdyout_b=OlI1OO01Ill0IO1;assign IlI0Ol0IO1IO0lI
=OlI1OOIl01OlI1O[24]^OlI1OOIl01OlI1O[25]^OlI1OOIl01OlI1O[26]^OlI1OOIl01OlI1O[27];assign I01lOIO01lOI01l
=LCELL(l10IOI01lOIIO0l|(IlI0OIO01llO10I&OlI1OO01Ill0IO1));assign lIO10I1lO0IO01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01IOIl0&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IOIl0I01lO[15:8];BUF IOOIl1OIl01O1lIO
(I01lOI1lO0I1lO0,OOl1IIOIl0l10IO);assign IOIl0IIO0lOOIl1=(IO01llIO10IO0lI[7:0]==8'h08)?1'b1:1'b0;dff IIlO01IIO0llO10I
(IIO0lO01IlIIO0l,O1lIOOOl1Il0IO1,clk,reset_b,1'b1);BUF IOOIl1lIO10OIl01(I1lO0IO0lIOlI01,O01IlOlI01IlI0O);assign OI01lI01lOOI01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01OIl01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IlI0OIlI0O[23:16];BUF IOIl01OIl01IlI0O
(lIO10OI01lOlI1O,l10IOIO01lOOIl1);dff IOOIl1IO01ll10IO(lIO10OlI01l0IO1[0],O01IlIlO01l10IO,clk,reset_b,1'b1);assign IIO0lO01IllIO10
=(adin[28]^adin[29]^adin[30]^adin[31]);dff IOlI01O1lIOI1lO0(oe_par,OI01llO10IIO0lI,clk,reset_b,1'b1);assign O1lIOI01lOIO01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01I1lO0&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IlI0OI01lO[31:24];assign l10IOIlI0OlIO10
=~IIO0lIlI0OOlI01[15]&~IIO0lIlI0OOlI01[14]&~IIO0lIlI0OOlI01[13]&~IIO0lIlI0OOlI01[12];dff32 IOOIl1IlO01OIl01
(IOIl0IOIl0lIO10,O1lIOI1lO0l0IO1,clk,reset_b,1'b1);assign l10IOlIO10IIO0l
=CASCADE(OOl1IlO10Il10IO|IO01lIO0lII1lO0)&((IlI0OIlO01I1lO0&~parin)|(~IlI0OIlO01I1lO0&parin));assign OOl1IOOIl1O1lIO[3]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[3])|
(IlI0OIlO01OOl1I&h_din[3])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[3]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[3])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[3]);assign O1lIOIO01lIOIl0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IlO01OOl1IOOl1I&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0OI01lIIO0l[7:0];dff IIO0lIOOIl1IO01l
(OOl1IOIl01IlO01,IIO0lOIl01I01lO,clk,reset_b,1'b1);assign OlI1Ol0IO1l0IO1[31:16]=device_id;assign l10IOOOIl1lIO10
=(lO10IO01IlOlI1O&~I01lOlIO10lO10I&~OlI1OO01Ill0IO1)|(O01IlOOl1IO1lIO&~I01lOlIO10lO10I);assign OOl1IOOIl1O1lIO[22]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[22])|
(IlI0OIlO01OOl1I&h_din[22])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[22]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[22])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[22]);assign IIO0lOlI1OlIO10[15]
=IO01lIO0lIOI01l;dff IIOIl0lO10IIIO0l(OI01lOIl01I1lO0,IOIl0OOIl1I01lO,clk,reset_b,1'b1);assign IOIl0OlI01OOIl1
=(IlO01IlO01IlO01[7:2]==6'b101010)?1'b1:1'b0;assign O1lIOOlI01O01Il
=
(I01lOlIO10lO10I&LCELL(~OlI1OO01Ill0IO1&(OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
(~IIO0lIlO01OOIl1|(~OOl1IIlO01OIl01&IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1))))|
LCELL(O1lIOOlI01OlI1O&IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1);assign O01Ill10IOIlI0O[31:2]
=(O01IlIIO0lIlI0O)?h_ain[31:2]:IO01lIIO0lIO0lI[31:2];assign IO01lOlI1OOI01l[12:0]=13'b0000000000001;assign lIO10IOIl0IO01l
=~(framein_b&irdyin_b&~gnt_b&((O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~lO10IOIl01IOIl0)|l10IOIIO0llIO10|O01IlIIO0ll10IO))&frameout_b;assign IlO01OOl1IOOl1I
=(IlO01IlO01IlO01[7:2]==6'b111101)?1'b1:1'b0;dff Il0IO1IlI0OIOIl0(IO01lOI01lI1lO0,lIO10OI01lIO01l,clk,reset_b,1'b1);assign lIO10lO10IO01Il[26]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[26])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff IIlI0OOOIl1OOIl1
(O01Ill0IO1OIl01,IIO0ll0IO1IIO0l,clk,reset_b,1'b1);assign IIO0ll10IOI01lO[2]
=~IlI0Ol10IOOI01l&~lO10Il10IOl0IO1&
(l10IOlO10IOlI01|(~O1lIOIIO0lIO01l[2]&OOl1Il10IOIlO01[2])|O1lIOIIO0lIO01l[2]);assign OI01ll10IOI1lO0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OI01ll10IO&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IIO0ll10IO[31:24];assign l10IOlO10IOlI01
=~devselin_b;assign h_wrout=lO10IOIl01IOIl0;assign lIO10lO10IO01Il[7]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[7])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign OI01lIlI0OOI01l
=(IlO01IlO01IlO01[7:2]==6'b001111)?1'b1:1'b0;assign OI01lOlI01I1lO0[1]=~OI01llO10IlO10I[0];assign OI01lI1lO0IO0lI[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lIlO01&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IOIl0O1lIO[7:0];dff Il0IO1OOl1IO01Il
(l10IOIIO0llIO10,OOl1IIIO0lO1lIO,clk,reset_b,1'b1);assign l10IOOOl1II01lO=~I01lOlIO10IO0lI;assign h_beout_b[3:0]
=O01IlOOIl1IlI0O[3:0];assign OOIl1O1lIOOIl01=(IlO01IlO01IlO01[31:13]==lO10IO01IlIO01l[31:13])?1'b1:1'b0;dffe4 II1lO0lIO10IIO0l
(IO01lIIO0llO10I,lIO10lO10IOlI1O,clk,reset_b,1'b1,OOl1Il10IOOIl01);assign O1lIOI1lO0l0IO1[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01IO0lI&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IOIl0lIO10[15:8];assign I01lOl10IOIO0lI
=l10IOIIO0llIO10&~lO10IOIl01IOIl0&(framein_b&~gnt_b&irdyin_b);dff30 IOlI01OI01lIO0lI
(IIO0lIlO01I01lO[31:2],O1lIOOlI01IO01l[31:2],clk,reset_b,1'b1);dff IIlO01IIO0lIO0lI
(IIO0lOlI01I01lO,O1lIOOOl1IIOIl0,clk,reset_b,1'b1);assign O01IlOI01lIlO01
=LCELL(OlI1Ol10IOO01Il&~OOl1IOIl01IlO01&~O1lIOIIO0lO01Il);assign IO01lI01lOIO0lI[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OlI01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IlI0OO1lIO[23:16];assign l10IOIlI0OIIO0l
=~O01IlIOIl0OIl01[3]&~O01IlIOIl0OIl01[2]&O01IlIOIl0OIl01[1]&~O01IlIOIl0OIl01[0];dff32 IOIl01IO01lOIl01
(OI01llIO10I1lO0[31:0],IlO01IlO01IlO01[31:0],clk,reset_b,1'b1);dff IOIl01I1lO0O1lIO
(IO01lO1lIOIO0lI,l10IOlIO10IIO0l,clk,reset_b,1'b1);assign IlI0OIlO01OI01l
=(IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1)|IIO0ll10IOOlI01|l10IOIlO01lIO10;assign lIO10I01lOl0IO1[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01l0IO1&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IlI0OlIO10[31:24];assign OOl1II01lOIlO01
=(O1lIOOI01lIOIl0&IO01lOI01lOI01l)|
(O1lIOOI01lIOIl0&~IIO0lOIl01I01lO);dff32 IOOIl1IlO01O1lIO
(IOIl0IIO0lI01lO,O1lIOl10IOIO01l,clk,reset_b,1'b1);assign O1lIOIO0lIl0IO1
=CASCADE(OI01lOOIl1OI01l&IO01lOOIl1IO0lI&IO01lIO0lII1lO0)&((IlI0OIlO01I1lO0&~parin)|(~IlI0OIlO01I1lO0&parin));dffe4 II1lO0l0IO1OOIl1
(OlI1OOIl01OlI1O[35:32],OOl1IOOIl1O1lIO[35:32],clk,reset_b,1'b1,I01lOIO01lI1lO0);assign lIO10IO01lOlI1O[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01IO01l&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0OI01lOOIl1[7:0];assign O1lIOO1lIOO01Il
=OOl1IIIO0lOIl01&O01IllO10IO1lIO;dff32 Il0IO1O01IlOlI1O(OIl01IlI0Ol10IO,OI01lI01lOI1lO0,clk,reset_b,1'b1);dff IIO0lIIOIl0l0IO1
(lO10IO01IlO01Il,lO10IlO10IOlI1O,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[14]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[14])|
(IlI0OIlO01OOl1I&h_din[14])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[14]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[14])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[14]);assign OlI1OlO10Il0IO1[7]
=1'b0;dff IOIl01lO10IO1lIO(IIO0llO10IIIO0l,O1lIOOlI1OIOIl0,clk,reset_b,1'b1);assign IOIl0OI01llIO10
=(IlO01IlO01IlO01[7:2]==6'b100010)?1'b1:1'b0;dff Il0IO1IOIl0IO01l(IIO0lIlO01OOIl1,OOl1IIlO01O1lIO,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[33]
=(IlI0OIlO01OOl1I&h_bein_b[1])|
(O01IlOI01lIlO01&l10IOOOIl1IIO0l[1])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[33]);assign IlI0Ol0IO1lO10I[15:8]
=OOl1IOIl01OIl01;BUF IOlI01OlI1OlO10I(O01IlI1lO0IlO01,lIO10IOIl0IO01l);assign IO01lIlO01lO10I
=(IlO01IlO01IlO01[7:2]==6'b110101)?1'b1:1'b0;assign IIO0lIlO01OlI01
=(O1lIOOlI01OlI1O&IIO0lO1lIOI01lO&IO01lOI01lI1lO0&~I1lO0OOl1IOOIl1);dffe8 IIO0lIIO0lIl0IO1
(OI01lOlI01OOl1I[15:8],adin[15:8],clk,reset_b,1'b1,lIO10O01IlO01Il);assign l10IOOlI1OOlI01
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[1]:IlI0OOIl01OOl1I;assign I01lOI1lO0OOl1I
=(CASCADE(~(IlI0Ol10IOOI01l)&
~(lO10Il10IOl0IO1)&
~(lIO10IOIl0OlI1O&~I01lOI1lO0OI01l&~IIO0lOIl01I01lO)&
~(lIO10IOIl0OlI1O&~I01lOI1lO0OI01l&IIO0lOIl01I01lO))&
~(lIO10IOIl0OlI1O&~OI01lIIO0lI1lO0&~IIO0lOIl01I01lO&~OI01lOOIl1I1lO0))|lIO10l10IOIOIl0;assign IO01ll10IOlO10I[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OI01llIO10&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OOIl1IIO0lOIl01[31:24];assign O01IlO1lIOl10IO
=((O01IlOOl1IOIl01==4'b0110)|
(O01IlOOl1IOIl01==4'b1100)|
(O01IlOOl1IOIl01==4'b1110)|
(O01IlOOl1IOIl01==4'b0111)|
(O01IlOOl1IOIl01==4'b1111))?1'b1:1'b0;assign lIO10lO10IO01Il[15]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[15])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign OI01lIO0lIIO0lI
=~(OOl1IlIO10OIl01&OOIl1OlI1OIlI0O[28])&(O1lIOO1lIOO01Il|lIO10IO0lIO01Il);dff IIO0lIO1lIOOlI1O
(OI01llIO10OOl1I,IOIl0O1lIOOOIl1,clk,reset_b,1'b1);assign IO01lI1lO0OOl1I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OI01lI01lO&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IIO0lIlO01[7:0];assign IIO0lO1lIOI01lO
=~h_rdyh_b;dff IIO0lIIlI0OIO01l(lIO10OOIl1l0IO1,O01IlOIl01l10IO,clk,reset_b,1'b1);assign h_aout[31:2]
=(~O1lIOlO10IIOIl0)?OOl1IIlO01IlO01[31:2]:I1lO0OOl1II01lO[31:2];assign OOl1IOlI1OIlI0O[23:16]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IIO0lI01lOOlI01&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:lO10IO01IlIO01l[23:16];assign I1lO0OlI1OOlI01[2]
=CASCADE(~((OlI1Ol10IOO01Il&IIO0lOIl01I01lO)|IO01llO10IOI01l)&
~(O01IlIIO0lIlI0O))&
~(I01lOl10IOlO10I)&
LCELL(~((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0]))&
O1lIOIIO0lOlI1O[2];assign lIO10I1lO0O01Il[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01OlI1O&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IOIl0OlI01[15:8];assign l10IOI1lO0OlI01
=LCELL(~IIO0lIOIl0lIO10&~I01lOI1lO0OI01l);assign OlI1OlIO10OlI1O=~OOl1IOOl1Il10IO&~I01lOlIO10lO10I;assign OOl1IIO0lIIlI0O
=LCELL(OlI1OlIO10IO01l^OOl1IO1lIOIlO01^I01lOl0IO1OOl1I^l10IOIO0lIOOIl1);assign O01IlOI01lOIl01
=LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO);assign OI01lI01lOOOl1I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01IlI0O&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IOIl0IlO01[23:16];assign OI01lOI01llO10I
=(h_size==16'h0000)?1'b1:1'b0;assign I1lO0OOIl1IIO0l[7:0]
=(l10IOl0IO1I01lO&l10IOOOl1IOOIl1)?OOIl1OOIl1O1lIO[7:0]:O1lIOOIl01OlI1O[7:0];dff IOIl01l10IOl10IO
(IIO0llO10IlIO10,OI01lOlI1OlO10I,clk,reset_b,1'b1);BUF Il0IO1O1lIOl0IO1(OI01ll0IO1lO10I,OlI1OIlO01O01Il);assign O1lIOI01lOO01Il[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01lO10I&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IlI0OOlI01[31:24];BUF IIO0lIOOIl1O01Il
(OI01lOI01lIO0lI,O01IlIO01lO1lIO);assign lIO10OlI01l0IO1[1]=1'b0;assign IO01lOOl1II1lO0
=LCELL(l10IOO01IlOOIl1^lIO10OOl1IOlI1O^O01IlO01IlO1lIO^OI01lOOl1IIO0lI);assign OOl1II1lO0IlI0O
=LCELL(OOl1IIIO0lIlO01&framein_b&irdyin_b&LCELL(O01IlIIO0lIlI0O|O01IlIIO0ll10IO|l10IOIIO0llIO10));assign O1lIOI01lOIO01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01I1lO0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IlI0OI01lO[7:0];assign IlI0OI01lOI1lO0
=~IIO0lIlI0OOlI01[3]&~IIO0lIlI0OOlI01[2]&~IIO0lIlI0OOlI01[1];dff32 Il0IO1OlI01l0IO1
(OIl01IOIl0IlO01,OI01lI01lOOOl1I,clk,reset_b,1'b1);dff IIO0lIIOIl0IOIl0(lO10IO01IlOlI1O,OlI1OOIl01O01Il,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[6]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[6])|
(IlI0OIlO01OOl1I&h_din[6])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[6]))|
(O01IlOI01lIlO01&I01lOOIl01IO0lI[6])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[6]);assign IO01lIO01lOI01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0O01IlOOIl1&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1OI01lIlI0O[15:8];dff II1lO0lO10IOOIl1
(l10IOOI01lOOIl1,OlI1OI01lOIO01l,clk,reset_b,1'b1);assign O01IlIO0lIOIl01[15:0]=OlI1OlO10Il0IO1;assign IIO0lOOIl1I01lO
=
LCELL((l10IOO1lIOlIO10&I01lOlIO10lO10I)|
(~I01lOlIO10lO10I&LCELL(~(~h_retry_b|(~h_abort_b&~I1lO0OOl1IOOIl1)|(~h_bii_b&IIO0lO1lIOI01lO))))|
(~l10IOO1lIOlIO10&LCELL(OlI1OO01Ill0IO1&I01lOO01IlI1lO0)));assign OOl1IOOIl1O1lIO[25]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[25])|
(IlI0OIlO01OOl1I&h_din[25])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[25]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[25])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[25]);assign IIO0lOlI1OlIO10[12]
=lIO10IO0lIO01Il;assign IOIl0OOIl1I01lO=OOIl1OOIl1IlO01&(O1lIOOIl01IO01l|OI01lOIl01I1lO0);assign IO01lIlO01IO0lI
=(IlO01IlO01IlO01[7:2]==6'b101101)?1'b1:1'b0;assign O1lIOOIl01O01Il
=((OlI1OO01IlIOIl0|(OOl1IOOl1IIlI0O&~lIO10O01IlIO01l))&
~OlI1OO01Ill0IO1&IIO0lIlO01OOIl1&~(IIO0lO1lIOI01lO&~I1lO0OOl1IOOIl1&IO01lOI01lI1lO0));assign IOIl0IO0lIlIO10[1:0]
=
(~l10IOl10IOlIO10[3]&~l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0]&~IO01lOlI01lO10I[32])?2'b00:
(~l10IOl10IOlIO10[3]&~l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0]&~IO01lOlI01lO10I[33])?2'b01:
(~l10IOl10IOlIO10[3]&~l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0]&~IO01lOlI01lO10I[34])?2'b10:
(~l10IOl10IOlIO10[3]&~l10IOl10IOlIO10[2]&l10IOl10IOlIO10[1]&l10IOl10IOlIO10[0]&~IO01lOlI01lO10I[35])?2'b11:IO01lIIO0lIO0lI[1:0];dff IOlI01O01IllO10I
(O1lIOOOIl1OlI1O,OOl1IOIl01O1lIO,clk,reset_b,1'b1);dff IIOIl0lO10IlIO10(OlI1OI1lO0IOIl0,IIO0lIOIl0IIO0l,clk,1'b1,reset_b);assign OI01ll10IOOI01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lOIl01&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:OIl01IIO0lIlI0O[31:24];dff4 IOIl01I01lOIlI0O
(O01IlOOl1IOIl01,O01IlOlI1OO1lIO,clk,reset_b,1'b1);assign lIO10lO10IO01Il[23]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[23])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign l10IOl0IO1OOIl1
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);dff8 II1lO0lO10II01lO
(lIO10IO0lIIO01l,O01Ill0IO1IlO01,clk,1'b1,reset_b);assign OI01ll10IOI1lO0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OI01ll10IO&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IIO0ll10IO[7:0];assign IIO0lOIl01I01lO
=~trdyin_b&~I1lO0IIO0lIIO0l;assign h_cs_b[1]=I1lO0OOl1IOOIl1|~IO01ll0IO1I1lO0;assign lIO10lO10IO01Il[4]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[4])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign IO01lOOIl1lO10I
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlI0OOI01l&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:l10IOOIl01lIO10;assign IOIl0O1lIOOOIl1
=~O01IlIIO0lIlI0O&(O1lIOlIO10OlI1O|OI01llIO10OOl1I);assign O1lIOI1lO0IOIl0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OOl1I&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IOIl0IIO0l[15:8];dff IIOIl0O01IllIO10
(OIl01O1lIOIlI0O,OI01llIO10OI01l,clk,reset_b,1'b1);assign IIO0lO1lIOOlI01
=
(LCELL(lO10IO01IlOlI1O&IIO0lO1lIOI01lO&OlI1OO01Ill0IO1)|
LCELL((IIO0lOOl1IIIO0l&h_retry_b)|
(lO10IO01IlO01Il))|
(~OlI1OO01Ill0IO1&~I01lOlIO10lO10I));assign OOl1IO1lIOIlO01
=OlI1OOIl01OlI1O[4]^OlI1OOIl01OlI1O[5]^OlI1OOIl01OlI1O[6]^OlI1OOIl01OlI1O[7];assign IO01lIlI0OlO10I
=(IO01llIO10lO10I&IIO0lOOIl1OOIl1&IlI0OlIO10I1lO0)?1'b1:1'b0;dffe Il0IO1O1lIOIOIl0
(OOIl1OOl1IIlI0O,h_wrin,clk,reset_b,1'b1,OOl1Il10IOOIl01);assign IO01lI1lO0I1lO0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&I1lO0OlI01IIO0l&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IOIl0l10IO[23:16];assign lO10Il10IOIOIl0
=(OOl1IIIO0lOIl01&OI01lOlI1OIO0lI&IIO0lI01lOI01lO)|(IlI0Ol10IOI1lO0&~I01lOI01lOlO10I);dff IOOIl1IO01lIlI0O
(OI01ll10IOOOl1I,OIl01IO0lIIlO01,clk,reset_b,1'b1);dff IOIl01l10IOIlI0O(IO01lOOl1IOOl1I,l10IOO01IlOlI01,clk,reset_b,1'b1);assign OlI1OIlO01OlI1O
=lO10Il10IOl0IO1;assign lIO10I01lOIOIl0[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01O01Il&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IlI0OIIO0l[31:24];assign OOl1IIOIl0l10IO
=lIO10OI01lOlI1O|O1lIOOI01lIOIl0;dff IIO0lIOI01ll0IO1(O1lIOlIO10IO01l,IOIl0O1lIOI01lO,clk,reset_b,1'b1);assign IO01lOOl1IOI01l
=(adin[8]^adin[9]^adin[10]^adin[11]);assign OOl1IOlI01OIl01=(IIO0lOIl01I01lO&IIO0lIIO0lOlI01)|IOIl0IO0lIIIO0l|I1lO0IO0lIOlI01;assign lIO10I01lOl0IO1[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01l0IO1&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IlI0OlIO10[7:0];dff16 IOOIl1OIl01OIl01
(IIO0lIlI0OOlI01,IlI0OI01lOOI01l,clk,1'b1,reset_b);dff32 Il0IO1OlI01IOIl0(OIl01IOIl0O1lIO,OI01lI1lO0IO0lI,clk,reset_b,1'b1);assign IO01lOlI1OI1lO0
=(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe32 IOlI01IO0lIIO0lI
(IO01lOlI01lO10I[31:0],OlI1OOIl01OlI1O[31:0],clk,reset_b,1'b1,OOl1IIIO0lOIl01);assign OI01lIO01lIO0lI[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01IlO01&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01OI01lO1lIO[15:8];assign lO10IIO01lOlI1O
=((IIO0lIIO0lOlI01|OlI1Ol10IOO01Il)&IIO0lOIl01I01lO&IIO0lIOIl0lIO10&~OI01lIIO0lI1lO0)|
(OOl1IIIO0lOIl01&IIO0lIIO0lI01lO)|
(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0));dff32 IIlI0OOOl1IIIO0l
(I1lO0OI01lOOIl1,lIO10IO01lOlI1O,clk,reset_b,1'b1);assign IlI0OOIl01OI01l
=
(I01lOO01IlOOl1I&~l10IOO1lIOlIO10)|
(lO10IO01IlOlI1O&((IIO0lO1lIOI01lO&~l10IOO1lIOlIO10)|(~OlI1OO01Ill0IO1&~l10IOO1lIOlIO10)))|
(O01IlOOl1IO1lIO&~l10IOO1lIOlIO10)|
(I01lOO01IlOI01l&~l10IOO1lIOlIO10)|
(IlI0OO01IlIO0lI&~l10IOO1lIOlIO10)|
(lO10IO01IlOlI1O&(~h_retry_b|~h_abort_b)&~l10IOO1lIOlIO10)|
(OlI1OO01IlIOIl0&~l10IOO1lIOlIO10&(~OlI1OO01Ill0IO1|~I01lOO01IlI1lO0));assign OOl1IOOIl1O1lIO[17]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[17])|
(IlI0OIlO01OOl1I&h_din[17])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[17]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[17])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[17]);assign OlI1OlO10Il0IO1[4]
=IOIl0OlI1OlIO10;assign OI01lOOIl1OOl1I
=
(~I01lOI1lO0OI01l|trdyin_b)&
(~I01lOI1lO0OI01l|LCELL((I01lOI1lO0OI01l&~l10IOIOIl0OOIl1)&~(lIO10IOIl0OlI1O&OI01lIIO0lI1lO0)))&
(~I01lOI1lO0OI01l|stopin_b);assign IO01lIO01lI1lO0
=(IlO01IlO01IlO01[7:2]==6'b100101)?1'b1:1'b0;BUF IIOIl0I01lOOOIl1(IOIl0OOIl1OlI01,OI01lOIl01OI01l);assign adout[31:0]
=I1lO0IIO0lIIO0l?32'hxxxxxxxx:OlI1OOIl01OlI1O[31:0];assign IIO0lIO0lIlIO10[15:8]=interrupt_pin;assign OI01lIlI0OOOl1I
=(IlI0Ol10IOOI01l&(~l10IOIOIl0OlI01|IIO0lIO01llIO10)&h_wait_b)|(lO10Il10IOl0IO1&IIO0lIOIl0lIO10);assign OIl01OlI01l10IO
=(IlO01IlO01IlO01[7:2]==6'b111000)?1'b1:1'b0;assign lIO10OlI01IOIl0=IOIl0OOl1IlIO10&(h_abort_b|I1lO0OOl1IOOIl1);assign lIO10lO10IO01Il[31]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[31])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign O01IlOIl01IlI0O
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[6]:lIO10OOIl1IOIl0;dff IIlO01OlI1OI1lO0
(OI01lIIO0lI1lO0,O01Ill10IOl10IO,clk,reset_b,1'b1);assign IO01ll10IOlO10I[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OI01llIO10&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OOIl1IIO0lOIl01[7:0];dff IIO0lIIlI0OO01Il
(I1lO0OOl1IOOIl1,IO01lO01IlOOl1I,clk,1'b1,reset_b);assign lIO10lO10IO01Il[12]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[12])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign lIO10IO0lIOlI1O
=(~(lIO10O1lIOIOIl0&OOIl1OlI1OIlI0O[31]))&(IO01lO1lIOIO0lI|(IO01lIO0lIOI01l));assign OI01lIlI0OI1lO0=h_cmd[1]&~h_cmd[0]&~h_mio;assign lIO10I1lO0OlI1O[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IO01lIO01l&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IOIl0OOIl1[15:8];dff IIOIl0O01IlIIO0l
(IlI0Ol10IOOI01l,lO10Il0IO1IO01l,clk,reset_b,1'b1);BUF II1lO0IO01lOOIl1(OIl01IO0lIO1lIO,lIO10OOIl1l0IO1);dffe4 Il0IO1IO0lIIO01l
(O01IlOOIl1IlI0O,IlI0OlO10IlO10I,clk,reset_b,1'b1,lIO10O01IlOlI1O);assign I01lOlO10IOI01l[23:16]
=
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlI0OO01Il&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:O01IlOOl1IIlO01[23:16];assign OOl1Il10IOO1lIO[1]
=
(IIO0lOIl01I01lO&LCELL(OlI1Ol10IOO01Il&OOl1IOOIl1O1lIO[33]))|
LCELL((IO01llO10IOI01l&OOl1IOOIl1O1lIO[33])|
((O01IlIIO0lIlI0O)&OI01lOlI01I1lO0[1])|
((I01lOl10IOlO10I)&OOIl1O1lIOO1lIO[1])|
(((lO10Il10IOl0IO1|IlI0Ol10IOOI01l)&~l10IOl10IOlIO10[0])&IO01lIIO0llO10I[1]))|
I1lO0OlI1OOlI01[1];assign OI01lI1lO0lO10I[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OOIl1OlI01O1lIO&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OIl01IOIl0OIl01[23:16];assign O01IlIO0lIIlO01
=(LCELL(IlI0Ol10IOOI01l&~OOIl1OOl1IIlI0O&h_wait_b)|
(IIO0lIIO0lOlI01&IIO0lOIl01I01lO&OI01lOOIl1I1lO0&~IIO0lIOIl0lIO10&~(h_wait_b|I01lOI1lO0OI01l))|
LCELL(O01IlI1lO0OIl01&~OI01lOOIl1I1lO0&(~IIO0lOIl01I01lO|l10IOI1lO0OlI01))|
(lO10Il10IOl0IO1&~l10IOl10IOlIO10[0]));assign OlI1OlO10IIOIl0
=~(IIO0lO1lIOOOIl1);assign parout=l10IOIO0lIOlI01;assign OlI1OIO01ll0IO1
=CASCADE(OlI1Ol10IOO01Il|
(I01lOlIO10lO10I&lO10IIO01lO01Il)|
OlI1OIO01lIOIl0)&
(IIO0lOIl01I01lO|(I01lOlIO10lO10I&lO10IIO01lO01Il)|OlI1OIO01lIOIl0);assign O1lIOI01lOOlI1O[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OI01lIlO01OI01l&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:IOIl0IlI0OOOIl1[31:24];assign lO10II1lO0O01Il
=((l10IOIO01lOlI01|IIO0lIO01llIO10)&IlI0Ol10IOOI01l)?16'h0001:
(~l10IOIO01lOlI01&~IIO0lIO01llIO10&IlI0Ol10IOOI01l&~O01IlIO01lOIl01)?h_size:
(~l10IOIO01lOlI01&O01IlIO01lOIl01&~IIO0lIO01llIO10)?16'hffff:
(O1lIOIlI0OIO01l)?16'h0003:
(OOl1II01lOIlO01)?16'h0002:
(IO01lOI01lOOl1I)?16'h0001:
IlI0OI1lO0lO10I;assign O1lIOOlI01IO01l[31:10]
=OOl1IIlO01IlO01[31:10];dff IIO0lIIIO0lIO01l(l10IOlO10II01lO,IO01lOlI1OI1lO0,clk,reset_b,1'b1);assign OOl1IOlI01O1lIO
=(OlI1OO01IlIOIl0|OOl1IOOl1IIlI0O)&~IIO0lIlO01OOIl1;assign O1lIOI01lOO01Il[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIlO01lO10I&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:IOIl0IlI0OOlI01[7:0];assign O01IlIlI0OIlI0O
=~IIO0lIlI0OOOIl1|~OlI1OI01lOOlI1O|~OOl1IIlI0OO1lIO|O01IlIOIl0OIl01[3]|
O01IlIOIl0OIl01[2]|O01IlIOIl0OIl01[1];dff32 Il0IO1OI01lIO01l
(OIl01IIO0lIlI0O,OI01ll10IOOI01l,clk,reset_b,1'b1);assign O01IllO10IOIl01
=IO01lOOIl1IO0lI&((IIO0lIIO0lOlI01&IIO0lOIl01I01lO)|
LCELL((IIO0lOOl1IIIO0l&h_retry_b)|
(OlI1OO01IlIOIl0&I01lOlIO10lO10I)|
(l10IOOOl1IOlI01&IlI0OlIO10OOl1I)|
(lO10IO01IlO01Il&IlI0OlIO10OOl1I)|
(OI01lIOIl0IO0lI)));assign oe_ad
=OI01llO10IIO0lI;assign IO01lIO01lOOl1I[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01I01lO&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OOIl1IlI0OIlO01[15:8];dff Il0IO1OOIl1l0IO1
(O01IllO10IO1lIO,l10IOlO10IOOIl1,clk,reset_b,1'b1);dff32 IIOIl0IlO01I01lO(I1lO0IlI0OIIO0l,lIO10I01lOIOIl0,clk,reset_b,1'b1);dff II1lO0I1lO0OlI01
(IIO0lOOl1IIIO0l,O01IlOOIl1l10IO,clk,reset_b,1'b1);assign OOl1IOOIl1O1lIO[9]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[9])|
(IlI0OIlO01OOl1I&h_din[9])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[9]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[9])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[9]);assign lIO10IO01lO01Il[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&l0IO1OOl1IOlI1O&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:I1lO0OI01lOlI01[23:16];assign IIO0lIlI0OI01lO
=IlI0Ol10IOOI01l&OOIl1OOl1IIlI0O&l10IOIOIl0OlI01&~IIO0lIO01llIO10&~l10IOIO01lOlI01&h_wait_b;assign I01lOl0IO1I1lO0[31:16]
=subsystem_id;assign I01lOlO10IOOl1I
=
LCELL((l10IOOOl1IOOIl1&lO10IOIl01IOIl0&lO10IlIO10l0IO1)|
(l10IOOOl1IOOIl1&~lO10IlIO10l0IO1)|
(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&~h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO)|
(l10IOOOl1IOOIl1&~lO10IOIl01IOIl0&lO10IlIO10l0IO1&~lO10IlO10IIO01l&~l10IOOlI1OI01lO&~O01IlOlI1OIlO01&~IlI0OlIO10OOl1I)|
(IIO0lOOl1IIIO0l&~h_retry_b)|
(lO10IO01IlO01Il));assign OOl1IOOIl1O1lIO[28]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[28])|
(IlI0OIlO01OOl1I&h_din[28])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[28]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[28])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[28]);assign IIO0lOlI1OlIO10[8]
=OI01lIO0lIlO10I;BUF IOOIl1lO10IIlI0O(IIO0lI01lOOOIl1,OI01lIlI0OOOl1I);assign OIl01OlI01IlI0O
=(IlO01IlO01IlO01[7:2]==6'b110000)?1'b1:1'b0;assign I1lO0OOl1IOlI01
=(I01lOlIO10lO10I&OIl01OOIl1IlI0O)|(IIO0lIIO0lOlI01&IIO0lOIl01I01lO);dffe8 II1lO0l0IO1OlI01
(OI01lIIO0lOI01l[7:0],O01IlIO01lIlO01[7:0],clk,reset_b,1'b1,OOl1IOlI01OIl01);dff IOlI1OOOl1Il10IO
(l10IOOIl01IIO0l,lIO10OOIl1IOIl0,clk,reset_b,1'b1);assign IlI0OI1lO0IO0lI=O01IlIOIl0O1lIO&(lO10II1lO0OlI1O|~OlI1OI1lO0IOIl0);assign OI01ll10IOOI01l[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OI01lOIl01&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:OIl01IIO0lIlI0O[7:0];assign IlI0OlO10IIO0lI
=(I01lOO01IlOOl1I)?idsel:IIO0lOOl1IlIO10;assign lIO10lO10IO01Il[20]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[20])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));assign OI01lO1lIOI1lO0
=LCELL(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlI0OIOIl0&~IlI0OO01IllO10I[3]);assign l10IOI01lOlIO10
=(lIO10IO0lIIO01l==8'b00000000)?1'b1:1'b0;assign O1lIOl10IOIO01l[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IO01lIO01lI1lO0&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:IOIl0IIO0lI01lO[15:8];assign OOl1IIIO0lIlO01
=~gnt_b;dff II1lO0I01lOlIO10(OlI1OO01Ill0IO1,IIO0lOlI1OIIO0l,clk,1'b1,reset_b);assign lIO10lO10IO01Il[1]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[1])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff16 IIlI0OOOIl1OlI01
(O01IlOOl1IIlO01[31:16],I01lOlO10IOI01l[31:16],clk,1'b1,reset_b);assign OOIl1O1lIOO1lIO[3:0]
=OI01llIO10OOl1I?4'b0111:
I1lO0OlI1OI01lO?4'b0110:l10IOl10IOlIO10[3:0];assign IO01lI1lO0OI01l[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IOIl0OlI01OOIl1&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:OOIl1IOIl0IlI0O[23:16];dff IIlO01OOl1II1lO0
(O1lIOIIO0lO01Il,IlI0Ol10IOOI01l,clk,reset_b,1'b1);assign IlI0OlIO10OI01l=IIO0lO1lIOOlI01|OlI1OlIO10O01Il|OOl1IO1lIOOIl01;assign lO10Il0IO1OlI1O
=OlI1OOIl01OlI1O[16]^OlI1OOIl01OlI1O[17]^OlI1OOIl01OlI1O[18]^OlI1OOIl01OlI1O[19];assign OlI1OIO01lIOIl0
=LCELL(l10IOI01lOIIO0l|(lO10IIO01lO01Il&OlI1OO01Ill0IO1));assign lIO10I1lO0IO01l[31:24]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&lIO10IlO01IOIl0&~IlI0OO01IllO10I[3])?OOIl1OlI1OIlI0O[31:24]:I1lO0IOIl0I01lO[31:24];dff IIOIl0OIl01OOIl1
(l10IOIOIl0OlI01,IOIl0OOl1IIIO0l,clk,reset_b,1'b1);assign IOIl0OOIl1OOIl1
=(lO10IO01IlOlI1O&IIO0lO1lIOI01lO)|(OlI1OO01IlIOIl0&~OlI1OO01Ill0IO1&I01lOlIO10lO10I);dff IIO0lIIIO0lO01Il
(O01IlO01IlO1lIO,OI01lOOl1IlO10I,clk,reset_b,1'b1);BUF IIOIl0lIO10OlI01(OOIl1IO0lIIlI0O,l10IOOlI01IIO0l);assign lIO10I01lOIOIl0[7:0]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIlO01O01Il&~IlI0OO01IllO10I[0])?OOIl1OlI1OIlI0O[7:0]:I1lO0IlI0OIIO0l[7:0];assign OlI1OI1lO0l0IO1
=(~IIO0lOIl01I01lO&I01lOI1lO0I1lO0)|
(lO10II1lO0IO01l&IIO0lOIl01I01lO)|IlI0OI01lOOOl1I;assign IOIl0O1lIOI01lO
=(l10IOl0IO1I01lO&~lO10IOIl01IOIl0)?O01IlO1lIOl10IO:O1lIOlIO10IO01l;assign O01IlO01IlOIl01
=(adin[20]^adin[21]^adin[22]^adin[23]);assign lO10IIlO01l0IO1
=(IIO0lOIl01I01lO&IIO0lIIO0lOlI01)|IO01ll0IO1OI01l|OI01ll0IO1lO10I;assign OI01lI01lOI1lO0[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&OIl01OlI01l10IO&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:OIl01IlI0Ol10IO[15:8];assign OlI1OI01lOO01Il
=IIO0lIlI0OOlI01-16'h0001;dff32 IIOIl0IlO01OlI01(I1lO0IOIl0OlI01,lIO10I1lO0O01Il,clk,reset_b,1'b1);assign OI01lO1lIOOI01l
=CASCADE(OI01lOOIl1OI01l&IO01lOOIl1IO0lI&IO01lIO0lII1lO0)&((IlI0OIlO01I1lO0&~parin)|(~IlI0OIlO01I1lO0&parin));assign OOl1IOOIl1O1lIO[1]
=CASCADE((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[1])|
(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[1])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[1]))|
((O01IlOI01lIlO01&I01lOOIl01IO0lI[1])|
(IlI0OIlO01OOl1I&h_din[1]));assign O1lIOIO01lIOIl0[23:16]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&IlO01OOl1IOOl1I&~IlI0OO01IllO10I[2])?OOIl1OlI1OIlI0O[23:16]:IOIl0OI01lIIO0l[23:16];assign O01IlOI01lO1lIO
=(OOl1IIIO0lOIl01&IIO0lIIO0lI01lO&~(OI01lOlI1OIO0lI&IIO0lI01lOI01lO))|
(O01IlIIO0lIlI0O&O1lIOOOIl1IO01l&~(O1lIOOOIl1OlI1O|OI01lIlI0OI1lO0))|
(l10IOOOl1IOOIl1&h_retry_b&lO10IlIO10l0IO1&l10IOOlI1OI01lO)|
(l10IOOOl1IOOIl1&lO10IlIO10l0IO1&lO10IlO10IIO01l)|
(lO10IO01IlOlI1O)|
(O01IlOOl1IO1lIO)|
(IlI0OO01IlIO0lI)|
(IIO0lOOl1IIIO0l&h_retry_b)|
(lO10IOIl01IOIl0);dff32 IIlO01O01IlOI01l
(OOIl1OI01lIlI0O,IO01lIO01lOI01l,clk,reset_b,1'b1);assign I01lOOIl01lO10I
=
(~l10IOO1lIOlIO10&(~IIO0lO1lIOI01lO&OlI1OO01Ill0IO1)&(lO10IO01IlOlI1O&h_abort_b&h_retry_b));assign OOl1IOOIl1O1lIO[20]
=((lO10IIO01lIO01l&OOl1IOlI1Ol10IO[20])|
(IlI0OIlO01OOl1I&h_din[20])|(IIO0lOlI01OOIl1&l10IOl10IOIIO0l[20]))|
CASCADE(O01IlOI01lIlO01&I01lOOIl01IO0lI[20])|
(OlI1OIlO01OlI1O&IO01lOlI01lO10I[20]);assign OlI1OlO10Il0IO1[1]
=IlI0OOIl01OOl1I;assign O1lIOOlI1OIOIl0
=(IIO0lOIl01I01lO&LCELL(lIO10IOIl0OlI1O&IIO0lIOIl0lIO10))|(OOl1IIIO0lOIl01&~l10IOIOIl0OOIl1);assign OIl01OI01lIlO01
=(IlO01IlO01IlO01[7:2]==6'b101000)?1'b1:1'b0;BUF IIlO01IlI0OIO0lI(OIl01OOIl1l10IO,lIO10OIl01l0IO1);dffe IIlO01IO0lIOI01l
(lIO10l0IO1IO01l,h_mio,clk,1'b1,reset_b,IlI0Ol10IOOI01l);assign OOl1IlO10IIlI0O[12:0]=13'b0000000001000;assign O1lIOIOIl0l0IO1
=(IIO0lOIl01I01lO&OOl1II01lOO1lIO)|(lIO10IOIl0OlI1O&(OI01lIIO0lOOl1I|IIO0lIOIl0lIO10)&I1lO0IIO0lIIO0l&h_wait_b);assign O1lIOIlO01IO01l
=(IlO01IlO01IlO01[7:2]==6'b111011)?1'b1:1'b0;assign IO01lOlI01IO0lI=lIO10OlI01IOIl0|(~OI01lOlI01OI01l&O1lIOOlI01OlI1O);assign lIO10lO10IO01Il[28]
=LCELL((IIO0lIlO01OlI01&OI01lOlI01OOl1I[28])|(~IIO0lIlO01OlI01&l10IOIlO01lIO10));dff IlO10IOOl1IIlO01
(IIO0ll0IO1lIO10,O1lIOIO0lIIOIl0,clk,reset_b,1'b1);assign IIO0ll10IOI01lO[0]
=~l10IOlO10IOlI01&
CASCADE((IO01lIOIl0OOl1I&OOl1Il10IOIlO01[0])|(l10IOI1lO0OOIl1&O1lIOIIO0lIO01l[0]));assign lIO10l10IOl0IO1[15:8]
=(l10IOOOl1IOlI01&IlI0OlIO10OOl1I&O1lIOIO01ll0IO1&~IlI0OO01IllO10I[1])?OOIl1OlI1OIlI0O[15:8]:I1lO0IIO0llIO10[15:8];assign intaout_b
=h_inta_b;
function LCELL;
input val;
begin
LCELL=val;
end
endfunction
function CASCADE;
input val;
begin
CASCADE=val;
end
endfunction
endmodule
