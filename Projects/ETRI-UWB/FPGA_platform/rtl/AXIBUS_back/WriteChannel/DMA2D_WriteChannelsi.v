// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  DMA2D_WriteChannelsi(

    SelMAP1,

    //Global signal
    ACLK    ,
    ARESETn ,

    //For Master
    //Write address channel
//ENABLE_ID
    AWIDm2si    ,
    AWADDRm2si  ,
    AWLENm2si   ,
    AWSIZEm2si  ,
    AWBURSTm2si ,
//ENABLE_LOCK
    AWLOCKm2si  ,
//ENABLE_CACHE
    AWCACHEm2si ,
//ENABLE_PROT
    AWPROTm2si  ,

    AWVALIDm2si ,
    AWREADYsi2m ,

    //Write data channel
//ENABLE_ID
    WIDm2si     ,
    WDATAm2si   ,
//ENABLE_WSTRB
    WSTRBm2si   ,
    WLASTm2si   ,
    WVALIDm2si  ,
    WREADYsi2m  ,

    //Write response channel
//ENABLE_ID
    BIDsi2m     ,
    BRESPsi2m   ,
    BVALIDsi2m  ,
    BREADYm2si  ,

    //For Master interface slave Number = 0
    //Write address channel
    AWIDsi2mi0    ,
    AWADDRsi2mi0  ,
    AWLENsi2mi0   ,
    AWSIZEsi2mi0  ,
    AWBURSTsi2mi0 ,
    AWLOCKsi2mi0  ,
    AWCACHEsi2mi0 ,
    AWPROTsi2mi0  ,

    //Write data channel
    WIDsi2mi0     ,
    WDATAsi2mi0   ,
    WSTRBsi2mi0   ,
    //For Master interface slave Number = 3
    //Write address channel
    AWIDsi2mi3    ,
    AWADDRsi2mi3  ,
    AWLENsi2mi3   ,
    AWSIZEsi2mi3  ,
    AWBURSTsi2mi3 ,
    AWLOCKsi2mi3  ,
    AWCACHEsi2mi3 ,
    AWPROTsi2mi3  ,

    //Write data channel
    WIDsi2mi3     ,
    WDATAsi2mi3   ,
    WSTRBsi2mi3   ,
    //For Master interface slave Number = 4
    //Write address channel
    AWIDsi2mi4    ,
    AWADDRsi2mi4  ,
    AWLENsi2mi4   ,
    AWSIZEsi2mi4  ,
    AWBURSTsi2mi4 ,
    AWLOCKsi2mi4  ,
    AWCACHEsi2mi4 ,
    AWPROTsi2mi4  ,

    //Write data channel
    WIDsi2mi4     ,
    WDATAsi2mi4   ,
    WSTRBsi2mi4   ,

//Default Slave Number = 5    //For Master interface slave Number = 5
    //Write address channel
    AWIDsi2mi5    ,
    AWADDRsi2mi5  ,
    AWLENsi2mi5   ,
    AWSIZEsi2mi5  ,
    AWBURSTsi2mi5 ,
    AWLOCKsi2mi5  ,
    AWCACHEsi2mi5 ,
    AWPROTsi2mi5  ,

    //Write data channel
    WIDsi2mi5     ,
    WDATAsi2mi5   ,
    WSTRBsi2mi5   ,
////////////////////////////

    //VALID & READY signal
    AWVALIDsi2mi ,
    AWREADYmi2si ,

    WLASTsi2mi   ,
    WVALIDsi2mi  ,
    WREADYmi2si  ,
    //Write response channel

    
    //Slave Number 0
    BIDmi02si     ,
    BRESPmi02si   ,
    
    //Slave Number 3
    BIDmi32si     ,
    BRESPmi32si   ,
    
    //Slave Number 4
    BIDmi42si     ,
    BRESPmi42si   ,

//Default Slave Number = 5    
    //Slave Number 5
    BIDmi52si     ,
    BRESPmi52si   ,
////////////////////////////

    BVALIDmi2si  ,
    BREADYsi2mi
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 4;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 7;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   SelMAP1;

    input   ACLK;
    input   ARESETn;

    //For Master
    //Write address channel
    input   [ADDR_WID-1:0]     AWADDRm2si;
    input   [AWLEN_WID-1:0]    AWLENm2si;
    input   [AWSIZE_WID-1:0]   AWSIZEm2si;  
    input   [AWBURST_WID-1:0]  AWBURSTm2si; 
//ENABLE_ID
    input   [MASTERID_WID-1:0] AWIDm2si;    
//ENABLE_LOCK
    input   [AWLOCK_WID-1:0]   AWLOCKm2si;  
//ENABLE_CACHE
    input   [AWCACHE_WID-1:0]  AWCACHEm2si; 
//ENABLE_PROT
    input   [AWPROT_WID-1:0]   AWPROTm2si;  

    input   AWVALIDm2si; 
    output  AWREADYsi2m; 

    //Write data channel
//ENABLE_ID
    input   [MASTERID_WID-1:0] WIDm2si;     
    input   [BUS_WID-1:0]      WDATAm2si;   
//ENABLE_WSTRB
    input   [WSTRB_WID-1:0]    WSTRBm2si;   
    input   WLASTm2si;   
    input   WVALIDm2si;  
    output  WREADYsi2m;  

    //Write response channel
//ENABLE_ID
    output   [MASTERID_WID-1:0]      BIDsi2m;     
    output   [BRESP_WID-1:0]   BRESPsi2m;   
    output   BVALIDsi2m;  
    input    BREADYm2si;  

    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi0;    
    output  [ADDR_WID-1:0] AWADDRsi2mi0;  
    output  [AWLEN_WID-1:0] AWLENsi2mi0;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi0;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi0; 
//ENABLE_LOCK_WriteOutput
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi0;  
//ENABLE_CACHE_WriteOutput
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi0; 
//ENABLE_PROT_WriteOutput
    output  [AWPROT_WID-1:0] AWPROTsi2mi0;  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi0;     
//ENABLE_WSTRB_WriteOutput
    output  [WSTRB_WID-1:0]WSTRBsi2mi0;   
    output  [BUS_WID-1:0] WDATAsi2mi0;   
    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi3;    
    output  [ADDR_WID-1:0] AWADDRsi2mi3;  
    output  [AWLEN_WID-1:0] AWLENsi2mi3;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi3;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi3; 
//ENABLE_LOCK_WriteOutput
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi3;  
//ENABLE_CACHE_WriteOutput
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi3; 
//ENABLE_PROT_WriteOutput
    output  [AWPROT_WID-1:0] AWPROTsi2mi3;  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi3;     
//ENABLE_WSTRB_WriteOutput
    output  [WSTRB_WID-1:0]WSTRBsi2mi3;   
    output  [BUS_WID-1:0] WDATAsi2mi3;   
    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi4;    
    output  [ADDR_WID-1:0] AWADDRsi2mi4;  
    output  [AWLEN_WID-1:0] AWLENsi2mi4;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi4;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi4; 
//ENABLE_LOCK_WriteOutput
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi4;  
//ENABLE_CACHE_WriteOutput
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi4; 
//ENABLE_PROT_WriteOutput
    output  [AWPROT_WID-1:0] AWPROTsi2mi4;  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi4;     
//ENABLE_WSTRB_WriteOutput
    output  [WSTRB_WID-1:0]WSTRBsi2mi4;   
    output  [BUS_WID-1:0] WDATAsi2mi4;   

//Default Slave Number = 5    //For Master interface
    //Write address channel
    output  [MASTERID_WID-1:0] AWIDsi2mi5;    
    output  [ADDR_WID-1:0] AWADDRsi2mi5;  
    output  [AWLEN_WID-1:0] AWLENsi2mi5;   
    output  [AWSIZE_WID-1:0] AWSIZEsi2mi5;  
    output  [AWBURST_WID-1:0] AWBURSTsi2mi5; 
//ENABLE_LOCK_WriteOutput
    output  [AWLOCK_WID-1:0] AWLOCKsi2mi5;  
//ENABLE_CACHE_WriteOutput
    output  [AWCACHE_WID-1:0] AWCACHEsi2mi5; 
//ENABLE_PROT_WriteOutput
    output  [AWPROT_WID-1:0] AWPROTsi2mi5;  

    //Write data channel
    output  [MASTERID_WID-1:0] WIDsi2mi5;     
//ENABLE_WSTRB_WriteOutput
    output  [WSTRB_WID-1:0]WSTRBsi2mi5;   
    output  [BUS_WID-1:0] WDATAsi2mi5;   
////////////////////////////

    //Write response channel

    //Slave Number 0
    input   [MASTERID_WID-1:0] BIDmi02si;     
    input   [BRESP_WID-1:0] BRESPmi02si;   

    //Slave Number 3
    input   [MASTERID_WID-1:0] BIDmi32si;     
    input   [BRESP_WID-1:0] BRESPmi32si;   

    //Slave Number 4
    input   [MASTERID_WID-1:0] BIDmi42si;     
    input   [BRESP_WID-1:0] BRESPmi42si;   

//Default Slave Number = 5
    //Slave Number 5
    input   [MASTERID_WID-1:0] BIDmi52si;     
    input   [BRESP_WID-1:0] BRESPmi52si;   
////////////////////////////
    
    output  [SLAVE_NUM-1:0]AWVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]AWREADYmi2si; 

    output  [SLAVE_NUM-1:0]WLASTsi2mi;   
    output  [SLAVE_NUM-1:0]WVALIDsi2mi;  
    input   [SLAVE_NUM-1:0]WREADYmi2si;  

    input   [SLAVE_NUM-1:0]BVALIDmi2si;  
    output  [SLAVE_NUM-1:0]BREADYsi2mi;

    
    wire [MASTERID_WID-1:0] WIDsi2mi;     
    wire [BUS_WID-1:0] WDATAsi2mi;   
    wire [WSTRB_WID-1:0]WSTRBsi2mi;   
    wire [SLAVE_WID  :0] CtlData2writech; 

    //SLAVE 0
    assign  AWIDsi2mi0 = AWIDm2si;    
    assign  AWADDRsi2mi0 = AWADDRm2si;  
    assign  AWLENsi2mi0 = AWLENm2si;   
    assign  AWSIZEsi2mi0 = AWSIZEm2si;  
    assign  AWBURSTsi2mi0 = AWBURSTm2si; 
    assign  AWLOCKsi2mi0 = AWLOCKm2si;  
    assign  AWCACHEsi2mi0 = AWCACHEm2si; 
    assign  AWPROTsi2mi0 = AWPROTm2si;  

    assign  WIDsi2mi0 = WIDm2si;
    assign  WDATAsi2mi0 = WDATAm2si;   
    assign  WSTRBsi2mi0 = WSTRBm2si;

    //SLAVE 3
    assign  AWIDsi2mi3 = AWIDm2si;    
    assign  AWADDRsi2mi3 = AWADDRm2si;  
    assign  AWLENsi2mi3 = AWLENm2si;   
    assign  AWSIZEsi2mi3 = AWSIZEm2si;  
    assign  AWBURSTsi2mi3 = AWBURSTm2si; 
    assign  AWLOCKsi2mi3 = AWLOCKm2si;  
    assign  AWCACHEsi2mi3 = AWCACHEm2si; 
    assign  AWPROTsi2mi3 = AWPROTm2si;  

    assign  WIDsi2mi3 = WIDm2si;
    assign  WDATAsi2mi3 = WDATAm2si;   
    assign  WSTRBsi2mi3 = WSTRBm2si;

    //SLAVE 4
    assign  AWIDsi2mi4 = AWIDm2si;    
    assign  AWADDRsi2mi4 = AWADDRm2si;  
    assign  AWLENsi2mi4 = AWLENm2si;   
    assign  AWSIZEsi2mi4 = AWSIZEm2si;  
    assign  AWBURSTsi2mi4 = AWBURSTm2si; 
    assign  AWLOCKsi2mi4 = AWLOCKm2si;  
    assign  AWCACHEsi2mi4 = AWCACHEm2si; 
    assign  AWPROTsi2mi4 = AWPROTm2si;  

    assign  WIDsi2mi4 = WIDm2si;
    assign  WDATAsi2mi4 = WDATAm2si;   
    assign  WSTRBsi2mi4 = WSTRBm2si;

    //SLAVE 5
    assign  AWIDsi2mi5 = AWIDm2si;    
    assign  AWADDRsi2mi5 = AWADDRm2si;  
    assign  AWLENsi2mi5 = AWLENm2si;   
    assign  AWSIZEsi2mi5 = AWSIZEm2si;  
    assign  AWBURSTsi2mi5 = AWBURSTm2si; 
    assign  AWLOCKsi2mi5 = AWLOCKm2si;  
    assign  AWCACHEsi2mi5 = AWCACHEm2si; 
    assign  AWPROTsi2mi5 = AWPROTm2si;  

    assign  WIDsi2mi5 = WIDm2si;
    assign  WDATAsi2mi5 = WDATAm2si;   
    assign  WSTRBsi2mi5 = WSTRBm2si;


//Write address channel
//____________________________________________________________________


//AWVALID MUX 
reg [SLAVE_NUM-1:0]AWVALIDsi2mi; 


//MUX TYPE 00 was Generated 
always @(CtlData2writech  or 
         AWVALIDm2si  )
begin

    if(CtlData2writech [SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2writech [SLAVE_WID-1:0])
        //synopsys parallel_case full_case
            3'd0:   
            begin
                 AWVALIDsi2mi[0] <= AWVALIDm2si ;
                 AWVALIDsi2mi[3] <= 1'b0;
                 AWVALIDsi2mi[4] <= 1'b0;
                 AWVALIDsi2mi[5] <= 1'b0;
            end
            3'd3:   
            begin
                 AWVALIDsi2mi[0] <= 1'b0;
                 AWVALIDsi2mi[3] <= AWVALIDm2si ;
                 AWVALIDsi2mi[4] <= 1'b0;
                 AWVALIDsi2mi[5] <= 1'b0;
            end
            3'd4:   
            begin
                 AWVALIDsi2mi[0] <= 1'b0;
                 AWVALIDsi2mi[3] <= 1'b0;
                 AWVALIDsi2mi[4] <= AWVALIDm2si ;
                 AWVALIDsi2mi[5] <= 1'b0;
            end
            default:
            begin
                AWVALIDsi2mi[0] <= 1'b0;
                AWVALIDsi2mi[3] <= 1'b0;
                AWVALIDsi2mi[4] <= 1'b0;
                AWVALIDsi2mi[5] <= AWVALIDm2si ;
            end
        endcase
    end
    else
    begin
        AWVALIDsi2mi[0] <= 1'b0;
        AWVALIDsi2mi[3] <= 1'b0;
        AWVALIDsi2mi[4] <= 1'b0;
        AWVALIDsi2mi[5] <= 1'b0;
    end
end

reg AWREADYsi2m;

//AWREADY Demux
always @(CtlData2writech or AWREADYmi2si)
begin

    if(CtlData2writech[SLAVE_WID]) //Mux enable bit
    begin
        case(CtlData2writech[SLAVE_WID-1:0])
            //synopsys parallel_case full_case
            3'd0: AWREADYsi2m <= AWREADYmi2si[0];
            3'd3: AWREADYsi2m <= AWREADYmi2si[3];
            3'd4: AWREADYsi2m <= AWREADYmi2si[4];
            3'd5: AWREADYsi2m <= AWREADYmi2si[5];
            default:
                AWREADYsi2m <= 1'b0;
        endcase
    end
    else
        AWREADYsi2m <= 1'b0;
end

reg [SLAVE_WID-1:0] SlaveNum;

//ADDRESS Decoder
//____________________________________________________________________

//Slave Number 0
wire Slave0MAX0En = (AWADDRm2si >= 32'h60000000) ? 1'b1:1'b0;
wire Slave0MIN0En = (32'h70000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave0_0En = Slave0MAX0En & Slave0MIN0En;

//Slave Number 3
wire Slave3MAX0En = (AWADDRm2si >= 32'h0) ? 1'b1:1'b0;
wire Slave3MIN0En = (32'h20000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave3_0En = Slave3MAX0En & Slave3MIN0En;

//Slave Number 4
wire Slave4MAX0En = (AWADDRm2si >= 32'h20000000) ? 1'b1:1'b0;
wire Slave4MIN0En = (32'h30000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave4_0En = Slave4MAX0En & Slave4MIN0En;


//Slave Number 0
wire Slave0MAX1En = (AWADDRm2si >= 32'h60000000) ? 1'b1:1'b0;
wire Slave0MIN1En = (32'h70000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave0_1En = Slave0MAX1En & Slave0MIN1En;

//Selection mux
wire Slave0En = (SelMAP1) ? Slave0_1En : Slave0_0En;

//Slave Number 3
wire Slave3MAX1En = (AWADDRm2si >= 32'h20000000) ? 1'b1:1'b0;
wire Slave3MIN1En = (32'h40000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave3_1En = Slave3MAX1En & Slave3MIN1En;

//Selection mux
wire Slave3En = (SelMAP1) ? Slave3_1En : Slave3_0En;

//Slave Number 4
wire Slave4MAX1En = (AWADDRm2si >= 32'h0) ? 1'b1:1'b0;
wire Slave4MIN1En = (32'h10000000 >  AWADDRm2si)  ? 1'b1:1'b0;
wire Slave4_1En = Slave4MAX1En & Slave4MIN1En;

//Selection mux
wire Slave4En = (SelMAP1) ? Slave4_1En : Slave4_0En;



wire Slave5En = 
                !Slave0En &
                !Slave3En &
                !Slave4En ;

always @(
         Slave0En or
         Slave3En or
         Slave4En or
         Slave5En  
        )
begin
    case(1'b1) //synopsys parallel_case
        Slave0En:   SlaveNum <= 3'd0;
        Slave3En:   SlaveNum <= 3'd3;
        Slave4En:   SlaveNum <= 3'd4;
        Slave5En:   SlaveNum <= 3'd5;
        default:   SlaveNum <= {3{1'd0}};
    endcase
end

//STATE_END

//____________________________________________________________________

// Write data channel ////////////////////////////////////////////////
//____________________________________________________________________

//WVALID MUX 
wire  [SLAVE_WID  :0] CtlData2datach;
reg   [SLAVE_NUM-1:0] WVALIDsi2mi;  
reg   [SLAVE_NUM-1:0] WLASTsi2mi;   

//MUX TYPE 00 was Generated 
always @(CtlData2datach or 
         WVALIDm2si  )
begin

    if(CtlData2datach[SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2datach[SLAVE_WID-1:0])
        //synopsys parallel_case full_case
            3'd0:   
            begin
                 WVALIDsi2mi[0] <= WVALIDm2si ;
                 WVALIDsi2mi[3] <= 1'b0;
                 WVALIDsi2mi[4] <= 1'b0;
                 WVALIDsi2mi[5] <= 1'b0;
            end
            3'd3:   
            begin
                 WVALIDsi2mi[0] <= 1'b0;
                 WVALIDsi2mi[3] <= WVALIDm2si ;
                 WVALIDsi2mi[4] <= 1'b0;
                 WVALIDsi2mi[5] <= 1'b0;
            end
            3'd4:   
            begin
                 WVALIDsi2mi[0] <= 1'b0;
                 WVALIDsi2mi[3] <= 1'b0;
                 WVALIDsi2mi[4] <= WVALIDm2si ;
                 WVALIDsi2mi[5] <= 1'b0;
            end
            default:
            begin
                WVALIDsi2mi[0] <= 1'b0;
                WVALIDsi2mi[3] <= 1'b0;
                WVALIDsi2mi[4] <= 1'b0;
                WVALIDsi2mi[5] <= WVALIDm2si ;
            end
        endcase
    end
    else
    begin
        WVALIDsi2mi[0] <= 1'b0;
        WVALIDsi2mi[3] <= 1'b0;
        WVALIDsi2mi[4] <= 1'b0;
        WVALIDsi2mi[5] <= 1'b0;
    end
end

//MUX TYPE 00 was Generated 
always @(CtlData2datach or 
         WLASTm2si  )
begin

    if(CtlData2datach[SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2datach[SLAVE_WID-1:0])
        //synopsys parallel_case full_case
            3'd0:   
            begin
                 WLASTsi2mi[0] <= WLASTm2si ;
                 WLASTsi2mi[3] <= 1'b0;
                 WLASTsi2mi[4] <= 1'b0;
                 WLASTsi2mi[5] <= 1'b0;
            end
            3'd3:   
            begin
                 WLASTsi2mi[0] <= 1'b0;
                 WLASTsi2mi[3] <= WLASTm2si ;
                 WLASTsi2mi[4] <= 1'b0;
                 WLASTsi2mi[5] <= 1'b0;
            end
            3'd4:   
            begin
                 WLASTsi2mi[0] <= 1'b0;
                 WLASTsi2mi[3] <= 1'b0;
                 WLASTsi2mi[4] <= WLASTm2si ;
                 WLASTsi2mi[5] <= 1'b0;
            end
            default:
            begin
                WLASTsi2mi[0] <= 1'b0;
                WLASTsi2mi[3] <= 1'b0;
                WLASTsi2mi[4] <= 1'b0;
                WLASTsi2mi[5] <= WLASTm2si ;
            end
        endcase
    end
    else
    begin
        WLASTsi2mi[0] <= 1'b0;
        WLASTsi2mi[3] <= 1'b0;
        WLASTsi2mi[4] <= 1'b0;
        WLASTsi2mi[5] <= 1'b0;
    end
end

//____________________________________________________________________
reg WREADYsi2m;

//WREADY Demux
always @(CtlData2datach or WREADYmi2si)
begin
    if(CtlData2datach[SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2datach[SLAVE_WID-1:0])
            //synopsys parallel_case full_case
            3'd0: WREADYsi2m <= WREADYmi2si[0];
            3'd3: WREADYsi2m <= WREADYmi2si[3];
            3'd4: WREADYsi2m <= WREADYmi2si[4];
            3'd5: WREADYsi2m <= WREADYmi2si[5];
            default:
                WREADYsi2m <= 1'b0;
        endcase
    end
    else
        WREADYsi2m <= 1'b0;
end
//____________________________________________________________________



//Write response channel
//____________________________________________________________________

reg   [MASTERID_WID-1:0]      BIDsi2m;     
reg   [BRESP_WID-1:0]   BRESPsi2m;   
reg   BVALIDsi2m;  
reg   [SLAVE_NUM-1:0]   BREADYsi2mi;    


//Arbiter
//_______________________________________________________________
reg   [SLAVE_WID-1:0] CtlData2resch;
//Response Arbiter
//Arbiter was Generated TYPE00
reg   EnArbiter;

always @(
         BVALIDmi2si or
         CtlData2resch
        )
begin
    case(CtlData2resch)
        //synopsys parallel_case full_case
        3'd0:    EnArbiter <= BVALIDmi2si[0];
        3'd3:    EnArbiter <= BVALIDmi2si[3];
        3'd4:    EnArbiter <= BVALIDmi2si[4];
        3'd5:    EnArbiter <= BVALIDmi2si[5];
        default: EnArbiter <= 1'b0;
    endcase
end

always  @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        CtlData2resch <= 0;
    end
    else if(!EnArbiter)
    begin
          if(BVALIDmi2si[0]) CtlData2resch <= 3'd0;
          else if(BVALIDmi2si[3]) CtlData2resch <= 3'd3;
          else if(BVALIDmi2si[4]) CtlData2resch <= 3'd4;
          else if(BVALIDmi2si[5]) CtlData2resch <= 3'd5;
    end
end


//Demux reaponse channel
//MUX TYPE 01 was Generated 
always @(CtlData2resch  or 
         BREADYm2si  )
begin

   case(CtlData2resch )
   //synopsys parallel_case full_case
        3'd0:   
            begin
                 BREADYsi2mi[0] <= BREADYm2si ;
                 BREADYsi2mi[3] <= 1'b0;
                 BREADYsi2mi[4] <= 1'b0;
                 BREADYsi2mi[5] <= 1'b0;
            end
        3'd3:   
            begin
                 BREADYsi2mi[0] <= 1'b0;
                 BREADYsi2mi[3] <= BREADYm2si ;
                 BREADYsi2mi[4] <= 1'b0;
                 BREADYsi2mi[5] <= 1'b0;
            end
        3'd4:   
            begin
                 BREADYsi2mi[0] <= 1'b0;
                 BREADYsi2mi[3] <= 1'b0;
                 BREADYsi2mi[4] <= BREADYm2si ;
                 BREADYsi2mi[5] <= 1'b0;
            end
         default:
            begin
                BREADYsi2mi[0] <= 1'b0;
                BREADYsi2mi[3] <= 1'b0;
                BREADYsi2mi[4] <= 1'b0;
                BREADYsi2mi[5] <= BREADYm2si ;
            end
   endcase
end

//Demux reaponse channel

always @(
         BIDmi02si or
         BIDmi32si or
         BIDmi42si or
         BIDmi52si or
        CtlData2resch 
        )
begin
    case(CtlData2resch)
        3'd0: BIDsi2m      <= BIDmi02si;     
        3'd3: BIDsi2m      <= BIDmi32si;     
        3'd4: BIDsi2m      <= BIDmi42si;     
        3'd5: BIDsi2m      <= BIDmi52si;     
//Syn Warning
        default:       BIDsi2m      <= 0;
    endcase
end

always @(
         BRESPmi02si   or
         BRESPmi32si   or
         BRESPmi42si   or
         BRESPmi52si   or
         CtlData2resch 
        )
begin
    case(CtlData2resch)
        3'd0: BRESPsi2m   <= BRESPmi02si;     
        3'd3: BRESPsi2m   <= BRESPmi32si;     
        3'd4: BRESPsi2m   <= BRESPmi42si;     
        3'd5: BRESPsi2m   <= BRESPmi52si;     
//Syn Warning
        default:       BRESPsi2m   <= 0;
    endcase
end


always @(CtlData2resch or
         BVALIDmi2si    
        )
begin
    case(CtlData2resch)
        3'd0: BVALIDsi2m   <= BVALIDmi2si[0];     
        3'd3: BVALIDsi2m   <= BVALIDmi2si[3];     
        3'd4: BVALIDsi2m   <= BVALIDmi2si[4];     
        3'd5: BVALIDsi2m   <= BVALIDmi2si[5];     
//Syn Warning
        default:       BVALIDsi2m   <= 0;
    endcase
end

WRCH_DMA2D_PermitCtl
    U0PermitCtl(

    .ACLK       (ACLK)      ,
    .ARESETn    (ARESETn)   ,
    .SlaveNum   (SlaveNum)  ,

    .SID       (AWIDm2si),
    .AREADY    (AWREADYsi2m),
    .AVALID    (AWVALIDm2si),    

    .WID       (WIDm2si),
    .WREADY    (WREADYsi2m),
    .WVALID    (WVALIDm2si),
    .WLAST     (WLASTm2si),
    /*
    .WREADY     (1'b0),
    .WVALID     (1'b0),
    .WLAST      (1'b0),
    */

    .LID       (BIDsi2m),
    .LAST      (BVALIDsi2m),
    .READY     (BREADYm2si),
    .RVALID    (1'b1),

    .CtlData2datach  (CtlData2datach),
    .CtlData2writech (CtlData2writech) 

    );
endmodule
//Code_END
