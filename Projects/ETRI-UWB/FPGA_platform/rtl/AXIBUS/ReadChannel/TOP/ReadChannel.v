// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannel.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code

`timescale 1 ns/ 10ps
module  ReadChannel(

    SelMAP1,

    //_______________________________________________________________
    //For Master 0
    //Read address channel
//Disable_id_port
    ARADDRm02si0  ,
    ARLENm02si0   ,
    ARSIZEm02si0  ,
    ARBURSTm02si0 ,
    ARLOCKm02si0  ,
//Disable_cache_port
//Disable_protect_port

    ARVALIDm02si0 ,
    ARREADYsi02m0 ,

    //Read data channel
//Disable_id_port
    RRESPsi02m0   ,
    RDATAsi02m0   ,
    RLASTsi02m0   ,
    RVALIDsi02m0  ,
    RREADYm02si0  ,

 
    //_______________________________________________________________
    //For Master 1
    //Read address channel
//Disable_id_port
    ARADDRm12si1  ,
    ARLENm12si1   ,
    ARSIZEm12si1  ,
    ARBURSTm12si1 ,
    ARLOCKm12si1  ,
//Disable_cache_port
//Disable_protect_port

    ARVALIDm12si1 ,
    ARREADYsi12m1 ,

    //Read data channel
//Disable_id_port
    RRESPsi12m1   ,
    RDATAsi12m1   ,
    RLASTsi12m1   ,
    RVALIDsi12m1  ,
    RREADYm12si1  ,

 
    //_______________________________________________________________
    //For Master 2
    //Read address channel
    ARIDm22si2    ,
    ARADDRm22si2  ,
    ARLENm22si2   ,
    ARSIZEm22si2  ,
    ARBURSTm22si2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDm22si2 ,
    ARREADYsi22m2 ,

    //Read data channel
    RIDsi22m2     ,
    RRESPsi22m2   ,
    RDATAsi22m2   ,
    RLASTsi22m2   ,
    RVALIDsi22m2  ,
    RREADYm22si2  ,

 
    //_______________________________________________________________
    //For Master 3
    //Read address channel
//Disable_id_port
    ARADDRm32si3  ,
    ARLENm32si3   ,
    ARSIZEm32si3  ,
    ARBURSTm32si3 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDm32si3 ,
    ARREADYsi32m3 ,

    //Read data channel
//Disable_id_port
    RRESPsi32m3   ,
    RDATAsi32m3   ,
    RLASTsi32m3   ,
    RVALIDsi32m3  ,
    RREADYm32si3  ,

 
    //_______________________________________________________________
    //For Master 4
    //Read address channel
//Disable_id_port
    ARADDRm42si4  ,
    ARLENm42si4   ,
    ARSIZEm42si4  ,
    ARBURSTm42si4 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDm42si4 ,
    ARREADYsi42m4 ,

    //Read data channel
//Disable_id_port
    RRESPsi42m4   ,
    RDATAsi42m4   ,
    RLASTsi42m4   ,
    RVALIDsi42m4  ,
    RREADYm42si4  ,

 


    //_______________________________________________________________
    //For Slave 0
    //Read address channel
    ARIDmi02s0    ,
    ARADDRmi02s0  ,
    ARLENmi02s0   ,
    ARSIZEmi02s0  ,
    ARBURSTmi02s0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi02s0 ,
    ARREADYs02mi0 ,

    //Read data channel
    RIDs02mi0     ,
    RRESPs02mi0   ,
    RDATAs02mi0  ,
    RLASTs02mi0  ,
    RVALIDs02mi0  ,
    RREADYmi02s0  ,
    //_______________________________________________________________
    //For Slave 1
    //Read address channel
    ARIDmi12s1    ,
    ARADDRmi12s1  ,
    ARLENmi12s1   ,
    ARSIZEmi12s1  ,
    ARBURSTmi12s1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi12s1 ,
    ARREADYs12mi1 ,

    //Read data channel
    RIDs12mi1     ,
    RRESPs12mi1   ,
    RDATAs12mi1  ,
    RLASTs12mi1  ,
    RVALIDs12mi1  ,
    RREADYmi12s1  ,
    //_______________________________________________________________
    //For Slave 2
    //Read address channel
    ARIDmi22s2    ,
    ARADDRmi22s2  ,
    ARLENmi22s2   ,
    ARSIZEmi22s2  ,
    ARBURSTmi22s2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi22s2 ,
    ARREADYs22mi2 ,

    //Read data channel
    RIDs22mi2     ,
    RRESPs22mi2   ,
    RDATAs22mi2  ,
    RLASTs22mi2  ,
    RVALIDs22mi2  ,
    RREADYmi22s2  ,
    //_______________________________________________________________
    //For Slave 3
    //Read address channel
    ARIDmi32s3    ,
    ARADDRmi32s3  ,
    ARLENmi32s3   ,
    ARSIZEmi32s3  ,
    ARBURSTmi32s3 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi32s3 ,
    ARREADYs32mi3 ,

    //Read data channel
    RIDs32mi3     ,
    RRESPs32mi3   ,
    RDATAs32mi3  ,
    RLASTs32mi3  ,
    RVALIDs32mi3  ,
    RREADYmi32s3  ,
    //_______________________________________________________________
    //For Slave 4
    //Read address channel
    ARIDmi42s4    ,
    ARADDRmi42s4  ,
    ARLENmi42s4   ,
    ARSIZEmi42s4  ,
    ARBURSTmi42s4 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi42s4 ,
    ARREADYs42mi4 ,

    //Read data channel
    RIDs42mi4     ,
    RRESPs42mi4   ,
    RDATAs42mi4  ,
    RLASTs42mi4  ,
    RVALIDs42mi4  ,
    RREADYmi42s4  ,
    //_______________________________________________________________
    //For Slave 5
    //Read address channel
    ARIDmi52s5    ,
    ARADDRmi52s5  ,
    ARLENmi52s5   ,
    ARSIZEmi52s5  ,
    ARBURSTmi52s5 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi52s5 ,
    ARREADYs52mi5 ,

    //Read data channel
    RIDs52mi5     ,
    RRESPs52mi5   ,
    RDATAs52mi5  ,
    RLASTs52mi5  ,
    RVALIDs52mi5  ,
    RREADYmi52s5  ,
    //_______________________________________________________________
    //For Slave 6
    //Read address channel
    ARIDmi62s6    ,
    ARADDRmi62s6  ,
    ARLENmi62s6   ,
    ARSIZEmi62s6  ,
    ARBURSTmi62s6 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi62s6 ,
    ARREADYs62mi6 ,

    //Read data channel
    RIDs62mi6     ,
    RRESPs62mi6   ,
    RDATAs62mi6  ,
    RLASTs62mi6  ,
    RVALIDs62mi6  ,
    RREADYmi62s6  ,
    //_______________________________________________________________
    //For Slave 7
    //Read address channel
    ARIDmi72s7    ,
    ARADDRmi72s7  ,
    ARLENmi72s7   ,
    ARSIZEmi72s7  ,
    ARBURSTmi72s7 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi72s7 ,
    ARREADYs72mi7 ,

    //Read data channel
    RIDs72mi7     ,
    RRESPs72mi7   ,
    RDATAs72mi7  ,
    RLASTs72mi7  ,
    RVALIDs72mi7  ,
    RREADYmi72s7  ,
    //_______________________________________________________________
    //For Slave 8
    //Read address channel
    ARIDmi82s8    ,
    ARADDRmi82s8  ,
    ARLENmi82s8   ,
    ARSIZEmi82s8  ,
    ARBURSTmi82s8 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    ARVALIDmi82s8 ,
    ARREADYs82mi8 ,

    //Read data channel
    RIDs82mi8     ,
    RRESPs82mi8   ,
    RDATAs82mi8  ,
    RLASTs82mi8  ,
    RVALIDs82mi8  ,
    RREADYmi82s8  ,

    //Lock Access
    //_______________________________________________________________

    Lock2rdmi0  ,
    Lock2rdmi1  ,
    Lock2rdmi2  ,
    Lock2rdmi3  ,
    Lock2rdmi4  ,
    Lock2rdmi5  ,
    Lock2rdmi6  ,
    Lock2rdmi7  ,
    Lock2rdmi8  ,

    Lock2wrmi0  ,
    Lock2wrmi1  ,
    Lock2wrmi2  ,
    Lock2wrmi3  ,
    Lock2wrmi4  ,
    Lock2wrmi5  ,
    Lock2wrmi6  ,
    Lock2wrmi7  ,
    Lock2wrmi8  ,

    UnLock2rdmi0 ,
    UnLock2rdmi1 ,
    UnLock2rdmi2 ,
    UnLock2rdmi3 ,
    UnLock2rdmi4 ,
    UnLock2rdmi5 ,
    UnLock2rdmi6 ,
    UnLock2rdmi7 ,
    UnLock2rdmi8 ,

    UnLock2wrmi0 ,
    UnLock2wrmi1 ,
    UnLock2wrmi2 ,
    UnLock2wrmi3 ,
    UnLock2wrmi4 ,
    UnLock2wrmi5 ,
    UnLock2wrmi6 ,
    UnLock2wrmi7 ,
    UnLock2wrmi8 ,

    AWVALIDmi02s0,
    AWVALIDmi12s1,
    AWVALIDmi22s2,
    AWVALIDmi32s3,
    AWVALIDmi42s4,
    AWVALIDmi52s5,
    AWVALIDmi62s6,
    AWVALIDmi72s7,
    AWVALIDmi82s8,

    LockPort2rdmi0,
    LockPort2rdmi1,
    LockPort2rdmi2,
    LockPort2rdmi3,
    LockPort2rdmi4,
    LockPort2rdmi5,
    LockPort2rdmi6,
    LockPort2rdmi7,
    LockPort2rdmi8,

    ReadIntEmptyWrmi02Rdmi0,
    ReadIntEmptyWrmi12Rdmi1,
    ReadIntEmptyWrmi22Rdmi2,
    ReadIntEmptyWrmi32Rdmi3,
    ReadIntEmptyWrmi42Rdmi4,
    ReadIntEmptyWrmi52Rdmi5,
    ReadIntEmptyWrmi62Rdmi6,
    ReadIntEmptyWrmi72Rdmi7,
    ReadIntEmptyWrmi82Rdmi8,

    DataCntEmptyRdmi02Wrmi0,
    DataCntEmptyRdmi12Wrmi1,
    DataCntEmptyRdmi22Wrmi2,
    DataCntEmptyRdmi32Wrmi3,
    DataCntEmptyRdmi42Wrmi4,
    DataCntEmptyRdmi52Wrmi5,
    DataCntEmptyRdmi62Wrmi6,
    DataCntEmptyRdmi72Wrmi7,
    DataCntEmptyRdmi82Wrmi8,

    CtlDataRead2Lock0      ,
    CtlDataRead2Lock1      ,
    CtlDataRead2Lock2      ,
    CtlDataRead2Lock3      ,
    CtlDataRead2Lock4      ,
    CtlDataRead2Lock5      ,
    CtlDataRead2Lock6      ,
    CtlDataRead2Lock7      ,
    CtlDataRead2Lock8      ,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 4;
parameter SLAVE_NUM= 9;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter MASTERID0_WID = 1 ;
parameter MASTERID1_WID = 1 ;
parameter MASTERID2_WID = 1 ;
parameter MASTERID3_WID = 1 ;
parameter MASTERID4_WID = 1 ;
parameter MAXMASTERID_WID = 1 ;
parameter BLANKMASTERID0_WID = 0 ;
parameter BLANKMASTERID1_WID = 0 ;
parameter BLANKMASTERID2_WID = 0 ;
parameter BLANKMASTERID3_WID = 0 ;
parameter BLANKMASTERID4_WID = 0 ;
parameter SLAVEID0_WID = 2 ;
parameter SLAVEID1_WID = 2 ;
parameter SLAVEID2_WID = 2 ;
parameter SLAVEID3_WID = 4 ;
parameter SLAVEID4_WID = 2 ;
parameter SLAVEID5_WID = 2 ;
parameter SLAVEID6_WID = 4 ;
parameter SLAVEID7_WID = 4 ;
parameter SLAVEID8_WID = 4 ;
parameter SELMASTER0_WID = 1 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 3 ;
parameter SELMASTER4_WID = 1 ;
parameter SELMASTER5_WID = 1 ;
parameter SELMASTER6_WID = 3 ;
parameter SELMASTER7_WID = 3 ;
parameter SELMASTER8_WID = 3 ;
parameter SLAVE_MASTERID0_WID = 1 ;
parameter SLAVE_MASTERID1_WID = 1 ;
parameter SLAVE_MASTERID2_WID = 1 ;
parameter SLAVE_MASTERID3_WID = 1 ;
parameter SLAVE_MASTERID4_WID = 1 ;
parameter SLAVE_MASTERID5_WID = 1 ;
parameter SLAVE_MASTERID6_WID = 1 ;
parameter SLAVE_MASTERID7_WID = 1 ;
parameter SLAVE_MASTERID8_WID = 1 ;
    
    input   SelMAP1;
    input   ACLK;
    input   ARESETn;  

    //Lock Access
    //_______________________________________________________________


    //Slave 0
    //_____________________________________

    input    Lock2rdmi0 ;
    input    UnLock2rdmi0 ;
    input    AWVALIDmi02s0;
    input    Lock2wrmi0;
    output   UnLock2wrmi0 ;
    input    ReadIntEmptyWrmi02Rdmi0;
    output   DataCntEmptyRdmi02Wrmi0;
    output   [SELMASTER0_WID-1:0]CtlDataRead2Lock0;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER0_WID-1:0]LockPort2rdmi0;
    input    [SELMASTER0_WID:0]LockPort2rdmi0;

    //Slave 1
    //_____________________________________

    input    Lock2rdmi1 ;
    input    UnLock2rdmi1 ;
    input    AWVALIDmi12s1;
    input    Lock2wrmi1;
    output   UnLock2wrmi1 ;
    input    ReadIntEmptyWrmi12Rdmi1;
    output   DataCntEmptyRdmi12Wrmi1;
    output   [SELMASTER1_WID-1:0]CtlDataRead2Lock1;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER1_WID-1:0]LockPort2rdmi1;
    input    [SELMASTER1_WID:0]LockPort2rdmi1;

    //Slave 2
    //_____________________________________

    input    Lock2rdmi2 ;
    input    UnLock2rdmi2 ;
    input    AWVALIDmi22s2;
    input    Lock2wrmi2;
    output   UnLock2wrmi2 ;
    input    ReadIntEmptyWrmi22Rdmi2;
    output   DataCntEmptyRdmi22Wrmi2;
    output   [SELMASTER2_WID-1:0]CtlDataRead2Lock2;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER2_WID-1:0]LockPort2rdmi2;
    input    [SELMASTER2_WID:0]LockPort2rdmi2;

    //Slave 3
    //_____________________________________

    input    Lock2rdmi3 ;
    input    UnLock2rdmi3 ;
    input    AWVALIDmi32s3;
    input    Lock2wrmi3;
    output   UnLock2wrmi3 ;
    input    ReadIntEmptyWrmi32Rdmi3;
    output   DataCntEmptyRdmi32Wrmi3;
    output   [SELMASTER3_WID-1:0]CtlDataRead2Lock3;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER3_WID-1:0]LockPort2rdmi3;
    input    [SELMASTER3_WID:0]LockPort2rdmi3;

    //Slave 4
    //_____________________________________

    input    Lock2rdmi4 ;
    input    UnLock2rdmi4 ;
    input    AWVALIDmi42s4;
    input    Lock2wrmi4;
    output   UnLock2wrmi4 ;
    input    ReadIntEmptyWrmi42Rdmi4;
    output   DataCntEmptyRdmi42Wrmi4;
    output   [SELMASTER4_WID-1:0]CtlDataRead2Lock4;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER4_WID-1:0]LockPort2rdmi4;
    input    [SELMASTER4_WID:0]LockPort2rdmi4;

    //Slave 5
    //_____________________________________

    input    Lock2rdmi5 ;
    input    UnLock2rdmi5 ;
    input    AWVALIDmi52s5;
    input    Lock2wrmi5;
    output   UnLock2wrmi5 ;
    input    ReadIntEmptyWrmi52Rdmi5;
    output   DataCntEmptyRdmi52Wrmi5;
    output   [SELMASTER5_WID-1:0]CtlDataRead2Lock5;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER5_WID-1:0]LockPort2rdmi5;
    input    [SELMASTER5_WID:0]LockPort2rdmi5;

    //Slave 6
    //_____________________________________

    input    Lock2rdmi6 ;
    input    UnLock2rdmi6 ;
    input    AWVALIDmi62s6;
    input    Lock2wrmi6;
    output   UnLock2wrmi6 ;
    input    ReadIntEmptyWrmi62Rdmi6;
    output   DataCntEmptyRdmi62Wrmi6;
    output   [SELMASTER6_WID-1:0]CtlDataRead2Lock6;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER6_WID-1:0]LockPort2rdmi6;
    input    [SELMASTER6_WID:0]LockPort2rdmi6;

    //Slave 7
    //_____________________________________

    input    Lock2rdmi7 ;
    input    UnLock2rdmi7 ;
    input    AWVALIDmi72s7;
    input    Lock2wrmi7;
    output   UnLock2wrmi7 ;
    input    ReadIntEmptyWrmi72Rdmi7;
    output   DataCntEmptyRdmi72Wrmi7;
    output   [SELMASTER7_WID-1:0]CtlDataRead2Lock7;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER7_WID-1:0]LockPort2rdmi7;
    input    [SELMASTER7_WID:0]LockPort2rdmi7;

    //Slave 8
    //_____________________________________

    input    Lock2rdmi8 ;
    input    UnLock2rdmi8 ;
    input    AWVALIDmi82s8;
    input    Lock2wrmi8;
    output   UnLock2wrmi8 ;
    input    ReadIntEmptyWrmi82Rdmi8;
    output   DataCntEmptyRdmi82Wrmi8;
    output   [SELMASTER8_WID-1:0]CtlDataRead2Lock8;     
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER8_WID-1:0]LockPort2rdmi8;
    input    [SELMASTER8_WID:0]LockPort2rdmi8;
    //_______________________________________________________________


    //SlaveInterface
    //_______________________________________________________________

    //For Master 0
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDRm02si0;
    input   [ARLEN_WID-1:0]    ARLENm02si0;
    input   [ARSIZE_WID-1:0]   ARSIZEm02si0;  
    input   [ARBURST_WID-1:0]  ARBURSTm02si0; 
    input   [ARLOCK_WID-1:0]   ARLOCKm02si0;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALIDm02si0; 
    output  ARREADYsi02m0; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESPsi02m0;   
    output   [BUS_WID-1:0]     RDATAsi02m0;
    output   RLASTsi02m0;
    output   RVALIDsi02m0;  
    input    RREADYm02si0;  

 
    //For Master 1
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDRm12si1;
    input   [ARLEN_WID-1:0]    ARLENm12si1;
    input   [ARSIZE_WID-1:0]   ARSIZEm12si1;  
    input   [ARBURST_WID-1:0]  ARBURSTm12si1; 
    input   [ARLOCK_WID-1:0]   ARLOCKm12si1;  
//Disable_cache_port
//Disable_protect_port

    input   ARVALIDm12si1; 
    output  ARREADYsi12m1; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESPsi12m1;   
    output   [BUS_WID-1:0]     RDATAsi12m1;
    output   RLASTsi12m1;
    output   RVALIDsi12m1;  
    input    RREADYm12si1;  

 
    //For Master 2
    //Read address channel
    input   [MASTERID2_WID-1:0]ARIDm22si2;    
    input   [ADDR_WID-1:0]     ARADDRm22si2;
    input   [ARLEN_WID-1:0]    ARLENm22si2;
    input   [ARSIZE_WID-1:0]   ARSIZEm22si2;  
    input   [ARBURST_WID-1:0]  ARBURSTm22si2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALIDm22si2; 
    output  ARREADYsi22m2; 

    //Read data channel
    output   [MASTERID2_WID-1:0]RIDsi22m2;     
    output   [BRESP_WID-1:0]   RRESPsi22m2;   
    output   [BUS_WID-1:0]     RDATAsi22m2;
    output   RLASTsi22m2;
    output   RVALIDsi22m2;  
    input    RREADYm22si2;  

 
    //For Master 3
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDRm32si3;
    input   [ARLEN_WID-1:0]    ARLENm32si3;
    input   [ARSIZE_WID-1:0]   ARSIZEm32si3;  
    input   [ARBURST_WID-1:0]  ARBURSTm32si3; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALIDm32si3; 
    output  ARREADYsi32m3; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESPsi32m3;   
    output   [BUS_WID-1:0]     RDATAsi32m3;
    output   RLASTsi32m3;
    output   RVALIDsi32m3;  
    input    RREADYm32si3;  

 
    //For Master 4
    //Read address channel
//Disable_id_port
    input   [ADDR_WID-1:0]     ARADDRm42si4;
    input   [ARLEN_WID-1:0]    ARLENm42si4;
    input   [ARSIZE_WID-1:0]   ARSIZEm42si4;  
    input   [ARBURST_WID-1:0]  ARBURSTm42si4; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    input   ARVALIDm42si4; 
    output  ARREADYsi42m4; 

    //Read data channel
//Disable_id_port
    output   [BRESP_WID-1:0]   RRESPsi42m4;   
    output   [BUS_WID-1:0]     RDATAsi42m4;
    output   RLASTsi42m4;
    output   RVALIDsi42m4;  
    input    RREADYm42si4;  

 
    //_______________________________________________________________


    //MasterInterface
    //_______________________________________________________________

    // For slave 0
    //__________________________________________________

    // Read address channel
    output   [SLAVEID0_WID-1:0]ARIDmi02s0;    
    output   [ADDR_WID-1:0]     ARADDRmi02s0;
    output   [ARLEN_WID-1:0]    ARLENmi02s0;
    output   [ARSIZE_WID-1:0]   ARSIZEmi02s0;  
    output   [ARBURST_WID-1:0]  ARBURSTmi02s0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi02s0; 
    input    ARREADYs02mi0; 
    

    //Read data channel
    input   [SLAVEID0_WID-1:0] RIDs02mi0;     
    input   [RRESP_WID-1:0]     RRESPs02mi0;   
    input   [BUS_WID-1:0]       RDATAs02mi0;  
    input   RLASTs02mi0;  
    input   RVALIDs02mi0;  
    output  RREADYmi02s0;  

    // For slave 1
    //__________________________________________________

    // Read address channel
    output   [SLAVEID1_WID-1:0]ARIDmi12s1;    
    output   [ADDR_WID-1:0]     ARADDRmi12s1;
    output   [ARLEN_WID-1:0]    ARLENmi12s1;
    output   [ARSIZE_WID-1:0]   ARSIZEmi12s1;  
    output   [ARBURST_WID-1:0]  ARBURSTmi12s1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi12s1; 
    input    ARREADYs12mi1; 
    

    //Read data channel
    input   [SLAVEID1_WID-1:0] RIDs12mi1;     
    input   [RRESP_WID-1:0]     RRESPs12mi1;   
    input   [BUS_WID-1:0]       RDATAs12mi1;  
    input   RLASTs12mi1;  
    input   RVALIDs12mi1;  
    output  RREADYmi12s1;  

    // For slave 2
    //__________________________________________________

    // Read address channel
    output   [SLAVEID2_WID-1:0]ARIDmi22s2;    
    output   [ADDR_WID-1:0]     ARADDRmi22s2;
    output   [ARLEN_WID-1:0]    ARLENmi22s2;
    output   [ARSIZE_WID-1:0]   ARSIZEmi22s2;  
    output   [ARBURST_WID-1:0]  ARBURSTmi22s2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi22s2; 
    input    ARREADYs22mi2; 
    

    //Read data channel
    input   [SLAVEID2_WID-1:0] RIDs22mi2;     
    input   [RRESP_WID-1:0]     RRESPs22mi2;   
    input   [BUS_WID-1:0]       RDATAs22mi2;  
    input   RLASTs22mi2;  
    input   RVALIDs22mi2;  
    output  RREADYmi22s2;  

    // For slave 3
    //__________________________________________________

    // Read address channel
    output   [SLAVEID3_WID-1:0]ARIDmi32s3;    
    output   [ADDR_WID-1:0]     ARADDRmi32s3;
    output   [ARLEN_WID-1:0]    ARLENmi32s3;
    output   [ARSIZE_WID-1:0]   ARSIZEmi32s3;  
    output   [ARBURST_WID-1:0]  ARBURSTmi32s3; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi32s3; 
    input    ARREADYs32mi3; 
    

    //Read data channel
    input   [SLAVEID3_WID-1:0] RIDs32mi3;     
    input   [RRESP_WID-1:0]     RRESPs32mi3;   
    input   [BUS_WID-1:0]       RDATAs32mi3;  
    input   RLASTs32mi3;  
    input   RVALIDs32mi3;  
    output  RREADYmi32s3;  

    // For slave 4
    //__________________________________________________

    // Read address channel
    output   [SLAVEID4_WID-1:0]ARIDmi42s4;    
    output   [ADDR_WID-1:0]     ARADDRmi42s4;
    output   [ARLEN_WID-1:0]    ARLENmi42s4;
    output   [ARSIZE_WID-1:0]   ARSIZEmi42s4;  
    output   [ARBURST_WID-1:0]  ARBURSTmi42s4; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi42s4; 
    input    ARREADYs42mi4; 
    

    //Read data channel
    input   [SLAVEID4_WID-1:0] RIDs42mi4;     
    input   [RRESP_WID-1:0]     RRESPs42mi4;   
    input   [BUS_WID-1:0]       RDATAs42mi4;  
    input   RLASTs42mi4;  
    input   RVALIDs42mi4;  
    output  RREADYmi42s4;  

    // For slave 5
    //__________________________________________________

    // Read address channel
    output   [SLAVEID5_WID-1:0]ARIDmi52s5;    
    output   [ADDR_WID-1:0]     ARADDRmi52s5;
    output   [ARLEN_WID-1:0]    ARLENmi52s5;
    output   [ARSIZE_WID-1:0]   ARSIZEmi52s5;  
    output   [ARBURST_WID-1:0]  ARBURSTmi52s5; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi52s5; 
    input    ARREADYs52mi5; 
    

    //Read data channel
    input   [SLAVEID5_WID-1:0] RIDs52mi5;     
    input   [RRESP_WID-1:0]     RRESPs52mi5;   
    input   [BUS_WID-1:0]       RDATAs52mi5;  
    input   RLASTs52mi5;  
    input   RVALIDs52mi5;  
    output  RREADYmi52s5;  

    // For slave 6
    //__________________________________________________

    // Read address channel
    output   [SLAVEID6_WID-1:0]ARIDmi62s6;    
    output   [ADDR_WID-1:0]     ARADDRmi62s6;
    output   [ARLEN_WID-1:0]    ARLENmi62s6;
    output   [ARSIZE_WID-1:0]   ARSIZEmi62s6;  
    output   [ARBURST_WID-1:0]  ARBURSTmi62s6; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi62s6; 
    input    ARREADYs62mi6; 
    

    //Read data channel
    input   [SLAVEID6_WID-1:0] RIDs62mi6;     
    input   [RRESP_WID-1:0]     RRESPs62mi6;   
    input   [BUS_WID-1:0]       RDATAs62mi6;  
    input   RLASTs62mi6;  
    input   RVALIDs62mi6;  
    output  RREADYmi62s6;  

    // For slave 7
    //__________________________________________________

    // Read address channel
    output   [SLAVEID7_WID-1:0]ARIDmi72s7;    
    output   [ADDR_WID-1:0]     ARADDRmi72s7;
    output   [ARLEN_WID-1:0]    ARLENmi72s7;
    output   [ARSIZE_WID-1:0]   ARSIZEmi72s7;  
    output   [ARBURST_WID-1:0]  ARBURSTmi72s7; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi72s7; 
    input    ARREADYs72mi7; 
    

    //Read data channel
    input   [SLAVEID7_WID-1:0] RIDs72mi7;     
    input   [RRESP_WID-1:0]     RRESPs72mi7;   
    input   [BUS_WID-1:0]       RDATAs72mi7;  
    input   RLASTs72mi7;  
    input   RVALIDs72mi7;  
    output  RREADYmi72s7;  

    // For slave 8
    //__________________________________________________

    // Read address channel
    output   [SLAVEID8_WID-1:0]ARIDmi82s8;    
    output   [ADDR_WID-1:0]     ARADDRmi82s8;
    output   [ARLEN_WID-1:0]    ARLENmi82s8;
    output   [ARSIZE_WID-1:0]   ARSIZEmi82s8;  
    output   [ARBURST_WID-1:0]  ARBURSTmi82s8; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   ARVALIDmi82s8; 
    input    ARREADYs82mi8; 
    

    //Read data channel
    input   [SLAVEID8_WID-1:0] RIDs82mi8;     
    input   [RRESP_WID-1:0]     RRESPs82mi8;   
    input   [BUS_WID-1:0]       RDATAs82mi8;  
    input   RLASTs82mi8;  
    input   RVALIDs82mi8;  
    output  RREADYmi82s8;  

    
    //_______________________________________________________________

//Master module wire were generated
//Master module 0 - 0   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi0;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi0 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi0};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi0;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi0;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi0;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi0; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi0;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi0; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi0;

//Master module wire were generated
//Master module 0 - 1   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi1;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi1 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi1};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi1;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi1;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi1;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi1; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi1;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi1; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi1;

//Master module wire were generated
//Master module 0 - 2   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi2;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi2 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi2};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi2;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi2;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi2;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi2; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi2;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi2; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi2;

//Master module wire were generated
//Master module 0 - 3   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi3;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi3 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi3};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi3;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi3;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi3;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi3; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi3;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi3; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi3;

//Master module wire were generated
//Master module 0 - 4   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi4;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi4 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi4};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi4;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi4;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi4;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi4; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi4;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi4; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi4;

//Master module wire were generated
//Master module 0 - 5   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi5;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi5 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi5};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi5;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi5;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi5;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi5; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi5;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi5; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi5;

//Master module wire were generated
//Master module 0 - 6   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi6;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi6 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi6};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi6;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi6;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi6;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi6; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi6;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi6; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi6;

//Master module wire were generated
//Master module 0 - 7   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi7;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi7 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi7};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi7;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi7;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi7;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi7; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi7;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi7; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi7;

//Master module wire were generated
//Master module 0 - 8   
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]ARIDsi02mi8;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi02mi8 =    
            {{BLANKMASTERID0_WID{1'b0}},ARIDsi02mi8};    
    wire  [ADDR_WID-1:0]    ARADDRsi02mi8;  
    wire  [ARLEN_WID-1:0]   ARLENsi02mi8;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi02mi8;  
    wire  [ARBURST_WID-1:0] ARBURSTsi02mi8; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi02mi8;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi02mi8; 
    wire  [ARPROT_WID-1:0]  ARPROTsi02mi8;

//Master module wire were generated
//Master module 1 - 3   
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]ARIDsi12mi3;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi12mi3 =    
            {{BLANKMASTERID1_WID{1'b0}},ARIDsi12mi3};    
    wire  [ADDR_WID-1:0]    ARADDRsi12mi3;  
    wire  [ARLEN_WID-1:0]   ARLENsi12mi3;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi12mi3;  
    wire  [ARBURST_WID-1:0] ARBURSTsi12mi3; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi12mi3;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi12mi3; 
    wire  [ARPROT_WID-1:0]  ARPROTsi12mi3;

//Master module wire were generated
//Master module 1 - 6   
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]ARIDsi12mi6;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi12mi6 =    
            {{BLANKMASTERID1_WID{1'b0}},ARIDsi12mi6};    
    wire  [ADDR_WID-1:0]    ARADDRsi12mi6;  
    wire  [ARLEN_WID-1:0]   ARLENsi12mi6;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi12mi6;  
    wire  [ARBURST_WID-1:0] ARBURSTsi12mi6; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi12mi6;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi12mi6; 
    wire  [ARPROT_WID-1:0]  ARPROTsi12mi6;

//Master module wire were generated
//Master module 1 - 7   
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]ARIDsi12mi7;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi12mi7 =    
            {{BLANKMASTERID1_WID{1'b0}},ARIDsi12mi7};    
    wire  [ADDR_WID-1:0]    ARADDRsi12mi7;  
    wire  [ARLEN_WID-1:0]   ARLENsi12mi7;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi12mi7;  
    wire  [ARBURST_WID-1:0] ARBURSTsi12mi7; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi12mi7;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi12mi7; 
    wire  [ARPROT_WID-1:0]  ARPROTsi12mi7;

//Master module wire were generated
//Master module 1 - 8   
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]ARIDsi12mi8;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi12mi8 =    
            {{BLANKMASTERID1_WID{1'b0}},ARIDsi12mi8};    
    wire  [ADDR_WID-1:0]    ARADDRsi12mi8;  
    wire  [ARLEN_WID-1:0]   ARLENsi12mi8;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi12mi8;  
    wire  [ARBURST_WID-1:0] ARBURSTsi12mi8; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi12mi8;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi12mi8; 
    wire  [ARPROT_WID-1:0]  ARPROTsi12mi8;

//Master module wire were generated
//Master module 2 - 0   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi0;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi0 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi0};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi0;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi0;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi0;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi0; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi0;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi0; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi0;

//Master module wire were generated
//Master module 2 - 1   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi1;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi1 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi1};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi1;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi1;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi1;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi1; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi1;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi1; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi1;

//Master module wire were generated
//Master module 2 - 2   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi2;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi2 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi2};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi2;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi2;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi2;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi2; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi2;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi2; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi2;

//Master module wire were generated
//Master module 2 - 3   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi3;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi3 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi3};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi3;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi3;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi3;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi3; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi3;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi3; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi3;

//Master module wire were generated
//Master module 2 - 4   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi4;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi4 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi4};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi4;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi4;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi4;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi4; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi4;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi4; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi4;

//Master module wire were generated
//Master module 2 - 5   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi5;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi5 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi5};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi5;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi5;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi5;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi5; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi5;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi5; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi5;

//Master module wire were generated
//Master module 2 - 6   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi6;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi6 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi6};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi6;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi6;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi6;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi6; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi6;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi6; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi6;

//Master module wire were generated
//Master module 2 - 7   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi7;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi7 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi7};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi7;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi7;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi7;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi7; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi7;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi7; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi7;

//Master module wire were generated
//Master module 2 - 8   
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]ARIDsi22mi8;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi22mi8 =    
            {{BLANKMASTERID2_WID{1'b0}},ARIDsi22mi8};    
    wire  [ADDR_WID-1:0]    ARADDRsi22mi8;  
    wire  [ARLEN_WID-1:0]   ARLENsi22mi8;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi22mi8;  
    wire  [ARBURST_WID-1:0] ARBURSTsi22mi8; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi22mi8;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi22mi8; 
    wire  [ARPROT_WID-1:0]  ARPROTsi22mi8;

//Master module wire were generated
//Master module 3 - 3   
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]ARIDsi32mi3;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi32mi3 =    
            {{BLANKMASTERID3_WID{1'b0}},ARIDsi32mi3};    
    wire  [ADDR_WID-1:0]    ARADDRsi32mi3;  
    wire  [ARLEN_WID-1:0]   ARLENsi32mi3;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi32mi3;  
    wire  [ARBURST_WID-1:0] ARBURSTsi32mi3; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi32mi3;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi32mi3; 
    wire  [ARPROT_WID-1:0]  ARPROTsi32mi3;

//Master module wire were generated
//Master module 3 - 6   
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]ARIDsi32mi6;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi32mi6 =    
            {{BLANKMASTERID3_WID{1'b0}},ARIDsi32mi6};    
    wire  [ADDR_WID-1:0]    ARADDRsi32mi6;  
    wire  [ARLEN_WID-1:0]   ARLENsi32mi6;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi32mi6;  
    wire  [ARBURST_WID-1:0] ARBURSTsi32mi6; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi32mi6;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi32mi6; 
    wire  [ARPROT_WID-1:0]  ARPROTsi32mi6;

//Master module wire were generated
//Master module 3 - 7   
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]ARIDsi32mi7;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi32mi7 =    
            {{BLANKMASTERID3_WID{1'b0}},ARIDsi32mi7};    
    wire  [ADDR_WID-1:0]    ARADDRsi32mi7;  
    wire  [ARLEN_WID-1:0]   ARLENsi32mi7;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi32mi7;  
    wire  [ARBURST_WID-1:0] ARBURSTsi32mi7; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi32mi7;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi32mi7; 
    wire  [ARPROT_WID-1:0]  ARPROTsi32mi7;

//Master module wire were generated
//Master module 3 - 8   
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]ARIDsi32mi8;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi32mi8 =    
            {{BLANKMASTERID3_WID{1'b0}},ARIDsi32mi8};    
    wire  [ADDR_WID-1:0]    ARADDRsi32mi8;  
    wire  [ARLEN_WID-1:0]   ARLENsi32mi8;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi32mi8;  
    wire  [ARBURST_WID-1:0] ARBURSTsi32mi8; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi32mi8;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi32mi8; 
    wire  [ARPROT_WID-1:0]  ARPROTsi32mi8;

//Master module wire were generated
//Master module 4 - 3   
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]ARIDsi42mi3;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi42mi3 =    
            {{BLANKMASTERID4_WID{1'b0}},ARIDsi42mi3};    
    wire  [ADDR_WID-1:0]    ARADDRsi42mi3;  
    wire  [ARLEN_WID-1:0]   ARLENsi42mi3;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi42mi3;  
    wire  [ARBURST_WID-1:0] ARBURSTsi42mi3; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi42mi3;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi42mi3; 
    wire  [ARPROT_WID-1:0]  ARPROTsi42mi3;

//Master module wire were generated
//Master module 4 - 6   
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]ARIDsi42mi6;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi42mi6 =    
            {{BLANKMASTERID4_WID{1'b0}},ARIDsi42mi6};    
    wire  [ADDR_WID-1:0]    ARADDRsi42mi6;  
    wire  [ARLEN_WID-1:0]   ARLENsi42mi6;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi42mi6;  
    wire  [ARBURST_WID-1:0] ARBURSTsi42mi6; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi42mi6;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi42mi6; 
    wire  [ARPROT_WID-1:0]  ARPROTsi42mi6;

//Master module wire were generated
//Master module 4 - 7   
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]ARIDsi42mi7;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi42mi7 =    
            {{BLANKMASTERID4_WID{1'b0}},ARIDsi42mi7};    
    wire  [ADDR_WID-1:0]    ARADDRsi42mi7;  
    wire  [ARLEN_WID-1:0]   ARLENsi42mi7;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi42mi7;  
    wire  [ARBURST_WID-1:0] ARBURSTsi42mi7; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi42mi7;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi42mi7; 
    wire  [ARPROT_WID-1:0]  ARPROTsi42mi7;

//Master module wire were generated
//Master module 4 - 8   
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]ARIDsi42mi8;    
    wire  [MAXMASTERID_WID-1:0]wARIDsi42mi8 =    
            {{BLANKMASTERID4_WID{1'b0}},ARIDsi42mi8};    
    wire  [ADDR_WID-1:0]    ARADDRsi42mi8;  
    wire  [ARLEN_WID-1:0]   ARLENsi42mi8;   
    wire  [ARSIZE_WID-1:0]  ARSIZEsi42mi8;  
    wire  [ARBURST_WID-1:0] ARBURSTsi42mi8; 
    wire  [ARLOCK_WID-1:0]  ARLOCKsi42mi8;  
    wire  [ARCACHE_WID-1:0] ARCACHEsi42mi8; 
    wire  [ARPROT_WID-1:0]  ARPROTsi42mi8;

    
    wire  [SLAVE_NUM-1:0]   ARVALIDsi02mi;
    wire  [SLAVE_NUM-1:0]   ARREADYmi2si0;
    wire  [SLAVE_NUM-1:0]   RVALIDmi2si0;
    wire  [SLAVE_NUM-1:0]   RLASTmi2si0;
    wire  [SLAVE_NUM-1:0]   RREADYsi02mi;	
    wire  [SLAVE_NUM-1:0]   ARVALIDsi12mi;
    wire  [SLAVE_NUM-1:0]   ARREADYmi2si1;
    wire  [SLAVE_NUM-1:0]   RVALIDmi2si1;
    wire  [SLAVE_NUM-1:0]   RLASTmi2si1;
    wire  [SLAVE_NUM-1:0]   RREADYsi12mi;	
    wire  [SLAVE_NUM-1:0]   ARVALIDsi22mi;
    wire  [SLAVE_NUM-1:0]   ARREADYmi2si2;
    wire  [SLAVE_NUM-1:0]   RVALIDmi2si2;
    wire  [SLAVE_NUM-1:0]   RLASTmi2si2;
    wire  [SLAVE_NUM-1:0]   RREADYsi22mi;	
    wire  [SLAVE_NUM-1:0]   ARVALIDsi32mi;
    wire  [SLAVE_NUM-1:0]   ARREADYmi2si3;
    wire  [SLAVE_NUM-1:0]   RVALIDmi2si3;
    wire  [SLAVE_NUM-1:0]   RLASTmi2si3;
    wire  [SLAVE_NUM-1:0]   RREADYsi32mi;	
    wire  [SLAVE_NUM-1:0]   ARVALIDsi42mi;
    wire  [SLAVE_NUM-1:0]   ARREADYmi2si4;
    wire  [SLAVE_NUM-1:0]   RVALIDmi2si4;
    wire  [SLAVE_NUM-1:0]   RLASTmi2si4;
    wire  [SLAVE_NUM-1:0]   RREADYsi42mi;	
//_____________________________________________________________________

    //Slave Number 0(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID0_WID-1:0] RIDmi02si0;     
    wire   [RRESP_WID-1:0]            RRESPmi02si0;   
    wire   [BUS_WID-1:0]              RDATAmi02si0;
    //Slave Number 0(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID0_WID-1:0] RIDmi02si2;     
    wire   [RRESP_WID-1:0]            RRESPmi02si2;   
    wire   [BUS_WID-1:0]              RDATAmi02si2;
    //Slave Number 1(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID1_WID-1:0] RIDmi12si0;     
    wire   [RRESP_WID-1:0]            RRESPmi12si0;   
    wire   [BUS_WID-1:0]              RDATAmi12si0;
    //Slave Number 1(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID1_WID-1:0] RIDmi12si2;     
    wire   [RRESP_WID-1:0]            RRESPmi12si2;   
    wire   [BUS_WID-1:0]              RDATAmi12si2;
    //Slave Number 2(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID2_WID-1:0] RIDmi22si0;     
    wire   [RRESP_WID-1:0]            RRESPmi22si0;   
    wire   [BUS_WID-1:0]              RDATAmi22si0;
    //Slave Number 2(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID2_WID-1:0] RIDmi22si2;     
    wire   [RRESP_WID-1:0]            RRESPmi22si2;   
    wire   [BUS_WID-1:0]              RDATAmi22si2;
    //Slave Number 3(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID3_WID-1:0] RIDmi32si0;     
    wire   [RRESP_WID-1:0]            RRESPmi32si0;   
    wire   [BUS_WID-1:0]              RDATAmi32si0;
    //Slave Number 3(master interface) to 1 (slave interface)
    wire   [SLAVE_MASTERID3_WID-1:0] RIDmi32si1;     
    wire   [RRESP_WID-1:0]            RRESPmi32si1;   
    wire   [BUS_WID-1:0]              RDATAmi32si1;
    //Slave Number 3(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID3_WID-1:0] RIDmi32si2;     
    wire   [RRESP_WID-1:0]            RRESPmi32si2;   
    wire   [BUS_WID-1:0]              RDATAmi32si2;
    //Slave Number 3(master interface) to 3 (slave interface)
    wire   [SLAVE_MASTERID3_WID-1:0] RIDmi32si3;     
    wire   [RRESP_WID-1:0]            RRESPmi32si3;   
    wire   [BUS_WID-1:0]              RDATAmi32si3;
    //Slave Number 3(master interface) to 4 (slave interface)
    wire   [SLAVE_MASTERID3_WID-1:0] RIDmi32si4;     
    wire   [RRESP_WID-1:0]            RRESPmi32si4;   
    wire   [BUS_WID-1:0]              RDATAmi32si4;
    //Slave Number 4(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID4_WID-1:0] RIDmi42si0;     
    wire   [RRESP_WID-1:0]            RRESPmi42si0;   
    wire   [BUS_WID-1:0]              RDATAmi42si0;
    //Slave Number 4(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID4_WID-1:0] RIDmi42si2;     
    wire   [RRESP_WID-1:0]            RRESPmi42si2;   
    wire   [BUS_WID-1:0]              RDATAmi42si2;
    //Slave Number 5(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID5_WID-1:0] RIDmi52si0;     
    wire   [RRESP_WID-1:0]            RRESPmi52si0;   
    wire   [BUS_WID-1:0]              RDATAmi52si0;
    //Slave Number 5(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID5_WID-1:0] RIDmi52si2;     
    wire   [RRESP_WID-1:0]            RRESPmi52si2;   
    wire   [BUS_WID-1:0]              RDATAmi52si2;
    //Slave Number 6(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID6_WID-1:0] RIDmi62si0;     
    wire   [RRESP_WID-1:0]            RRESPmi62si0;   
    wire   [BUS_WID-1:0]              RDATAmi62si0;
    //Slave Number 6(master interface) to 1 (slave interface)
    wire   [SLAVE_MASTERID6_WID-1:0] RIDmi62si1;     
    wire   [RRESP_WID-1:0]            RRESPmi62si1;   
    wire   [BUS_WID-1:0]              RDATAmi62si1;
    //Slave Number 6(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID6_WID-1:0] RIDmi62si2;     
    wire   [RRESP_WID-1:0]            RRESPmi62si2;   
    wire   [BUS_WID-1:0]              RDATAmi62si2;
    //Slave Number 6(master interface) to 3 (slave interface)
    wire   [SLAVE_MASTERID6_WID-1:0] RIDmi62si3;     
    wire   [RRESP_WID-1:0]            RRESPmi62si3;   
    wire   [BUS_WID-1:0]              RDATAmi62si3;
    //Slave Number 6(master interface) to 4 (slave interface)
    wire   [SLAVE_MASTERID6_WID-1:0] RIDmi62si4;     
    wire   [RRESP_WID-1:0]            RRESPmi62si4;   
    wire   [BUS_WID-1:0]              RDATAmi62si4;
    //Slave Number 7(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID7_WID-1:0] RIDmi72si0;     
    wire   [RRESP_WID-1:0]            RRESPmi72si0;   
    wire   [BUS_WID-1:0]              RDATAmi72si0;
    //Slave Number 7(master interface) to 1 (slave interface)
    wire   [SLAVE_MASTERID7_WID-1:0] RIDmi72si1;     
    wire   [RRESP_WID-1:0]            RRESPmi72si1;   
    wire   [BUS_WID-1:0]              RDATAmi72si1;
    //Slave Number 7(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID7_WID-1:0] RIDmi72si2;     
    wire   [RRESP_WID-1:0]            RRESPmi72si2;   
    wire   [BUS_WID-1:0]              RDATAmi72si2;
    //Slave Number 7(master interface) to 3 (slave interface)
    wire   [SLAVE_MASTERID7_WID-1:0] RIDmi72si3;     
    wire   [RRESP_WID-1:0]            RRESPmi72si3;   
    wire   [BUS_WID-1:0]              RDATAmi72si3;
    //Slave Number 7(master interface) to 4 (slave interface)
    wire   [SLAVE_MASTERID7_WID-1:0] RIDmi72si4;     
    wire   [RRESP_WID-1:0]            RRESPmi72si4;   
    wire   [BUS_WID-1:0]              RDATAmi72si4;
    //Slave Number 8(master interface) to 0 (slave interface)
    wire   [SLAVE_MASTERID8_WID-1:0] RIDmi82si0;     
    wire   [RRESP_WID-1:0]            RRESPmi82si0;   
    wire   [BUS_WID-1:0]              RDATAmi82si0;
    //Slave Number 8(master interface) to 1 (slave interface)
    wire   [SLAVE_MASTERID8_WID-1:0] RIDmi82si1;     
    wire   [RRESP_WID-1:0]            RRESPmi82si1;   
    wire   [BUS_WID-1:0]              RDATAmi82si1;
    //Slave Number 8(master interface) to 2 (slave interface)
    wire   [SLAVE_MASTERID8_WID-1:0] RIDmi82si2;     
    wire   [RRESP_WID-1:0]            RRESPmi82si2;   
    wire   [BUS_WID-1:0]              RDATAmi82si2;
    //Slave Number 8(master interface) to 3 (slave interface)
    wire   [SLAVE_MASTERID8_WID-1:0] RIDmi82si3;     
    wire   [RRESP_WID-1:0]            RRESPmi82si3;   
    wire   [BUS_WID-1:0]              RDATAmi82si3;
    //Slave Number 8(master interface) to 4 (slave interface)
    wire   [SLAVE_MASTERID8_WID-1:0] RIDmi82si4;     
    wire   [RRESP_WID-1:0]            RRESPmi82si4;   
    wire   [BUS_WID-1:0]              RDATAmi82si4;

//Slave module wire were generated
//Slave module 0    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi0;
    wire    [MASTER_NUM-1:0] ARREADYmi02si;
    wire    [MASTER_NUM-1:0] RVALIDmi02si;
    wire    [MASTER_NUM-1:0] RLASTmi02si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi0;

    wire    [MASTER_NUM-1:0] SetARREADYmi02si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi02si;
    wire    [MASTER_NUM-1:0] SetRLASTmi02si;
//Slave module wire were generated
//Slave module 1    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi1;
    wire    [MASTER_NUM-1:0] ARREADYmi12si;
    wire    [MASTER_NUM-1:0] RVALIDmi12si;
    wire    [MASTER_NUM-1:0] RLASTmi12si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi1;

    wire    [MASTER_NUM-1:0] SetARREADYmi12si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi12si;
    wire    [MASTER_NUM-1:0] SetRLASTmi12si;
//Slave module wire were generated
//Slave module 2    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi2;
    wire    [MASTER_NUM-1:0] ARREADYmi22si;
    wire    [MASTER_NUM-1:0] RVALIDmi22si;
    wire    [MASTER_NUM-1:0] RLASTmi22si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi2;

    wire    [MASTER_NUM-1:0] SetARREADYmi22si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi22si;
    wire    [MASTER_NUM-1:0] SetRLASTmi22si;
//Slave module wire were generated
//Slave module 3    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi3;
    wire    [MASTER_NUM-1:0] ARREADYmi32si;
    wire    [MASTER_NUM-1:0] RVALIDmi32si;
    wire    [MASTER_NUM-1:0] RLASTmi32si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi3;

    wire    [MASTER_NUM-1:0] SetARREADYmi32si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi32si;
    wire    [MASTER_NUM-1:0] SetRLASTmi32si;
//Slave module wire were generated
//Slave module 4    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi4;
    wire    [MASTER_NUM-1:0] ARREADYmi42si;
    wire    [MASTER_NUM-1:0] RVALIDmi42si;
    wire    [MASTER_NUM-1:0] RLASTmi42si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi4;

    wire    [MASTER_NUM-1:0] SetARREADYmi42si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi42si;
    wire    [MASTER_NUM-1:0] SetRLASTmi42si;
//Slave module wire were generated
//Slave module 5    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi5;
    wire    [MASTER_NUM-1:0] ARREADYmi52si;
    wire    [MASTER_NUM-1:0] RVALIDmi52si;
    wire    [MASTER_NUM-1:0] RLASTmi52si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi5;

    wire    [MASTER_NUM-1:0] SetARREADYmi52si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi52si;
    wire    [MASTER_NUM-1:0] SetRLASTmi52si;
//Slave module wire were generated
//Slave module 6    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi6;
    wire    [MASTER_NUM-1:0] ARREADYmi62si;
    wire    [MASTER_NUM-1:0] RVALIDmi62si;
    wire    [MASTER_NUM-1:0] RLASTmi62si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi6;

    wire    [MASTER_NUM-1:0] SetARREADYmi62si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi62si;
    wire    [MASTER_NUM-1:0] SetRLASTmi62si;
//Slave module wire were generated
//Slave module 7    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi7;
    wire    [MASTER_NUM-1:0] ARREADYmi72si;
    wire    [MASTER_NUM-1:0] RVALIDmi72si;
    wire    [MASTER_NUM-1:0] RLASTmi72si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi7;

    wire    [MASTER_NUM-1:0] SetARREADYmi72si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi72si;
    wire    [MASTER_NUM-1:0] SetRLASTmi72si;
//Slave module wire were generated
//Slave module 8    
//_____________________________________________________________________

    wire    [MASTER_NUM-1:0] ARVALIDsi2mi8;
    wire    [MASTER_NUM-1:0] ARREADYmi82si;
    wire    [MASTER_NUM-1:0] RVALIDmi82si;
    wire    [MASTER_NUM-1:0] RLASTmi82si;
    wire    [MASTER_NUM-1:0] RREADYsi2mi8;

    wire    [MASTER_NUM-1:0] SetARREADYmi82si;
    wire    [MASTER_NUM-1:0] SetRVALIDmi82si;
    wire    [MASTER_NUM-1:0] SetRLASTmi82si;
//_____________________________________________________________________

//MaserInterface to SlaveInterface Setting
//_____________________________________________________________________
//SlaveNum  [0]
/////////////////////////////
    assign SetARREADYmi02si[0] = ARREADYmi02si[0]; 
    assign SetARREADYmi02si[1] = 1'b0;
    assign SetARREADYmi02si[2] = ARREADYmi02si[1]; 
    assign SetARREADYmi02si[3] = 1'b0;
    assign SetARREADYmi02si[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetARREADYmi12si[0] = ARREADYmi12si[0]; 
    assign SetARREADYmi12si[1] = 1'b0;
    assign SetARREADYmi12si[2] = ARREADYmi12si[1]; 
    assign SetARREADYmi12si[3] = 1'b0;
    assign SetARREADYmi12si[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetARREADYmi22si[0] = ARREADYmi22si[0]; 
    assign SetARREADYmi22si[1] = 1'b0;
    assign SetARREADYmi22si[2] = ARREADYmi22si[1]; 
    assign SetARREADYmi22si[3] = 1'b0;
    assign SetARREADYmi22si[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetARREADYmi32si[0] = ARREADYmi32si[0]; 
    assign SetARREADYmi32si[1] = ARREADYmi32si[1]; 
    assign SetARREADYmi32si[2] = ARREADYmi32si[2]; 
    assign SetARREADYmi32si[3] = ARREADYmi32si[3]; 
    assign SetARREADYmi32si[4] = ARREADYmi32si[4]; 
//SlaveNum  [4]
/////////////////////////////
    assign SetARREADYmi42si[0] = ARREADYmi42si[0]; 
    assign SetARREADYmi42si[1] = 1'b0;
    assign SetARREADYmi42si[2] = ARREADYmi42si[1]; 
    assign SetARREADYmi42si[3] = 1'b0;
    assign SetARREADYmi42si[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetARREADYmi52si[0] = ARREADYmi52si[0]; 
    assign SetARREADYmi52si[1] = 1'b0;
    assign SetARREADYmi52si[2] = ARREADYmi52si[1]; 
    assign SetARREADYmi52si[3] = 1'b0;
    assign SetARREADYmi52si[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign SetARREADYmi62si[0] = ARREADYmi62si[0]; 
    assign SetARREADYmi62si[1] = ARREADYmi62si[1]; 
    assign SetARREADYmi62si[2] = ARREADYmi62si[2]; 
    assign SetARREADYmi62si[3] = ARREADYmi62si[3]; 
    assign SetARREADYmi62si[4] = ARREADYmi62si[4]; 
//SlaveNum  [7]
/////////////////////////////
    assign SetARREADYmi72si[0] = ARREADYmi72si[0]; 
    assign SetARREADYmi72si[1] = ARREADYmi72si[1]; 
    assign SetARREADYmi72si[2] = ARREADYmi72si[2]; 
    assign SetARREADYmi72si[3] = ARREADYmi72si[3]; 
    assign SetARREADYmi72si[4] = ARREADYmi72si[4]; 
//SlaveNum  [8]
/////////////////////////////
    assign SetARREADYmi82si[0] = ARREADYmi82si[0]; 
    assign SetARREADYmi82si[1] = ARREADYmi82si[1]; 
    assign SetARREADYmi82si[2] = ARREADYmi82si[2]; 
    assign SetARREADYmi82si[3] = ARREADYmi82si[3]; 
    assign SetARREADYmi82si[4] = ARREADYmi82si[4]; 

//SlaveNum  [0]
/////////////////////////////
    assign SetRVALIDmi02si[0]  = RVALIDmi02si[0];
    assign SetRVALIDmi02si[1]  = 1'b0;
    assign SetRVALIDmi02si[2]  = RVALIDmi02si[1];
    assign SetRVALIDmi02si[3]  = 1'b0;
    assign SetRVALIDmi02si[4]  = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetRVALIDmi12si[0]  = RVALIDmi12si[0];
    assign SetRVALIDmi12si[1]  = 1'b0;
    assign SetRVALIDmi12si[2]  = RVALIDmi12si[1];
    assign SetRVALIDmi12si[3]  = 1'b0;
    assign SetRVALIDmi12si[4]  = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetRVALIDmi22si[0]  = RVALIDmi22si[0];
    assign SetRVALIDmi22si[1]  = 1'b0;
    assign SetRVALIDmi22si[2]  = RVALIDmi22si[1];
    assign SetRVALIDmi22si[3]  = 1'b0;
    assign SetRVALIDmi22si[4]  = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetRVALIDmi32si[0]  = RVALIDmi32si[0];
    assign SetRVALIDmi32si[1]  = RVALIDmi32si[1];
    assign SetRVALIDmi32si[2]  = RVALIDmi32si[2];
    assign SetRVALIDmi32si[3]  = RVALIDmi32si[3];
    assign SetRVALIDmi32si[4]  = RVALIDmi32si[4];
//SlaveNum  [4]
/////////////////////////////
    assign SetRVALIDmi42si[0]  = RVALIDmi42si[0];
    assign SetRVALIDmi42si[1]  = 1'b0;
    assign SetRVALIDmi42si[2]  = RVALIDmi42si[1];
    assign SetRVALIDmi42si[3]  = 1'b0;
    assign SetRVALIDmi42si[4]  = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetRVALIDmi52si[0]  = RVALIDmi52si[0];
    assign SetRVALIDmi52si[1]  = 1'b0;
    assign SetRVALIDmi52si[2]  = RVALIDmi52si[1];
    assign SetRVALIDmi52si[3]  = 1'b0;
    assign SetRVALIDmi52si[4]  = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign SetRVALIDmi62si[0]  = RVALIDmi62si[0];
    assign SetRVALIDmi62si[1]  = RVALIDmi62si[1];
    assign SetRVALIDmi62si[2]  = RVALIDmi62si[2];
    assign SetRVALIDmi62si[3]  = RVALIDmi62si[3];
    assign SetRVALIDmi62si[4]  = RVALIDmi62si[4];
//SlaveNum  [7]
/////////////////////////////
    assign SetRVALIDmi72si[0]  = RVALIDmi72si[0];
    assign SetRVALIDmi72si[1]  = RVALIDmi72si[1];
    assign SetRVALIDmi72si[2]  = RVALIDmi72si[2];
    assign SetRVALIDmi72si[3]  = RVALIDmi72si[3];
    assign SetRVALIDmi72si[4]  = RVALIDmi72si[4];
//SlaveNum  [8]
/////////////////////////////
    assign SetRVALIDmi82si[0]  = RVALIDmi82si[0];
    assign SetRVALIDmi82si[1]  = RVALIDmi82si[1];
    assign SetRVALIDmi82si[2]  = RVALIDmi82si[2];
    assign SetRVALIDmi82si[3]  = RVALIDmi82si[3];
    assign SetRVALIDmi82si[4]  = RVALIDmi82si[4];

//SlaveNum  [0]
/////////////////////////////
    assign SetRLASTmi02si[0]  = RLASTmi02si[0];
    assign SetRLASTmi02si[1]  = 1'b0;
    assign SetRLASTmi02si[2]  = RLASTmi02si[1];
    assign SetRLASTmi02si[3]  = 1'b0;
    assign SetRLASTmi02si[4]  = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetRLASTmi12si[0]  = RLASTmi12si[0];
    assign SetRLASTmi12si[1]  = 1'b0;
    assign SetRLASTmi12si[2]  = RLASTmi12si[1];
    assign SetRLASTmi12si[3]  = 1'b0;
    assign SetRLASTmi12si[4]  = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetRLASTmi22si[0]  = RLASTmi22si[0];
    assign SetRLASTmi22si[1]  = 1'b0;
    assign SetRLASTmi22si[2]  = RLASTmi22si[1];
    assign SetRLASTmi22si[3]  = 1'b0;
    assign SetRLASTmi22si[4]  = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetRLASTmi32si[0]  = RLASTmi32si[0];
    assign SetRLASTmi32si[1]  = RLASTmi32si[1];
    assign SetRLASTmi32si[2]  = RLASTmi32si[2];
    assign SetRLASTmi32si[3]  = RLASTmi32si[3];
    assign SetRLASTmi32si[4]  = RLASTmi32si[4];
//SlaveNum  [4]
/////////////////////////////
    assign SetRLASTmi42si[0]  = RLASTmi42si[0];
    assign SetRLASTmi42si[1]  = 1'b0;
    assign SetRLASTmi42si[2]  = RLASTmi42si[1];
    assign SetRLASTmi42si[3]  = 1'b0;
    assign SetRLASTmi42si[4]  = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetRLASTmi52si[0]  = RLASTmi52si[0];
    assign SetRLASTmi52si[1]  = 1'b0;
    assign SetRLASTmi52si[2]  = RLASTmi52si[1];
    assign SetRLASTmi52si[3]  = 1'b0;
    assign SetRLASTmi52si[4]  = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign SetRLASTmi62si[0]  = RLASTmi62si[0];
    assign SetRLASTmi62si[1]  = RLASTmi62si[1];
    assign SetRLASTmi62si[2]  = RLASTmi62si[2];
    assign SetRLASTmi62si[3]  = RLASTmi62si[3];
    assign SetRLASTmi62si[4]  = RLASTmi62si[4];
//SlaveNum  [7]
/////////////////////////////
    assign SetRLASTmi72si[0]  = RLASTmi72si[0];
    assign SetRLASTmi72si[1]  = RLASTmi72si[1];
    assign SetRLASTmi72si[2]  = RLASTmi72si[2];
    assign SetRLASTmi72si[3]  = RLASTmi72si[3];
    assign SetRLASTmi72si[4]  = RLASTmi72si[4];
//SlaveNum  [8]
/////////////////////////////
    assign SetRLASTmi82si[0]  = RLASTmi82si[0];
    assign SetRLASTmi82si[1]  = RLASTmi82si[1];
    assign SetRLASTmi82si[2]  = RLASTmi82si[2];
    assign SetRLASTmi82si[3]  = RLASTmi82si[3];
    assign SetRLASTmi82si[4]  = RLASTmi82si[4];

//ARREADYmi2si///////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  ARREADYmi2si0[0] = SetARREADYmi02si[0];
    assign  ARREADYmi2si0[1] = SetARREADYmi12si[0];
    assign  ARREADYmi2si0[2] = SetARREADYmi22si[0];
    assign  ARREADYmi2si0[3] = SetARREADYmi32si[0];
    assign  ARREADYmi2si0[4] = SetARREADYmi42si[0];
    assign  ARREADYmi2si0[5] = SetARREADYmi52si[0];
    assign  ARREADYmi2si0[6] = SetARREADYmi62si[0];
    assign  ARREADYmi2si0[7] = SetARREADYmi72si[0];
    assign  ARREADYmi2si0[8] = SetARREADYmi82si[0];
//MasterNum  [1]
/////////////////////////////
    assign  ARREADYmi2si1[0] = SetARREADYmi02si[1];
    assign  ARREADYmi2si1[1] = SetARREADYmi12si[1];
    assign  ARREADYmi2si1[2] = SetARREADYmi22si[1];
    assign  ARREADYmi2si1[3] = SetARREADYmi32si[1];
    assign  ARREADYmi2si1[4] = SetARREADYmi42si[1];
    assign  ARREADYmi2si1[5] = SetARREADYmi52si[1];
    assign  ARREADYmi2si1[6] = SetARREADYmi62si[1];
    assign  ARREADYmi2si1[7] = SetARREADYmi72si[1];
    assign  ARREADYmi2si1[8] = SetARREADYmi82si[1];
//MasterNum  [2]
/////////////////////////////
    assign  ARREADYmi2si2[0] = SetARREADYmi02si[2];
    assign  ARREADYmi2si2[1] = SetARREADYmi12si[2];
    assign  ARREADYmi2si2[2] = SetARREADYmi22si[2];
    assign  ARREADYmi2si2[3] = SetARREADYmi32si[2];
    assign  ARREADYmi2si2[4] = SetARREADYmi42si[2];
    assign  ARREADYmi2si2[5] = SetARREADYmi52si[2];
    assign  ARREADYmi2si2[6] = SetARREADYmi62si[2];
    assign  ARREADYmi2si2[7] = SetARREADYmi72si[2];
    assign  ARREADYmi2si2[8] = SetARREADYmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  ARREADYmi2si3[0] = SetARREADYmi02si[3];
    assign  ARREADYmi2si3[1] = SetARREADYmi12si[3];
    assign  ARREADYmi2si3[2] = SetARREADYmi22si[3];
    assign  ARREADYmi2si3[3] = SetARREADYmi32si[3];
    assign  ARREADYmi2si3[4] = SetARREADYmi42si[3];
    assign  ARREADYmi2si3[5] = SetARREADYmi52si[3];
    assign  ARREADYmi2si3[6] = SetARREADYmi62si[3];
    assign  ARREADYmi2si3[7] = SetARREADYmi72si[3];
    assign  ARREADYmi2si3[8] = SetARREADYmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  ARREADYmi2si4[0] = SetARREADYmi02si[4];
    assign  ARREADYmi2si4[1] = SetARREADYmi12si[4];
    assign  ARREADYmi2si4[2] = SetARREADYmi22si[4];
    assign  ARREADYmi2si4[3] = SetARREADYmi32si[4];
    assign  ARREADYmi2si4[4] = SetARREADYmi42si[4];
    assign  ARREADYmi2si4[5] = SetARREADYmi52si[4];
    assign  ARREADYmi2si4[6] = SetARREADYmi62si[4];
    assign  ARREADYmi2si4[7] = SetARREADYmi72si[4];
    assign  ARREADYmi2si4[8] = SetARREADYmi82si[4];

//RVALIDmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  RVALIDmi2si0[0] = SetRVALIDmi02si[0];
    assign  RVALIDmi2si0[1] = SetRVALIDmi12si[0];
    assign  RVALIDmi2si0[2] = SetRVALIDmi22si[0];
    assign  RVALIDmi2si0[3] = SetRVALIDmi32si[0];
    assign  RVALIDmi2si0[4] = SetRVALIDmi42si[0];
    assign  RVALIDmi2si0[5] = SetRVALIDmi52si[0];
    assign  RVALIDmi2si0[6] = SetRVALIDmi62si[0];
    assign  RVALIDmi2si0[7] = SetRVALIDmi72si[0];
    assign  RVALIDmi2si0[8] = SetRVALIDmi82si[0];
//MasterNum  [1]
/////////////////////////////
    assign  RVALIDmi2si1[0] = SetRVALIDmi02si[1];
    assign  RVALIDmi2si1[1] = SetRVALIDmi12si[1];
    assign  RVALIDmi2si1[2] = SetRVALIDmi22si[1];
    assign  RVALIDmi2si1[3] = SetRVALIDmi32si[1];
    assign  RVALIDmi2si1[4] = SetRVALIDmi42si[1];
    assign  RVALIDmi2si1[5] = SetRVALIDmi52si[1];
    assign  RVALIDmi2si1[6] = SetRVALIDmi62si[1];
    assign  RVALIDmi2si1[7] = SetRVALIDmi72si[1];
    assign  RVALIDmi2si1[8] = SetRVALIDmi82si[1];
//MasterNum  [2]
/////////////////////////////
    assign  RVALIDmi2si2[0] = SetRVALIDmi02si[2];
    assign  RVALIDmi2si2[1] = SetRVALIDmi12si[2];
    assign  RVALIDmi2si2[2] = SetRVALIDmi22si[2];
    assign  RVALIDmi2si2[3] = SetRVALIDmi32si[2];
    assign  RVALIDmi2si2[4] = SetRVALIDmi42si[2];
    assign  RVALIDmi2si2[5] = SetRVALIDmi52si[2];
    assign  RVALIDmi2si2[6] = SetRVALIDmi62si[2];
    assign  RVALIDmi2si2[7] = SetRVALIDmi72si[2];
    assign  RVALIDmi2si2[8] = SetRVALIDmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  RVALIDmi2si3[0] = SetRVALIDmi02si[3];
    assign  RVALIDmi2si3[1] = SetRVALIDmi12si[3];
    assign  RVALIDmi2si3[2] = SetRVALIDmi22si[3];
    assign  RVALIDmi2si3[3] = SetRVALIDmi32si[3];
    assign  RVALIDmi2si3[4] = SetRVALIDmi42si[3];
    assign  RVALIDmi2si3[5] = SetRVALIDmi52si[3];
    assign  RVALIDmi2si3[6] = SetRVALIDmi62si[3];
    assign  RVALIDmi2si3[7] = SetRVALIDmi72si[3];
    assign  RVALIDmi2si3[8] = SetRVALIDmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  RVALIDmi2si4[0] = SetRVALIDmi02si[4];
    assign  RVALIDmi2si4[1] = SetRVALIDmi12si[4];
    assign  RVALIDmi2si4[2] = SetRVALIDmi22si[4];
    assign  RVALIDmi2si4[3] = SetRVALIDmi32si[4];
    assign  RVALIDmi2si4[4] = SetRVALIDmi42si[4];
    assign  RVALIDmi2si4[5] = SetRVALIDmi52si[4];
    assign  RVALIDmi2si4[6] = SetRVALIDmi62si[4];
    assign  RVALIDmi2si4[7] = SetRVALIDmi72si[4];
    assign  RVALIDmi2si4[8] = SetRVALIDmi82si[4];

//RLASTmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  RLASTmi2si0[0] = SetRLASTmi02si[0];
    assign  RLASTmi2si0[1] = SetRLASTmi12si[0];
    assign  RLASTmi2si0[2] = SetRLASTmi22si[0];
    assign  RLASTmi2si0[3] = SetRLASTmi32si[0];
    assign  RLASTmi2si0[4] = SetRLASTmi42si[0];
    assign  RLASTmi2si0[5] = SetRLASTmi52si[0];
    assign  RLASTmi2si0[6] = SetRLASTmi62si[0];
    assign  RLASTmi2si0[7] = SetRLASTmi72si[0];
    assign  RLASTmi2si0[8] = SetRLASTmi82si[0];
//MasterNum  [1]
/////////////////////////////
    assign  RLASTmi2si1[0] = SetRLASTmi02si[1];
    assign  RLASTmi2si1[1] = SetRLASTmi12si[1];
    assign  RLASTmi2si1[2] = SetRLASTmi22si[1];
    assign  RLASTmi2si1[3] = SetRLASTmi32si[1];
    assign  RLASTmi2si1[4] = SetRLASTmi42si[1];
    assign  RLASTmi2si1[5] = SetRLASTmi52si[1];
    assign  RLASTmi2si1[6] = SetRLASTmi62si[1];
    assign  RLASTmi2si1[7] = SetRLASTmi72si[1];
    assign  RLASTmi2si1[8] = SetRLASTmi82si[1];
//MasterNum  [2]
/////////////////////////////
    assign  RLASTmi2si2[0] = SetRLASTmi02si[2];
    assign  RLASTmi2si2[1] = SetRLASTmi12si[2];
    assign  RLASTmi2si2[2] = SetRLASTmi22si[2];
    assign  RLASTmi2si2[3] = SetRLASTmi32si[2];
    assign  RLASTmi2si2[4] = SetRLASTmi42si[2];
    assign  RLASTmi2si2[5] = SetRLASTmi52si[2];
    assign  RLASTmi2si2[6] = SetRLASTmi62si[2];
    assign  RLASTmi2si2[7] = SetRLASTmi72si[2];
    assign  RLASTmi2si2[8] = SetRLASTmi82si[2];
//MasterNum  [3]
/////////////////////////////
    assign  RLASTmi2si3[0] = SetRLASTmi02si[3];
    assign  RLASTmi2si3[1] = SetRLASTmi12si[3];
    assign  RLASTmi2si3[2] = SetRLASTmi22si[3];
    assign  RLASTmi2si3[3] = SetRLASTmi32si[3];
    assign  RLASTmi2si3[4] = SetRLASTmi42si[3];
    assign  RLASTmi2si3[5] = SetRLASTmi52si[3];
    assign  RLASTmi2si3[6] = SetRLASTmi62si[3];
    assign  RLASTmi2si3[7] = SetRLASTmi72si[3];
    assign  RLASTmi2si3[8] = SetRLASTmi82si[3];
//MasterNum  [4]
/////////////////////////////
    assign  RLASTmi2si4[0] = SetRLASTmi02si[4];
    assign  RLASTmi2si4[1] = SetRLASTmi12si[4];
    assign  RLASTmi2si4[2] = SetRLASTmi22si[4];
    assign  RLASTmi2si4[3] = SetRLASTmi32si[4];
    assign  RLASTmi2si4[4] = SetRLASTmi42si[4];
    assign  RLASTmi2si4[5] = SetRLASTmi52si[4];
    assign  RLASTmi2si4[6] = SetRLASTmi62si[4];
    assign  RLASTmi2si4[7] = SetRLASTmi72si[4];
    assign  RLASTmi2si4[8] = SetRLASTmi82si[4];


//SlaveInterface to MasterInterface Setting
//_____________________________________________________________________

//ARVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  ARVALIDsi2mi0[0] = ARVALIDsi02mi[0];
    assign  ARVALIDsi2mi0[1] = ARVALIDsi22mi[0];
    assign  ARVALIDsi2mi0[2] = 1'b0;
    assign  ARVALIDsi2mi0[3] = 1'b0;
    assign  ARVALIDsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  ARVALIDsi2mi1[0] = ARVALIDsi02mi[1];
    assign  ARVALIDsi2mi1[1] = ARVALIDsi22mi[1];
    assign  ARVALIDsi2mi1[2] = 1'b0;
    assign  ARVALIDsi2mi1[3] = 1'b0;
    assign  ARVALIDsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  ARVALIDsi2mi2[0] = ARVALIDsi02mi[2];
    assign  ARVALIDsi2mi2[1] = ARVALIDsi22mi[2];
    assign  ARVALIDsi2mi2[2] = 1'b0;
    assign  ARVALIDsi2mi2[3] = 1'b0;
    assign  ARVALIDsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  ARVALIDsi2mi3[0] = ARVALIDsi02mi[3];
    assign  ARVALIDsi2mi3[1] = ARVALIDsi12mi[3];
    assign  ARVALIDsi2mi3[2] = ARVALIDsi22mi[3];
    assign  ARVALIDsi2mi3[3] = ARVALIDsi32mi[3];
    assign  ARVALIDsi2mi3[4] = ARVALIDsi42mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  ARVALIDsi2mi4[0] = ARVALIDsi02mi[4];
    assign  ARVALIDsi2mi4[1] = ARVALIDsi22mi[4];
    assign  ARVALIDsi2mi4[2] = 1'b0;
    assign  ARVALIDsi2mi4[3] = 1'b0;
    assign  ARVALIDsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  ARVALIDsi2mi5[0] = ARVALIDsi02mi[5];
    assign  ARVALIDsi2mi5[1] = ARVALIDsi22mi[5];
    assign  ARVALIDsi2mi5[2] = 1'b0;
    assign  ARVALIDsi2mi5[3] = 1'b0;
    assign  ARVALIDsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  ARVALIDsi2mi6[0] = ARVALIDsi02mi[6];
    assign  ARVALIDsi2mi6[1] = ARVALIDsi12mi[6];
    assign  ARVALIDsi2mi6[2] = ARVALIDsi22mi[6];
    assign  ARVALIDsi2mi6[3] = ARVALIDsi32mi[6];
    assign  ARVALIDsi2mi6[4] = ARVALIDsi42mi[6];
//SlaveNum  [7]
/////////////////////////////
    assign  ARVALIDsi2mi7[0] = ARVALIDsi02mi[7];
    assign  ARVALIDsi2mi7[1] = ARVALIDsi12mi[7];
    assign  ARVALIDsi2mi7[2] = ARVALIDsi22mi[7];
    assign  ARVALIDsi2mi7[3] = ARVALIDsi32mi[7];
    assign  ARVALIDsi2mi7[4] = ARVALIDsi42mi[7];
//SlaveNum  [8]
/////////////////////////////
    assign  ARVALIDsi2mi8[0] = ARVALIDsi02mi[8];
    assign  ARVALIDsi2mi8[1] = ARVALIDsi12mi[8];
    assign  ARVALIDsi2mi8[2] = ARVALIDsi22mi[8];
    assign  ARVALIDsi2mi8[3] = ARVALIDsi32mi[8];
    assign  ARVALIDsi2mi8[4] = ARVALIDsi42mi[8];

//RREADYsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  RREADYsi2mi0[0] = RREADYsi02mi[0];
    assign  RREADYsi2mi0[1] = RREADYsi22mi[0];
    assign  RREADYsi2mi0[2] = 1'b0;
    assign  RREADYsi2mi0[3] = 1'b0;
    assign  RREADYsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  RREADYsi2mi1[0] = RREADYsi02mi[1];
    assign  RREADYsi2mi1[1] = RREADYsi22mi[1];
    assign  RREADYsi2mi1[2] = 1'b0;
    assign  RREADYsi2mi1[3] = 1'b0;
    assign  RREADYsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  RREADYsi2mi2[0] = RREADYsi02mi[2];
    assign  RREADYsi2mi2[1] = RREADYsi22mi[2];
    assign  RREADYsi2mi2[2] = 1'b0;
    assign  RREADYsi2mi2[3] = 1'b0;
    assign  RREADYsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  RREADYsi2mi3[0] = RREADYsi02mi[3];
    assign  RREADYsi2mi3[1] = RREADYsi12mi[3];
    assign  RREADYsi2mi3[2] = RREADYsi22mi[3];
    assign  RREADYsi2mi3[3] = RREADYsi32mi[3];
    assign  RREADYsi2mi3[4] = RREADYsi42mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  RREADYsi2mi4[0] = RREADYsi02mi[4];
    assign  RREADYsi2mi4[1] = RREADYsi22mi[4];
    assign  RREADYsi2mi4[2] = 1'b0;
    assign  RREADYsi2mi4[3] = 1'b0;
    assign  RREADYsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  RREADYsi2mi5[0] = RREADYsi02mi[5];
    assign  RREADYsi2mi5[1] = RREADYsi22mi[5];
    assign  RREADYsi2mi5[2] = 1'b0;
    assign  RREADYsi2mi5[3] = 1'b0;
    assign  RREADYsi2mi5[4] = 1'b0;
//SlaveNum  [6]
/////////////////////////////
    assign  RREADYsi2mi6[0] = RREADYsi02mi[6];
    assign  RREADYsi2mi6[1] = RREADYsi12mi[6];
    assign  RREADYsi2mi6[2] = RREADYsi22mi[6];
    assign  RREADYsi2mi6[3] = RREADYsi32mi[6];
    assign  RREADYsi2mi6[4] = RREADYsi42mi[6];
//SlaveNum  [7]
/////////////////////////////
    assign  RREADYsi2mi7[0] = RREADYsi02mi[7];
    assign  RREADYsi2mi7[1] = RREADYsi12mi[7];
    assign  RREADYsi2mi7[2] = RREADYsi22mi[7];
    assign  RREADYsi2mi7[3] = RREADYsi32mi[7];
    assign  RREADYsi2mi7[4] = RREADYsi42mi[7];
//SlaveNum  [8]
/////////////////////////////
    assign  RREADYsi2mi8[0] = RREADYsi02mi[8];
    assign  RREADYsi2mi8[1] = RREADYsi12mi[8];
    assign  RREADYsi2mi8[2] = RREADYsi22mi[8];
    assign  RREADYsi2mi8[3] = RREADYsi32mi[8];
    assign  RREADYsi2mi8[4] = RREADYsi42mi[8];



//Master module 0    
//_____________________________________________________________________

ARMD_RS_ReadChannelsi
ARMD_RS_ReadChannelsi(

    ///////////////////////////////////////////////
    //Read address channel
//Disable_id_port
    .ARADDRm2si  (ARADDRm02si0),
    .ARLENm2si   (ARLENm02si0),
    .ARSIZEm2si  (ARSIZEm02si0),
    .ARBURSTm2si (ARBURSTm02si0),
    .ARLOCKm2si  (ARLOCKm02si0),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm2si (ARVALIDm02si0),
    .ARREADYsi2m (ARREADYsi02m0),

    //Read data channel
//Disable_id_port
    .RRESPsi2m   (RRESPsi02m0),
    .RVALIDsi2m  (RVALIDsi02m0),
    .RDATAsi2m   (RDATAsi02m0),
    .RREADYm2si  (RREADYm02si0),
    .RLASTsi2m   (RLASTsi02m0),


    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi0    (ARIDsi02mi0),
    .ARADDRsi2mi0  (ARADDRsi02mi0),
    .ARLENsi2mi0   (ARLENsi02mi0),
    .ARSIZEsi2mi0  (ARSIZEsi02mi0),
    .ARBURSTsi2mi0 (ARBURSTsi02mi0),
    .ARLOCKsi2mi0  (ARLOCKsi02mi0),
    .ARCACHEsi2mi0 (ARCACHEsi02mi0),
    .ARPROTsi2mi0  (ARPROTsi02mi0),


    //Slave Number 0
    .RIDmi02si     (RIDmi02si0[MASTERID0_WID-1:0]),
    .RRESPmi02si   (RRESPmi02si0),
    .RDATAmi02si   (RDATAmi02si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi1    (ARIDsi02mi1),
    .ARADDRsi2mi1  (ARADDRsi02mi1),
    .ARLENsi2mi1   (ARLENsi02mi1),
    .ARSIZEsi2mi1  (ARSIZEsi02mi1),
    .ARBURSTsi2mi1 (ARBURSTsi02mi1),
    .ARLOCKsi2mi1  (ARLOCKsi02mi1),
    .ARCACHEsi2mi1 (ARCACHEsi02mi1),
    .ARPROTsi2mi1  (ARPROTsi02mi1),


    //Slave Number 1
    .RIDmi12si     (RIDmi12si0[MASTERID0_WID-1:0]),
    .RRESPmi12si   (RRESPmi12si0),
    .RDATAmi12si   (RDATAmi12si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi2    (ARIDsi02mi2),
    .ARADDRsi2mi2  (ARADDRsi02mi2),
    .ARLENsi2mi2   (ARLENsi02mi2),
    .ARSIZEsi2mi2  (ARSIZEsi02mi2),
    .ARBURSTsi2mi2 (ARBURSTsi02mi2),
    .ARLOCKsi2mi2  (ARLOCKsi02mi2),
    .ARCACHEsi2mi2 (ARCACHEsi02mi2),
    .ARPROTsi2mi2  (ARPROTsi02mi2),


    //Slave Number 2
    .RIDmi22si     (RIDmi22si0[MASTERID0_WID-1:0]),
    .RRESPmi22si   (RRESPmi22si0),
    .RDATAmi22si   (RDATAmi22si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi3    (ARIDsi02mi3),
    .ARADDRsi2mi3  (ARADDRsi02mi3),
    .ARLENsi2mi3   (ARLENsi02mi3),
    .ARSIZEsi2mi3  (ARSIZEsi02mi3),
    .ARBURSTsi2mi3 (ARBURSTsi02mi3),
    .ARLOCKsi2mi3  (ARLOCKsi02mi3),
    .ARCACHEsi2mi3 (ARCACHEsi02mi3),
    .ARPROTsi2mi3  (ARPROTsi02mi3),


    //Slave Number 3
    .RIDmi32si     (RIDmi32si0[MASTERID0_WID-1:0]),
    .RRESPmi32si   (RRESPmi32si0),
    .RDATAmi32si   (RDATAmi32si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi4    (ARIDsi02mi4),
    .ARADDRsi2mi4  (ARADDRsi02mi4),
    .ARLENsi2mi4   (ARLENsi02mi4),
    .ARSIZEsi2mi4  (ARSIZEsi02mi4),
    .ARBURSTsi2mi4 (ARBURSTsi02mi4),
    .ARLOCKsi2mi4  (ARLOCKsi02mi4),
    .ARCACHEsi2mi4 (ARCACHEsi02mi4),
    .ARPROTsi2mi4  (ARPROTsi02mi4),


    //Slave Number 4
    .RIDmi42si     (RIDmi42si0[MASTERID0_WID-1:0]),
    .RRESPmi42si   (RRESPmi42si0),
    .RDATAmi42si   (RDATAmi42si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi5    (ARIDsi02mi5),
    .ARADDRsi2mi5  (ARADDRsi02mi5),
    .ARLENsi2mi5   (ARLENsi02mi5),
    .ARSIZEsi2mi5  (ARSIZEsi02mi5),
    .ARBURSTsi2mi5 (ARBURSTsi02mi5),
    .ARLOCKsi2mi5  (ARLOCKsi02mi5),
    .ARCACHEsi2mi5 (ARCACHEsi02mi5),
    .ARPROTsi2mi5  (ARPROTsi02mi5),


    //Slave Number 5
    .RIDmi52si     (RIDmi52si0[MASTERID0_WID-1:0]),
    .RRESPmi52si   (RRESPmi52si0),
    .RDATAmi52si   (RDATAmi52si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi6    (ARIDsi02mi6),
    .ARADDRsi2mi6  (ARADDRsi02mi6),
    .ARLENsi2mi6   (ARLENsi02mi6),
    .ARSIZEsi2mi6  (ARSIZEsi02mi6),
    .ARBURSTsi2mi6 (ARBURSTsi02mi6),
    .ARLOCKsi2mi6  (ARLOCKsi02mi6),
    .ARCACHEsi2mi6 (ARCACHEsi02mi6),
    .ARPROTsi2mi6  (ARPROTsi02mi6),


    //Slave Number 6
    .RIDmi62si     (RIDmi62si0[MASTERID0_WID-1:0]),
    .RRESPmi62si   (RRESPmi62si0),
    .RDATAmi62si   (RDATAmi62si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi7    (ARIDsi02mi7),
    .ARADDRsi2mi7  (ARADDRsi02mi7),
    .ARLENsi2mi7   (ARLENsi02mi7),
    .ARSIZEsi2mi7  (ARSIZEsi02mi7),
    .ARBURSTsi2mi7 (ARBURSTsi02mi7),
    .ARLOCKsi2mi7  (ARLOCKsi02mi7),
    .ARCACHEsi2mi7 (ARCACHEsi02mi7),
    .ARPROTsi2mi7  (ARPROTsi02mi7),


    //Slave Number 7
    .RIDmi72si     (RIDmi72si0[MASTERID0_WID-1:0]),
    .RRESPmi72si   (RRESPmi72si0),
    .RDATAmi72si   (RDATAmi72si0),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi8    (ARIDsi02mi8),
    .ARADDRsi2mi8  (ARADDRsi02mi8),
    .ARLENsi2mi8   (ARLENsi02mi8),
    .ARSIZEsi2mi8  (ARSIZEsi02mi8),
    .ARBURSTsi2mi8 (ARBURSTsi02mi8),
    .ARLOCKsi2mi8  (ARLOCKsi02mi8),
    .ARCACHEsi2mi8 (ARCACHEsi02mi8),
    .ARPROTsi2mi8  (ARPROTsi02mi8),


    //Slave Number 8
    .RIDmi82si     (RIDmi82si0[MASTERID0_WID-1:0]),
    .RRESPmi82si   (RRESPmi82si0),
    .RDATAmi82si   (RDATAmi82si0),

    .ARVALIDsi2mi (ARVALIDsi02mi),
    .ARREADYmi2si (ARREADYmi2si0),

    .RVALIDmi2si  (RVALIDmi2si0),
    .RREADYsi2mi  (RREADYsi02mi),
    .RLASTmi2si	  (RLASTmi2si0),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
	.SelMAP1 (SelMAP1)
);

//Master module 1    
//_____________________________________________________________________

ARMI_RS_ReadChannelsi
ARMI_RS_ReadChannelsi(

    ///////////////////////////////////////////////
    //Read address channel
//Disable_id_port
    .ARADDRm2si  (ARADDRm12si1),
    .ARLENm2si   (ARLENm12si1),
    .ARSIZEm2si  (ARSIZEm12si1),
    .ARBURSTm2si (ARBURSTm12si1),
    .ARLOCKm2si  (ARLOCKm12si1),
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm2si (ARVALIDm12si1),
    .ARREADYsi2m (ARREADYsi12m1),

    //Read data channel
//Disable_id_port
    .RRESPsi2m   (RRESPsi12m1),
    .RVALIDsi2m  (RVALIDsi12m1),
    .RDATAsi2m   (RDATAsi12m1),
    .RREADYm2si  (RREADYm12si1),
    .RLASTsi2m   (RLASTsi12m1),


    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi3    (ARIDsi12mi3),
    .ARADDRsi2mi3  (ARADDRsi12mi3),
    .ARLENsi2mi3   (ARLENsi12mi3),
    .ARSIZEsi2mi3  (ARSIZEsi12mi3),
    .ARBURSTsi2mi3 (ARBURSTsi12mi3),
    .ARLOCKsi2mi3  (ARLOCKsi12mi3),
    .ARCACHEsi2mi3 (ARCACHEsi12mi3),
    .ARPROTsi2mi3  (ARPROTsi12mi3),


    //Slave Number 3
    .RIDmi32si     (RIDmi32si1[MASTERID1_WID-1:0]),
    .RRESPmi32si   (RRESPmi32si1),
    .RDATAmi32si   (RDATAmi32si1),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi6    (ARIDsi12mi6),
    .ARADDRsi2mi6  (ARADDRsi12mi6),
    .ARLENsi2mi6   (ARLENsi12mi6),
    .ARSIZEsi2mi6  (ARSIZEsi12mi6),
    .ARBURSTsi2mi6 (ARBURSTsi12mi6),
    .ARLOCKsi2mi6  (ARLOCKsi12mi6),
    .ARCACHEsi2mi6 (ARCACHEsi12mi6),
    .ARPROTsi2mi6  (ARPROTsi12mi6),


    //Slave Number 6
    .RIDmi62si     (RIDmi62si1[MASTERID1_WID-1:0]),
    .RRESPmi62si   (RRESPmi62si1),
    .RDATAmi62si   (RDATAmi62si1),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi7    (ARIDsi12mi7),
    .ARADDRsi2mi7  (ARADDRsi12mi7),
    .ARLENsi2mi7   (ARLENsi12mi7),
    .ARSIZEsi2mi7  (ARSIZEsi12mi7),
    .ARBURSTsi2mi7 (ARBURSTsi12mi7),
    .ARLOCKsi2mi7  (ARLOCKsi12mi7),
    .ARCACHEsi2mi7 (ARCACHEsi12mi7),
    .ARPROTsi2mi7  (ARPROTsi12mi7),


    //Slave Number 7
    .RIDmi72si     (RIDmi72si1[MASTERID1_WID-1:0]),
    .RRESPmi72si   (RRESPmi72si1),
    .RDATAmi72si   (RDATAmi72si1),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi8    (ARIDsi12mi8),
    .ARADDRsi2mi8  (ARADDRsi12mi8),
    .ARLENsi2mi8   (ARLENsi12mi8),
    .ARSIZEsi2mi8  (ARSIZEsi12mi8),
    .ARBURSTsi2mi8 (ARBURSTsi12mi8),
    .ARLOCKsi2mi8  (ARLOCKsi12mi8),
    .ARCACHEsi2mi8 (ARCACHEsi12mi8),
    .ARPROTsi2mi8  (ARPROTsi12mi8),


    //Slave Number 8
    .RIDmi82si     (RIDmi82si1[MASTERID1_WID-1:0]),
    .RRESPmi82si   (RRESPmi82si1),
    .RDATAmi82si   (RDATAmi82si1),

    .ARVALIDsi2mi (ARVALIDsi12mi),
    .ARREADYmi2si (ARREADYmi2si1),

    .RVALIDmi2si  (RVALIDmi2si1),
    .RREADYsi2mi  (RREADYsi12mi),
    .RLASTmi2si	  (RLASTmi2si1),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
	.SelMAP1 (SelMAP1)
);

//Master module 2    
//_____________________________________________________________________

DMAC_RS_ReadChannelsi
DMAC_RS_ReadChannelsi(

    ///////////////////////////////////////////////
    //Read address channel
    .ARIDm2si    (ARIDm22si2),
    .ARADDRm2si  (ARADDRm22si2),
    .ARLENm2si   (ARLENm22si2),
    .ARSIZEm2si  (ARSIZEm22si2),
    .ARBURSTm2si (ARBURSTm22si2),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm2si (ARVALIDm22si2),
    .ARREADYsi2m (ARREADYsi22m2),

    //Read data channel
    .RIDsi2m     (RIDsi22m2),
    .RRESPsi2m   (RRESPsi22m2),
    .RVALIDsi2m  (RVALIDsi22m2),
    .RDATAsi2m   (RDATAsi22m2),
    .RREADYm2si  (RREADYm22si2),
    .RLASTsi2m   (RLASTsi22m2),


    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi0    (ARIDsi22mi0),
    .ARADDRsi2mi0  (ARADDRsi22mi0),
    .ARLENsi2mi0   (ARLENsi22mi0),
    .ARSIZEsi2mi0  (ARSIZEsi22mi0),
    .ARBURSTsi2mi0 (ARBURSTsi22mi0),
    .ARLOCKsi2mi0  (ARLOCKsi22mi0),
    .ARCACHEsi2mi0 (ARCACHEsi22mi0),
    .ARPROTsi2mi0  (ARPROTsi22mi0),


    //Slave Number 0
    .RIDmi02si     (RIDmi02si2[MASTERID2_WID-1:0]),
    .RRESPmi02si   (RRESPmi02si2),
    .RDATAmi02si   (RDATAmi02si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi1    (ARIDsi22mi1),
    .ARADDRsi2mi1  (ARADDRsi22mi1),
    .ARLENsi2mi1   (ARLENsi22mi1),
    .ARSIZEsi2mi1  (ARSIZEsi22mi1),
    .ARBURSTsi2mi1 (ARBURSTsi22mi1),
    .ARLOCKsi2mi1  (ARLOCKsi22mi1),
    .ARCACHEsi2mi1 (ARCACHEsi22mi1),
    .ARPROTsi2mi1  (ARPROTsi22mi1),


    //Slave Number 1
    .RIDmi12si     (RIDmi12si2[MASTERID2_WID-1:0]),
    .RRESPmi12si   (RRESPmi12si2),
    .RDATAmi12si   (RDATAmi12si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi2    (ARIDsi22mi2),
    .ARADDRsi2mi2  (ARADDRsi22mi2),
    .ARLENsi2mi2   (ARLENsi22mi2),
    .ARSIZEsi2mi2  (ARSIZEsi22mi2),
    .ARBURSTsi2mi2 (ARBURSTsi22mi2),
    .ARLOCKsi2mi2  (ARLOCKsi22mi2),
    .ARCACHEsi2mi2 (ARCACHEsi22mi2),
    .ARPROTsi2mi2  (ARPROTsi22mi2),


    //Slave Number 2
    .RIDmi22si     (RIDmi22si2[MASTERID2_WID-1:0]),
    .RRESPmi22si   (RRESPmi22si2),
    .RDATAmi22si   (RDATAmi22si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi3    (ARIDsi22mi3),
    .ARADDRsi2mi3  (ARADDRsi22mi3),
    .ARLENsi2mi3   (ARLENsi22mi3),
    .ARSIZEsi2mi3  (ARSIZEsi22mi3),
    .ARBURSTsi2mi3 (ARBURSTsi22mi3),
    .ARLOCKsi2mi3  (ARLOCKsi22mi3),
    .ARCACHEsi2mi3 (ARCACHEsi22mi3),
    .ARPROTsi2mi3  (ARPROTsi22mi3),


    //Slave Number 3
    .RIDmi32si     (RIDmi32si2[MASTERID2_WID-1:0]),
    .RRESPmi32si   (RRESPmi32si2),
    .RDATAmi32si   (RDATAmi32si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi4    (ARIDsi22mi4),
    .ARADDRsi2mi4  (ARADDRsi22mi4),
    .ARLENsi2mi4   (ARLENsi22mi4),
    .ARSIZEsi2mi4  (ARSIZEsi22mi4),
    .ARBURSTsi2mi4 (ARBURSTsi22mi4),
    .ARLOCKsi2mi4  (ARLOCKsi22mi4),
    .ARCACHEsi2mi4 (ARCACHEsi22mi4),
    .ARPROTsi2mi4  (ARPROTsi22mi4),


    //Slave Number 4
    .RIDmi42si     (RIDmi42si2[MASTERID2_WID-1:0]),
    .RRESPmi42si   (RRESPmi42si2),
    .RDATAmi42si   (RDATAmi42si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi5    (ARIDsi22mi5),
    .ARADDRsi2mi5  (ARADDRsi22mi5),
    .ARLENsi2mi5   (ARLENsi22mi5),
    .ARSIZEsi2mi5  (ARSIZEsi22mi5),
    .ARBURSTsi2mi5 (ARBURSTsi22mi5),
    .ARLOCKsi2mi5  (ARLOCKsi22mi5),
    .ARCACHEsi2mi5 (ARCACHEsi22mi5),
    .ARPROTsi2mi5  (ARPROTsi22mi5),


    //Slave Number 5
    .RIDmi52si     (RIDmi52si2[MASTERID2_WID-1:0]),
    .RRESPmi52si   (RRESPmi52si2),
    .RDATAmi52si   (RDATAmi52si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi6    (ARIDsi22mi6),
    .ARADDRsi2mi6  (ARADDRsi22mi6),
    .ARLENsi2mi6   (ARLENsi22mi6),
    .ARSIZEsi2mi6  (ARSIZEsi22mi6),
    .ARBURSTsi2mi6 (ARBURSTsi22mi6),
    .ARLOCKsi2mi6  (ARLOCKsi22mi6),
    .ARCACHEsi2mi6 (ARCACHEsi22mi6),
    .ARPROTsi2mi6  (ARPROTsi22mi6),


    //Slave Number 6
    .RIDmi62si     (RIDmi62si2[MASTERID2_WID-1:0]),
    .RRESPmi62si   (RRESPmi62si2),
    .RDATAmi62si   (RDATAmi62si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi7    (ARIDsi22mi7),
    .ARADDRsi2mi7  (ARADDRsi22mi7),
    .ARLENsi2mi7   (ARLENsi22mi7),
    .ARSIZEsi2mi7  (ARSIZEsi22mi7),
    .ARBURSTsi2mi7 (ARBURSTsi22mi7),
    .ARLOCKsi2mi7  (ARLOCKsi22mi7),
    .ARCACHEsi2mi7 (ARCACHEsi22mi7),
    .ARPROTsi2mi7  (ARPROTsi22mi7),


    //Slave Number 7
    .RIDmi72si     (RIDmi72si2[MASTERID2_WID-1:0]),
    .RRESPmi72si   (RRESPmi72si2),
    .RDATAmi72si   (RDATAmi72si2),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi8    (ARIDsi22mi8),
    .ARADDRsi2mi8  (ARADDRsi22mi8),
    .ARLENsi2mi8   (ARLENsi22mi8),
    .ARSIZEsi2mi8  (ARSIZEsi22mi8),
    .ARBURSTsi2mi8 (ARBURSTsi22mi8),
    .ARLOCKsi2mi8  (ARLOCKsi22mi8),
    .ARCACHEsi2mi8 (ARCACHEsi22mi8),
    .ARPROTsi2mi8  (ARPROTsi22mi8),


    //Slave Number 8
    .RIDmi82si     (RIDmi82si2[MASTERID2_WID-1:0]),
    .RRESPmi82si   (RRESPmi82si2),
    .RDATAmi82si   (RDATAmi82si2),

    .ARVALIDsi2mi (ARVALIDsi22mi),
    .ARREADYmi2si (ARREADYmi2si2),

    .RVALIDmi2si  (RVALIDmi2si2),
    .RREADYsi2mi  (RREADYsi22mi),
    .RLASTmi2si	  (RLASTmi2si2),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
	.SelMAP1 (SelMAP1)
);

//Master module 3    
//_____________________________________________________________________

MAC_RS_ReadChannelsi
MAC_RS_ReadChannelsi(

    ///////////////////////////////////////////////
    //Read address channel
//Disable_id_port
    .ARADDRm2si  (ARADDRm32si3),
    .ARLENm2si   (ARLENm32si3),
    .ARSIZEm2si  (ARSIZEm32si3),
    .ARBURSTm2si (ARBURSTm32si3),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm2si (ARVALIDm32si3),
    .ARREADYsi2m (ARREADYsi32m3),

    //Read data channel
//Disable_id_port
    .RRESPsi2m   (RRESPsi32m3),
    .RVALIDsi2m  (RVALIDsi32m3),
    .RDATAsi2m   (RDATAsi32m3),
    .RREADYm2si  (RREADYm32si3),
    .RLASTsi2m   (RLASTsi32m3),


    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi3    (ARIDsi32mi3),
    .ARADDRsi2mi3  (ARADDRsi32mi3),
    .ARLENsi2mi3   (ARLENsi32mi3),
    .ARSIZEsi2mi3  (ARSIZEsi32mi3),
    .ARBURSTsi2mi3 (ARBURSTsi32mi3),
    .ARLOCKsi2mi3  (ARLOCKsi32mi3),
    .ARCACHEsi2mi3 (ARCACHEsi32mi3),
    .ARPROTsi2mi3  (ARPROTsi32mi3),


    //Slave Number 3
    .RIDmi32si     (RIDmi32si3[MASTERID3_WID-1:0]),
    .RRESPmi32si   (RRESPmi32si3),
    .RDATAmi32si   (RDATAmi32si3),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi6    (ARIDsi32mi6),
    .ARADDRsi2mi6  (ARADDRsi32mi6),
    .ARLENsi2mi6   (ARLENsi32mi6),
    .ARSIZEsi2mi6  (ARSIZEsi32mi6),
    .ARBURSTsi2mi6 (ARBURSTsi32mi6),
    .ARLOCKsi2mi6  (ARLOCKsi32mi6),
    .ARCACHEsi2mi6 (ARCACHEsi32mi6),
    .ARPROTsi2mi6  (ARPROTsi32mi6),


    //Slave Number 6
    .RIDmi62si     (RIDmi62si3[MASTERID3_WID-1:0]),
    .RRESPmi62si   (RRESPmi62si3),
    .RDATAmi62si   (RDATAmi62si3),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi7    (ARIDsi32mi7),
    .ARADDRsi2mi7  (ARADDRsi32mi7),
    .ARLENsi2mi7   (ARLENsi32mi7),
    .ARSIZEsi2mi7  (ARSIZEsi32mi7),
    .ARBURSTsi2mi7 (ARBURSTsi32mi7),
    .ARLOCKsi2mi7  (ARLOCKsi32mi7),
    .ARCACHEsi2mi7 (ARCACHEsi32mi7),
    .ARPROTsi2mi7  (ARPROTsi32mi7),


    //Slave Number 7
    .RIDmi72si     (RIDmi72si3[MASTERID3_WID-1:0]),
    .RRESPmi72si   (RRESPmi72si3),
    .RDATAmi72si   (RDATAmi72si3),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi8    (ARIDsi32mi8),
    .ARADDRsi2mi8  (ARADDRsi32mi8),
    .ARLENsi2mi8   (ARLENsi32mi8),
    .ARSIZEsi2mi8  (ARSIZEsi32mi8),
    .ARBURSTsi2mi8 (ARBURSTsi32mi8),
    .ARLOCKsi2mi8  (ARLOCKsi32mi8),
    .ARCACHEsi2mi8 (ARCACHEsi32mi8),
    .ARPROTsi2mi8  (ARPROTsi32mi8),


    //Slave Number 8
    .RIDmi82si     (RIDmi82si3[MASTERID3_WID-1:0]),
    .RRESPmi82si   (RRESPmi82si3),
    .RDATAmi82si   (RDATAmi82si3),

    .ARVALIDsi2mi (ARVALIDsi32mi),
    .ARREADYmi2si (ARREADYmi2si3),

    .RVALIDmi2si  (RVALIDmi2si3),
    .RREADYsi2mi  (RREADYsi32mi),
    .RLASTmi2si	  (RLASTmi2si3),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
	.SelMAP1 (SelMAP1)
);

//Master module 4    
//_____________________________________________________________________

PCI_RS_ReadChannelsi
PCI_RS_ReadChannelsi(

    ///////////////////////////////////////////////
    //Read address channel
//Disable_id_port
    .ARADDRm2si  (ARADDRm42si4),
    .ARLENm2si   (ARLENm42si4),
    .ARSIZEm2si  (ARSIZEm42si4),
    .ARBURSTm2si (ARBURSTm42si4),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDm2si (ARVALIDm42si4),
    .ARREADYsi2m (ARREADYsi42m4),

    //Read data channel
//Disable_id_port
    .RRESPsi2m   (RRESPsi42m4),
    .RVALIDsi2m  (RVALIDsi42m4),
    .RDATAsi2m   (RDATAsi42m4),
    .RREADYm2si  (RREADYm42si4),
    .RLASTsi2m   (RLASTsi42m4),


    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi3    (ARIDsi42mi3),
    .ARADDRsi2mi3  (ARADDRsi42mi3),
    .ARLENsi2mi3   (ARLENsi42mi3),
    .ARSIZEsi2mi3  (ARSIZEsi42mi3),
    .ARBURSTsi2mi3 (ARBURSTsi42mi3),
    .ARLOCKsi2mi3  (ARLOCKsi42mi3),
    .ARCACHEsi2mi3 (ARCACHEsi42mi3),
    .ARPROTsi2mi3  (ARPROTsi42mi3),


    //Slave Number 3
    .RIDmi32si     (RIDmi32si4[MASTERID4_WID-1:0]),
    .RRESPmi32si   (RRESPmi32si4),
    .RDATAmi32si   (RDATAmi32si4),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi6    (ARIDsi42mi6),
    .ARADDRsi2mi6  (ARADDRsi42mi6),
    .ARLENsi2mi6   (ARLENsi42mi6),
    .ARSIZEsi2mi6  (ARSIZEsi42mi6),
    .ARBURSTsi2mi6 (ARBURSTsi42mi6),
    .ARLOCKsi2mi6  (ARLOCKsi42mi6),
    .ARCACHEsi2mi6 (ARCACHEsi42mi6),
    .ARPROTsi2mi6  (ARPROTsi42mi6),


    //Slave Number 6
    .RIDmi62si     (RIDmi62si4[MASTERID4_WID-1:0]),
    .RRESPmi62si   (RRESPmi62si4),
    .RDATAmi62si   (RDATAmi62si4),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi7    (ARIDsi42mi7),
    .ARADDRsi2mi7  (ARADDRsi42mi7),
    .ARLENsi2mi7   (ARLENsi42mi7),
    .ARSIZEsi2mi7  (ARSIZEsi42mi7),
    .ARBURSTsi2mi7 (ARBURSTsi42mi7),
    .ARLOCKsi2mi7  (ARLOCKsi42mi7),
    .ARCACHEsi2mi7 (ARCACHEsi42mi7),
    .ARPROTsi2mi7  (ARPROTsi42mi7),


    //Slave Number 7
    .RIDmi72si     (RIDmi72si4[MASTERID4_WID-1:0]),
    .RRESPmi72si   (RRESPmi72si4),
    .RDATAmi72si   (RDATAmi72si4),
    
    ///////////////////////////////////////////////
    //For Master interface
    //Read address channel
    .ARIDsi2mi8    (ARIDsi42mi8),
    .ARADDRsi2mi8  (ARADDRsi42mi8),
    .ARLENsi2mi8   (ARLENsi42mi8),
    .ARSIZEsi2mi8  (ARSIZEsi42mi8),
    .ARBURSTsi2mi8 (ARBURSTsi42mi8),
    .ARLOCKsi2mi8  (ARLOCKsi42mi8),
    .ARCACHEsi2mi8 (ARCACHEsi42mi8),
    .ARPROTsi2mi8  (ARPROTsi42mi8),


    //Slave Number 8
    .RIDmi82si     (RIDmi82si4[MASTERID4_WID-1:0]),
    .RRESPmi82si   (RRESPmi82si4),
    .RDATAmi82si   (RDATAmi82si4),

    .ARVALIDsi2mi (ARVALIDsi42mi),
    .ARREADYmi2si (ARREADYmi2si4),

    .RVALIDmi2si  (RVALIDmi2si4),
    .RREADYsi2mi  (RREADYsi42mi),
    .RLASTmi2si	  (RLASTmi2si4),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),
	.SelMAP1 (SelMAP1)
);

//Slave module 0    
//_____________________________________________________________________

AHB0_RS_ReadChannelmi
AHB0_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi02s0),
    .ARADDRmi2s  (ARADDRmi02s0),
    .ARLENmi2s   (ARLENmi02s0),
    .ARSIZEmi2s  (ARSIZEmi02s0),
    .ARBURSTmi2s (ARBURSTmi02s0),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi02s0),
    .ARREADYs2mi (ARREADYs02mi0),

    //Read data channel
    .RIDs2mi     (RIDs02mi0),
    .RRESPs2mi   (RRESPs02mi0),
    .RDATAs2mi   (RDATAs02mi0),
    .RVALIDs2mi  (RVALIDs02mi0),
    .RLASTs2mi   (RLASTs02mi0),
    .RREADYmi2s  (RREADYmi02s0),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi0),
    .ARLENsi02mi   (ARLENsi02mi0),
    .ARSIZEsi02mi  (ARSIZEsi02mi0),
    .ARBURSTsi02mi (ARBURSTsi02mi0),
    .ARLOCKsi02mi  (ARLOCKsi02mi0),
    .ARCACHEsi02mi (ARCACHEsi02mi0),
    .ARPROTsi02mi  (ARPROTsi02mi0),


    //Read data channel
    .RIDmi2si0     (RIDmi02si0),
    .RRESPmi2si0   (RRESPmi02si0),
    .RDATAmi2si0   (RDATAmi02si0),

    //Master Number 2
    .ARIDsi12mi    (wARIDsi22mi0[SLAVE_MASTERID0_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi22mi0),
    .ARLENsi12mi   (ARLENsi22mi0),
    .ARSIZEsi12mi  (ARSIZEsi22mi0),
    .ARBURSTsi12mi (ARBURSTsi22mi0),
    .ARLOCKsi12mi  (ARLOCKsi22mi0),
    .ARCACHEsi12mi (ARCACHEsi22mi0),
    .ARPROTsi12mi  (ARPROTsi22mi0),


    //Read data channel
    .RIDmi2si1     (RIDmi02si2),
    .RRESPmi2si1   (RRESPmi02si2),
    .RDATAmi2si1   (RDATAmi02si2),

    
    .RVALIDmi2si  (RVALIDmi02si),
    .RLASTmi2si   (RLASTmi02si),
    .RREADYsi2mi  (RREADYsi2mi0),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi0),
    .UnLock2Rdmi    (UnLock2rdmi0),

    .Lock2Wrmi      (Lock2wrmi0),
    .UnLock2Wrmi    (UnLock2wrmi0),

    .AWVALID        (AWVALIDmi02s0),
    .LockPort       (LockPort2rdmi0),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi02Rdmi0),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi02Wrmi0),
    .CtlDataRead2Lock       (CtlDataRead2Lock0),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi0),
    .ARREADYmi2si  (ARREADYmi02si)
);

//Slave module 1    
//_____________________________________________________________________

AHB1_RS_ReadChannelmi
AHB1_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi12s1),
    .ARADDRmi2s  (ARADDRmi12s1),
    .ARLENmi2s   (ARLENmi12s1),
    .ARSIZEmi2s  (ARSIZEmi12s1),
    .ARBURSTmi2s (ARBURSTmi12s1),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi12s1),
    .ARREADYs2mi (ARREADYs12mi1),

    //Read data channel
    .RIDs2mi     (RIDs12mi1),
    .RRESPs2mi   (RRESPs12mi1),
    .RDATAs2mi   (RDATAs12mi1),
    .RVALIDs2mi  (RVALIDs12mi1),
    .RLASTs2mi   (RLASTs12mi1),
    .RREADYmi2s  (RREADYmi12s1),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi1),
    .ARLENsi02mi   (ARLENsi02mi1),
    .ARSIZEsi02mi  (ARSIZEsi02mi1),
    .ARBURSTsi02mi (ARBURSTsi02mi1),
    .ARLOCKsi02mi  (ARLOCKsi02mi1),
    .ARCACHEsi02mi (ARCACHEsi02mi1),
    .ARPROTsi02mi  (ARPROTsi02mi1),


    //Read data channel
    .RIDmi2si0     (RIDmi12si0),
    .RRESPmi2si0   (RRESPmi12si0),
    .RDATAmi2si0   (RDATAmi12si0),

    //Master Number 2
    .ARIDsi12mi    (wARIDsi22mi1[SLAVE_MASTERID1_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi22mi1),
    .ARLENsi12mi   (ARLENsi22mi1),
    .ARSIZEsi12mi  (ARSIZEsi22mi1),
    .ARBURSTsi12mi (ARBURSTsi22mi1),
    .ARLOCKsi12mi  (ARLOCKsi22mi1),
    .ARCACHEsi12mi (ARCACHEsi22mi1),
    .ARPROTsi12mi  (ARPROTsi22mi1),


    //Read data channel
    .RIDmi2si1     (RIDmi12si2),
    .RRESPmi2si1   (RRESPmi12si2),
    .RDATAmi2si1   (RDATAmi12si2),

    
    .RVALIDmi2si  (RVALIDmi12si),
    .RLASTmi2si   (RLASTmi12si),
    .RREADYsi2mi  (RREADYsi2mi1),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi1),
    .UnLock2Rdmi    (UnLock2rdmi1),

    .Lock2Wrmi      (Lock2wrmi1),
    .UnLock2Wrmi    (UnLock2wrmi1),

    .AWVALID        (AWVALIDmi12s1),
    .LockPort       (LockPort2rdmi1),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi12Rdmi1),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi12Wrmi1),
    .CtlDataRead2Lock       (CtlDataRead2Lock1),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi1),
    .ARREADYmi2si  (ARREADYmi12si)
);

//Slave module 2    
//_____________________________________________________________________

AHB2_RS_ReadChannelmi
AHB2_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi22s2),
    .ARADDRmi2s  (ARADDRmi22s2),
    .ARLENmi2s   (ARLENmi22s2),
    .ARSIZEmi2s  (ARSIZEmi22s2),
    .ARBURSTmi2s (ARBURSTmi22s2),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi22s2),
    .ARREADYs2mi (ARREADYs22mi2),

    //Read data channel
    .RIDs2mi     (RIDs22mi2),
    .RRESPs2mi   (RRESPs22mi2),
    .RDATAs2mi   (RDATAs22mi2),
    .RVALIDs2mi  (RVALIDs22mi2),
    .RLASTs2mi   (RLASTs22mi2),
    .RREADYmi2s  (RREADYmi22s2),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi2),
    .ARLENsi02mi   (ARLENsi02mi2),
    .ARSIZEsi02mi  (ARSIZEsi02mi2),
    .ARBURSTsi02mi (ARBURSTsi02mi2),
    .ARLOCKsi02mi  (ARLOCKsi02mi2),
    .ARCACHEsi02mi (ARCACHEsi02mi2),
    .ARPROTsi02mi  (ARPROTsi02mi2),


    //Read data channel
    .RIDmi2si0     (RIDmi22si0),
    .RRESPmi2si0   (RRESPmi22si0),
    .RDATAmi2si0   (RDATAmi22si0),

    //Master Number 2
    .ARIDsi12mi    (wARIDsi22mi2[SLAVE_MASTERID2_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi22mi2),
    .ARLENsi12mi   (ARLENsi22mi2),
    .ARSIZEsi12mi  (ARSIZEsi22mi2),
    .ARBURSTsi12mi (ARBURSTsi22mi2),
    .ARLOCKsi12mi  (ARLOCKsi22mi2),
    .ARCACHEsi12mi (ARCACHEsi22mi2),
    .ARPROTsi12mi  (ARPROTsi22mi2),


    //Read data channel
    .RIDmi2si1     (RIDmi22si2),
    .RRESPmi2si1   (RRESPmi22si2),
    .RDATAmi2si1   (RDATAmi22si2),

    
    .RVALIDmi2si  (RVALIDmi22si),
    .RLASTmi2si   (RLASTmi22si),
    .RREADYsi2mi  (RREADYsi2mi2),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi2),
    .UnLock2Rdmi    (UnLock2rdmi2),

    .Lock2Wrmi      (Lock2wrmi2),
    .UnLock2Wrmi    (UnLock2wrmi2),

    .AWVALID        (AWVALIDmi22s2),
    .LockPort       (LockPort2rdmi2),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi22Rdmi2),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi22Wrmi2),
    .CtlDataRead2Lock       (CtlDataRead2Lock2),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi2),
    .ARREADYmi2si  (ARREADYmi22si)
);

//Slave module 3    
//_____________________________________________________________________

DDR_RS_ReadChannelmi
DDR_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi32s3),
    .ARADDRmi2s  (ARADDRmi32s3),
    .ARLENmi2s   (ARLENmi32s3),
    .ARSIZEmi2s  (ARSIZEmi32s3),
    .ARBURSTmi2s (ARBURSTmi32s3),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi32s3),
    .ARREADYs2mi (ARREADYs32mi3),

    //Read data channel
    .RIDs2mi     (RIDs32mi3),
    .RRESPs2mi   (RRESPs32mi3),
    .RDATAs2mi   (RDATAs32mi3),
    .RVALIDs2mi  (RVALIDs32mi3),
    .RLASTs2mi   (RLASTs32mi3),
    .RREADYmi2s  (RREADYmi32s3),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi3),
    .ARLENsi02mi   (ARLENsi02mi3),
    .ARSIZEsi02mi  (ARSIZEsi02mi3),
    .ARBURSTsi02mi (ARBURSTsi02mi3),
    .ARLOCKsi02mi  (ARLOCKsi02mi3),
    .ARCACHEsi02mi (ARCACHEsi02mi3),
    .ARPROTsi02mi  (ARPROTsi02mi3),


    //Read data channel
    .RIDmi2si0     (RIDmi32si0),
    .RRESPmi2si0   (RRESPmi32si0),
    .RDATAmi2si0   (RDATAmi32si0),

    //Master Number 1
    .ARIDsi12mi    (wARIDsi12mi3[SLAVE_MASTERID3_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi12mi3),
    .ARLENsi12mi   (ARLENsi12mi3),
    .ARSIZEsi12mi  (ARSIZEsi12mi3),
    .ARBURSTsi12mi (ARBURSTsi12mi3),
    .ARLOCKsi12mi  (ARLOCKsi12mi3),
    .ARCACHEsi12mi (ARCACHEsi12mi3),
    .ARPROTsi12mi  (ARPROTsi12mi3),


    //Read data channel
    .RIDmi2si1     (RIDmi32si1),
    .RRESPmi2si1   (RRESPmi32si1),
    .RDATAmi2si1   (RDATAmi32si1),

    //Master Number 2
    .ARIDsi22mi    (wARIDsi22mi3[SLAVE_MASTERID3_WID-1:0]),
    .ARADDRsi22mi  (ARADDRsi22mi3),
    .ARLENsi22mi   (ARLENsi22mi3),
    .ARSIZEsi22mi  (ARSIZEsi22mi3),
    .ARBURSTsi22mi (ARBURSTsi22mi3),
    .ARLOCKsi22mi  (ARLOCKsi22mi3),
    .ARCACHEsi22mi (ARCACHEsi22mi3),
    .ARPROTsi22mi  (ARPROTsi22mi3),


    //Read data channel
    .RIDmi2si2     (RIDmi32si2),
    .RRESPmi2si2   (RRESPmi32si2),
    .RDATAmi2si2   (RDATAmi32si2),

    //Master Number 3
    .ARIDsi32mi    (wARIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),
    .ARADDRsi32mi  (ARADDRsi32mi3),
    .ARLENsi32mi   (ARLENsi32mi3),
    .ARSIZEsi32mi  (ARSIZEsi32mi3),
    .ARBURSTsi32mi (ARBURSTsi32mi3),
    .ARLOCKsi32mi  (ARLOCKsi32mi3),
    .ARCACHEsi32mi (ARCACHEsi32mi3),
    .ARPROTsi32mi  (ARPROTsi32mi3),


    //Read data channel
    .RIDmi2si3     (RIDmi32si3),
    .RRESPmi2si3   (RRESPmi32si3),
    .RDATAmi2si3   (RDATAmi32si3),

    //Master Number 4
    .ARIDsi42mi    (wARIDsi42mi3[SLAVE_MASTERID3_WID-1:0]),
    .ARADDRsi42mi  (ARADDRsi42mi3),
    .ARLENsi42mi   (ARLENsi42mi3),
    .ARSIZEsi42mi  (ARSIZEsi42mi3),
    .ARBURSTsi42mi (ARBURSTsi42mi3),
    .ARLOCKsi42mi  (ARLOCKsi42mi3),
    .ARCACHEsi42mi (ARCACHEsi42mi3),
    .ARPROTsi42mi  (ARPROTsi42mi3),


    //Read data channel
    .RIDmi2si4     (RIDmi32si4),
    .RRESPmi2si4   (RRESPmi32si4),
    .RDATAmi2si4   (RDATAmi32si4),

    
    .RVALIDmi2si  (RVALIDmi32si),
    .RLASTmi2si   (RLASTmi32si),
    .RREADYsi2mi  (RREADYsi2mi3),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi3),
    .UnLock2Rdmi    (UnLock2rdmi3),

    .Lock2Wrmi      (Lock2wrmi3),
    .UnLock2Wrmi    (UnLock2wrmi3),

    .AWVALID        (AWVALIDmi32s3),
    .LockPort       (LockPort2rdmi3),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi32Rdmi3),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi32Wrmi3),
    .CtlDataRead2Lock       (CtlDataRead2Lock3),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi3),
    .ARREADYmi2si  (ARREADYmi32si)
);

//Slave module 4    
//_____________________________________________________________________

APB0_RS_ReadChannelmi
APB0_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi42s4),
    .ARADDRmi2s  (ARADDRmi42s4),
    .ARLENmi2s   (ARLENmi42s4),
    .ARSIZEmi2s  (ARSIZEmi42s4),
    .ARBURSTmi2s (ARBURSTmi42s4),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi42s4),
    .ARREADYs2mi (ARREADYs42mi4),

    //Read data channel
    .RIDs2mi     (RIDs42mi4),
    .RRESPs2mi   (RRESPs42mi4),
    .RDATAs2mi   (RDATAs42mi4),
    .RVALIDs2mi  (RVALIDs42mi4),
    .RLASTs2mi   (RLASTs42mi4),
    .RREADYmi2s  (RREADYmi42s4),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi4),
    .ARLENsi02mi   (ARLENsi02mi4),
    .ARSIZEsi02mi  (ARSIZEsi02mi4),
    .ARBURSTsi02mi (ARBURSTsi02mi4),
    .ARLOCKsi02mi  (ARLOCKsi02mi4),
    .ARCACHEsi02mi (ARCACHEsi02mi4),
    .ARPROTsi02mi  (ARPROTsi02mi4),


    //Read data channel
    .RIDmi2si0     (RIDmi42si0),
    .RRESPmi2si0   (RRESPmi42si0),
    .RDATAmi2si0   (RDATAmi42si0),

    //Master Number 2
    .ARIDsi12mi    (wARIDsi22mi4[SLAVE_MASTERID4_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi22mi4),
    .ARLENsi12mi   (ARLENsi22mi4),
    .ARSIZEsi12mi  (ARSIZEsi22mi4),
    .ARBURSTsi12mi (ARBURSTsi22mi4),
    .ARLOCKsi12mi  (ARLOCKsi22mi4),
    .ARCACHEsi12mi (ARCACHEsi22mi4),
    .ARPROTsi12mi  (ARPROTsi22mi4),


    //Read data channel
    .RIDmi2si1     (RIDmi42si2),
    .RRESPmi2si1   (RRESPmi42si2),
    .RDATAmi2si1   (RDATAmi42si2),

    
    .RVALIDmi2si  (RVALIDmi42si),
    .RLASTmi2si   (RLASTmi42si),
    .RREADYsi2mi  (RREADYsi2mi4),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi4),
    .UnLock2Rdmi    (UnLock2rdmi4),

    .Lock2Wrmi      (Lock2wrmi4),
    .UnLock2Wrmi    (UnLock2wrmi4),

    .AWVALID        (AWVALIDmi42s4),
    .LockPort       (LockPort2rdmi4),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi42Rdmi4),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi42Wrmi4),
    .CtlDataRead2Lock       (CtlDataRead2Lock4),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi4),
    .ARREADYmi2si  (ARREADYmi42si)
);

//Slave module 5    
//_____________________________________________________________________

APB1_RS_ReadChannelmi
APB1_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi52s5),
    .ARADDRmi2s  (ARADDRmi52s5),
    .ARLENmi2s   (ARLENmi52s5),
    .ARSIZEmi2s  (ARSIZEmi52s5),
    .ARBURSTmi2s (ARBURSTmi52s5),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi52s5),
    .ARREADYs2mi (ARREADYs52mi5),

    //Read data channel
    .RIDs2mi     (RIDs52mi5),
    .RRESPs2mi   (RRESPs52mi5),
    .RDATAs2mi   (RDATAs52mi5),
    .RVALIDs2mi  (RVALIDs52mi5),
    .RLASTs2mi   (RLASTs52mi5),
    .RREADYmi2s  (RREADYmi52s5),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi5),
    .ARLENsi02mi   (ARLENsi02mi5),
    .ARSIZEsi02mi  (ARSIZEsi02mi5),
    .ARBURSTsi02mi (ARBURSTsi02mi5),
    .ARLOCKsi02mi  (ARLOCKsi02mi5),
    .ARCACHEsi02mi (ARCACHEsi02mi5),
    .ARPROTsi02mi  (ARPROTsi02mi5),


    //Read data channel
    .RIDmi2si0     (RIDmi52si0),
    .RRESPmi2si0   (RRESPmi52si0),
    .RDATAmi2si0   (RDATAmi52si0),

    //Master Number 2
    .ARIDsi12mi    (wARIDsi22mi5[SLAVE_MASTERID5_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi22mi5),
    .ARLENsi12mi   (ARLENsi22mi5),
    .ARSIZEsi12mi  (ARSIZEsi22mi5),
    .ARBURSTsi12mi (ARBURSTsi22mi5),
    .ARLOCKsi12mi  (ARLOCKsi22mi5),
    .ARCACHEsi12mi (ARCACHEsi22mi5),
    .ARPROTsi12mi  (ARPROTsi22mi5),


    //Read data channel
    .RIDmi2si1     (RIDmi52si2),
    .RRESPmi2si1   (RRESPmi52si2),
    .RDATAmi2si1   (RDATAmi52si2),

    
    .RVALIDmi2si  (RVALIDmi52si),
    .RLASTmi2si   (RLASTmi52si),
    .RREADYsi2mi  (RREADYsi2mi5),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi5),
    .UnLock2Rdmi    (UnLock2rdmi5),

    .Lock2Wrmi      (Lock2wrmi5),
    .UnLock2Wrmi    (UnLock2wrmi5),

    .AWVALID        (AWVALIDmi52s5),
    .LockPort       (LockPort2rdmi5),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi52Rdmi5),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi52Wrmi5),
    .CtlDataRead2Lock       (CtlDataRead2Lock5),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi5),
    .ARREADYmi2si  (ARREADYmi52si)
);

//Slave module 6    
//_____________________________________________________________________

SMC_RS_ReadChannelmi
SMC_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi62s6),
    .ARADDRmi2s  (ARADDRmi62s6),
    .ARLENmi2s   (ARLENmi62s6),
    .ARSIZEmi2s  (ARSIZEmi62s6),
    .ARBURSTmi2s (ARBURSTmi62s6),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi62s6),
    .ARREADYs2mi (ARREADYs62mi6),

    //Read data channel
    .RIDs2mi     (RIDs62mi6),
    .RRESPs2mi   (RRESPs62mi6),
    .RDATAs2mi   (RDATAs62mi6),
    .RVALIDs2mi  (RVALIDs62mi6),
    .RLASTs2mi   (RLASTs62mi6),
    .RREADYmi2s  (RREADYmi62s6),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi6[SLAVE_MASTERID6_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi6),
    .ARLENsi02mi   (ARLENsi02mi6),
    .ARSIZEsi02mi  (ARSIZEsi02mi6),
    .ARBURSTsi02mi (ARBURSTsi02mi6),
    .ARLOCKsi02mi  (ARLOCKsi02mi6),
    .ARCACHEsi02mi (ARCACHEsi02mi6),
    .ARPROTsi02mi  (ARPROTsi02mi6),


    //Read data channel
    .RIDmi2si0     (RIDmi62si0),
    .RRESPmi2si0   (RRESPmi62si0),
    .RDATAmi2si0   (RDATAmi62si0),

    //Master Number 1
    .ARIDsi12mi    (wARIDsi12mi6[SLAVE_MASTERID6_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi12mi6),
    .ARLENsi12mi   (ARLENsi12mi6),
    .ARSIZEsi12mi  (ARSIZEsi12mi6),
    .ARBURSTsi12mi (ARBURSTsi12mi6),
    .ARLOCKsi12mi  (ARLOCKsi12mi6),
    .ARCACHEsi12mi (ARCACHEsi12mi6),
    .ARPROTsi12mi  (ARPROTsi12mi6),


    //Read data channel
    .RIDmi2si1     (RIDmi62si1),
    .RRESPmi2si1   (RRESPmi62si1),
    .RDATAmi2si1   (RDATAmi62si1),

    //Master Number 2
    .ARIDsi22mi    (wARIDsi22mi6[SLAVE_MASTERID6_WID-1:0]),
    .ARADDRsi22mi  (ARADDRsi22mi6),
    .ARLENsi22mi   (ARLENsi22mi6),
    .ARSIZEsi22mi  (ARSIZEsi22mi6),
    .ARBURSTsi22mi (ARBURSTsi22mi6),
    .ARLOCKsi22mi  (ARLOCKsi22mi6),
    .ARCACHEsi22mi (ARCACHEsi22mi6),
    .ARPROTsi22mi  (ARPROTsi22mi6),


    //Read data channel
    .RIDmi2si2     (RIDmi62si2),
    .RRESPmi2si2   (RRESPmi62si2),
    .RDATAmi2si2   (RDATAmi62si2),

    //Master Number 3
    .ARIDsi32mi    (wARIDsi32mi6[SLAVE_MASTERID6_WID-1:0]),
    .ARADDRsi32mi  (ARADDRsi32mi6),
    .ARLENsi32mi   (ARLENsi32mi6),
    .ARSIZEsi32mi  (ARSIZEsi32mi6),
    .ARBURSTsi32mi (ARBURSTsi32mi6),
    .ARLOCKsi32mi  (ARLOCKsi32mi6),
    .ARCACHEsi32mi (ARCACHEsi32mi6),
    .ARPROTsi32mi  (ARPROTsi32mi6),


    //Read data channel
    .RIDmi2si3     (RIDmi62si3),
    .RRESPmi2si3   (RRESPmi62si3),
    .RDATAmi2si3   (RDATAmi62si3),

    //Master Number 4
    .ARIDsi42mi    (wARIDsi42mi6[SLAVE_MASTERID6_WID-1:0]),
    .ARADDRsi42mi  (ARADDRsi42mi6),
    .ARLENsi42mi   (ARLENsi42mi6),
    .ARSIZEsi42mi  (ARSIZEsi42mi6),
    .ARBURSTsi42mi (ARBURSTsi42mi6),
    .ARLOCKsi42mi  (ARLOCKsi42mi6),
    .ARCACHEsi42mi (ARCACHEsi42mi6),
    .ARPROTsi42mi  (ARPROTsi42mi6),


    //Read data channel
    .RIDmi2si4     (RIDmi62si4),
    .RRESPmi2si4   (RRESPmi62si4),
    .RDATAmi2si4   (RDATAmi62si4),

    
    .RVALIDmi2si  (RVALIDmi62si),
    .RLASTmi2si   (RLASTmi62si),
    .RREADYsi2mi  (RREADYsi2mi6),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi6),
    .UnLock2Rdmi    (UnLock2rdmi6),

    .Lock2Wrmi      (Lock2wrmi6),
    .UnLock2Wrmi    (UnLock2wrmi6),

    .AWVALID        (AWVALIDmi62s6),
    .LockPort       (LockPort2rdmi6),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi62Rdmi6),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi62Wrmi6),
    .CtlDataRead2Lock       (CtlDataRead2Lock6),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi6),
    .ARREADYmi2si  (ARREADYmi62si)
);

//Slave module 7    
//_____________________________________________________________________

SSRAM_RS_ReadChannelmi
SSRAM_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi72s7),
    .ARADDRmi2s  (ARADDRmi72s7),
    .ARLENmi2s   (ARLENmi72s7),
    .ARSIZEmi2s  (ARSIZEmi72s7),
    .ARBURSTmi2s (ARBURSTmi72s7),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi72s7),
    .ARREADYs2mi (ARREADYs72mi7),

    //Read data channel
    .RIDs2mi     (RIDs72mi7),
    .RRESPs2mi   (RRESPs72mi7),
    .RDATAs2mi   (RDATAs72mi7),
    .RVALIDs2mi  (RVALIDs72mi7),
    .RLASTs2mi   (RLASTs72mi7),
    .RREADYmi2s  (RREADYmi72s7),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi7[SLAVE_MASTERID7_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi7),
    .ARLENsi02mi   (ARLENsi02mi7),
    .ARSIZEsi02mi  (ARSIZEsi02mi7),
    .ARBURSTsi02mi (ARBURSTsi02mi7),
    .ARLOCKsi02mi  (ARLOCKsi02mi7),
    .ARCACHEsi02mi (ARCACHEsi02mi7),
    .ARPROTsi02mi  (ARPROTsi02mi7),


    //Read data channel
    .RIDmi2si0     (RIDmi72si0),
    .RRESPmi2si0   (RRESPmi72si0),
    .RDATAmi2si0   (RDATAmi72si0),

    //Master Number 1
    .ARIDsi12mi    (wARIDsi12mi7[SLAVE_MASTERID7_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi12mi7),
    .ARLENsi12mi   (ARLENsi12mi7),
    .ARSIZEsi12mi  (ARSIZEsi12mi7),
    .ARBURSTsi12mi (ARBURSTsi12mi7),
    .ARLOCKsi12mi  (ARLOCKsi12mi7),
    .ARCACHEsi12mi (ARCACHEsi12mi7),
    .ARPROTsi12mi  (ARPROTsi12mi7),


    //Read data channel
    .RIDmi2si1     (RIDmi72si1),
    .RRESPmi2si1   (RRESPmi72si1),
    .RDATAmi2si1   (RDATAmi72si1),

    //Master Number 2
    .ARIDsi22mi    (wARIDsi22mi7[SLAVE_MASTERID7_WID-1:0]),
    .ARADDRsi22mi  (ARADDRsi22mi7),
    .ARLENsi22mi   (ARLENsi22mi7),
    .ARSIZEsi22mi  (ARSIZEsi22mi7),
    .ARBURSTsi22mi (ARBURSTsi22mi7),
    .ARLOCKsi22mi  (ARLOCKsi22mi7),
    .ARCACHEsi22mi (ARCACHEsi22mi7),
    .ARPROTsi22mi  (ARPROTsi22mi7),


    //Read data channel
    .RIDmi2si2     (RIDmi72si2),
    .RRESPmi2si2   (RRESPmi72si2),
    .RDATAmi2si2   (RDATAmi72si2),

    //Master Number 3
    .ARIDsi32mi    (wARIDsi32mi7[SLAVE_MASTERID7_WID-1:0]),
    .ARADDRsi32mi  (ARADDRsi32mi7),
    .ARLENsi32mi   (ARLENsi32mi7),
    .ARSIZEsi32mi  (ARSIZEsi32mi7),
    .ARBURSTsi32mi (ARBURSTsi32mi7),
    .ARLOCKsi32mi  (ARLOCKsi32mi7),
    .ARCACHEsi32mi (ARCACHEsi32mi7),
    .ARPROTsi32mi  (ARPROTsi32mi7),


    //Read data channel
    .RIDmi2si3     (RIDmi72si3),
    .RRESPmi2si3   (RRESPmi72si3),
    .RDATAmi2si3   (RDATAmi72si3),

    //Master Number 4
    .ARIDsi42mi    (wARIDsi42mi7[SLAVE_MASTERID7_WID-1:0]),
    .ARADDRsi42mi  (ARADDRsi42mi7),
    .ARLENsi42mi   (ARLENsi42mi7),
    .ARSIZEsi42mi  (ARSIZEsi42mi7),
    .ARBURSTsi42mi (ARBURSTsi42mi7),
    .ARLOCKsi42mi  (ARLOCKsi42mi7),
    .ARCACHEsi42mi (ARCACHEsi42mi7),
    .ARPROTsi42mi  (ARPROTsi42mi7),


    //Read data channel
    .RIDmi2si4     (RIDmi72si4),
    .RRESPmi2si4   (RRESPmi72si4),
    .RDATAmi2si4   (RDATAmi72si4),

    
    .RVALIDmi2si  (RVALIDmi72si),
    .RLASTmi2si   (RLASTmi72si),
    .RREADYsi2mi  (RREADYsi2mi7),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi7),
    .UnLock2Rdmi    (UnLock2rdmi7),

    .Lock2Wrmi      (Lock2wrmi7),
    .UnLock2Wrmi    (UnLock2wrmi7),

    .AWVALID        (AWVALIDmi72s7),
    .LockPort       (LockPort2rdmi7),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi72Rdmi7),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi72Wrmi7),
    .CtlDataRead2Lock       (CtlDataRead2Lock7),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi7),
    .ARREADYmi2si  (ARREADYmi72si)
);

//Slave module 8    
//_____________________________________________________________________

default_RS_ReadChannelmi
default_RS_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Read address channel
    .ARIDmi2s    (ARIDmi82s8),
    .ARADDRmi2s  (ARADDRmi82s8),
    .ARLENmi2s   (ARLENmi82s8),
    .ARSIZEmi2s  (ARSIZEmi82s8),
    .ARBURSTmi2s (ARBURSTmi82s8),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .ARVALIDmi2s (ARVALIDmi82s8),
    .ARREADYs2mi (ARREADYs82mi8),

    //Read data channel
    .RIDs2mi     (RIDs82mi8),
    .RRESPs2mi   (RRESPs82mi8),
    .RDATAs2mi   (RDATAs82mi8),
    .RVALIDs2mi  (RVALIDs82mi8),
    .RLASTs2mi   (RLASTs82mi8),
    .RREADYmi2s  (RREADYmi82s8),
    //////////////////////////////////////////////


    //Master Number 0
    .ARIDsi02mi    (wARIDsi02mi8[SLAVE_MASTERID8_WID-1:0]),
    .ARADDRsi02mi  (ARADDRsi02mi8),
    .ARLENsi02mi   (ARLENsi02mi8),
    .ARSIZEsi02mi  (ARSIZEsi02mi8),
    .ARBURSTsi02mi (ARBURSTsi02mi8),
    .ARLOCKsi02mi  (ARLOCKsi02mi8),
    .ARCACHEsi02mi (ARCACHEsi02mi8),
    .ARPROTsi02mi  (ARPROTsi02mi8),


    //Read data channel
    .RIDmi2si0     (RIDmi82si0),
    .RRESPmi2si0   (RRESPmi82si0),
    .RDATAmi2si0   (RDATAmi82si0),

    //Master Number 1
    .ARIDsi12mi    (wARIDsi12mi8[SLAVE_MASTERID8_WID-1:0]),
    .ARADDRsi12mi  (ARADDRsi12mi8),
    .ARLENsi12mi   (ARLENsi12mi8),
    .ARSIZEsi12mi  (ARSIZEsi12mi8),
    .ARBURSTsi12mi (ARBURSTsi12mi8),
    .ARLOCKsi12mi  (ARLOCKsi12mi8),
    .ARCACHEsi12mi (ARCACHEsi12mi8),
    .ARPROTsi12mi  (ARPROTsi12mi8),


    //Read data channel
    .RIDmi2si1     (RIDmi82si1),
    .RRESPmi2si1   (RRESPmi82si1),
    .RDATAmi2si1   (RDATAmi82si1),

    //Master Number 2
    .ARIDsi22mi    (wARIDsi22mi8[SLAVE_MASTERID8_WID-1:0]),
    .ARADDRsi22mi  (ARADDRsi22mi8),
    .ARLENsi22mi   (ARLENsi22mi8),
    .ARSIZEsi22mi  (ARSIZEsi22mi8),
    .ARBURSTsi22mi (ARBURSTsi22mi8),
    .ARLOCKsi22mi  (ARLOCKsi22mi8),
    .ARCACHEsi22mi (ARCACHEsi22mi8),
    .ARPROTsi22mi  (ARPROTsi22mi8),


    //Read data channel
    .RIDmi2si2     (RIDmi82si2),
    .RRESPmi2si2   (RRESPmi82si2),
    .RDATAmi2si2   (RDATAmi82si2),

    //Master Number 3
    .ARIDsi32mi    (wARIDsi32mi8[SLAVE_MASTERID8_WID-1:0]),
    .ARADDRsi32mi  (ARADDRsi32mi8),
    .ARLENsi32mi   (ARLENsi32mi8),
    .ARSIZEsi32mi  (ARSIZEsi32mi8),
    .ARBURSTsi32mi (ARBURSTsi32mi8),
    .ARLOCKsi32mi  (ARLOCKsi32mi8),
    .ARCACHEsi32mi (ARCACHEsi32mi8),
    .ARPROTsi32mi  (ARPROTsi32mi8),


    //Read data channel
    .RIDmi2si3     (RIDmi82si3),
    .RRESPmi2si3   (RRESPmi82si3),
    .RDATAmi2si3   (RDATAmi82si3),

    //Master Number 4
    .ARIDsi42mi    (wARIDsi42mi8[SLAVE_MASTERID8_WID-1:0]),
    .ARADDRsi42mi  (ARADDRsi42mi8),
    .ARLENsi42mi   (ARLENsi42mi8),
    .ARSIZEsi42mi  (ARSIZEsi42mi8),
    .ARBURSTsi42mi (ARBURSTsi42mi8),
    .ARLOCKsi42mi  (ARLOCKsi42mi8),
    .ARCACHEsi42mi (ARCACHEsi42mi8),
    .ARPROTsi42mi  (ARPROTsi42mi8),


    //Read data channel
    .RIDmi2si4     (RIDmi82si4),
    .RRESPmi2si4   (RRESPmi82si4),
    .RDATAmi2si4   (RDATAmi82si4),

    
    .RVALIDmi2si  (RVALIDmi82si),
    .RLASTmi2si   (RLASTmi82si),
    .RREADYsi2mi  (RREADYsi2mi8),

    //Lock access
    ////////////////////////////////////////

    .Lock2Rdmi      (Lock2rdmi8),
    .UnLock2Rdmi    (UnLock2rdmi8),

    .Lock2Wrmi      (Lock2wrmi8),
    .UnLock2Wrmi    (UnLock2wrmi8),

    .AWVALID        (AWVALIDmi82s8),
    .LockPort       (LockPort2rdmi8),
    .ReadIntEmptyWrmi2Rdmi  (ReadIntEmptyWrmi82Rdmi8),
    .DataCntEmptyRdmi2Wrmi  (DataCntEmptyRdmi82Wrmi8),
    .CtlDataRead2Lock       (CtlDataRead2Lock8),

    ////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .ARVALIDsi2mi  (ARVALIDsi2mi8),
    .ARREADYmi2si  (ARREADYmi82si)
);

endmodule
