// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelmi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel Master Interface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  MAC_RS_ReadChannelsi(

    SelMAP1,

    //Global signal
    ACLK    ,
    ARESETn ,

    //Read address channel
    ARADDRm2si  ,
    ARLENm2si   ,
    ARSIZEm2si  ,
    ARBURSTm2si ,
    ARVALIDm2si ,
    ARREADYsi2m ,

    //Read data channel
    RRESPsi2m   ,
    RVALIDsi2m  ,
    RDATAsi2m   ,
    RREADYm2si  ,
    RLASTsi2m   ,

    
    //For Master interface slave Number = 3
    //Read address channel
    ARIDsi2mi3    ,
    ARADDRsi2mi3  ,
    ARLENsi2mi3   ,
    ARSIZEsi2mi3  ,
    ARBURSTsi2mi3 ,
    ARLOCKsi2mi3  ,
    ARCACHEsi2mi3 ,
    ARPROTsi2mi3  ,
    
    //For Master interface slave Number = 6
    //Read address channel
    ARIDsi2mi6    ,
    ARADDRsi2mi6  ,
    ARLENsi2mi6   ,
    ARSIZEsi2mi6  ,
    ARBURSTsi2mi6 ,
    ARLOCKsi2mi6  ,
    ARCACHEsi2mi6 ,
    ARPROTsi2mi6  ,
    
    //For Master interface slave Number = 7
    //Read address channel
    ARIDsi2mi7    ,
    ARADDRsi2mi7  ,
    ARLENsi2mi7   ,
    ARSIZEsi2mi7  ,
    ARBURSTsi2mi7 ,
    ARLOCKsi2mi7  ,
    ARCACHEsi2mi7 ,
    ARPROTsi2mi7  ,

//Default Slave Number = 8    
    //For Master interface slave Number = 8
    //Read address channel
    ARIDsi2mi8    ,
    ARADDRsi2mi8  ,
    ARLENsi2mi8   ,
    ARSIZEsi2mi8  ,
    ARBURSTsi2mi8 ,
    ARLOCKsi2mi8  ,
    ARCACHEsi2mi8 ,
    ARPROTsi2mi8  ,
////////////////////////////

    ARVALIDsi2mi ,
    ARREADYmi2si ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    
    //Slave3
    //Read data channel
    //____________________________________
    RIDmi32si     ,
    RRESPmi32si   ,
    RDATAmi32si   ,

    
    //Slave6
    //Read data channel
    //____________________________________
    RIDmi62si     ,
    RRESPmi62si   ,
    RDATAmi62si   ,

    
    //Slave7
    //Read data channel
    //____________________________________
    RIDmi72si     ,
    RRESPmi72si   ,
    RDATAmi72si   ,


//Default Slave Number = 8    
    //Slave8
    //Read data channel
    //____________________________________
    RIDmi82si     ,
    RRESPmi82si   ,
    RDATAmi82si   ,

////////////////////////////

    RVALIDmi2si  ,
    RREADYsi2mi  ,
    RLASTmi2si
);

parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 4;
parameter SLAVE_NUM= 9;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

    input   SelMAP1;

    input   ACLK;
    input   ARESETn;

    //Read Address channel
    input   [ADDR_WID-1:0]     ARADDRm2si;
    input   [ARLEN_WID-1:0]    ARLENm2si;
    input   [ARSIZE_WID-1:0]   ARSIZEm2si;  
    input   [ARBURST_WID-1:0]  ARBURSTm2si; 
    wire   [MASTERID_WID-1:0] ARIDm2si = 1'b0;
    input   ARVALIDm2si; 
    output  ARREADYsi2m; 

    //Read data channel
     wire    [MASTERID_WID-1:0] RIDsi2m;
    output   [RRESP_WID-1:0]   RRESPsi2m;   
    output   [BUS_WID-1:0]     RDATAsi2m;
    output   RVALIDsi2m;  
    input    RREADYm2si;  
    output   RLASTsi2m;   

    //For Master interface SlaveNum = 3
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi3;    
    output  [ADDR_WID-1:0] ARADDRsi2mi3;  
    output  [ARLEN_WID-1:0] ARLENsi2mi3;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi3;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi3; 
//Disable_LockPortReadChannel(master)
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi3;  
    assign  ARLOCKsi2mi3 = {ARLOCK_WID{1'b0}};  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi3; 
    assign  ARCACHEsi2mi3 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi3;  
    assign  ARPROTsi2mi3 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 6
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi6;    
    output  [ADDR_WID-1:0] ARADDRsi2mi6;  
    output  [ARLEN_WID-1:0] ARLENsi2mi6;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi6;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi6; 
//Disable_LockPortReadChannel(master)
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi6;  
    assign  ARLOCKsi2mi6 = {ARLOCK_WID{1'b0}};  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi6; 
    assign  ARCACHEsi2mi6 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi6;  
    assign  ARPROTsi2mi6 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 7
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi7;    
    output  [ADDR_WID-1:0] ARADDRsi2mi7;  
    output  [ARLEN_WID-1:0] ARLENsi2mi7;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi7;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi7; 
//Disable_LockPortReadChannel(master)
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi7;  
    assign  ARLOCKsi2mi7 = {ARLOCK_WID{1'b0}};  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi7; 
    assign  ARCACHEsi2mi7 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi7;  
    assign  ARPROTsi2mi7 = {ARPROT_WID{1'b0}};  


//Default Slave Number = 8    //For Master interface SlaveNum = 8
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi8;    
    output  [ADDR_WID-1:0] ARADDRsi2mi8;  
    output  [ARLEN_WID-1:0] ARLENsi2mi8;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi8;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi8; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi8;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi8; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi8;  

////////////////////////////

    output  [SLAVE_NUM-1:0]ARVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]ARREADYmi2si; 

    //From SI(slave interface)
    
    //Slave3
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi32si;     
    input   [RRESP_WID-1:0] RRESPmi32si;   
    input   [BUS_WID-1:0]   RDATAmi32si;

    
    //Slave6
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi62si;     
    input   [RRESP_WID-1:0] RRESPmi62si;   
    input   [BUS_WID-1:0]   RDATAmi62si;

    
    //Slave7
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi72si;     
    input   [RRESP_WID-1:0] RRESPmi72si;   
    input   [BUS_WID-1:0]   RDATAmi72si;


//Default Slave Number = 8    
    //Slave8
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi82si;     
    input   [RRESP_WID-1:0] RRESPmi82si;   
    input   [BUS_WID-1:0]   RDATAmi82si;

////////////////////////////

    input   [SLAVE_NUM-1:0] RVALIDmi2si;  
    input   [SLAVE_NUM-1:0] RLASTmi2si;  
    output  [SLAVE_NUM-1:0] RREADYsi2mi;    

    
//_______________________________________RS Number = 0
//
    
    //for register slice
    wire   [MASTERID_WID-1:0] w0ARIDm2si;    
    wire   [ADDR_WID-1:0]     w0ARADDRm2si;
    wire   [ARLEN_WID-1:0]    w0ARLENm2si;
    wire   [ARSIZE_WID-1:0]   w0ARSIZEm2si;  
    wire   [ARBURST_WID-1:0]  w0ARBURSTm2si; 
    wire   [ARLOCK_WID-1:0]   w0ARLOCKm2si;  
    wire   [ARCACHE_WID-1:0]  w0ARCACHEm2si; 
    wire   [ARPROT_WID-1:0]   w0ARPROTm2si;  
    wire   w0ARVALIDm2si; 
    wire   w0ARREADYsi2m; 

    //Read data channel
    wire   [MASTERID_WID-1:0]w0RIDsi2m;     
    wire   [RRESP_WID-1:0]   w0RRESPsi2m;   
    wire   [BUS_WID-1:0]     w0RDATAsi2m;
    wire   w0RVALIDsi2m;  
    wire   w0RREADYm2si;  
    wire   w0RLASTsi2m;   



//Mater to Slave interface register slice 
//Number == 0
//_________________________________________

MAC_ARSIm2si_registered
MAC_0_ARSIm2si_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 
		.INFORMATION_S({ ARIDm2si, 
                         ARLENm2si, 
                         ARSIZEm2si,  
                         ARBURSTm2si, 
                         ARADDRm2si 
                        }),

		.VALID_S      ( ARVALIDm2si),
		.READY_S      ( ARREADYsi2m),

		.INFORMATION_R({w0ARIDm2si, 
                        w0ARLENm2si, 
                        w0ARSIZEm2si,  
                        w0ARBURSTm2si, 
                        w0ARADDRm2si 
                        }),

		.VALID_R      (w0ARVALIDm2si),
		.READY_R      (w0ARREADYsi2m)
);

//Read data channel
MAC_RDSIm2si_registered
MAC_0_RDSIm2si_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 

		.INFORMATION_R({ RIDsi2m, 
                         RRESPsi2m, 
                         RDATAsi2m, 
                         RLASTsi2m }),

		.VALID_R      ( RVALIDsi2m),
		.READY_R      ( RREADYm2si),

		.INFORMATION_S({w0RIDsi2m, 
                        w0RRESPsi2m, 
                        w0RDATAsi2m, 
                        w0RLASTsi2m }), 

		.VALID_S      (w0RVALIDsi2m),
		.READY_S      (w0RREADYm2si)
);

//////////////////////////////////////////////////



//////////////////////////////////////////////////





//Master module     
//__________________________________________________

MAC_ReadChannelsi
MAC_ReadChannelsi(



    //Read address channel
    .ARIDm2si    (1'b0),
    .ARADDRm2si  (w0ARADDRm2si  ),
    .ARLENm2si   (w0ARLENm2si   ),
    .ARSIZEm2si  (w0ARSIZEm2si  ),
    .ARBURSTm2si (w0ARBURSTm2si ),
    .ARLOCKm2si  ({ARLOCK_WID{1'b0}}),
    .ARCACHEm2si ({ARCACHE_WID{1'b0}}),
    .ARPROTm2si  ({ARPROT_WID{1'b0}}),

    .ARVALIDm2si (w0ARVALIDm2si ),
    .ARREADYsi2m (w0ARREADYsi2m ),

    //Read data channel
    .RIDsi2m     (w0RIDsi2m     ),
    .RRESPsi2m   (w0RRESPsi2m   ),
    .RVALIDsi2m  (w0RVALIDsi2m  ),
    .RDATAsi2m   (w0RDATAsi2m   ),
    .RREADYm2si  (w0RREADYm2si  ),
    .RLASTsi2m   (w0RLASTsi2m   ),

    .ARVALIDsi2mi ( ARVALIDsi2mi ),
    .ARREADYmi2si ( ARREADYmi2si ),
    .RVALIDmi2si  ( RVALIDmi2si  ),
    .RREADYsi2mi  ( RREADYsi2mi  ),
    .RLASTmi2si   ( RLASTmi2si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 3
    //Write address channel

    .ARIDsi2mi3    ( ARIDsi2mi3   ),
    .ARADDRsi2mi3  ( ARADDRsi2mi3 ),
    .ARLENsi2mi3   ( ARLENsi2mi3  ),
    .ARSIZEsi2mi3  ( ARSIZEsi2mi3 ),
    .ARBURSTsi2mi3 ( ARBURSTsi2mi3),
//Disable_LockPortReadChannel(master)
    .ARLOCKsi2mi3  ( ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi3 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi3  ( ),

    .RIDmi32si     ( RIDmi32si     ),
    .RRESPmi32si   ( RRESPmi32si   ),
    .RDATAmi32si   ( RDATAmi32si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 6
    //Write address channel

    .ARIDsi2mi6    ( ARIDsi2mi6   ),
    .ARADDRsi2mi6  ( ARADDRsi2mi6 ),
    .ARLENsi2mi6   ( ARLENsi2mi6  ),
    .ARSIZEsi2mi6  ( ARSIZEsi2mi6 ),
    .ARBURSTsi2mi6 ( ARBURSTsi2mi6),
//Disable_LockPortReadChannel(master)
    .ARLOCKsi2mi6  ( ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi6 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi6  ( ),

    .RIDmi62si     ( RIDmi62si     ),
    .RRESPmi62si   ( RRESPmi62si   ),
    .RDATAmi62si   ( RDATAmi62si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 7
    //Write address channel

    .ARIDsi2mi7    ( ARIDsi2mi7   ),
    .ARADDRsi2mi7  ( ARADDRsi2mi7 ),
    .ARLENsi2mi7   ( ARLENsi2mi7  ),
    .ARSIZEsi2mi7  ( ARSIZEsi2mi7 ),
    .ARBURSTsi2mi7 ( ARBURSTsi2mi7),
//Disable_LockPortReadChannel(master)
    .ARLOCKsi2mi7  ( ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi7 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi7  ( ),

    .RIDmi72si     ( RIDmi72si     ),
    .RRESPmi72si   ( RRESPmi72si   ),
    .RDATAmi72si   ( RDATAmi72si   ),


//Default Slave Number = 8    ///////////////////////////////////////////////
    //For Master interface  slave Number = 8
    //Write address channel

    .ARIDsi2mi8    ( ARIDsi2mi8   ),
    .ARADDRsi2mi8  ( ARADDRsi2mi8 ),
    .ARLENsi2mi8   ( ARLENsi2mi8  ),
    .ARSIZEsi2mi8  ( ARSIZEsi2mi8 ),
    .ARBURSTsi2mi8 ( ARBURSTsi2mi8),
//Disable_LockPortReadChannel(master)
    .ARLOCKsi2mi8  ( ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi8 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi8  ( ),

    .RIDmi82si     ( RIDmi82si     ),
    .RRESPmi82si   ( RRESPmi82si   ),
    .RDATAmi82si   ( RDATAmi82si   ),

////////////////////////////
    
    //Global signal

    .ACLK    (ACLK    ),
    .ARESETn (ARESETn ),
    .SelMAP1 (SelMAP1)

);
endmodule
//STATE_END
