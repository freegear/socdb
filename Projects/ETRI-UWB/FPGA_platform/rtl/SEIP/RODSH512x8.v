
module RODSH512x8 (CLK, CEN, A, Q);
input	CLK, CEN;
input	[8:0]	A;
output	[7:0]	Q;
reg		[7:0]	Q;

always @(posedge CLK)
	if (!CEN) begin
		case(A) // synopsys parallel_case
			9'b000000000 	: Q <= 8'b00000001;
			9'b000000001 	: Q <= 8'b00000001;
			9'b000000010 	: Q <= 8'b00000001;
			9'b000000011 	: Q <= 8'b00000001;
			9'b000000100 	: Q <= 8'b00000001;
			9'b000000101 	: Q <= 8'b00000001;
			9'b000000110 	: Q <= 8'b00000001;
			9'b000000111 	: Q <= 8'b00000001;
			9'b000001000 	: Q <= 8'b00000001;
			9'b000001001 	: Q <= 8'b00000001;
			9'b000001010 	: Q <= 8'b00000001;
			9'b000001011 	: Q <= 8'b00000001;
			9'b000001100 	: Q <= 8'b00000010;
			9'b000001101 	: Q <= 8'b00000010;
			9'b000001110 	: Q <= 8'b00000001;
			9'b000001111 	: Q <= 8'b00000010;
			9'b000010000 	: Q <= 8'b00000010;
			9'b000010001 	: Q <= 8'b00000010;
			9'b000010010 	: Q <= 8'b00000010;
			9'b000010011 	: Q <= 8'b00000010;
			9'b000010100 	: Q <= 8'b00000010;
			9'b000010101 	: Q <= 8'b00000011;
			9'b000010110 	: Q <= 8'b00000011;
			9'b000010111 	: Q <= 8'b00000011;
			9'b000011000 	: Q <= 8'b00000011;
			9'b000011001 	: Q <= 8'b00000011;
			9'b000011010 	: Q <= 8'b00000100;
			9'b000011011 	: Q <= 8'b00000100;
			9'b000011100 	: Q <= 8'b00000100;
			9'b000011101 	: Q <= 8'b00000100;
			9'b000011110 	: Q <= 8'b00000100;
			9'b000011111 	: Q <= 8'b00000101;
			9'b000100000 	: Q <= 8'b00000101;
			9'b000100001 	: Q <= 8'b00000101;
			9'b000100010 	: Q <= 8'b00000101;
			9'b000100011 	: Q <= 8'b00000101;
			9'b000100100 	: Q <= 8'b00000110;
			9'b000100101 	: Q <= 8'b00000110;
			9'b000100110 	: Q <= 8'b00000110;
			9'b000100111 	: Q <= 8'b00000111;
			9'b000101000 	: Q <= 8'b00000111;
			9'b000101001 	: Q <= 8'b00000111;
			9'b000101010 	: Q <= 8'b00001000;
			9'b000101011 	: Q <= 8'b00001000;
			9'b000101100 	: Q <= 8'b00001001;
			9'b000101101 	: Q <= 8'b00001001;
			9'b000101110 	: Q <= 8'b00001001;
			9'b000101111 	: Q <= 8'b00001001;
			9'b000110000 	: Q <= 8'b00001010;
			9'b000110001 	: Q <= 8'b00001010;
			9'b000110010 	: Q <= 8'b00001010;
			9'b000110011 	: Q <= 8'b00001011;
			9'b000110100 	: Q <= 8'b00001100;
			9'b000110101 	: Q <= 8'b00001100;
			9'b000110110 	: Q <= 8'b00001100;
			9'b000110111 	: Q <= 8'b00001101;
			9'b000111000 	: Q <= 8'b00001110;
			9'b000111001 	: Q <= 8'b00001110;
			9'b000111010 	: Q <= 8'b00001111;
			9'b000111011 	: Q <= 8'b00001111;
			9'b000111100 	: Q <= 8'b00010000;
			9'b000111101 	: Q <= 8'b00010000;
			9'b000111110 	: Q <= 8'b00010001;
			9'b000111111 	: Q <= 8'b00010001;
			9'b001000000 	: Q <= 8'b00010010;
			9'b001000001 	: Q <= 8'b00010010;
			9'b001000010 	: Q <= 8'b00010011;
			9'b001000011 	: Q <= 8'b00010100;
			9'b001000100 	: Q <= 8'b00010100;
			9'b001000101 	: Q <= 8'b00010101;
			9'b001000110 	: Q <= 8'b00010110;
			9'b001000111 	: Q <= 8'b00010110;
			9'b001001000 	: Q <= 8'b00010111;
			9'b001001001 	: Q <= 8'b00011000;
			9'b001001010 	: Q <= 8'b00011001;
			9'b001001011 	: Q <= 8'b00011001;
			9'b001001100 	: Q <= 8'b00011010;
			9'b001001101 	: Q <= 8'b00011011;
			9'b001001110 	: Q <= 8'b00011011;
			9'b001001111 	: Q <= 8'b00011101;
			9'b001010000 	: Q <= 8'b00011110;
			9'b001010001 	: Q <= 8'b00011110;
			9'b001010010 	: Q <= 8'b00011111;
			9'b001010011 	: Q <= 8'b00100000;
			9'b001010100 	: Q <= 8'b00100001;
			9'b001010101 	: Q <= 8'b00100010;
			9'b001010110 	: Q <= 8'b00100010;
			9'b001010111 	: Q <= 8'b00100100;
			9'b001011000 	: Q <= 8'b00100101;
			9'b001011001 	: Q <= 8'b00100101;
			9'b001011010 	: Q <= 8'b00100111;
			9'b001011011 	: Q <= 8'b00100111;
			9'b001011100 	: Q <= 8'b00101000;
			9'b001011101 	: Q <= 8'b00101001;
			9'b001011110 	: Q <= 8'b00101010;
			9'b001011111 	: Q <= 8'b00101011;
			9'b001100000 	: Q <= 8'b00101101;
			9'b001100001 	: Q <= 8'b00101110;
			9'b001100010 	: Q <= 8'b00101111;
			9'b001100011 	: Q <= 8'b00110000;
			9'b001100100 	: Q <= 8'b00110001;
			9'b001100101 	: Q <= 8'b00110010;
			9'b001100110 	: Q <= 8'b00110100;
			9'b001100111 	: Q <= 8'b00110101;
			9'b001101000 	: Q <= 8'b00110110;
			9'b001101001 	: Q <= 8'b00110111;
			9'b001101010 	: Q <= 8'b00111000;
			9'b001101011 	: Q <= 8'b00111001;
			9'b001101100 	: Q <= 8'b00111011;
			9'b001101101 	: Q <= 8'b00111100;
			9'b001101110 	: Q <= 8'b00111101;
			9'b001101111 	: Q <= 8'b00111111;
			9'b001110000 	: Q <= 8'b01000000;
			9'b001110001 	: Q <= 8'b01000001;
			9'b001110010 	: Q <= 8'b01000010;
			9'b001110011 	: Q <= 8'b01000100;
			9'b001110100 	: Q <= 8'b01000101;
			9'b001110101 	: Q <= 8'b01000111;
			9'b001110110 	: Q <= 8'b01001000;
			9'b001110111 	: Q <= 8'b01001010;
			9'b001111000 	: Q <= 8'b01001011;
			9'b001111001 	: Q <= 8'b01001100;
			9'b001111010 	: Q <= 8'b01001110;
			9'b001111011 	: Q <= 8'b01001111;
			9'b001111100 	: Q <= 8'b01010001;
			9'b001111101 	: Q <= 8'b01010010;
			9'b001111110 	: Q <= 8'b01010100;
			9'b001111111 	: Q <= 8'b01010101;
			9'b010000000 	: Q <= 8'b01010111;
			9'b010000001 	: Q <= 8'b01011001;
			9'b010000010 	: Q <= 8'b01011010;
			9'b010000011 	: Q <= 8'b01011100;
			9'b010000100 	: Q <= 8'b01011101;
			9'b010000101 	: Q <= 8'b01011111;
			9'b010000110 	: Q <= 8'b01100000;
			9'b010000111 	: Q <= 8'b01100010;
			9'b010001000 	: Q <= 8'b01100100;
			9'b010001001 	: Q <= 8'b01100101;
			9'b010001010 	: Q <= 8'b01100111;
			9'b010001011 	: Q <= 8'b01101001;
			9'b010001100 	: Q <= 8'b01101010;
			9'b010001101 	: Q <= 8'b01101100;
			9'b010001110 	: Q <= 8'b01101110;
			9'b010001111 	: Q <= 8'b01101111;
			9'b010010000 	: Q <= 8'b01110001;
			9'b010010001 	: Q <= 8'b01110011;
			9'b010010010 	: Q <= 8'b01110101;
			9'b010010011 	: Q <= 8'b01110110;
			9'b010010100 	: Q <= 8'b01111000;
			9'b010010101 	: Q <= 8'b01111010;
			9'b010010110 	: Q <= 8'b01111011;
			9'b010010111 	: Q <= 8'b01111101;
			9'b010011000 	: Q <= 8'b01111111;
			9'b010011001 	: Q <= 8'b10000001;
			9'b010011010 	: Q <= 8'b10000010;
			9'b010011011 	: Q <= 8'b10000100;
			9'b010011100 	: Q <= 8'b10000110;
			9'b010011101 	: Q <= 8'b10001000;
			9'b010011110 	: Q <= 8'b10001010;
			9'b010011111 	: Q <= 8'b10001011;
			9'b010100000 	: Q <= 8'b10001101;
			9'b010100001 	: Q <= 8'b10001111;
			9'b010100010 	: Q <= 8'b10010001;
			9'b010100011 	: Q <= 8'b10010010;
			9'b010100100 	: Q <= 8'b10010100;
			9'b010100101 	: Q <= 8'b10010110;
			9'b010100110 	: Q <= 8'b10011000;
			9'b010100111 	: Q <= 8'b10011010;
			9'b010101000 	: Q <= 8'b10011011;
			9'b010101001 	: Q <= 8'b10011101;
			9'b010101010 	: Q <= 8'b10011111;
			9'b010101011 	: Q <= 8'b10100000;
			9'b010101100 	: Q <= 8'b10100010;
			9'b010101101 	: Q <= 8'b10100100;
			9'b010101110 	: Q <= 8'b10100110;
			9'b010101111 	: Q <= 8'b10101000;
			9'b010110000 	: Q <= 8'b10101001;
			9'b010110001 	: Q <= 8'b10101011;
			9'b010110010 	: Q <= 8'b10101101;
			9'b010110011 	: Q <= 8'b10101111;
			9'b010110100 	: Q <= 8'b10110000;
			9'b010110101 	: Q <= 8'b10110010;
			9'b010110110 	: Q <= 8'b10110100;
			9'b010110111 	: Q <= 8'b10110101;
			9'b010111000 	: Q <= 8'b10110111;
			9'b010111001 	: Q <= 8'b10111001;
			9'b010111010 	: Q <= 8'b10111010;
			9'b010111011 	: Q <= 8'b10111100;
			9'b010111100 	: Q <= 8'b10111110;
			9'b010111101 	: Q <= 8'b10111111;
			9'b010111110 	: Q <= 8'b11000001;
			9'b010111111 	: Q <= 8'b11000010;
			9'b011000000 	: Q <= 8'b11000100;
			9'b011000001 	: Q <= 8'b11000110;
			9'b011000010 	: Q <= 8'b11000111;
			9'b011000011 	: Q <= 8'b11001001;
			9'b011000100 	: Q <= 8'b11001010;
			9'b011000101 	: Q <= 8'b11001100;
			9'b011000110 	: Q <= 8'b11001101;
			9'b011000111 	: Q <= 8'b11001111;
			9'b011001000 	: Q <= 8'b11010000;
			9'b011001001 	: Q <= 8'b11010010;
			9'b011001010 	: Q <= 8'b11010011;
			9'b011001011 	: Q <= 8'b11010101;
			9'b011001100 	: Q <= 8'b11010110;
			9'b011001101 	: Q <= 8'b11010111;
			9'b011001110 	: Q <= 8'b11011001;
			9'b011001111 	: Q <= 8'b11011010;
			9'b011010000 	: Q <= 8'b11011011;
			9'b011010001 	: Q <= 8'b11011101;
			9'b011010010 	: Q <= 8'b11011110;
			9'b011010011 	: Q <= 8'b11011111;
			9'b011010100 	: Q <= 8'b11100000;
			9'b011010101 	: Q <= 8'b11100010;
			9'b011010110 	: Q <= 8'b11100011;
			9'b011010111 	: Q <= 8'b11100100;
			9'b011011000 	: Q <= 8'b11100101;
			9'b011011001 	: Q <= 8'b11100110;
			9'b011011010 	: Q <= 8'b11100111;
			9'b011011011 	: Q <= 8'b11101001;
			9'b011011100 	: Q <= 8'b11101010;
			9'b011011101 	: Q <= 8'b11101011;
			9'b011011110 	: Q <= 8'b11101100;
			9'b011011111 	: Q <= 8'b11101101;
			9'b011100000 	: Q <= 8'b11101101;
			9'b011100001 	: Q <= 8'b11101110;
			9'b011100010 	: Q <= 8'b11101111;
			9'b011100011 	: Q <= 8'b11110000;
			9'b011100100 	: Q <= 8'b11110001;
			9'b011100101 	: Q <= 8'b11110010;
			9'b011100110 	: Q <= 8'b11110011;
			9'b011100111 	: Q <= 8'b11110011;
			9'b011101000 	: Q <= 8'b11110100;
			9'b011101001 	: Q <= 8'b11110101;
			9'b011101010 	: Q <= 8'b11110110;
			9'b011101011 	: Q <= 8'b11110110;
			9'b011101100 	: Q <= 8'b11110111;
			9'b011101101 	: Q <= 8'b11111000;
			9'b011101110 	: Q <= 8'b11111000;
			9'b011101111 	: Q <= 8'b11111000;
			9'b011110000 	: Q <= 8'b11111001;
			9'b011110001 	: Q <= 8'b11111010;
			9'b011110010 	: Q <= 8'b11111010;
			9'b011110011 	: Q <= 8'b11111010;
			9'b011110100 	: Q <= 8'b11111011;
			9'b011110101 	: Q <= 8'b11111011;
			9'b011110110 	: Q <= 8'b11111100;
			9'b011110111 	: Q <= 8'b11111100;
			9'b011111000 	: Q <= 8'b11111100;
			9'b011111001 	: Q <= 8'b11111101;
			9'b011111010 	: Q <= 8'b11111100;
			9'b011111011 	: Q <= 8'b11111101;
			9'b011111100 	: Q <= 8'b11111101;
			9'b011111101 	: Q <= 8'b11111101;
			9'b011111110 	: Q <= 8'b11111101;
			9'b011111111 	: Q <= 8'b11111101;
			9'b100000000 	: Q <= 8'b11111101;
			9'b100000001 	: Q <= 8'b11111101;
			9'b100000010 	: Q <= 8'b11111101;
			9'b100000011 	: Q <= 8'b11111101;
			9'b100000100 	: Q <= 8'b11111101;
			9'b100000101 	: Q <= 8'b11111101;
			9'b100000110 	: Q <= 8'b11111101;
			9'b100000111 	: Q <= 8'b11111100;
			9'b100001000 	: Q <= 8'b11111100;
			9'b100001001 	: Q <= 8'b11111100;
			9'b100001010 	: Q <= 8'b11111100;
			9'b100001011 	: Q <= 8'b11111011;
			9'b100001100 	: Q <= 8'b11111011;
			9'b100001101 	: Q <= 8'b11111010;
			9'b100001110 	: Q <= 8'b11111010;
			9'b100001111 	: Q <= 8'b11111010;
			9'b100010000 	: Q <= 8'b11111001;
			9'b100010001 	: Q <= 8'b11111000;
			9'b100010010 	: Q <= 8'b11111000;
			9'b100010011 	: Q <= 8'b11111000;
			9'b100010100 	: Q <= 8'b11110111;
			9'b100010101 	: Q <= 8'b11110110;
			9'b100010110 	: Q <= 8'b11110110;
			9'b100010111 	: Q <= 8'b11110101;
			9'b100011000 	: Q <= 8'b11110100;
			9'b100011001 	: Q <= 8'b11110011;
			9'b100011010 	: Q <= 8'b11110011;
			9'b100011011 	: Q <= 8'b11110010;
			9'b100011100 	: Q <= 8'b11110001;
			9'b100011101 	: Q <= 8'b11110000;
			9'b100011110 	: Q <= 8'b11101111;
			9'b100011111 	: Q <= 8'b11101110;
			9'b100100000 	: Q <= 8'b11101101;
			9'b100100001 	: Q <= 8'b11101100;
			9'b100100010 	: Q <= 8'b11101100;
			9'b100100011 	: Q <= 8'b11101011;
			9'b100100100 	: Q <= 8'b11101010;
			9'b100100101 	: Q <= 8'b11101001;
			9'b100100110 	: Q <= 8'b11101000;
			9'b100100111 	: Q <= 8'b11100110;
			9'b100101000 	: Q <= 8'b11100101;
			9'b100101001 	: Q <= 8'b11100100;
			9'b100101010 	: Q <= 8'b11100011;
			9'b100101011 	: Q <= 8'b11100010;
			9'b100101100 	: Q <= 8'b11100000;
			9'b100101101 	: Q <= 8'b11011111;
			9'b100101110 	: Q <= 8'b11011110;
			9'b100101111 	: Q <= 8'b11011101;
			9'b100110000 	: Q <= 8'b11011100;
			9'b100110001 	: Q <= 8'b11011010;
			9'b100110010 	: Q <= 8'b11011001;
			9'b100110011 	: Q <= 8'b11010111;
			9'b100110100 	: Q <= 8'b11010110;
			9'b100110101 	: Q <= 8'b11010101;
			9'b100110110 	: Q <= 8'b11010011;
			9'b100110111 	: Q <= 8'b11010010;
			9'b100111000 	: Q <= 8'b11010000;
			9'b100111001 	: Q <= 8'b11001111;
			9'b100111010 	: Q <= 8'b11001101;
			9'b100111011 	: Q <= 8'b11001100;
			9'b100111100 	: Q <= 8'b11001010;
			9'b100111101 	: Q <= 8'b11001001;
			9'b100111110 	: Q <= 8'b11000111;
			9'b100111111 	: Q <= 8'b11000110;
			9'b101000000 	: Q <= 8'b11000100;
			9'b101000001 	: Q <= 8'b11000011;
			9'b101000010 	: Q <= 8'b11000001;
			9'b101000011 	: Q <= 8'b10111111;
			9'b101000100 	: Q <= 8'b10111110;
			9'b101000101 	: Q <= 8'b10111100;
			9'b101000110 	: Q <= 8'b10111010;
			9'b101000111 	: Q <= 8'b10111001;
			9'b101001000 	: Q <= 8'b10110111;
			9'b101001001 	: Q <= 8'b10110101;
			9'b101001010 	: Q <= 8'b10110100;
			9'b101001011 	: Q <= 8'b10110010;
			9'b101001100 	: Q <= 8'b10110000;
			9'b101001101 	: Q <= 8'b10101111;
			9'b101001110 	: Q <= 8'b10101101;
			9'b101001111 	: Q <= 8'b10101011;
			9'b101010000 	: Q <= 8'b10101001;
			9'b101010001 	: Q <= 8'b10101000;
			9'b101010010 	: Q <= 8'b10100110;
			9'b101010011 	: Q <= 8'b10100100;
			9'b101010100 	: Q <= 8'b10100011;
			9'b101010101 	: Q <= 8'b10100000;
			9'b101010110 	: Q <= 8'b10011111;
			9'b101010111 	: Q <= 8'b10011101;
			9'b101011000 	: Q <= 8'b10011011;
			9'b101011001 	: Q <= 8'b10011010;
			9'b101011010 	: Q <= 8'b10011000;
			9'b101011011 	: Q <= 8'b10010110;
			9'b101011100 	: Q <= 8'b10010100;
			9'b101011101 	: Q <= 8'b10010010;
			9'b101011110 	: Q <= 8'b10010001;
			9'b101011111 	: Q <= 8'b10001111;
			9'b101100000 	: Q <= 8'b10001101;
			9'b101100001 	: Q <= 8'b10001011;
			9'b101100010 	: Q <= 8'b10001010;
			9'b101100011 	: Q <= 8'b10001000;
			9'b101100100 	: Q <= 8'b10000110;
			9'b101100101 	: Q <= 8'b10000100;
			9'b101100110 	: Q <= 8'b10000010;
			9'b101100111 	: Q <= 8'b10000001;
			9'b101101000 	: Q <= 8'b01111111;
			9'b101101001 	: Q <= 8'b01111101;
			9'b101101010 	: Q <= 8'b01111011;
			9'b101101011 	: Q <= 8'b01111010;
			9'b101101100 	: Q <= 8'b01111000;
			9'b101101101 	: Q <= 8'b01110110;
			9'b101101110 	: Q <= 8'b01110101;
			9'b101101111 	: Q <= 8'b01110011;
			9'b101110000 	: Q <= 8'b01110001;
			9'b101110001 	: Q <= 8'b01101111;
			9'b101110010 	: Q <= 8'b01101110;
			9'b101110011 	: Q <= 8'b01101100;
			9'b101110100 	: Q <= 8'b01101010;
			9'b101110101 	: Q <= 8'b01101001;
			9'b101110110 	: Q <= 8'b01100111;
			9'b101110111 	: Q <= 8'b01100101;
			9'b101111000 	: Q <= 8'b01100100;
			9'b101111001 	: Q <= 8'b01100010;
			9'b101111010 	: Q <= 8'b01100001;
			9'b101111011 	: Q <= 8'b01011111;
			9'b101111100 	: Q <= 8'b01011101;
			9'b101111101 	: Q <= 8'b01011100;
			9'b101111110 	: Q <= 8'b01011010;
			9'b101111111 	: Q <= 8'b01011001;
			9'b110000000 	: Q <= 8'b01010111;
			9'b110000001 	: Q <= 8'b01010101;
			9'b110000010 	: Q <= 8'b01010100;
			9'b110000011 	: Q <= 8'b01010010;
			9'b110000100 	: Q <= 8'b01010001;
			9'b110000101 	: Q <= 8'b01001111;
			9'b110000110 	: Q <= 8'b01001110;
			9'b110000111 	: Q <= 8'b01001101;
			9'b110001000 	: Q <= 8'b01001011;
			9'b110001001 	: Q <= 8'b01001010;
			9'b110001010 	: Q <= 8'b01001000;
			9'b110001011 	: Q <= 8'b01000111;
			9'b110001100 	: Q <= 8'b01000101;
			9'b110001101 	: Q <= 8'b01000100;
			9'b110001110 	: Q <= 8'b01000011;
			9'b110001111 	: Q <= 8'b01000001;
			9'b110010000 	: Q <= 8'b01000000;
			9'b110010001 	: Q <= 8'b00111111;
			9'b110010010 	: Q <= 8'b00111101;
			9'b110010011 	: Q <= 8'b00111100;
			9'b110010100 	: Q <= 8'b00111011;
			9'b110010101 	: Q <= 8'b00111001;
			9'b110010110 	: Q <= 8'b00111000;
			9'b110010111 	: Q <= 8'b00110111;
			9'b110011000 	: Q <= 8'b00110110;
			9'b110011001 	: Q <= 8'b00110101;
			9'b110011010 	: Q <= 8'b00110011;
			9'b110011011 	: Q <= 8'b00110010;
			9'b110011100 	: Q <= 8'b00110001;
			9'b110011101 	: Q <= 8'b00110000;
			9'b110011110 	: Q <= 8'b00101111;
			9'b110011111 	: Q <= 8'b00101110;
			9'b110100000 	: Q <= 8'b00101101;
			9'b110100001 	: Q <= 8'b00101100;
			9'b110100010 	: Q <= 8'b00101010;
			9'b110100011 	: Q <= 8'b00101010;
			9'b110100100 	: Q <= 8'b00101000;
			9'b110100101 	: Q <= 8'b00100111;
			9'b110100110 	: Q <= 8'b00100110;
			9'b110100111 	: Q <= 8'b00100101;
			9'b110101000 	: Q <= 8'b00100101;
			9'b110101001 	: Q <= 8'b00100100;
			9'b110101010 	: Q <= 8'b00100010;
			9'b110101011 	: Q <= 8'b00100010;
			9'b110101100 	: Q <= 8'b00100001;
			9'b110101101 	: Q <= 8'b00100000;
			9'b110101110 	: Q <= 8'b00011111;
			9'b110101111 	: Q <= 8'b00011110;
			9'b110110000 	: Q <= 8'b00011101;
			9'b110110001 	: Q <= 8'b00011101;
			9'b110110010 	: Q <= 8'b00011100;
			9'b110110011 	: Q <= 8'b00011011;
			9'b110110100 	: Q <= 8'b00011010;
			9'b110110101 	: Q <= 8'b00011001;
			9'b110110110 	: Q <= 8'b00011001;
			9'b110110111 	: Q <= 8'b00011000;
			9'b110111000 	: Q <= 8'b00010111;
			9'b110111001 	: Q <= 8'b00010110;
			9'b110111010 	: Q <= 8'b00010110;
			9'b110111011 	: Q <= 8'b00010101;
			9'b110111100 	: Q <= 8'b00010100;
			9'b110111101 	: Q <= 8'b00010100;
			9'b110111110 	: Q <= 8'b00010011;
			9'b110111111 	: Q <= 8'b00010011;
			9'b111000000 	: Q <= 8'b00010010;
			9'b111000001 	: Q <= 8'b00010001;
			9'b111000010 	: Q <= 8'b00010001;
			9'b111000011 	: Q <= 8'b00010000;
			9'b111000100 	: Q <= 8'b00010000;
			9'b111000101 	: Q <= 8'b00001111;
			9'b111000110 	: Q <= 8'b00001111;
			9'b111000111 	: Q <= 8'b00001110;
			9'b111001000 	: Q <= 8'b00001110;
			9'b111001001 	: Q <= 8'b00001101;
			9'b111001010 	: Q <= 8'b00001100;
			9'b111001011 	: Q <= 8'b00001100;
			9'b111001100 	: Q <= 8'b00001100;
			9'b111001101 	: Q <= 8'b00001011;
			9'b111001110 	: Q <= 8'b00001011;
			9'b111001111 	: Q <= 8'b00001010;
			9'b111010000 	: Q <= 8'b00001010;
			9'b111010001 	: Q <= 8'b00001001;
			9'b111010010 	: Q <= 8'b00001001;
			9'b111010011 	: Q <= 8'b00001001;
			9'b111010100 	: Q <= 8'b00001000;
			9'b111010101 	: Q <= 8'b00001000;
			9'b111010110 	: Q <= 8'b00001000;
			9'b111010111 	: Q <= 8'b00000111;
			9'b111011000 	: Q <= 8'b00000111;
			9'b111011001 	: Q <= 8'b00000111;
			9'b111011010 	: Q <= 8'b00000110;
			9'b111011011 	: Q <= 8'b00000110;
			9'b111011100 	: Q <= 8'b00000110;
			9'b111011101 	: Q <= 8'b00000110;
			9'b111011110 	: Q <= 8'b00000101;
			9'b111011111 	: Q <= 8'b00000101;
			9'b111100000 	: Q <= 8'b00000101;
			9'b111100001 	: Q <= 8'b00000101;
			9'b111100010 	: Q <= 8'b00000100;
			9'b111100011 	: Q <= 8'b00000100;
			9'b111100100 	: Q <= 8'b00000100;
			9'b111100101 	: Q <= 8'b00000100;
			9'b111100110 	: Q <= 8'b00000011;
			9'b111100111 	: Q <= 8'b00000011;
			9'b111101000 	: Q <= 8'b00000011;
			9'b111101001 	: Q <= 8'b00000011;
			9'b111101010 	: Q <= 8'b00000011;
			9'b111101011 	: Q <= 8'b00000011;
			9'b111101100 	: Q <= 8'b00000010;
			9'b111101101 	: Q <= 8'b00000010;
			9'b111101110 	: Q <= 8'b00000010;
			9'b111101111 	: Q <= 8'b00000010;
			9'b111110000 	: Q <= 8'b00000010;
			9'b111110001 	: Q <= 8'b00000010;
			9'b111110010 	: Q <= 8'b00000010;
			9'b111110011 	: Q <= 8'b00000010;
			9'b111110100 	: Q <= 8'b00000010;
			9'b111110101 	: Q <= 8'b00000001;
			9'b111110110 	: Q <= 8'b00000001;
			9'b111110111 	: Q <= 8'b00000001;
			9'b111111000 	: Q <= 8'b00000001;
			9'b111111001 	: Q <= 8'b00000001;
			9'b111111010 	: Q <= 8'b00000001;
			9'b111111011 	: Q <= 8'b00000001;
			9'b111111100 	: Q <= 8'b00000001;
			9'b111111101 	: Q <= 8'b00000001;
			9'b111111110 	: Q <= 8'b00000001;
			9'b111111111 	: Q <= 8'b00000001;
		endcase
	end

endmodule