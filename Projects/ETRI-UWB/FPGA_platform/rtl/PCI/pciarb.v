// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module pciarb(
clk,
framein_b,
gnt_b,
irdyin_b,
req_b,
reset_b
);
input clk;
input framein_b;
output[8:0] gnt_b;
input irdyin_b;
input[8:0] req_b;
input reset_b;
wire[4:0] I01lOOOl1IOI01l;wire[4:0] l0IO1OOl1II01lO;wire[3:0] OIl01OOIl1IOIl0;wire[4:0] OOl1IOIl01OlI1O;wire[4:0] I01lOOIl01OIl01;
wire[4:0] l0IO1lO10IOOl1I;wire IO0lIOOIl1I1lO0;wire[4:0] OOIl1OlI1OIIO0l;wire[4:0] IO01lOlI1Ol0IO1;wire[8:0] IlI0OlO10IO01Il;wire[4:0] IO0lIlO10IIlO01;
wire[4:0] OOIl1lIO10OI01l;wire[8:0] OIl01O1lIOIO0lI;wire[4:0] OI01lO1lIOlIO10;wire[4:0] IIO0lIO0lIOlI1O;wire[8:0] l0IO1lIO10IO01l;
wire[4:0] OIl01l0IO1IlI0O;wire[4:0] OI01ll0IO1I1lO0;wire[8:0] IO01lIO0lIlO10I;wire[4:0] l10IOIIO0lOOIl1;wire[4:0] lO10IIIO0lO01Il;
wire[3:0] OlI01IIO0lIlO01;wire[4:0] IO01ll10IOl10IO;wire[4:0] l10IOI1lO0IO0lI;wire[8:0] lO10II1lO0lIO10;wire[8:0] OlI1OIOIl0OlI01;
wire[4:0] IlO01IOIl0IO01l;wire[4:0] I1lO0IlI0OIlI0O;wire[8:0] IIO0lI01lOO1lIO;wire[4:0] OlI1OI01lOlO10I;wire[4:0] IlO01IO01lOOIl1;
wire[8:0] OlI01IlI0OI01lO;wire[4:0] IOIl0OI01lIOIl0;wire[4:0] O1lIOOI01ll10IO;wire[8:0] lO10IIO01lOIl01;wire[4:0] OlI01IlO01OOl1I;
wire[4:0] IOIl0IlO01OlI01;wire[8:0] I1lO0OlI01IIO0l;wire[4:0] lIO10OlI01l0IO1;wire[4:0] O01IlO01IlO1lIO;wire[8:0] IlI0OO01IllO10I;
wire IlO01IlO01IlO01;
assign I1lO0OlI01IIO0l[0]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&~IO01lIO0lIlO10I[4]&
~IO01lIO0lIlO10I[5]&~IO01lIO0lIlO10I[6]&~IO01lIO0lIlO10I[7]&~IO01lIO0lIlO10I[8];assign OlI01IlI0OI01lO[7]
=(~(IlO01IO01lOOIl1[3]&IlO01IO01lOOIl1[2]&IlO01IO01lOOIl1[1]&IlO01IO01lOOIl1[0]))
&~IlI0OO01IllO10I[7]&~IlO01IO01lOOIl1[4];dff5 Il10IOO1lIOO1lIO
(OIl01l0IO1IlI0O,l10IOIIO0lOOIl1,clk,reset_b,1'b1);assign lO10II1lO0lIO10[4]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|~OIl01OOIl1IOIl0[2]|OIl01OOIl1IOIl0[1]|OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[4];assign I1lO0OlI01IIO0l[1]
=IO01lIO0lIlO10I[1];dff9 IIIO0ll10IOIIO0l(OIl01O1lIOIO0lI,lO10IIO01lOIl01,clk,1'b1,1'b1);assign IlO01IOIl0IO01l
=(~l10IOI1lO0IO0lI[4]&~IlI0OO01IllO10I[4]&~lO10II1lO0lIO10[4]&framein_b&irdyin_b)?I01lOOIl01OIl01:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[4])?5'b00000:
(l10IOI1lO0IO0lI[4]&~IlI0OO01IllO10I[4])?l10IOI1lO0IO0lI:5'b00000;assign OOIl1lIO10OI01l
=IlO01IO01lOOIl1+5'b00001;assign IO01lIO0lIlO10I[1]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[8]:OlI01IlI0OI01lO[0];assign l0IO1lIO10IO01l[2]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[4]:I1lO0OlI01IIO0l[3];dff8 IO1lIOIlO01IO01l
(IlI0OlO10IO01Il[8:1],IIO0lI01lOO1lIO[8:1],clk,reset_b,1'b1);assign OlI1OI01lOlO10I=OOIl1OlI1OIIO0l+5'b00001;assign lO10II1lO0lIO10[7]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|~OIl01OOIl1IOIl0[2]|~OIl01OOIl1IOIl0[1]|~OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[7];assign I1lO0OlI01IIO0l[4]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&IO01lIO0lIlO10I[4];assign OlI01IlI0OI01lO[2]
=(~(IOIl0OI01lIOIl0[3]&IOIl0OI01lIOIl0[2]&IOIl0OI01lIOIl0[1]&IOIl0OI01lIOIl0[0]))
&~IlI0OO01IllO10I[2]&~IOIl0OI01lIOIl0[4];assign O1lIOOI01ll10IO
=(~IlO01IO01lOOIl1[4]&~IlI0OO01IllO10I[7]&~lO10II1lO0lIO10[7]&framein_b&irdyin_b)?OOIl1lIO10OI01l:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[7])?5'b00000:
(IlO01IO01lOOIl1[4]&~IlI0OO01IllO10I[7])?IlO01IO01lOOIl1:5'b00000;dff5 IOlI1Ol10IOl0IO1
(l0IO1lO10IOOl1I,IO01lOlI1Ol0IO1,clk,reset_b,1'b1);assign IO01lIO0lIlO10I[4]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[2]:OlI01IlI0OI01lO[3];assign l0IO1lIO10IO01l[5]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[7]:I1lO0OlI01IIO0l[6];dff9 IIO01llIO10I01lO
(OlI1OIOIl0OlI01,OIl01O1lIOIO0lI,clk,1'b1,1'b1);dff5 IOlI01I01lOOlI1O(l10IOI1lO0IO0lI,IlO01IOIl0IO01l,clk,reset_b,1'b1);assign OlI01IIO0lIlO01[0]
=~OIl01O1lIOIO0lI[1]|~OIl01O1lIOIO0lI[3]|~OIl01O1lIOIO0lI[5]|~OIl01O1lIOIO0lI[7];assign I1lO0OlI01IIO0l[7]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&~IO01lIO0lIlO10I[4]&
~IO01lIO0lIlO10I[5]&~IO01lIO0lIlO10I[6]&IO01lIO0lIlO10I[7];assign OlI01IlI0OI01lO[5]
=(~(O01IlO01IlO1lIO[3]&O01IlO01IlO1lIO[2]&O01IlO01IlO1lIO[1]&O01IlO01IlO1lIO[0]))
&~IlI0OO01IllO10I[5]&~O01IlO01IlO1lIO[4];dff5 II1lO0IO01lO01Il
(I01lOOOl1IOI01l,OOl1IOIl01OlI1O,clk,reset_b,1'b1);assign lO10II1lO0lIO10[2]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|OIl01OOIl1IOIl0[2]|~OIl01OOIl1IOIl0[1]|OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[2];assign IO01lIO0lIlO10I[7]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[5]:OlI01IlI0OI01lO[6];assign l0IO1lIO10IO01l[8]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[1]:I1lO0OlI01IIO0l[0];assign OlI01IlO01OOl1I
=(~IOIl0OI01lIOIl0[4]&~IlI0OO01IllO10I[2]&~lO10II1lO0lIO10[2]&framein_b&irdyin_b)?OI01lO1lIOlIO10:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[2])?5'b00000:
(IOIl0OI01lIOIl0[4]&~IlI0OO01IllO10I[2])?IOIl0OI01lIOIl0:5'b00000;assign IOIl0IlO01OlI01
=IIO0lIO0lIOlI1O+5'b00001;assign OlI01IIO0lIlO01[3]=~OIl01O1lIOIO0lI[8];assign IlI0OO01IllO10I=req_b;assign l0IO1lIO10IO01l[0]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[2]:I1lO0OlI01IIO0l[1];assign OlI01IlI0OI01lO[8]
=(~(l0IO1lO10IOOl1I[3]&l0IO1lO10IOOl1I[2]&l0IO1lO10IOOl1I[1]&l0IO1lO10IOOl1I[0]))
&~IlI0OO01IllO10I[8]&~l0IO1lO10IOOl1I[4];assign OI01lO1lIOlIO10
=IOIl0OI01lIOIl0+5'b00001;assign lO10II1lO0lIO10[5]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|~OIl01OOIl1IOIl0[2]|OIl01OOIl1IOIl0[1]|~OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[5];assign I1lO0OlI01IIO0l[2]
=~IO01lIO0lIlO10I[1]&IO01lIO0lIlO10I[2];assign OlI01IlI0OI01lO[0]
=(~(I01lOOOl1IOI01l[3]&I01lOOOl1IOI01l[2]&I01lOOOl1IOI01l[1]&I01lOOOl1IOI01l[0]))
&~IlI0OO01IllO10I[0]&~I01lOOOl1IOI01l[4];assign l0IO1OOl1II01lO
=(~O01IlO01IlO1lIO[4]&~IlI0OO01IllO10I[5]&~lO10II1lO0lIO10[5]&framein_b&irdyin_b)?lO10IIIO0lO01Il:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[5])?5'b00000:
(O01IlO01IlO1lIO[4]&~IlI0OO01IllO10I[5])?O01IlO01IlO1lIO:5'b00000;dff5 IIO0lIOIl01OOIl1
(IlO01IO01lOOIl1,O1lIOOI01ll10IO,clk,reset_b,1'b1);assign IO01lIO0lIlO10I[2]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[0]:OlI01IlI0OI01lO[1];assign l0IO1lIO10IO01l[3]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[5]:I1lO0OlI01IIO0l[4];dff IOlI1OIO0lIOIl01
(IlI0OlO10IO01Il[0],IIO0lI01lOO1lIO[0],clk,1'b1,reset_b);dff5 IOIl01lO10IOlI01
(OOIl1OlI1OIIO0l,IO0lIlO10IIlO01,clk,reset_b,1'b1);assign lO10II1lO0lIO10[8]
=(IO0lIOOIl1I1lO0&(~OIl01OOIl1IOIl0[3]|OIl01OOIl1IOIl0[2]|OIl01OOIl1IOIl0[1]|OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[8];assign I1lO0OlI01IIO0l[5]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&~IO01lIO0lIlO10I[4]&
IO01lIO0lIlO10I[5];assign OlI01IlI0OI01lO[3]
=(~(OOIl1OlI1OIIO0l[3]&OOIl1OlI1OIIO0l[2]&OOIl1OlI1OIIO0l[1]&OOIl1OlI1OIIO0l[0]))
&~IlI0OO01IllO10I[3]&~OOIl1OlI1OIIO0l[4];assign IO01lOlI1Ol0IO1
=(~l0IO1lO10IOOl1I[4]&~IlI0OO01IllO10I[8]&~lO10II1lO0lIO10[8]&framein_b&irdyin_b)?I1lO0IlI0OIlI0O:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[8])?5'b00000:
(l0IO1lO10IOOl1I[4]&~IlI0OO01IllO10I[8])?l0IO1lO10IOOl1I:5'b00000;assign lO10II1lO0lIO10[0]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|OIl01OOIl1IOIl0[2]|OIl01OOIl1IOIl0[1]|OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[0];assign IO01lIO0lIlO10I[5]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[3]:OlI01IlI0OI01lO[4];assign l0IO1lIO10IO01l[6]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[8]:I1lO0OlI01IIO0l[7];assign OOl1IOIl01OlI1O
=(~I01lOOOl1IOI01l[4]&~IlI0OO01IllO10I[0]&~lO10II1lO0lIO10[0]&framein_b&irdyin_b)?IO01ll10IOl10IO:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[0])?5'b00000:
(I01lOOOl1IOI01l[4]&~IlI0OO01IllO10I[0])?I01lOOOl1IOI01l:5'b00000;assign lO10IIIO0lO01Il
=O01IlO01IlO1lIO+5'b00001;assign OlI01IIO0lIlO01[1]
=~OIl01O1lIOIO0lI[2]|~OIl01O1lIOIO0lI[3]|~OIl01O1lIOIO0lI[6]|~OIl01O1lIOIO0lI[7];assign I1lO0OlI01IIO0l[8]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&~IO01lIO0lIlO10I[4]&
~IO01lIO0lIlO10I[5]&~IO01lIO0lIlO10I[6]&~IO01lIO0lIlO10I[7]&IO01lIO0lIlO10I[8];assign OlI01IlI0OI01lO[6]
=(~(IIO0lIO0lIOlI1O[3]&IIO0lIO0lIOlI1O[2]&IIO0lIO0lIOlI1O[1]&IIO0lIO0lIOlI1O[0]))
&~IlI0OO01IllO10I[6]&~IIO0lIO0lIOlI1O[4];assign lIO10OlI01l0IO1
=OIl01l0IO1IlI0O+5'b00001;assign lO10II1lO0lIO10[3]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|OIl01OOIl1IOIl0[2]|~OIl01OOIl1IOIl0[1]|~OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[3];assign IO01lIO0lIlO10I[8]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[6]:OlI01IlI0OI01lO[7];assign lO10IIO01lOIl01
=~l0IO1lIO10IO01l;assign IO0lIlO10IIlO01
=(~OOIl1OlI1OIIO0l[4]&~IlI0OO01IllO10I[3]&~lO10II1lO0lIO10[3]&framein_b&irdyin_b)?OlI1OI01lOlO10I:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[3])?5'b00000:
(OOIl1OlI1OIIO0l[4]&~IlI0OO01IllO10I[3])?OOIl1OlI1OIIO0l:5'b00000;dff5 IIOIl0IOIl0OI01l
(IIO0lIO0lIOlI1O,OI01ll0IO1I1lO0,clk,reset_b,1'b1);dff4 IOOIl1OOl1IIlI0O(OIl01OOIl1IOIl0,OlI01IIO0lIlO01,clk,1'b1,1'b1);assign IO01lIO0lIlO10I[0]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[7]:OlI01IlI0OI01lO[8];assign l0IO1lIO10IO01l[1]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[3]:I1lO0OlI01IIO0l[2];assign IIO0lI01lOO1lIO
=(IO0lIOOIl1I1lO0&~framein_b)?~OlI1OIOIl0OlI01:IlI0OlO10IO01Il;dff5 IlIO10IlI0OI1lO0
(IOIl0OI01lIOIl0,OlI01IlO01OOl1I,clk,reset_b,1'b1);assign lO10II1lO0lIO10[6]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|~OIl01OOIl1IOIl0[2]|~OIl01OOIl1IOIl0[1]|OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[6];assign I1lO0OlI01IIO0l[3]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&IO01lIO0lIlO10I[3];assign OlI01IlI0OI01lO[1]
=(~(OIl01l0IO1IlI0O[3]&OIl01l0IO1IlI0O[2]&OIl01l0IO1IlI0O[1]&OIl01l0IO1IlI0O[0]))
&~IlI0OO01IllO10I[1]&~OIl01l0IO1IlI0O[4];assign OI01ll0IO1I1lO0
=(~IIO0lIO0lIOlI1O[4]&~IlI0OO01IllO10I[6]&~lO10II1lO0lIO10[6]&framein_b&irdyin_b)?IOIl0IlO01OlI01:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[6])?5'b00000:
(IIO0lIO0lIOlI1O[4]&~IlI0OO01IllO10I[6])?IIO0lIO0lIOlI1O:5'b00000;assign I1lO0IlI0OIlI0O
=l0IO1lO10IOOl1I+5'b00001;assign IO01lIO0lIlO10I[3]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[4]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[5]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[1]:OlI01IlI0OI01lO[2];assign l0IO1lIO10IO01l[4]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[0]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[8]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[6]:I1lO0OlI01IIO0l[5];dff IOOl1IOlI01IO0lI
(IO0lIOOIl1I1lO0,IlO01IlO01IlO01,clk,1'b1,1'b1);assign I01lOOIl01OIl01=l10IOI1lO0IO0lI+5'b00001;assign gnt_b=lO10II1lO0lIO10;assign I1lO0OlI01IIO0l[6]
=~IO01lIO0lIlO10I[1]&~IO01lIO0lIlO10I[2]&~IO01lIO0lIlO10I[3]&~IO01lIO0lIlO10I[4]&
~IO01lIO0lIlO10I[5]&IO01lIO0lIlO10I[6];assign OlI01IlI0OI01lO[4]
=(~(l10IOI1lO0IO0lI[3]&l10IOI1lO0IO0lI[2]&l10IOI1lO0IO0lI[1]&l10IOI1lO0IO0lI[0]))
&~IlI0OO01IllO10I[4]&~l10IOI1lO0IO0lI[4];assign IO01ll10IOl10IO
=I01lOOOl1IOI01l+5'b00001;assign lO10II1lO0lIO10[1]
=(IO0lIOOIl1I1lO0&(OIl01OOIl1IOIl0[3]|OIl01OOIl1IOIl0[2]|OIl01OOIl1IOIl0[1]|~OIl01OOIl1IOIl0[0]))|OIl01O1lIOIO0lI[1];assign IO01lIO0lIlO10I[6]
=(IlI0OlO10IO01Il[0])?OlI01IlI0OI01lO[6]:
(IlI0OlO10IO01Il[1])?OlI01IlI0OI01lO[7]:
(IlI0OlO10IO01Il[2])?OlI01IlI0OI01lO[8]:
(IlI0OlO10IO01Il[3])?OlI01IlI0OI01lO[0]:
(IlI0OlO10IO01Il[4])?OlI01IlI0OI01lO[1]:
(IlI0OlO10IO01Il[5])?OlI01IlI0OI01lO[2]:
(IlI0OlO10IO01Il[6])?OlI01IlI0OI01lO[3]:
(IlI0OlO10IO01Il[7])?OlI01IlI0OI01lO[4]:OlI01IlI0OI01lO[5];assign l0IO1lIO10IO01l[7]
=(IlI0OlO10IO01Il[0])?I1lO0OlI01IIO0l[7]:
(IlI0OlO10IO01Il[1])?I1lO0OlI01IIO0l[6]:
(IlI0OlO10IO01Il[2])?I1lO0OlI01IIO0l[5]:
(IlI0OlO10IO01Il[3])?I1lO0OlI01IIO0l[4]:
(IlI0OlO10IO01Il[4])?I1lO0OlI01IIO0l[3]:
(IlI0OlO10IO01Il[5])?I1lO0OlI01IIO0l[2]:
(IlI0OlO10IO01Il[6])?I1lO0OlI01IIO0l[1]:
(IlI0OlO10IO01Il[7])?I1lO0OlI01IIO0l[0]:I1lO0OlI01IIO0l[8];assign l10IOIIO0lOOIl1
=(~OIl01l0IO1IlI0O[4]&~IlI0OO01IllO10I[1]&~lO10II1lO0lIO10[1]&framein_b&irdyin_b)?lIO10OlI01l0IO1:
(IO0lIOOIl1I1lO0&~framein_b&~OlI1OIOIl0OlI01[1])?5'b00000:
(OIl01l0IO1IlI0O[4]&~IlI0OO01IllO10I[1])?OIl01l0IO1IlI0O:5'b00000;dff5 IOI01lOOIl1l10IO
(O01IlO01IlO1lIO,l0IO1OOl1II01lO,clk,reset_b,1'b1);assign OlI01IIO0lIlO01[2]
=~OIl01O1lIOIO0lI[4]|~OIl01O1lIOIO0lI[5]|~OIl01O1lIOIO0lI[6]|~OIl01O1lIOIO0lI[7];assign IlO01IlO01IlO01=(framein_b&irdyin_b);
endmodule 
