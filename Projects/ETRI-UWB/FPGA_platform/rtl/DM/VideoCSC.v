
`timescale 1ns / 1ns

module VideoCSC (
			Clk ,
			nRST,
			ValidIn,
			Yin,
			Cbin,
			Crin,
			ValidOut,
			Rout,
			Gout,
			Bout 
);

//------------------------------------------------------------------
//INPUT DECLARATION
//------------------------------------------------------------------
input         Clk;
input         nRST;
input         ValidIn;
input  [ 7:0] Yin;
input  [ 7:0] Cbin;
input  [ 7:0] Crin;

//------------------------------------------------------------------
//OUTPUT DECLARATION
//------------------------------------------------------------------
output        ValidOut;
output [ 7:0] Rout;
output [ 7:0] Gout;
output [ 7:0] Bout;

//------------------------------------------------------------------
//REGISTER & WIRE DECLARATION
//------------------------------------------------------------------
wire [ 9:0] yp;
wire [24:0] y;
wire [ 9:0] rcrp;
wire [24:0] rcr;
wire [ 9:0] gcbp;
wire [24:0] gcb;
wire [ 9:0] gcrp;
wire [24:0] gcr;
wire [ 9:0] bcbp;
wire [24:0] bcb;
wire [24:0] rp;
wire [24:0] gp;
wire [25:0] bp;
wire [ 7:0] Routp;
wire [ 7:0] Goutp;
wire [ 7:0] Boutp;

reg  [24:0] yR;
reg  [24:0] rcrR;
reg  [24:0] gcbR;
reg  [24:0] gcrR;
reg  [24:0] bcbR;

reg         ValidOut0;
reg         ValidOut;
reg  [ 7:0] Rout;
reg  [ 7:0] Gout;
reg  [ 7:0] Bout;

//------------------------------------------------------------------
//FUNCTION DESCRIPTION
//------------------------------------------------------------------

/*
coeff = [ 1.1644      0     1.5960 ]
        [ 1.1644  -0.3918  -0.8130 ]
        [ 1.1644   2.0172      0   ]

Yin  = Yin - 16;
Cbin = Cbin - 128;
Crin = Crin - 128;

r = coeff(1,1) * Yin + coeff(1,3) * Crin;
g = coeff(2,1) * Yin + coeff(2,2) * Cbin + coeff(2,3) * Crin;
b = coeff(3,1) * Yin + coeff(3,2) * Cbin;

0.1644 = ".001010100001011"
0.5960 = ".100110001001001"
0.3918 = ".011001000100110"
0.8130 = ".110100000010000"
0.0172 = ".000001000110011"
*/

//-------------------------------------------------------------------
//YIN * 1.1644
//-------------------------------------------------------------------
assign yp = {2'd0, Yin} - {2'd0, 8'd16};
assign y = {yp, 15'd0}              +
           {{3{yp[8]}},  yp, 12'd0} +
           {{5{yp[8]}},  yp, 10'd0} +
           {{7{yp[8]}},  yp, 8'd0}  +
           {{12{yp[8]}}, yp, 3'd0}  +
           {{14{yp[8]}}, yp, 1'd0}  +
           {{15{yp[8]}}, yp};

always@(negedge nRST or posedge Clk)
	if (!nRST) 	yR <= 0;
	else		yR <= y;
//-------------------------------------------------------------------
//CRIN * 1.5960
//-------------------------------------------------------------------
assign rcrp = {2'd0, Crin} - {2'd0, 8'd128};
assign rcr = {rcrp, 15'd0}                +
             {{1{rcrp[8]}},  rcrp, 14'd0} +
             {{4{rcrp[8]}},  rcrp, 11'd0} +
             {{5{rcrp[8]}},  rcrp, 10'd0} +
             {{9{rcrp[8]}},  rcrp,  6'd0} +
             {{12{rcrp[8]}}, rcrp,  3'd0} +
             {{15{rcrp[8]}}, rcrp};

always@(negedge nRST or posedge Clk)
	if (!nRST) 	rcrR <= 0;
	else		rcrR <= rcr;
//-------------------------------------------------------------------
//-------------------------------------------------------------------
//R GEN
//-------------------------------------------------------------------
//-------------------------------------------------------------------
assign rp = yR + rcrR;

assign Routp = rp[24] ? 8'd0 : (rp[23] ? 8'd255 : rp[22:15]);

//-------------------------------------------------------------------
//CBIN * 0.3918
//-------------------------------------------------------------------
assign gcbp = {2'd0, Cbin} - {2'd0, 8'd128};
assign gcb = {{2{gcbp[8]}},  gcbp, 13'd0} +
             {{3{gcbp[8]}},  gcbp, 12'd0} +
             {{6{gcbp[8]}},  gcbp,  9'd0} +
             {{10{gcbp[8]}}, gcbp,  5'd0} +
             {{13{gcbp[8]}}, gcbp,  2'd0} +
             {{14{gcbp[8]}}, gcbp,  1'd0};

always@(negedge nRST or posedge Clk)
	if (!nRST) 	gcbR <= 0;
	else		gcbR <= gcb;

//-------------------------------------------------------------------
//CRIN * 0.8130
//-------------------------------------------------------------------
assign gcrp = {2'd0, Crin} - {2'd0, 8'd128};
assign gcr = {{1{gcrp[8]}},  gcrp, 14'd0} +
             {{2{gcrp[8]}},  gcrp, 13'd0} +
             {{4{gcrp[8]}},  gcrp, 11'd0} +
             {{11{gcrp[8]}}, gcrp,  4'd0};

always@(negedge nRST or posedge Clk)
	if (!nRST) 	gcrR <= 0;
	else		gcrR <= gcr;

//-------------------------------------------------------------------
//-------------------------------------------------------------------
//G GEN
//-------------------------------------------------------------------
//-------------------------------------------------------------------
assign gp = yR - gcbR - gcrR;

assign Goutp = gp[24] ? 8'd0 : (gp[23] ? 8'd255 : gp[22:15]);

//-------------------------------------------------------------------
//CBIN * 2.0172
//-------------------------------------------------------------------
assign bcbp = {2'd0, Cbin} - {2'd0, 8'd128};
assign bcb = {bcbp,                15'd0} +
             {bcbp,                15'd0} +
             {{6{bcbp[8]}},  bcbp,  9'd0} +
             {{10{bcbp[8]}}, bcbp,  5'd0} +
             {{11{bcbp[8]}}, bcbp,  4'd0} +
             {{14{bcbp[8]}}, bcbp,  1'd0} +
             {{15{bcbp[8]}}, bcbp       };

always@(negedge nRST or posedge Clk)
	if (!nRST) 	bcbR <= 0;
	else		bcbR <= bcb;

//-------------------------------------------------------------------
//-------------------------------------------------------------------
//B GEN
//-------------------------------------------------------------------
//-------------------------------------------------------------------
assign bp = {yR[24], yR} + {bcbR[24], bcbR};

assign Boutp = bp[25] ? 8'd0 : ((bp[23] | bp[24]) ? 8'd255 : bp[22:15]);

//-------------------------------------------------------------------
//OUTPUT DELAY ADJUST
//-------------------------------------------------------------------
always@(negedge nRST or posedge Clk)
	if (!nRST) begin
	   ValidOut0 <= 1'b0;
	   ValidOut  <= 1'b0;
	   Rout <= 8'd0;
	   Gout <= 8'd0;
	   Bout <= 8'd0;
	end
	else begin
	   ValidOut0 <= ValidIn;
	   ValidOut  <= ValidOut0;
	   Rout <= Routp;
	   Gout <= Goutp;
	   Bout <= Boutp;
	end

endmodule