// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module tbackpci(
cpu_adr,
db45_wea_word,
def_lat_cnt,
h_abort_b,
h_adsm_b,
h_aout,
h_beout_b,
h_boff_b,
h_burst_b,
h_burst_cont,
h_cs_b,
h_din,
h_discard,
h_dout,
h_drcmt_b,
h_mrd_cmd,
h_rdyh_b,
h_retry_b,
h_wrout,
more_wb,
mwr_doutb,
pci_bar,
pciclk,
reset_b,
tack_b,
trdreq_b,
trd_abort,
trd_addrb,
trd_be_b,
trd_dlysize,
trd_doutb,
trd_retry,
trd_size,
twrreq_b,
twr_addra,
twr_addrb,
twr_be_b,
twr_dina,
twr_dword_empty,
twr_dword_full,
valid_bit
);
output[31:0] cpu_adr;
output db45_wea_word;
input[4:0] def_lat_cnt;
output h_abort_b;
input h_adsm_b;
input[31:0] h_aout;
input[3:0] h_beout_b;
input h_boff_b;
input h_burst_b;
input h_burst_cont;
input[6:0] h_cs_b;
output[31:0] h_din;
input h_discard;
input[31:0] h_dout;
input h_drcmt_b;
input[1:0] h_mrd_cmd;
output h_rdyh_b;
output h_retry_b;
input h_wrout;
output more_wb;
input[31:0] mwr_doutb;
output[6:0] pci_bar;
input pciclk;
input reset_b;
input tack_b;
output trdreq_b;
input trd_abort;
output[7:0] trd_addrb;
output[3:0] trd_be_b;
output[4:0] trd_dlysize;
input[31:0] trd_doutb;
input trd_retry;
input[4:0] trd_size;
output twrreq_b;
output[7:0] twr_addra;
output[7:4] twr_addrb;
output[63:0] twr_be_b;
output[31:0] twr_dina;
output[15:0] twr_dword_empty;
output[15:0] twr_dword_full;
input[15:0] valid_bit;
wire[6:0] OlI01OlI1OOOl1I;wire OOIl1l0IO1OOl1I;wire O01IlI1lO0OOIl1;wire O1lIOOI01lOOIl1;wire lO10IO01IlOlI1O;wire IIO0lOlI1OOlI1O;
wire l0IO1IO0lIO1lIO;wire IOIl0I1lO0O1lIO;wire l10IOIO01lIO0lI;wire OI01lO01IlIO0lI;wire O01IlIO0lIIIO0l;wire[31:0] OIl01IO01lIOIl0;
wire[3:0] IO0lIO01IlIOIl0;wire lIO10lO10IIlI0O;wire IOIl0IO0lIIlI0O;wire l10IOIOIl0OI01l;wire[7:0] IlI0OIO01lOI01l;wire I01lOOOl1IOlI01;
wire[3:0] OlI01lO10IOlI01;wire[15:0] IO01ll0IO1O01Il;wire OIl01IOIl0O01Il;wire lIO10OOl1IOIl01;wire[63:0] l0IO1l0IO1lO10I;wire IlI0OIOIl0lO10I;
wire I1lO0OI01llIO10;wire OlI01OOl1IlIO10;wire IO01lOlI1Ol0IO1;wire O01Ill0IO1l0IO1;wire IlO01I1lO0l10IO;wire lO10IOI01ll10IO;wire[15:0] OOIl1O01IlI1lO0;
wire l0IO1OlI1OI1lO0;wire O1lIOIO0lII01lO;wire l10IOI1lO0I01lO;wire[31:0] I01lOO01IlIO01l;wire O01IlOlI1OIO01l;wire IlO01IO0lIIlO01;
wire[1:0] OIl01I1lO0IlO01;wire OOl1IIlO01OOl1I;wire[1:0] lIO10OIl01OOl1I;wire OlI1OlIO10OOIl1;wire l10IOIIO0lOOIl1;wire IO0lIIlI0OOlI1O;
wire I1lO0IlO01OlI1O;wire[4:0] IOIl0OOIl1O1lIO;wire IO01llIO10O1lIO;wire[6:0] OOl1IIlI0OIO0lI;wire lO10IIlO01IO0lI;wire OlI1OOOIl1IIO0l;
wire l0IO1lIO10IIO0l;wire[15:0] O1lIOl10IOIOIl0;wire I1lO0IlI0OIOIl0;wire IIO0lOlI01IlI0O;wire[6:0] IO01lOOIl1IlI0O;wire IlI0OO1lIOOI01l;
wire IlO01l10IOOI01l;wire[3:0] OI01lI01lOOlI01;wire OOIl1OlI01OlI01;wire O1lIOO1lIOO01Il;wire l10IOl10IOO01Il;wire[15:0] IO0lII01lOOIl01;
wire I01lOOlI01OIl01;wire IOIl0OIl01lO10I;wire IlO01O1lIOlO10I;wire OI01lIIO0llIO10;wire[5:2] OOl1II01lOlIO10;wire[3:0] OlI01IlO01l0IO1;
wire OlI1OOIl01l0IO1;wire OIl01lIO10l10IO;wire IO0lIIIO0ll10IO;wire IIO0lIlO01I1lO0;wire IO01lOIl01I1lO0;wire[15:0] IlI0OlIO10I01lO;
wire OOl1IIIO0lI01lO;wire[4:0] OlI01IlI0OIO01l;wire OOIl1IlO01IO01l;wire OIl01OOIl1IlO01;wire O1lIOlIO10IlO01;wire lO10II1lO0OOl1I;
wire IIO0lOI01lOOl1I;wire l0IO1O01IlOOIl1;wire IlI0OOlI1OOOIl1;wire OI01lI1lO0OlI1O;wire[6:0] O01IlO01IlO1lIO;wire O1lIOOlI1OO1lIO;
wire lO10IIO0lIIO0lI;wire[3:0] IO0lII1lO0IO0lI;wire lIO10IO01lIIO0l;wire IOIl0O01IlIIO0l;wire l10IOlO10IIOIl0;wire OI01lIO0lIIOIl0;
wire I01lOIOIl0IlI0O;wire OlI01IO01lIlI0O;wire OIl01lO10IOI01l;wire[63:0] lIO10IOIl0OlI01;wire IIO0lIO01lOlI01;wire[15:0] l10IOOOl1IO01Il;
wire IlI0OlO10IO01Il;wire I1lO0l0IO1OIl01;wire[7:0] OlI01IOIl0OIl01;wire IO01lOI01llO10I;wire[3:0] OIl01OOl1IlO10I;wire[15:0] OOl1IOlI1OlIO10;
wire lO10Il0IO1lIO10;wire l0IO1OI01ll0IO1;wire[31:0] I1lO0OlI1Ol10IO;wire OI01ll0IO1l10IO;wire I01lOI1lO0I1lO0;wire O01IlOI01lI1lO0;
wire IlO01O01IlI01lO;wire[1:0] lO10IOlI1OI01lO;wire OOIl1IO0lIIO01l;wire lIO10I1lO0IO01l;wire OlI1OIO01lIlO01;wire l10IOO01IlIlO01;
wire[6:0] IO0lIlIO10OOl1I;wire I01lOIIO0lOOl1I;wire[3:0] IO01lIlO01OOIl1;wire OIl01OIl01OOIl1;wire OOl1IlIO10OlI1O;wire[1:0] lIO10IIO0lOlI1O;
wire[15:0] OlI1OIlI0OO1lIO;wire l0IO1IlO01O1lIO;wire IO0lIOOIl1IO0lI;wire[1:0] I1lO0lIO10IO0lI;wire[15:0] IIO0ll10IOIIO0l;wire IO01lIlI0OIIO0l;
wire[31:0] IlI0OOlI01IOIl0;wire OOl1IOOIl1IOIl0;wire OOIl1l10IOIlI0O;wire l0IO1IlI0OIlI0O;wire[15:0] O1lIOOlI01OI01l;wire I1lO0OOIl1OI01l;
wire[15:0] IIO0lO1lIOOlI01;wire I01lOl10IOOlI01;wire IOIl0I01lOO01Il;wire[3:0] IlO01OlI01O01Il;wire OI01lOIl01OIl01;wire OOIl1O1lIOOIl01;
wire[3:0] O01IlIIO0llO10I;wire OlI1OI01lOlO10I;wire IO0lIOIl01lIO10;wire I01lOO1lIOlIO10;wire[15:0] IOIl0IIO0ll0IO1;wire IO01lI01lOl0IO1;
wire[4:0] IlI0OIlO01l10IO;wire OOl1IOIl01l10IO;wire OlI01lIO10I1lO0;wire[31:0] OlI1OIIO0lI1lO0;wire[3:0] OIl01IlI0OI01lO;wire O1lIOIlO01I01lO;
wire[31:0] lIO10OOIl1IO01l;wire IIO0llIO10IO01l;wire IlI0OIlI0OIlO01;wire IlO01IlO01IlO01;
assign OlI1OIO01lIlO01=l0IO1IlO01O1lIO;assign l10IOIOIl0OI01l
=IlO01l10IOOI01l&~h_adsm_b&~h_wrout&~h_burst_b&O1lIOIO0lII01lO&~I01lOIOIl0IlI0O;assign IIO0ll10IOIIO0l[14]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1110)))?1'b1:1'b0;assign lIO10lO10IIlI0O
=l10IOOOl1IO01Il[IO01lIlO01OOIl1];assign pci_bar
=((l0IO1OI01ll0IO1&~(IO01lI01lOl0IO1|IlO01O1lIOlO10I))|OIl01lO10IOI01l|OI01lI1lO0OlI1O)?IO0lIlIO10OOl1I:
(OlI01OOl1IlIO10)?OlI01OlI1OOOl1I:O01IlO01IlO1lIO;dffe7 IO01IlI01lOOI01l
(O01IlO01IlO1lIO,OOl1IIlI0OIO0lI,pciclk,reset_b,1'b1,IlI0OO1lIOOI01l);dff IO01IlOI01lIOIl0
(O1lIOIlO01I01lO,OlI1OOIl01l0IO1,pciclk,reset_b,1'b1);dffe4 IIO0lIOlI1OOIl01
(l0IO1l0IO1lO10I[63:60],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[15]);assign lIO10I1lO0IO01l
=~(~trd_size[4]&~trd_size[3]&~trd_size[2]&~trd_size[1]&trd_size[0]);dffe II01lOIlI0Ol0IO1
(IlI0OlIO10I01lO[2],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[2]);assign I1lO0OOIl1OI01l
=~O01IlOI01lI1lO0&O1lIOO1lIOO01Il&OlI1OOOIl1IIO0l;dffe IO01IllO10II01lO
(IOIl0IIO0ll0IO1[5],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[5]);assign lIO10IO01lIIO0l
=l0IO1OI01ll0IO1&IlO01O1lIOlO10I;dffe IO1lIOIO01lOOl1I
(IO0lII01lOOIl01[8],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[8]);dffe II01lOO1lIOO1lIO
(O1lIOOlI01OI01l[11],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[11]);assign OOl1IIlI0OIO0lI[0]=~h_cs_b[0];assign lO10Il0IO1lIO10
=(I1lO0IlO01OlI1O&h_burst_b&h_burst_cont&~OIl01lIO10l10IO)|
(l0IO1OlI1OI1lO0&h_burst_b&h_burst_cont);assign IIO0ll10IOIIO0l[6]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0110)))?1'b1:1'b0;dff IIO0lIIO01lIO01l
(lO10IIO0lIIO0lI,lIO10lO10IIlI0O,pciclk,reset_b,1'b1);assign OOIl1O01IlI1lO0[9]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1001)))?1'b1:1'b0;assign OOIl1l10IOIlI0O
=(IIO0lIlO01I1lO0&~OlI1OOOIl1IIO0l)|(O1lIOO1lIOO01Il&~OlI1OOOIl1IIO0l);assign OOIl1IlO01IO01l
=(l0IO1IlI0OIlI0O)?1'b0:~(h_beout_b[3]|h_beout_b[2]|h_beout_b[1]|h_beout_b[0]);dffe4 Il10IOIlI0Ol10IO
(l0IO1l0IO1lO10I[31:28],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[7]);assign IOIl0I01lOO01Il
=IIO0llIO10IO01l&~O1lIOIlO01I01lO;dffe4 IOI01llO10IIO01l
(lIO10IOIl0OlI01[43:40],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[10]);assign O01IlOlI1OIO01l
=~O1lIOIlO01I01lO|I1lO0l0IO1OIl01|OOl1IOOIl1IOIl0;dffe IOOIl1IO01lOOIl1
(IlI0OlIO10I01lO[13],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[13]);dff IIIO0lOOIl1lO10I
(O01IlOI01lI1lO0,OlI01OOl1IlIO10,pciclk,reset_b,1'b1);dffe Il10IOO1lIOIO0lI
(IO0lII01lOOIl01[0],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[0]);assign twr_addrb[7:5]=3'b000;dffe IOI01lOI01lIlI0O
(O1lIOOlI01OI01l[3],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[3]);dff IOOIl1lIO10O01Il
(I1lO0OI01llIO10,I01lOI1lO0I1lO0,pciclk,reset_b,1'b1);dff II01lOlO10IIIO0l
(OIl01IOIl0O01Il,OlI01IO01lIlI0O,pciclk,reset_b,1'b1);assign l10IOl10IOO01Il=I1lO0OOIl1OI01l;assign h_abort_b
=~(OOl1IOOIl1IOIl0&~h_burst_b&~OI01lIO0lIIOIl0&OOl1IlIO10OlI1O);assign OOIl1O01IlI1lO0[1]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0001)))?1'b1:1'b0;dff IIlO01IOIl0IOIl0
(OIl01lO10IOI01l,O01IlIO0lIIIO0l,pciclk,reset_b,1'b1);assign IlI0OOlI01IOIl0=(OIl01IOIl0O01Il)?lIO10OOIl1IO01l:h_aout[31:0];dffe32 IIOIl0lO10IIlO01
(I1lO0OlI1Ol10IO[31:0],IlI0OOlI01IOIl0[31:0],pciclk,reset_b,1'b1,OlI1OIO01lIlO01);dffe2 IIOIl0O1lIOI01lO
(OlI1OIIO0lI1lO0[7:6],h_aout[7:6],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IIlO01IO01lOlI1O
(lIO10IOIl0OlI01[11:8],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[2]);assign O1lIOl10IOIOIl0[15:0]
=
(IOIl0I1lO0O1lIO&(OOl1IlIO10OlI1O|I01lOI1lO0I1lO0|lIO10lO10IIlI0O))?OlI1OIlI0OO1lIO[15:0]:16'h0000;dffe IlIO10O1lIOIIO0l
(IlI0OlIO10I01lO[5],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[5]);assign l0IO1IlO01O1lIO
=IOIl0IO0lIIlI0O&l10IOIO01lIO0lI&
((IlO01l10IOOI01l&~h_adsm_b&h_wrout&O1lIOIO0lII01lO)|(OIl01IOIl0O01Il&~h_burst_b));dffe IIOIl0OI01lOI01l
(IOIl0IIO0ll0IO1[8],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[8]);assign OI01lI01lOOlI01
=(IlO01l10IOOI01l)?h_aout[5:2]:
(OIl01IOIl0O01Il)?4'b0000:
(I1lO0IlO01OlI1O)?O01IlIIO0llO10I+4'b0001:O01IlIIO0llO10I;dffe IIlO01lIO10OIl01
(IO0lII01lOOIl01[11],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[11]);dffe IlO10IIO01ll0IO1
(O1lIOOlI01OI01l[14],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[14]);assign OOl1IIlI0OIO0lI[3]=~h_cs_b[3];assign IO0lIIIO0ll10IO
=IlO01l10IOOI01l&~h_adsm_b&~h_wrout&~h_burst_b&O1lIOIO0lII01lO&~OOl1IIlO01OOl1I&I01lOIOIl0IlI0O;assign IIO0ll10IOIIO0l[9]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1001)))?1'b1:1'b0;assign OlI01IlO01l0IO1[3:0]
=(IlO01l10IOOI01l)?4'b0000:
(OIl01IOIl0O01Il)?4'b0000:
((I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&~h_burst_b)?OIl01IlI0OI01lO[3:0]+4'b0001:
OIl01IlI0OI01lO[3:0];assign OOIl1O01IlI1lO0[12]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1100)))?1'b1:1'b0;assign IlO01I1lO0l10IO
=~IO0lIOIl01lIO10;dffe32 II1lO0OOl1IIO01l(OIl01IO01lIOIl0,h_aout,pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IOIl01O1lIOIOIl0
(l0IO1l0IO1lO10I[43:40],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[10]);assign OI01lIIO0llIO10
=OIl01lO10IOI01l&~OlI1OOOIl1IIO0l;dffe4 IIO0lIOI01lOlI01
(lIO10IOIl0OlI01[55:52],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[13]);assign O1lIOlIO10IlO01
=OlI01IOIl0OIl01[7]|
(IOIl0O01IlIIO0l&~(OOl1IIIO0lI01lO&OOl1IOIl01l10IO));dffe II01lOlIO10lO10I
(IOIl0IIO0ll0IO1[0],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[0]);assign l0IO1O01IlOOIl1
=IO01lI01lOl0IO1&IlO01O1lIOlO10I;dffe IO01IlIO01ll10IO
(IO0lII01lOOIl01[3],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[3]);assign trd_addrb[3:0]=OlI01lO10IOlI01[3:0];dffe IIO0lIO1lIOIO01l
(O1lIOOlI01OI01l[6],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[6]);dff II01lOOlI01OOIl1
(IlO01IO0lIIlO01,OOl1IlIO10OlI1O,pciclk,reset_b,1'b1);dff IlIO10IlI0OI1lO0
(OlI1OI01lOlO10I,OOIl1OlI01OlI01,pciclk,reset_b,1'b1);assign IIO0ll10IOIIO0l[1]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0001)))?1'b1:1'b0;assign h_retry_b
=O1lIOIO0lII01lO;assign OOIl1O01IlI1lO0[4]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0100)))?1'b1:1'b0;dff Il10IOOOIl1I01lO
(O1lIOO1lIOO01Il,OOIl1l10IOIlI0O,pciclk,reset_b,1'b1);assign twr_be_b[63:0]
=(OlI01OOl1IlIO10)?lIO10IOIl0OlI01[63:0]:l0IO1l0IO1lO10I[63:0];dffe4 IOlI1OOI01lO01Il
(l0IO1l0IO1lO10I[11:8],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[2]);dffe4 IOOIl1IlO01OI01l
(IlO01OlI01O01Il[3:0],h_beout_b[3:0],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 Il10IOlIO10lIO10
(lIO10IOIl0OlI01[23:20],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[5]);dff8 IlIO10O01IlO01Il
(OlI01IOIl0OIl01[7:0],IlI0OIO01lOI01l[7:0],pciclk,reset_b,1'b1);dffe IOI01lIO01lI1lO0
(IlI0OlIO10I01lO[8],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[8]);assign OOl1IIIO0lI01lO
=(lIO10IIO0lOlI1O==2'b00)?1'b1:1'b0;dffe IOlI1OO1lIOIlO01
(IOIl0IIO0ll0IO1[11],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[11]);assign db45_wea_word
=(I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&~h_burst_b;dffe Il10IOOlI01OlI1O
(IO0lII01lOOIl01[14],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[14]);dff IOI01ll0IO1IIO0l
(OlI1OlIO10OOIl1,IO0lIOOIl1IO0lI,pciclk,1'b1,reset_b);assign OOl1IIlI0OIO0lI[6]=~h_cs_b[6];assign l10IOI1lO0I01lO
=IlO01l10IOOI01l&~h_adsm_b&~h_wrout&~h_burst_b&O1lIOIO0lII01lO&~OOl1IIlO01OOl1I&~I01lOIOIl0IlI0O;assign IIO0ll10IOIIO0l[12]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1100)))?1'b1:1'b0;assign OI01lIO0lIIOIl0
=
(OIl01OOl1IlO10I[3:0]==4'b0000)?l10IOOOl1IO01Il[0]:
(OIl01OOl1IlO10I[3:0]==4'b0001)?l10IOOOl1IO01Il[1]:
(OIl01OOl1IlO10I[3:0]==4'b0010)?l10IOOOl1IO01Il[2]:
(OIl01OOl1IlO10I[3:0]==4'b0011)?l10IOOOl1IO01Il[3]:
(OIl01OOl1IlO10I[3:0]==4'b0100)?l10IOOOl1IO01Il[4]:
(OIl01OOl1IlO10I[3:0]==4'b0101)?l10IOOOl1IO01Il[5]:
(OIl01OOl1IlO10I[3:0]==4'b0110)?l10IOOOl1IO01Il[6]:
(OIl01OOl1IlO10I[3:0]==4'b0111)?l10IOOOl1IO01Il[7]:
(OIl01OOl1IlO10I[3:0]==4'b1000)?l10IOOOl1IO01Il[8]:
(OIl01OOl1IlO10I[3:0]==4'b1001)?l10IOOOl1IO01Il[9]:
(OIl01OOl1IlO10I[3:0]==4'b1010)?l10IOOOl1IO01Il[10]:
(OIl01OOl1IlO10I[3:0]==4'b1011)?l10IOOOl1IO01Il[11]:
(OIl01OOl1IlO10I[3:0]==4'b1100)?l10IOOOl1IO01Il[12]:
(OIl01OOl1IlO10I[3:0]==4'b1101)?l10IOOOl1IO01Il[13]:
(OIl01OOl1IlO10I[3:0]==4'b1110)?l10IOOOl1IO01Il[14]:
l10IOOOl1IO01Il[15];assign OOIl1O01IlI1lO0[15]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1111)))?1'b1:1'b0;assign OOIl1IO0lIIO01l
=~IIO0lOlI01IlI0O&(IIO0lIO01lOlI01|IO01lOI01llO10I);assign trd_dlysize=IOIl0OOIl1O1lIO;dffe4 IIOIl0IO01lI01lO
(l0IO1l0IO1lO10I[55:52],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[13]);assign OOl1II01lOlIO10[5:2]
=(IIO0llIO10IO01l&~O1lIOIlO01I01lO)?h_aout[5:2]:
(OlI1OI01lOlO10I&(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0))?OlI1OIIO0lI1lO0[5:2]+4'b0001:
(OOl1IOOIl1IOIl0&~h_burst_b&OI01lIO0lIIOIl0&~O01IlI1lO0OOIl1)?OlI1OIIO0lI1lO0[5:2]+4'b0001:
(OOl1IOOIl1IOIl0&h_burst_b&h_discard)?OlI1OIIO0lI1lO0[5:2]-4'b0001:OlI1OIIO0lI1lO0[5:2];dffe IOOl1IIO0lIOOl1I
(IlI0OlIO10I01lO[0],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[0]);assign OIl01I1lO0IlO01
=(I1lO0OOIl1OI01l==1'b1)?2'b00:
(l0IO1lIO10IIO0l==1'b1)?2'b01:
(I01lOOlI01OIl01==1'b1)?2'b10:
lIO10IIO0lOlI1O;dffe IlIO10OlI01O1lIO
(IOIl0IIO0ll0IO1[3],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[3]);assign IOIl0IO0lIIlI0O
=~OIl01OIl01OOIl1&(lO10IO01IlOlI1O|IlI0OlO10IO01Il);dffe IIOIl0l0IO1IOIl0
(IO0lII01lOOIl01[6],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[6]);dffe IIlO01IlO01OlI01
(O1lIOOlI01OI01l[9],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[9]);assign I01lOI1lO0I1lO0=lO10II1lO0OOl1I;assign IO01lIlI0OIIO0l
=(IlO01l10IOOI01l&(h_adsm_b|h_burst_b|~O1lIOIO0lII01lO))|
(I1lO0IlO01OlI1O&h_burst_b&~h_burst_cont)|
(l0IO1OlI1OI1lO0&h_burst_b&~h_burst_cont)|
(OIl01IOIl0O01Il&(~l10IOIO01lIO0lI|h_burst_b))|
(OI01lO01IlIO0lI&h_burst_b&~h_burst_cont)|
(OOl1IOOIl1IOIl0&(h_burst_b|(~OI01lIO0lIIOIl0&(IOIl0OIl01lO10I|OOl1IlIO10OlI1O|I01lOI1lO0I1lO0))|(O01IlI1lO0OOIl1&OI01lIO0lIIOIl0)))|
(OlI1OI01lOlO10I&~(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)&IOIl0OIl01lO10I)|
(IIO0llIO10IO01l&O1lIOIlO01I01lO)|(I01lOIIO0lOOl1I);assign IIO0ll10IOIIO0l[4]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0100)))?1'b1:1'b0;assign IOIl0OIl01lO10I
=(OlI01IlI0OIO01l[4:0]==5'b00000)?1'b1:1'b0;assign OOIl1O01IlI1lO0[7]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0111)))?1'b1:1'b0;assign IlI0OIlI0OIlO01
=(OIl01lO10IOI01l&~OlI1OOOIl1IIO0l)|(OI01lI1lO0OlI1O&~OlI1OOOIl1IIO0l);assign twr_dword_empty[15:0]
=(OlI01OOl1IlIO10)?IOIl0IIO0ll0IO1[15:0]:IlI0OlIO10I01lO[15:0];dffe4 IIO01lIO0lIOOIl1
(l0IO1l0IO1lO10I[23:20],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[5]);dffe2 II01lOl0IO1IlO01
(I1lO0lIO10IO0lI[1:0],h_mrd_cmd[1:0],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IOIl01OlI01IO0lI
(lIO10IOIl0OlI01[35:32],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[8]);assign I1lO0l0IO1OIl01
=(((IOIl0I1lO0O1lIO&(IIO0llIO10IO01l|I01lOIIO0lOOl1I))==1'b1)&
(OlI1OIIO0lI1lO0==h_aout)&
((IlO01OlI01O01Il==h_beout_b)|(l10IOIIO0lOOIl1==1'b1))&
(IO01lOOIl1IlI0O==h_cs_b)&(lO10IOI01ll10IO==h_wrout)&
((OIl01OOl1IlO10I[3:0]!=4'b0000)|(I1lO0lIO10IO0lI==h_mrd_cmd)))?1'b1:1'b0;dffe IIO0lIl0IO1IlI0O
(IlI0OlIO10I01lO[11],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[11]);assign IlO01O1lIOlO10I
=(lIO10OIl01OOl1I==2'b10)?1'b1:1'b0;dffe II01lOIlO01O01Il
(IOIl0IIO0ll0IO1[14],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[14]);assign twr_addra[3:0]=OIl01IlI0OI01lO[3:0];dffe IOIl01IO0lIlIO10
(O1lIOOlI01OI01l[1],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[1]);dff IIO0lIOlI01I1lO0
(l0IO1IO0lIO1lIO,trd_retry,pciclk,reset_b,1'b1);dff IOOl1IOI01lOIl01(I1lO0IlO01OlI1O,l10IOO01IlIlO01,pciclk,reset_b,1'b1);assign OI01lOIl01OIl01
=(I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&~h_burst_b&~IlI0OlO10IO01Il;assign I01lOO1lIOlIO10
=OOl1IOOIl1IOIl0&((~OI01lIO0lIIOIl0&(IOIl0OIl01lO10I|OOl1IlIO10OlI1O|I01lOI1lO0I1lO0))|
h_burst_b|(O01IlI1lO0OOIl1&OI01lIO0lIIOIl0));assign IIO0ll10IOIIO0l[15]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1111)))?1'b1:1'b0;assign IlO01O01IlI01lO
=OOl1IOOIl1IOIl0&~h_burst_b&OI01lIO0lIIOIl0&O01IlI1lO0OOIl1;assign IO0lIO01IlIOIl0[3:0]
=(l10IOl10IOO01Il)?4'b1111:h_beout_b[3:0];dffe7 IOlI01OlI01IIO0l
(OlI01OlI1OOOl1I,OOl1IIlI0OIO0lI,pciclk,reset_b,1'b1,OlI1OIO01lIlO01);dff IOlI01OOl1IO1lIO
(IOIl0I1lO0O1lIO,IIO0lOI01lOOl1I,pciclk,reset_b,1'b1);dffe4 IOlI1Ol0IO1OI01l
(lIO10IOIl0OlI01[3:0],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[0]);assign OOl1IIlO01OOl1I
=((OlI1OIIO0lI1lO0==h_aout)&
((IlO01OlI01O01Il==h_beout_b)|(l10IOIIO0lOOIl1==1'b1))&
(IO01lOOIl1IlI0O==h_cs_b)&(lO10IOI01ll10IO==h_wrout)&
((OIl01OOl1IlO10I[3:0]!=4'b0000)|(I1lO0lIO10IO0lI==h_mrd_cmd))&
(IOIl0I1lO0O1lIO==1'b1)&
((OI01lIO0lIIOIl0==1'b1)|(lIO10lO10IIlI0O==1'b1)|
(OOl1IlIO10OlI1O==1'b1)|(I01lOI1lO0I1lO0==1'b1)))?1'b1:1'b0;dffe Il10IOIlO01OIl01
(IlI0OlIO10I01lO[3],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[3]);assign I1lO0IlI0OIOIl0
=O01IlOI01lI1lO0&O1lIOO1lIOO01Il&OlI1OOOIl1IIO0l;dffe IOlI01IO0lIl0IO1
(IOIl0IIO0ll0IO1[6],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[6]);assign OlI01OOl1IlIO10
=~lO10IIlO01IO0lI&(lIO10IO01lIIO0l|O01IlOI01lI1lO0);dffe IOlI1OOlI01I01lO
(IO0lII01lOOIl01[9],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[9]);dffe Il10IOl10IOOOl1I
(O1lIOOlI01OI01l[12],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[12]);assign OOl1IIlI0OIO0lI[1]=~h_cs_b[1];assign OlI01IO01lIlI0O
=(I1lO0IlO01OlI1O&~h_burst_b&OIl01lIO10l10IO)|
(OI01lO01IlIO0lI&~h_burst_b);assign IIO0ll10IOIIO0l[7]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0111)))?1'b1:1'b0;dff4 IO1lIOO01Ill10IO
(OIl01IlI0OI01lO[3:0],OlI01IlO01l0IO1[3:0],pciclk,reset_b,1'b1);assign OOIl1O01IlI1lO0[10]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1010)))?1'b1:1'b0;dff IlIO10lIO10l0IO1
(twrreq_b,IlO01I1lO0l10IO,pciclk,1'b1,reset_b);assign twr_dword_full[15:0]
=(OlI01OOl1IlIO10)?O1lIOOlI01OI01l[15:0]:IO0lII01lOOIl01[15:0];dffe4 IlIO10IlO01lO10I
(l0IO1l0IO1lO10I[35:32],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[8]);assign IlI0OIOIl0lO10I
=((IlO01l10IOOI01l|OOl1IOOIl1IOIl0)&~h_drcmt_b)|
((IlO01l10IOOI01l|OOl1IOOIl1IOIl0)&IO01lOlI1Ol0IO1&~h_discard)|
(OOl1IOOIl1IOIl0&~OI01lIO0lIIOIl0&lIO10lO10IIlI0O&~h_discard)|
(OOl1IOOIl1IOIl0&~h_burst_b&~OI01lIO0lIIOIl0&(OOl1IlIO10OlI1O|I01lOI1lO0I1lO0))|
O01Ill0IO1l0IO1|O1lIOlIO10IlO01;dffe4 IIlI0OIO0lIl10IO
(lIO10IOIl0OlI01[47:44],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[11]);assign IIO0lOlI1OOlI1O
=~O01IlOlI1OIO01l&(OIl01OOIl1IlO01|IOIl0O01IlIIO0l);dffe IOOl1IOlI01IO01l
(IlI0OlIO10I01lO[14],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[14]);assign I01lOIOIl0IlI0O
=OOl1IIIO0lI01lO&OOl1IOIl01l10IO;dffe IlIO10l10IOOOIl1
(IO0lII01lOOIl01[1],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[1]);assign twr_addrb[4]=OlI01OOl1IlIO10;dffe IIlI0OOOl1IIO0lI
(O1lIOOlI01OI01l[4],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[4]);dff IOOl1IIIO0lIlI0O
(I01lOOOl1IOlI01,trd_abort,pciclk,reset_b,1'b1);dff II1lO0IO0lIOlI1O(OI01lO01IlIO0lI,IlI0OOlI1OOOIl1,pciclk,reset_b,1'b1);assign l0IO1IlI0OIlI0O
=I1lO0IlI0OIOIl0;assign h_rdyh_b
=~(((I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI|(OOl1IOOIl1IOIl0&OI01lIO0lIIOIl0))&~h_burst_b)|
(OlI1OI01lOlO10I&(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)));assign OOIl1O01IlI1lO0[2]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0010)))?1'b1:1'b0;dff II01lOIO01lO1lIO
(OI01lI1lO0OlI1O,IlI0OIlI0OIlO01,pciclk,reset_b,1'b1);assign lIO10OOIl1IO01l[31:6]
=(IlI0OlO10IO01Il)?I1lO0OlI1Ol10IO[31:6]+26'h0000001:
I01lOO01IlIO01l[31:6]+26'h0000001;dffe4 IIIO0lIO0lII1lO0
(l0IO1l0IO1lO10I[3:0],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[0]);dff4 IIO0lIl10IOl0IO1
(OlI1OIIO0lI1lO0[5:2],OOl1II01lOlIO10[5:2],pciclk,reset_b,1'b1);dffe4 IIO01lOlI01IlO01
(lIO10IOIl0OlI01[15:12],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[3]);assign OlI1OIlI0OO1lIO[15:0]
=IIO0lO1lIOOlI01[15:0]+16'h0001;dffe IOIl01l10IOOlI1O
(IlI0OlIO10I01lO[6],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[6]);assign I01lOOlI01OIl01
=~IlI0OlO10IO01Il&(((I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&h_burst_b&~h_burst_cont)|OIl01IOIl0O01Il);dffe IIIO0lOOl1IIIO0l
(IOIl0IIO0ll0IO1[9],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[9]);dff4 IO1lIOlIO10OlI01
(O01IlIIO0llO10I,OI01lI01lOOlI01,pciclk,reset_b,1'b1);dffe IIO01lIIO0lOI01l
(IO0lII01lOOIl01[12],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[12]);dffe IOIl01O01IlOIl01
(O1lIOOlI01OI01l[15],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[15]);assign OOl1IIlI0OIO0lI[4]=~h_cs_b[4];assign OOIl1OlI01OlI01
=(IIO0llIO10IO01l&~O1lIOIlO01I01lO)|(OlI1OI01lOlO10I&~(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)&~IOIl0OIl01lO10I);assign IIO0ll10IOIIO0l[10]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1010)))?1'b1:1'b0;assign OlI01lO10IOlI01[3:0]
=(IIO0llIO10IO01l&~O1lIOIlO01I01lO)?4'b0000:
(OlI1OI01lOlO10I&IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)?OIl01OOl1IlO10I[2:0]+3'b001:
(OOl1IOOIl1IOIl0&~h_burst_b&OI01lIO0lIIOIl0&~O01IlI1lO0OOIl1)?OIl01OOl1IlO10I[3:0]+4'b0001:
(OOl1IOOIl1IOIl0&h_burst_b&h_discard)?OIl01OOl1IlO10I[3:0]-4'b0001:OIl01OOl1IlO10I[3:0];assign OOIl1O01IlI1lO0[13]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1101)))?1'b1:1'b0;assign IIO0lOlI01IlI0O
=l0IO1OI01ll0IO1&~(IO01lI01lOl0IO1|IlO01O1lIOlO10I)&
((O1lIOIlO01I01lO&~IOIl0I1lO0O1lIO)|
(IOIl0I01lOO01Il&~IOIl0I1lO0O1lIO));dffe Il0IO1lO10Il10IO
(IOIl0OOIl1O1lIO[0],trd_size[0],pciclk,1'b1,reset_b,OOIl1O1lIOOIl01);dffe4 IOlI01l10IOO1lIO
(l0IO1l0IO1lO10I[47:44],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[11]);assign OI01ll0IO1l10IO
=((IlO01l10IOOI01l|OOl1IOOIl1IOIl0)&~h_drcmt_b)|
((IlO01l10IOOI01l|OOl1IOOIl1IOIl0)&IO01lOlI1Ol0IO1&~h_discard)|
(OOl1IOOIl1IOIl0&~OI01lIO0lIIOIl0&lIO10lO10IIlI0O&~h_discard)|
(OOl1IOOIl1IOIl0&~h_burst_b&~OI01lIO0lIIOIl0&(OOl1IlIO10OlI1O|I01lOI1lO0I1lO0))|
O01Ill0IO1l0IO1|O1lIOlIO10IlO01;dffe4 IO1lIOOOl1IIOIl0
(lIO10IOIl0OlI01[59:56],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[14]);dff2 IOlI01IOIl0OOIl1
(lIO10IIO0lOlI1O[1:0],OIl01I1lO0IlO01[1:0],pciclk,reset_b,1'b1);dffe II1lO0IIO0lOlI01
(IOIl0IIO0ll0IO1[1],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[1]);assign OIl01OIl01OOIl1
=(IlO01l10IOOI01l|OIl01IOIl0O01Il)&OOl1IIIO0lI01lO;dffe IOlI01O01IllO10I
(IO0lII01lOOIl01[4],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[4]);assign h_din[31:0]
=(h_boff_b)?mwr_doutb[31:0]:trd_doutb[31:0];dffe IOlI1Ol10IOl10IO
(O1lIOOlI01OI01l[7],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[7]);assign OlI1OOOIl1IIO0l=OlI1OlIO10OOIl1;dff IOIl01IlO01lIO10
(OOl1IOOIl1IOIl0,IO01llIO10O1lIO,pciclk,reset_b,1'b1);assign IIO0ll10IOIIO0l[2]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0010)))?1'b1:1'b0;dff5 IIlI0Ol10IOIO0lI
(OlI01IlI0OIO01l[4:0],IlI0OIlO01l10IO[4:0],pciclk,reset_b,1'b1);assign OOIl1O01IlI1lO0[5]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0101)))?1'b1:1'b0;assign lIO10OOl1IOIl01
=(l0IO1OI01ll0IO1&~(O1lIOIlO01I01lO&~IOIl0I1lO0O1lIO)&~(IO01lI01lOl0IO1|IlO01O1lIOlO10I))|
(OI01lI1lO0OlI1O&OlI1OOOIl1IIO0l)|
(O1lIOO1lIOO01Il&OlI1OOOIl1IIO0l);assign O1lIOOlI1OO1lIO
=(l10IOl10IOO01Il)?1'b1:(h_beout_b[3]&h_beout_b[2]&h_beout_b[1]&h_beout_b[0]);dffe4 IOOIl1OOl1IIlI0O
(l0IO1l0IO1lO10I[15:12],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[3]);dffe7 IOOl1IOIl01IIO0l
(IO01lOOIl1IlI0O,h_cs_b,pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 Il0IO1IIO0lO01Il
(lIO10IOIl0OlI01[27:24],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[6]);dff IlO10IOlI1OIlI0O
(OIl01OOIl1IlO01,OlI01lIO10I1lO0,pciclk,reset_b,1'b1);dffe IIlI0OO01IllIO10
(IlI0OlIO10I01lO[9],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[9]);assign OOl1IOIl01l10IO
=(lIO10OIl01OOl1I==2'b00)?1'b1:1'b0;dffe IOOl1Il10IOI1lO0
(IOIl0IIO0ll0IO1[12],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[12]);assign twr_addra[7:5]=3'b000;dffe Il0IO1OOl1IIlO01
(IO0lII01lOOIl01[15],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[15]);dff16 IIlI0OIOIl0OlI1O
(OOl1IOlI1OlIO10[15:0],valid_bit[15:0],pciclk,reset_b,1'b1);assign IlI0OO1lIOOI01l=l0IO1lIO10IIO0l;dff IOlI01O1lIOIlI0O
(IlO01IlO01IlO01,IO01lOIl01I1lO0,pciclk,reset_b,1'b1);assign IIO0ll10IOIIO0l[13]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1101)))?1'b1:1'b0;assign IO01lIlO01OOIl1[3:0]
=IOIl0OOIl1O1lIO[3:0]-4'b0001;assign cpu_adr[31:0]
=((l0IO1OI01ll0IO1&~(IO01lI01lOl0IO1|IlO01O1lIOlO10I))|OIl01lO10IOI01l|OI01lI1lO0OlI1O)?OIl01IO01lIOIl0[31:0]:
(OlI01OOl1IlIO10)?I1lO0OlI1Ol10IO[31:0]:I01lOO01IlIO01l[31:0];assign trdreq_b
=IO01lOI01llO10I;dffe7 IOIl01I1lO0OlI01(IO0lIlIO10OOl1I,OOl1IIlI0OIO0lI,pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IIIO0lO01Ill0IO1
(l0IO1l0IO1lO10I[59:56],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[14]);assign OOIl1O1lIOOIl01
=IIO0llIO10IO01l&~O1lIOIlO01I01lO;dffe IIO01ll10IOI01lO
(IlI0OlIO10I01lO[1],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[1]);assign lO10IOlI1OI01lO
=(I1lO0IlI0OIOIl0==1'b1)?2'b00:
(l0IO1IlO01O1lIO==1'b1)?2'b01:
(I01lOl10IOOlI01==1'b1)?2'b10:
lIO10OIl01OOl1I;dffe IlO10IOOIl1OOl1I
(IOIl0IIO0ll0IO1[4],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[4]);assign lO10IIlO01IO0lI
=l0IO1OI01ll0IO1&IO01lI01lOl0IO1;dffe IIIO0lIOIl0O1lIO
(IO0lII01lOOIl01[7],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[7]);dffe IIO01lOIl01IOIl0
(O1lIOOlI01OI01l[10],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[10]);assign OOl1IlIO10OlI1O=l10IOlO10IIOIl0;assign l10IOO01IlIlO01
=(IlO01l10IOOI01l&~h_adsm_b&h_wrout&~h_burst_b&O1lIOIO0lII01lO)|
(I1lO0IlO01OlI1O&~h_burst_b&~OIl01lIO10l10IO)|
(l0IO1OlI1OI1lO0&~h_burst_b)|
(OIl01IOIl0O01Il&l10IOIO01lIO0lI&~h_burst_b);assign IIO0ll10IOIIO0l[5]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0101)))?1'b1:1'b0;dff IIOIl0IlI0OOOIl1
(IO01lOlI1Ol0IO1,IlO01O01IlI01lO,pciclk,reset_b,1'b1);assign OOIl1O01IlI1lO0[8]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1000)))?1'b1:1'b0;assign IO0lIOIl01lIO10
=(l0IO1OI01ll0IO1&(IO01lI01lOl0IO1|IlO01O1lIOlO10I))|(IIO0lIlO01I1lO0&OlI1OOOIl1IIO0l);assign OOIl1l0IO1OOl1I
=(l10IOl10IOO01Il)?1'b0:~(h_beout_b[3]|h_beout_b[2]|h_beout_b[1]|h_beout_b[0]);dffe4 II1lO0l10IOIO01l
(l0IO1l0IO1lO10I[27:24],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[6]);dffe II1lO0IOIl0I1lO0
(l10IOIIO0lOOIl1,lIO10I1lO0IO01l,pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IO01IlOOIl1OOIl1
(lIO10IOIl0OlI01[39:36],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[9]);assign OlI01lIO10I1lO0
=(IlO01l10IOOI01l&h_discard)|
(OOl1IOOIl1IOIl0&((~OI01lIO0lIIOIl0&~OOl1IlIO10OlI1O&~I01lOI1lO0I1lO0)|h_discard));dffe IO1lIOIOIl0IO0lI
(IlI0OlIO10I01lO[12],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[12]);dff IIOIl0OlI01l10IO
(IlI0OlO10IO01Il,IOIl0IO0lIIlI0O,pciclk,reset_b,1'b1);dffe II1lO0OIl01IlI0O
(IOIl0IIO0ll0IO1[15],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[15]);assign twr_dina[31:0]=h_dout[31:0];dffe IOlI01I1lO0O01Il
(O1lIOOlI01OI01l[2],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[2]);dff IO1lIOOOIl1lIO10
(lO10II1lO0OOl1I,l0IO1IO0lIO1lIO,pciclk,reset_b,1'b1);dff IIlO01OOl1IOI01l
(l0IO1OlI1OI1lO0,lO10Il0IO1lIO10,pciclk,reset_b,1'b1);assign IO0lIIlI0OOlI1O
=(I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&~h_burst_b&IlI0OlO10IO01Il;assign IO01lOIl01I1lO0
=~I01lOO1lIOlIO10&(l10IOIOIl0OI01l|IlO01IlO01IlO01);assign OOIl1O01IlI1lO0[0]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0000)))?1'b1:1'b0;dff IOOl1Il0IO1OlI01
(l0IO1OI01ll0IO1,lIO10OOl1IOIl01,pciclk,1'b1,reset_b);assign IO0lII1lO0IO0lI[3:0]=(l0IO1IlI0OIlI0O)?4'b1111:h_beout_b[3:0];dffe32 IOI01lOOIl1OlI1O
(I01lOO01IlIO01l[31:0],IlI0OOlI01IOIl0[31:0],pciclk,reset_b,1'b1,IlI0OO1lIOOI01l);dffe24 IIlI0OlO10IOOl1I
(OlI1OIIO0lI1lO0[31:8],h_aout[31:8],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IOOIl1IOIl0IIO0l
(lIO10IOIl0OlI01[7:4],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[1]);dff16 Il0IO1IO01llIO10
(IIO0lO1lIOOlI01[15:0],O1lIOl10IOIOIl0[15:0],pciclk,reset_b,1'b1);dffe Il0IO1OIl01OI01l
(IlI0OlIO10I01lO[4],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[4]);assign l0IO1lIO10IIO0l
=~IOIl0IO0lIIlI0O&l10IOIO01lIO0lI&
((IlO01l10IOOI01l&~h_adsm_b&h_wrout&O1lIOIO0lII01lO)|(OIl01IOIl0O01Il&~h_burst_b));dffe IIlI0OI1lO0OIl01
(IOIl0IIO0ll0IO1[7],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[7]);assign more_wb
=(I01lOIOIl0IlI0O)|
((I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&l10IOIO01lIO0lI&~IlO01IlO01IlO01);dffe IOOIl1OOIl1l0IO1
(IO0lII01lOOIl01[10],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[10]);dffe Il0IO1IOIl0I01lO
(O1lIOOlI01OI01l[13],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[13]);assign OOl1IIlI0OIO0lI[2]=~h_cs_b[2];assign IlI0OOlI1OOOIl1
=(I1lO0IlO01OlI1O&h_burst_b&h_burst_cont&OIl01lIO10l10IO)|
(OI01lO01IlIO0lI&h_burst_b&h_burst_cont);assign IIO0ll10IOIIO0l[8]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1000)))?1'b1:1'b0;dff4 IOlI1OOlI1OlO10I
(OIl01OOl1IlO10I[3:0],OlI01lO10IOlI01[3:0],pciclk,reset_b,1'b1);assign OOIl1O01IlI1lO0[11]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1011)))?1'b1:1'b0;dff IlO10IIIO0lOIl01
(IO01lOI01llO10I,OOIl1IO0lIIO01l,pciclk,1'b1,reset_b);assign trd_be_b[3:0]=IlO01OlI01O01Il[3:0];dffe4 IlO10IOIl01OlI01
(l0IO1l0IO1lO10I[39:36],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[9]);assign OlI1OOIl01l0IO1
=IOIl0I01lOO01Il|(~IlI0OIOIl0lO10I&O1lIOIlO01I01lO);dffe4 IIIO0lI1lO0lO10I
(lIO10IOIl0OlI01[51:48],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[12]);assign IlI0OIO01lOI01l[7:0]
=IOIl0O01IlIIO0l?OlI01IOIl0OIl01[7:0]+8'h01:8'h00;dffe IIlO01OOIl1l10IO
(IlI0OlIO10I01lO[15],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[15]);assign l10IOIO01lIO0lI
=OOl1IIIO0lI01lO|OOl1IOIl01l10IO;dffe IlO10IIOIl0IO01l
(IO0lII01lOOIl01[2],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[2]);assign trd_addrb[7:4]=4'b0000;dffe IIIO0llO10IOOIl1
(O1lIOOlI01OI01l[5],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[5]);dff IIO01lI01lOIO0lI
(l10IOlO10IIOIl0,I01lOOOl1IOlI01,pciclk,reset_b,1'b1);dff Il0IO1l10IOIlO01
(IIO0llIO10IO01l,IO0lIIIO0ll10IO,pciclk,reset_b,1'b1);assign IIO0ll10IOIIO0l[0]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0000)))?1'b1:1'b0;assign O1lIOIO0lII01lO
=~((IIO0llIO10IO01l&O1lIOIlO01I01lO)|
(OlI1OI01lOlO10I&~(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)&IOIl0OIl01lO10I)|
(OOl1IOOIl1IOIl0&~OI01lIO0lIIOIl0&(IOIl0OIl01lO10I|(I01lOI1lO0I1lO0&~OOl1IlIO10OlI1O)))|I01lOIIO0lOOl1I|
IO01lOlI1Ol0IO1|
l0IO1O01IlOOIl1|
((IO01lI01lOl0IO1|IlO01O1lIOlO10I)&IlO01IlO01IlO01&h_wrout));assign OOIl1O01IlI1lO0[3]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0011)))?1'b1:1'b0;dff II1lO0O01IlOOl1I
(IIO0lIlO01I1lO0,IO0lIOIl01lIO10,pciclk,reset_b,1'b1);assign lIO10OOIl1IO01l[5:0]=6'b000000;dffe4 IO1lIOI1lO0lIO10
(l0IO1l0IO1lO10I[7:4],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[1]);dffe2 IO1lIOIlI0OOIl01
(OlI1OIIO0lI1lO0[1:0],h_aout[1:0],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 II01lOOOIl1I1lO0
(lIO10IOIl0OlI01[19:16],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[4]);assign O01Ill0IO1l0IO1
=IIO0lO1lIOOlI01[15];dffe IO01IlIOIl0IlO01(IlI0OlIO10I01lO[7],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[7]);assign I01lOl10IOOlI01
=IlI0OlO10IO01Il&(((I1lO0IlO01OlI1O|l0IO1OlI1OI1lO0|OI01lO01IlIO0lI)&h_burst_b&~h_burst_cont)|OIl01IOIl0O01Il);dffe IO1lIOlO10IOlI1O
(IOIl0IIO0ll0IO1[10],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[10]);assign OIl01lIO10l10IO
=(O01IlIIO0llO10I==4'b1111)?1'b1:1'b0;dffe II1lO0I01lOIIO0l
(IO0lII01lOOIl01[13],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[13]);dff IO01IlOlI1OOI01l
(IO0lIOOIl1IO0lI,tack_b,pciclk,1'b1,reset_b);assign OOl1IIlI0OIO0lI[5]=~h_cs_b[5];assign IO01llIO10O1lIO
=(IlO01l10IOOI01l&~h_adsm_b&~h_wrout&~h_burst_b&O1lIOIO0lII01lO&OOl1IIlO01OOl1I)|
(OlI1OI01lOlO10I&(IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0))|
(OOl1IOOIl1IOIl0&~h_burst_b&(OI01lIO0lIIOIl0|(~IOIl0OIl01lO10I&~OOl1IlIO10OlI1O&~I01lOI1lO0I1lO0))&~(O01IlI1lO0OOIl1&OI01lIO0lIIOIl0));assign IIO0ll10IOIIO0l[11]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1011)))?1'b1:1'b0;assign O01IlI1lO0OOIl1
=OIl01OOl1IlO10I[3]&OIl01OOl1IlO10I[2]&OIl01OOl1IlO10I[1]&OIl01OOl1IlO10I[0];assign OOIl1O01IlI1lO0[14]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b1110)))?1'b1:1'b0;assign IIO0lIO01lOlI01
=(OIl01lO10IOI01l&~OlI1OOOIl1IIO0l&(OOl1IlIO10OlI1O|I01lOI1lO0I1lO0|lIO10lO10IIlI0O))|
(OI01lI1lO0OlI1O&OOl1IlIO10OlI1O&~IlO01IO0lIIlO01)|
(OI01lI1lO0OlI1O&I01lOI1lO0I1lO0&~I1lO0OI01llIO10)|
(OI01lI1lO0OlI1O&lIO10lO10IIlI0O&~lO10IIO0lIIO0lI)|
(OI01lI1lO0OlI1O&(IlO01l10IOOI01l|OOl1IOOIl1IOIl0)&~h_drcmt_b)|
(OI01lI1lO0OlI1O&O1lIOlIO10IlO01);dffe4 IlIO10IO0lIlO10I
(IOIl0OOIl1O1lIO[4:1],trd_size[4:1],pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IOI01lIlI0OOOl1I
(l0IO1l0IO1lO10I[51:48],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[12]);assign IIO0lOI01lOOl1I
=OI01lIIO0llIO10|(~OI01ll0IO1l10IO&IOIl0I1lO0O1lIO);dffe4 IOOIl1lO10IO1lIO
(lIO10IOIl0OlI01[63:60],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[15]);dff2 IIlI0OI01lOIO01l
(lIO10OIl01OOl1I[1:0],lO10IOlI1OI01lO[1:0],pciclk,reset_b,1'b1);dffe Il0IO1I01lOIOIl0
(IOIl0IIO0ll0IO1[2],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[2]);assign lO10IO01IlOlI1O
=(IlO01l10IOOI01l|OIl01IOIl0O01Il)&OOl1IOIl01l10IO;dffe IOI01lOlI1OOlI01
(IO0lII01lOOIl01[5],OOIl1l0IO1OOl1I,pciclk,reset_b,1'b1,IIO0ll10IOIIO0l[5]);dffe IOOIl1IlI0OlO10I
(O1lIOOlI01OI01l[8],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[8]);assign l10IOOOl1IO01Il[15:0]=IO01ll0IO1O01Il[15:0];dff IO01IlOIl01O01Il
(I01lOIIO0lOOl1I,l10IOI1lO0I01lO,pciclk,reset_b,1'b1);assign IIO0ll10IOIIO0l[3]
=((l10IOl10IOO01Il==1'b1)|((OI01lOIl01OIl01==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0011)))?1'b1:1'b0;assign IlI0OIlO01l10IO[4:0]
=(IIO0llIO10IO01l&~O1lIOIlO01I01lO)?def_lat_cnt[4:0]:
(OOl1IOOIl1IOIl0&OI01lIO0lIIOIl0)?5'b01000:
(OlI1OI01lOlO10I&IOIl0I1lO0O1lIO&OI01lIO0lIIOIl0)?5'b01000:
((OlI1OI01lOlO10I&~IOIl0OIl01lO10I)|(OOl1IOOIl1IOIl0&~OI01lIO0lIIOIl0))?OlI01IlI0OIO01l[4:0]-5'b00001:OlI01IlI0OIO01l[4:0];assign OOIl1O01IlI1lO0[6]
=((l0IO1IlI0OIlI0O==1'b1)|((IO0lIIlI0OOlI1O==1'b1)&(OIl01IlI0OI01lO[3:0]==4'b0110)))?1'b1:1'b0;assign O01IlIO0lIIIO0l
=(l0IO1OI01ll0IO1&O1lIOIlO01I01lO&~IOIl0I1lO0O1lIO&~(IO01lI01lOl0IO1|IlO01O1lIOlO10I))|
(OIl01lO10IOI01l&OlI1OOOIl1IIO0l);assign O1lIOOI01lOOIl1
=(l0IO1IlI0OIlI0O)?1'b1:(h_beout_b[3]&h_beout_b[2]&h_beout_b[1]&h_beout_b[0]);dffe4 IIlO01lO10IIO0lI
(l0IO1l0IO1lO10I[19:16],IO0lIO01IlIOIl0[3:0],pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[4]);dffe IIlO01O1lIOOlI1O
(lO10IOI01ll10IO,h_wrout,pciclk,reset_b,1'b1,OOIl1O1lIOOIl01);dffe4 IlO10II01lOIlI0O
(lIO10IOIl0OlI01[31:28],IO0lII1lO0IO0lI[3:0],pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[7]);dff IO01Ill0IO1IO0lI
(IOIl0O01IlIIO0l,IIO0lOlI1OOlI1O,pciclk,reset_b,1'b1);dffe IIOIl0OlI1OO01Il
(IlI0OlIO10I01lO[10],O1lIOOlI1OO1lIO,pciclk,1'b1,reset_b,IIO0ll10IOIIO0l[10]);assign IO01lI01lOl0IO1
=(lIO10IIO0lOlI1O==2'b10)?1'b1:1'b0;dffe IIlO01IlI0OlIO10
(IOIl0IIO0ll0IO1[13],O1lIOOI01lOOIl1,pciclk,1'b1,reset_b,OOIl1O01IlI1lO0[13]);assign twr_addra[4]=IlI0OlO10IO01Il;dffe IlO10IlO10II1lO0
(O1lIOOlI01OI01l[0],OOIl1IlO01IO01l,pciclk,reset_b,1'b1,OOIl1O01IlI1lO0[0]);dff16 IIIO0lI01lOIlO01
(IO01ll0IO1O01Il[15:0],OOl1IOlI1OlIO10[15:0],pciclk,reset_b,1'b1);dff IOOIl1I1lO0l0IO1
(IlO01l10IOOI01l,IO01lIlI0OIIO0l,pciclk,1'b1,reset_b);
endmodule 
