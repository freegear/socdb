// ##########################################################################
//
// Copyright (C) 2002 Eureka Technology Inc.
//
// Confidential & Proprietary Information
//
// All Rights Reserved
//
// The use, modification, or duplication of this product is protected
// according to FAR 12.212 and by Eureka's licensing agreement.
// This design contains confidential and proprietary information which
// are the properties of Eureka Technology Inc.
// Unauthorized use, disclosure, duplication, or reproduction are prohibited.
//
// ##########################################################################
//
`timescale 1ns / 100ps

module pciif(
adin,
adout,
cbein_b,
cbeout_b,
clk,
devselin_b,
devselout_b,
framein_b,
frameout_b,
gnt_b,
idsel,
intaout_b,
irdyin_b,
irdyout_b,
parin,
parout,
perrin_b,
perrout_b,
reqout_b,
reset_b,
serrout_b,
stopin_b,
stopout_b,
trdyin_b,
trdyout_b,

h_abort_b,
h_adsh_b,
h_adsm_b,
h_ain,
h_aout,
h_bein_b,
h_beout_b,
h_bii_b,
h_blast_b,
h_boff_b,
h_burst_b,
h_burst_cont,
h_cacheline,
h_cache_size,
h_cmd,
h_cs_b,
h_din,
h_discard,
h_done_b,
h_dout,
h_drcmt_b,
h_inta_b,
h_mio,
h_mrd_cmd,
h_par,
h_rdyh_b,
h_rdym_b,
h_retry_b,
h_size,
h_wrin,
h_wrout,
more_wb,
prefetch_limit,
trd_size,
status15,
status14,
status13,
status12,
status11,
status8,
status_rty,

oe_ad,
oe_cbe,
oe_devsel,
oe_frame,
oe_irdy,
oe_par,
oe_perr,
oe_req,
oe_stop,
oe_trdy,

bar0_setup,
bar1_setup,
device_id,
vendor_id,
class_code,
revision_id,
interrupt_pin,
subsystem_id,
subvendor_id,
run_66mhz,
sel_23
);
input[31:0] adin;
output[31:0] adout;
input[3:0] cbein_b;
output[3:0] cbeout_b;
input clk;
input devselin_b;
output devselout_b;
input framein_b;
output frameout_b;
input gnt_b;
input idsel;
output intaout_b;
input irdyin_b;
output irdyout_b;
input parin;
output parout;
input perrin_b;
output perrout_b;
output reqout_b;
input reset_b;
output serrout_b;
input stopin_b;
output stopout_b;
input trdyin_b;
output trdyout_b;
input h_abort_b;
input h_adsh_b;
output h_adsm_b;
input[31:0] h_ain;
output[31:0] h_aout;
input[3:0] h_bein_b;
output[3:0] h_beout_b;
input h_bii_b;
input h_blast_b;
output h_boff_b;
output h_burst_b;
output h_burst_cont;
input h_cacheline;
output[7:0] h_cache_size;
input[1:0] h_cmd;
output[1:0] h_cs_b;
input[31:0] h_din;
output h_discard;
output h_done_b;
output[31:0] h_dout;
output h_drcmt_b;
input h_inta_b;
input h_mio;
output[1:0] h_mrd_cmd;
output h_par;
input h_rdyh_b;
output h_rdym_b;
input h_retry_b;
input[15:0] h_size;
input h_wrin;
output h_wrout;
input more_wb;
input[1:0] prefetch_limit;
output[4:0] trd_size;
output status15;
output status14;
output status13;
output status12;
output status11;
output status8;
output status_rty;
output oe_ad;
output oe_cbe;
output oe_devsel;
output oe_frame;
output oe_irdy;
output oe_par;
output oe_perr;
output oe_req;
output oe_stop;
output oe_trdy;
input[34:16] bar0_setup;
input[34:16] bar1_setup;
input[15:0] device_id;
input[15:0] vendor_id;
input[23:0] class_code;
input[7:0] revision_id;
input[7:0] interrupt_pin;
input[15:0] subsystem_id;
input[15:0] subvendor_id;
input run_66mhz;
input sel_23;
wire l0IO1I01lOOI01l;wire IO0lIIIO0lOI01l;wire lIO10lIO10OI01l;wire OI01lO01IlI01lO;wire[31:0] O1lIOOOIl1OI01l;wire I01lOIO01lI01lO;
wire lO10IOlI01OI01l;wire IlI0OIOIl0I01lO;wire I1lO0l0IO1I01lO;wire IOIl0OlI1OI01lO;wire[15:0] OOIl1OOl1IIOIl0;wire l10IOO01IlI01lO;
wire O01IlOI01lIOIl0;wire IO0lIIO01lI01lO;wire IlO01I1lO0IOIl0;wire OlI01IO0lIIOIl0;wire IO01llO10IIOIl0;wire lIO10OlI01l10IO;wire OI01lOOl1IIOIl0;
wire OlI1OI01lOl10IO;wire I01lOOI01lIOIl0;wire lO10IIIO0ll10IO;wire OOIl1lIO10l10IO;wire OIl01OOIl1l10IO;wire IIO0lIlO01IO0lI;wire[15:0] OOl1IOlI01l10IO;
wire l10IOIlI0OIO0lI;wire OlI01I01lOl10IO;wire IO0lIl10IOIO0lI;wire[31:0] l0IO1O1lIOIO0lI;wire O1lIOOIl01IO0lI;wire[1:0] IO01lOI01llIO10;
wire lO10IIlO01IO0lI;wire IlI0OI1lO0lIO10;wire OlI1OIlI0OIO0lI;wire I01lOIO0lIlIO10;wire IOIl0lO10IlIO10;wire I1lO0OOl1IlIO10;wire IIO0lOI01llIO10;
wire OOl1IIOIl0OlI1O;wire l0IO1I1lO0lIO10;wire OlI01l0IO1OlI1O;wire IlO01OlI1OOlI1O;wire OI01lO01IlOlI1O;wire I01lOIO01lOlI1O;wire lO10Il10IOOIl01;
wire[31:0] IlI0OIOIl0OlI1O;wire OlI1OO1lIOOIl01;wire[3:0] I1lO0l0IO1OlI1O;wire OIl01OIl01OIl01;wire OOl1IIlO01OIl01;wire O01IlIlI0OOIl01;
wire[15:0] IIO0lIIO0lOOl1I;wire IlO01l10IOOIl01;wire l0IO1lIO10OOl1I;wire[31:0] OlI01O1lIOOIl01;wire IO0lIOOIl1OOl1I;wire lIO10OlI01OOl1I;
wire OlI1OI01lOOOl1I;wire I01lOl0IO1OlI01;wire lO10IIIO0lOOl1I;wire IlI0OOlI1OOlI01;wire OOIl1lIO10OOl1I;wire I1lO0O01IlOlI01;wire IIO0lIO01lOlI01;
wire l10IOIOIl0OlI01;wire O01IlO1lIOIO01l;wire[15:0] IO0lIl0IO1OlI01;wire IlO01OIl01IO01l;wire l0IO1OlI1OOlI01;wire OI01lIlO01IO01l;
wire[31:2] IO01lIlI0OIO01l;wire IlI0Ol10IOIO01l;wire OlI1OlIO10IlI0O;wire I01lOO1lIOIO01l;wire lO10IOOIl1IlI0O;wire IOIl0OIl01IO01l;
wire[31:2] OOIl1OlI01IlI0O;wire[2:0] O01IlI01lOIlI0O;wire OOl1IIIO0lIlI0O;wire OlI01lIO10IlI0O;wire IO0lIO01IlI1lO0;wire IlO01OOIl1IlI0O;
wire lIO10IO01lI1lO0;wire O1lIOIOIl0I1lO0;wire lO10Il0IO1I1lO0;wire OlI1OOlI1OI1lO0;wire I01lOOOl1IIIO0l;wire OIl01O01IlI1lO0;wire IOIl0OI01lIIO0l;
wire OOl1IIO01lI1lO0;wire l10IOI1lO0IIO0l;wire IIO0lIO0lIIIO0l;wire l0IO1lO10IIIO0l;wire OlI01OlI01l0IO1;wire IO0lIOOl1IIIO0l;wire IO01lI01lOl0IO1;
wire[35:0] lIO10OI01lIIO0l;wire OI01lIIO0ll0IO1;wire I01lOlIO10l0IO1;wire IlI0OOOIl1l0IO1;wire OOIl1IlO01O1lIO;wire I1lO0OlI01l0IO1;
wire OIl01IlI0OO1lIO;wire IIO0lI01lOl0IO1;wire OOl1Il10IOO1lIO;wire O01IlO1lIOO1lIO;wire IlO01OIl01O1lIO;wire l0IO1OI01llO10I;wire OI01lIlO01O1lIO;
wire O1lIOI1lO0lO10I;wire[31:16] IO01lIlI0OO1lIO;wire lIO10IO0lIlO10I;wire[31:0] OlI1OlO10IlO10I;wire lO10IOOl1IlO10I;wire IOIl0IO01lOOIl1;
wire OOIl1OI01llO10I;wire I1lO0IOIl0OOIl1;wire O01IlI1lO0lO10I;wire[3:0] IIO0ll0IO1OOIl1;wire l10IOOlI1OOOIl1;wire[7:0] IO0lIO01IlOOIl1;
wire lIO10IO01lOOIl1;wire[1:0] OI01ll10IOO01Il;wire O1lIOIOIl0OOIl1;wire IO01lO1lIOO01Il;wire IlI0OOIl01O01Il;wire I1lO0IlO01O01Il;
wire IOIl0IlI0OO01Il;wire OOIl1IO0lIIlO01;wire l10IOl10IOO01Il;wire O01IllO10IIlO01;wire IIO0lO1lIOO01Il;wire OOl1IOOl1IIlO01;wire OlI01OI01lIlO01;
wire IO01lI1lO0IlO01;wire lIO10l0IO1OI01l;wire OI01lIO0lIIlO01;wire O1lIOOlI1OOI01l;wire I01lOlO10IIlO01;wire lO10IO01IlOI01l;wire OOIl1IO01lOI01l;
wire OIl01IOIl0OI01l;wire IOIl0O1lIOI01lO;wire OOl1Il0IO1OI01l;wire l10IOOIl01I01lO;wire O01IlOlI1OOI01l;wire IO0lIIlO01I01lO;wire l0IO1IlI0OI01lO;
wire O1lIOl10IOI01lO;wire IO01llIO10IOIl0;wire lIO10O1lIOI01lO;wire[7:0] OI01lOOIl1IOIl0;wire OlI1OOIl01I01lO;wire[31:0] I01lOOlI01IOIl0;
wire[3:0] IOIl0I01lOIOIl0;wire I1lO0IIO0lIOIl0;wire OIl01OlI1Ol10IO;wire IIO0llIO10IOIl0;wire OOl1IO01Ill10IO;wire l10IOOOIl1IOIl0;
wire[35:0] OlI01IO01ll10IO;wire[3:0] IlO01IOIl0l10IO;wire[7:0] OI01ll0IO1l10IO;wire IO01lOlI1Ol10IO;wire lIO10OOl1IIO0lI;wire IlI0OO01Ill10IO;
wire OlI1OOI01lIO0lI;wire OIl01I1lO0IO0lI;wire[31:0] OOIl1IO0lIIO0lI;wire O01IllO10IIO0lI;wire IIO0lOlI01lIO10;wire OOl1IOOl1IIO0lI;
wire[3:0] l0IO1I01lOlIO10;wire OlI01OI01lIO0lI;wire IO0lIIIO0llIO10;wire lIO10lIO10lIO10;wire O1lIOOOIl1lIO10;wire I01lOIlO01OlI1O;
wire lO10IOlI01lIO10;wire IlI0OIlI0OOlI1O;wire[31:16] OOIl1I01lOlIO10;wire I1lO0l10IOOlI1O;wire IOIl0O1lIOOlI1O;wire l10IOOIl01OlI1O;
wire O01IlOI01lOIl01;wire IO0lIIlO01OlI1O;wire[3:0] IlO01I1lO0OIl01;wire l0IO1IlI0OOlI1O;wire OlI01IO0lIOIl01;wire IO01llO10IOIl01;
wire OI01lOOl1IOIl01;wire OlI1OIO01lOOl1I;wire I01lOOI01lOIl01;wire lO10IIOIl0OOl1I;wire IOIl0I1lO0OIl01;wire OOIl1l0IO1OOl1I;wire OIl01OlI1OOOl1I;
wire OOl1IO01IlOOl1I;wire l10IOIlI0OOlI01;wire OlI01IO01lOOl1I;wire[31:0] IO0lIl10IOOlI01;wire[31:0] IlO01IOIl0OOl1I;wire l0IO1O1lIOOlI01;
wire[3:0] O1lIOOIl01OlI01;wire lO10IIlO01OlI01;wire OlI1OIlI0OOlI01;wire I01lOIO0lIIO01l;wire OIl01l10IOOlI01;wire IOIl0lO10IIO01l;
wire I1lO0OOl1IIO01l;wire IIO0lOI01lIO01l;wire l0IO1I1lO0IO01l;wire OlI01l0IO1IlI0O;wire IO0lIIO0lIIO01l;wire[3:0] IlO01OlI1OIlI0O;
wire lIO10lO10IIO01l;wire OI01lO01IlIlI0O;wire I01lOIO01lIlI0O;wire IlI0OIOIl0IlI0O;wire OlI1OO1lIOI1lO0;wire[31:0] I1lO0l0IO1IlI0O;
wire OIl01OIl01I1lO0;wire IOIl0OlI1OIlI0O;wire OOl1IIlO01I1lO0;wire O01IlIlI0OI1lO0;wire IlO01l10IOI1lO0;wire l0IO1lIO10IIO0l;wire OlI01O1lIOI1lO0;
wire[31:0] IO0lIOOIl1IIO0l;wire IO01lOIl01I1lO0;wire lIO10OlI01IIO0l;wire OlI1OI01lOIIO0l;wire lO10IIIO0lIIO0l;wire IlI0OOlI1Ol0IO1;
wire OOIl1lIO10IIO0l;wire I1lO0O01Ill0IO1;wire OIl01OOIl1IIO0l;wire IIO0lIO01ll0IO1;wire[7:0] l10IOIOIl0l0IO1;wire IO0lIl0IO1l0IO1;
wire[4:0] IlO01lO10IO1lIO;wire l0IO1OlI1Ol0IO1;wire[1:0] OlI01OOl1IO1lIO;wire[15:0] O1lIOO01Ill0IO1;wire IO01lOI01lO1lIO;wire IlI0OI1lO0O1lIO;
wire I01lOIO0lIO1lIO;wire lO10IOOIl1lO10I;wire[15:0] IOIl0lO10IO1lIO;wire OOIl1OlI01lO10I;wire I1lO0OOl1IO1lIO;wire O01IlI01lOlO10I;
wire OOl1IIIO0llO10I;wire OlI01lIO10lO10I;wire IlO01OOIl1lO10I;wire lIO10IlO01OOIl1;wire OI01lOlI01lO10I;wire O1lIOIlI0OOOIl1;wire I01lOI01lOlO10I;
wire lO10Il10IOOOIl1;wire OlI1OO1lIOOOIl1;wire OIl01OIl01OOIl1;wire IOIl0OI01lO01Il;wire[31:0] OOl1IIlO01OOIl1;wire l10IOI1lO0O01Il;
wire O01IlIlI0OOOIl1;wire IIO0lIO0lIO01Il;wire l0IO1lO10IO01Il;wire IO0lIOOl1IO01Il;wire[15:0] IO01lI01lOIlO01;wire lIO10OI01lO01Il;
wire OI01lIIO0lIlO01;wire[3:0] OlI1OI1lO0O01Il;wire I01lOlIO10IlO01;wire IlI0OOOIl1IlO01;wire I1lO0OlI01IlO01;wire OIl01IlI0OOI01l;
wire IIO0lI01lOIlO01;wire OOl1Il10IOOI01l;wire l10IOIIO0lIlO01;wire O01IlO1lIOOI01l;wire IlO01OIl01OI01l;wire OI01lIlO01OI01l;wire O1lIOI1lO0I01lO;
wire IO01lIlI0OOI01l;wire lIO10IO0lII01lO;wire[3:0] IlI0Ol10IOOI01l;wire OlI1OlO10II01lO;wire lO10IOOl1II01lO;wire OOIl1OI01lI01lO;
wire[1:0] I1lO0IOIl0IOIl0;wire[15:0] O01IlI1lO0I01lO;wire IIO0ll0IO1IOIl0;wire OOl1IIO0lII01lO;wire l10IOOlI1OIOIl0;wire IO0lIO01IlIOIl0;
wire lIO10IO01lIOIl0;wire O1lIOIOIl0IOIl0;wire IO01lO1lIOl10IO;wire lO10Il0IO1IOIl0;wire IlI0OOIl01l10IO;wire I1lO0IlO01l10IO;wire IOIl0IlI0Ol10IO;
wire l10IOl10IOl10IO;wire O01IllIO10IO0lI;wire[31:0] IIO0lO1lIOl10IO;wire OOl1IOOIl1IO0lI;wire[3:0] l0IO1OIl01l10IO;wire OlI01OlI01IO0lI;
wire IO01lI01lOIO0lI;wire OI01lIIO0lIO0lI;wire[15:0] O1lIOOlI1OlIO10;wire I01lOlIO10IO0lI;wire[3:0] lO10IO01IllIO10;wire[3:0] IlI0OOOIl1IO0lI;
wire OOIl1IO01llIO10;wire OIl01IOIl0lIO10;wire OOl1Il0IO1lIO10;wire l10IOlO10IOlI1O;wire O01IlOlI1OlIO10;wire IIO0lOOl1IOlI1O;wire IlO01O01IllIO10;
wire l0IO1OI01lOlI1O;wire O1lIOI1lO0OlI1O;wire lIO10IO0lIOlI1O;wire OI01lOOIl1OIl01;wire[15:0] OlI1OlO10IOlI1O;wire I01lOOlI01OIl01;
wire lO10IOOl1IOlI1O;wire IOIl0I01lOOIl01;wire[31:2] I1lO0IIO0lOIl01;wire IIO0llIO10OIl01;wire OOl1IOIl01OOl1I;wire l10IOOOIl1OIl01;
wire OlI01IlO01OOl1I;wire IO0lIOlI01OIl01;wire[31:0] IlO01IlI0OOOl1I;wire[2:0] OI01ll10IOOOl1I;wire IO01lO1lIOOOl1I;wire IlI0OOIl01OOl1I;
wire OlI1OOI01lOlI01;wire I1lO0IlO01OOl1I;wire OIl01I1lO0OlI01;wire OOIl1IO0lIOlI01;wire O01IllO10IOlI01;wire OOl1IOOl1IOlI01;wire l0IO1I01lOIO01l;
wire OlI01OI01lOlI01;wire IO0lIIIO0lIO01l;wire IO01lI1lO0OlI01;wire lIO10lIO10IO01l;wire O1lIOOOIl1IO01l;wire lO10IOlI01IO01l;wire IlI0OIlI0OIlI0O;
wire OOIl1I01lOIO01l;wire I1lO0l10IOIlI0O;wire[35:0] OIl01IIO0lIO01l;wire IOIl0O1lIOIlI0O;wire l10IOOIl01IlI0O;wire IO0lIIlO01IlI0O;
wire IlO01I1lO0I1lO0;wire l0IO1IlI0OIlI0O;wire OlI01IO0lII1lO0;wire O1lIOl10IOIlI0O;wire IO01llO10II1lO0;wire OI01lOOl1II1lO0;wire I01lOOI01lI1lO0;
wire lO10IIOIl0IIO0l;wire IOIl0I1lO0I1lO0;wire OOIl1l0IO1IIO0l;wire I1lO0IO0lII1lO0;wire OIl01OlI1OIIO0l;wire[31:0] OOl1IO01IlIIO0l;
wire OlI01IO01lIIO0l;wire IO0lIl10IOl0IO1;wire IlO01IOIl0IIO0l;wire l0IO1O1lIOl0IO1;wire OI01ll0IO1IIO0l;wire[31:2] O1lIOOIl01l0IO1;
wire[2:0] lO10IIlO01l0IO1;wire OlI1OIlI0Ol0IO1;wire OIl01l10IOl0IO1;wire IOIl0lIO10O1lIO;wire OOIl1O1lIOl0IO1;wire I1lO0OOIl1O1lIO;
wire IIO0lOlI01O1lIO;wire l0IO1I01lOO1lIO;wire IO0lIIIO0lO1lIO;wire IlO01OlI1OlO10I;wire lIO10lIO10O1lIO;wire OI01lO01IllO10I;wire O1lIOOOIl1O1lIO;
wire I01lOIO01llO10I;wire IlI0OIOIl0lO10I;wire I1lO0l0IO1lO10I;wire OIl01lO10IOOIl1;wire IOIl0OlI1OlO10I;wire OOIl1OOl1IOOIl1;wire l10IOO01IllO10I;
wire O01IlOI01lOOIl1;wire IlO01I1lO0OOIl1;wire OlI01IO0lIOOIl1;wire IO0lIOOIl1O01Il;wire IO01llO10IOOIl1;wire[1:0] lIO10OlI01O01Il;
wire OI01lOOl1IOOIl1;wire OlI1OI01lOO01Il;wire lO10IIIO0lO01Il;wire OOIl1lIO10O01Il;wire I1lO0O01IlIlO01;wire OIl01OOIl1O01Il;wire[7:0] IIO0lIO01lIlO01;
wire[31:16] OOl1IOlI01O01Il;wire[35:0] l10IOIOIl0IlO01;wire[3:0] IO0lIl0IO1IlO01;wire l0IO1OlI1OIlO01;wire OlI01OOl1IOI01l;wire O1lIOO01IlIlO01;
wire IO01lOI01lOI01l;wire lO10IIO01lIlO01;wire IlI0OI1lO0OI01l;wire I01lOIO0lIOI01l;wire[7:0] IOIl0lO10IOI01l;wire I1lO0OOl1IOI01l;
wire O01IlI01lOI01lO;wire IIO0lOI01lOI01l;wire OOl1IIIO0lI01lO;wire OlI01lIO10I01lO;wire[31:0] IlO01OOIl1I01lO;wire OI01lOlI01I01lO;
wire O1lIOIlI0OIOIl0;wire I01lOI01lOI01lO;wire[3:0] lO10Il10IOIOIl0;wire IlI0OIIO0lI01lO;wire OlI1OO1lIOIOIl0;wire OIl01OIl01IOIl0;
wire OOl1IIlO01IOIl0;wire l10IOI1lO0l10IO;wire O01IlIlI0OIOIl0;wire IIO0lIO0lIl10IO;wire[31:16] IlO01l10IOIOIl0;wire l0IO1lO10Il10IO;
wire IO0lIOOl1Il10IO;wire lIO10OI01ll10IO;wire OI01lIOIl0IO0lI;wire OlI1OI1lO0l10IO;wire[31:0] I01lOl0IO1IO0lI;wire lO10IIO0lIl10IO;
wire IlI0OOlI1OIO0lI;wire I1lO0O01IlIO0lI;wire IIO0lIO01lIO0lI;wire OOl1Il10IOlIO10;wire l10IOIOIl0IO0lI;wire[3:0] O01IlO1lIOlIO10;
wire IO0lIl0IO1IO0lI;wire IlO01OIl01lIO10;wire OI01lIlO01lIO10;wire IO01lIlI0OlIO10;wire lIO10IIO0lOlI1O;wire IlI0Ol10IOlIO10;wire OlI1OlIO10OlI1O;
wire I01lOO1lIOlIO10;wire lO10IOOIl1OlI1O;wire[3:0] OOIl1OlI01OlI1O;wire[7:0] O01IlI01lOOlI1O;wire OOl1IIIO0lOlI1O;wire l10IOOlI1OOIl01;
wire OlI01lIO10OlI1O;wire IO0lIO01IlOIl01;wire lIO10IO01lOIl01;wire O1lIOIOIl0OIl01;wire lO10Il0IO1OIl01;wire IlI0OlO10IOOl1I;wire OlI1OOlI1OOIl01;
wire[3:0] I01lOOOl1IOOl1I;wire OIl01O01IlOIl01;wire IOIl0OI01lOOl1I;wire l10IOI1lO0OOl1I;wire IIO0lIO0lIOOl1I;wire OOl1IOOIl1OlI01;
wire l0IO1lO10IOOl1I;wire OlI01OlI01OlI01;wire IO0lIOOl1IOOl1I;wire IO01lI01lOOlI01;wire OI01lIIO0lOlI01;wire I01lOlIO10OlI01;wire lO10IO01IlIO01l;
wire IlI0OOOIl1OlI01;wire OOIl1IO01lIO01l;wire I1lO0OlI01OlI01;wire OIl01IOIl0IO01l;wire OOl1Il0IO1IO01l;wire O01IlOlI1OIO01l;wire IIO0lOOl1IIlI0O;
wire IlO01O01IlIO01l;wire l0IO1OI01lIlI0O;wire[3:0] OI01lIO01lIO01l;wire O1lIOI1lO0IlI0O;wire[7:0] lIO10IO0lIIlI0O;wire OlI1OlO10IIlI0O;
wire I01lOOlI01I1lO0;wire lO10IOOl1IIlI0O;wire[1:0] IOIl0I01lOI1lO0;wire[31:0] OOIl1OI01lIlI0O;wire I1lO0IIO0lI1lO0;wire IIO0llIO10I1lO0;
wire l10IOOOIl1I1lO0;wire IO0lIOlI01I1lO0;wire IlO01IlI0OIIO0l;wire lIO10I01lOI1lO0;wire OI01ll10IOIIO0l;wire IO01lO1lIOIIO0l;wire IlI0OOIl01IIO0l;
wire I1lO0IlO01IIO0l;wire OIl01I1lO0l0IO1;wire IOIl0IlI0OIIO0l;wire OOIl1IO0lIl0IO1;wire l10IOl10IOIIO0l;wire O01IllO10Il0IO1;wire OOl1IOOl1Il0IO1;
wire OlI01OI01ll0IO1;wire IO0lIIOIl0O1lIO;wire[31:0] IO01lI1lO0l0IO1;wire lIO10l0IO1O1lIO;wire OI01lIO0lIl0IO1;wire O1lIOOlI1OO1lIO;
wire lO10IO01IlO1lIO;wire OOIl1IO01lO1lIO;wire[31:0] I1lO0l10IOlO10I;wire OIl01IOIl0O1lIO;wire IOIl0O1lIOlO10I;wire OOl1Il0IO1O1lIO;
wire l10IOOIl01lO10I;wire IO0lIIlO01lO10I;wire l0IO1IlI0OlO10I;wire OlI01IIO0lOOIl1;wire O1lIOl10IOlO10I;wire IO01llIO10OOIl1;wire lIO10O1lIOlO10I;
wire OI01lOOIl1OOIl1;wire I01lOOlI01OOIl1;wire IOIl0I01lOOOIl1;wire OOIl1l0IO1O01Il;wire I1lO0IIO0lOOIl1;wire OIl01OlI1OO01Il;wire[15:0] IIO0llIO10OOIl1;
wire OOl1IO01IlO01Il;wire OlI01IO01lO01Il;wire IlO01IOIl0O01Il;wire l0IO1O1lIOIlO01;wire[15:0] OI01ll0IO1O01Il;wire O1lIOOIl01IlO01;
wire IO01lOlI1OO01Il;wire lO10IIlO01IlO01;wire OlI1OIlI0OIlO01;wire OIl01l10IOIlO01;wire OOIl1O1lIOIlO01;wire I1lO0OOIl1OI01l;wire O01IlOIl01IlO01;
wire IIO0lOlI01OI01l;wire[31:0] IlO01IlO01IlO01;
assign IO0lIO01IlOIl01=(IIO0lOI01lOI01l&l10IOI1lO0O01Il)|(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe8 IOOIl1IIO0lOlI01
(l0IO1O1lIOIO0lI[23:16],I01lOOlI01IOIl0[23:16],clk,reset_b,1'b1,l10IOOIl01OlI1O);dff IOOl1Il10IOIO01l
(oe_cbe,O01IlOI01lIOIl0,clk,reset_b,1'b1);assign OOIl1IO0lIIO0lI[27]=bar0_setup[33]&~bar0_setup[27]&OOIl1I01lOlIO10[27];assign status_rty
=I01lOIlO01OlI1O;assign IO0lIOOIl1O01Il
=(IIO0lIO01ll0IO1&~h_abort_b&~I01lOIO0lIlIO10)|
(O1lIOI1lO0IlI0O&~h_abort_b&~I01lOIO0lIlIO10);assign I01lOl0IO1IO0lI[20]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[20])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlO01I1lO0OIl01[3]
=CASCADE(~((IlI0OOOIl1OlI01&IO01lO1lIOOOl1I)|OOIl1IO01lIO01l)&
~(lIO10OI01lO01Il))&
~(OlI1OI1lO0l10IO)&
LCELL(~((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0]))&
IOIl0I01lOIOIl0[3];assign IlO01OOIl1I01lO[28]
=bar1_setup[33]&~bar1_setup[28]&IlO01l10IOIOIl0[28];assign l0IO1OlI1OIlO01
=CASCADE(framein_b&~gnt_b&irdyin_b)&
LCELL((lIO10OI01lO01Il&I1lO0OOl1IlIO10&(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O)&~IO0lIIO01lI01lO)|
(I1lO0OlI01l0IO1&~IO0lIIO01lI01lO&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)));dffe5 Il10IOO1lIOIOIl0
(trd_size[4:0],IlO01lO10IO1lIO[4:0],clk,reset_b,1'b1,OOIl1l0IO1O01Il);assign I01lOl0IO1IO0lI[1]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[1])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign OI01lOlI01I01lO
=LCELL(lIO10lIO10IO01l|(OOl1IOOl1IOlI01&O01IlIlI0OOOIl1));dff IOOIl1OOIl1OOIl1
(IlI0Ol10IOIO01l,IIO0llIO10OIl01,clk,reset_b,1'b1);BUF IIIO0lOlI01IO01l(lO10IOOl1IIlI0O,l0IO1OlI1Ol0IO1);assign h_cs_b[1]
=I01lOIO0lIlIO10|~l0IO1lO10Il10IO;assign OOl1IOOl1IIO0lI
=lIO10OI01lIIO0l[24]^lIO10OI01lIIO0l[25]^lIO10OI01lIIO0l[26]^lIO10OI01lIIO0l[27];BUF IlIO10IIO0lIlI0O
(I01lOIO0lIIO01l,OI01lIIO0lIO0lI);dff II01lOl10IOIO0lI(l0IO1IlI0OI01lO,IlI0OOOIl1IlO01,clk,reset_b,1'b1);BUF Il0IO1IO01lO1lIO
(OOl1Il10IOO1lIO,OlI1OI01lOO01Il);dff IIIO0lO01IlOI01l(I1lO0OOl1IO1lIO,IO01lOlI1OO01Il,clk,reset_b,1'b1);dff IlO10IOIl01OI01l
(O01IllO10IOlI01,lO10Il0IO1I1lO0,clk,reset_b,1'b1);dff IOlI1OlIO10lO10I(oe_par,OI01lIIO0lIlO01,clk,reset_b,1'b1);dff IOlI1OIO01ll10IO
(I01lOIlO01OlI1O,l10IOI1lO0l10IO,clk,reset_b,1'b1);assign I1lO0OOl1IOI01l
=~OI01ll0IO1O01Il[7]&~OI01ll0IO1O01Il[6]&~OI01ll0IO1O01Il[5]&~OI01ll0IO1O01Il[4];assign IOIl0OIl01IO01l
=~OI01lIO0lIl0IO1&~IIO0lOI01lOI01l;assign OI01lIlO01OI01l
=LCELL(IlI0OOOIl1l0IO1^IO0lIIlO01IlI0O^OlI1OI01lOOOl1I^OOl1Il0IO1lIO10);assign IlI0OlO10IOOl1I
=~OI01lIlO01O1lIO&~IO01lIlI0OOI01l;assign IO01lIlI0OO1lIO[23:16]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&O1lIOOlI1OO1lIO&~l0IO1OIl01l10IO[2])?IO0lIOOIl1IIO0l[23:16]:IlO01l10IOIOIl0[23:16];dff IOIl01lO10IIOIl0
(IIO0lOI01llIO10,OIl01l10IOl0IO1,clk,reset_b,1'b1);assign I01lOOOl1IOOl1I[3:0]
=
(O01IllIO10IO0lI&((~bar0_setup[34]&OOl1IIlO01I1lO0)|(~bar1_setup[34]&I1lO0l10IOOlI1O)))?4'b1111:
((I1lO0IlO01OOl1I|(~IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0])|(IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0]&OOl1IOOIl1IO0lI))&
(I1lO0l0IO1OlI1O[0]|lIO10IIO0lOlI1O))?IO0lIOOIl1IIO0l[5:2]:
((I1lO0IlO01OOl1I|(~IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0])|(IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0]&OOl1IOOIl1IO0lI))&
~I1lO0l0IO1OlI1O[0]&l10IOIlI0OOlI01)?{1'b1,IO0lIOOIl1IIO0l[4:2]}:
((I1lO0IlO01OOl1I|(~IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0])|(IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0]&OOl1IOOIl1IO0lI))&
~I1lO0l0IO1OlI1O[0]&I01lOOlI01I1lO0)?{2'b11,IO0lIOOIl1IIO0l[3:2]}:
(IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0]&IO0lIIIO0lIO01l&
(I1lO0l0IO1OlI1O[0]|l10IOIlI0OOlI01|lIO10IIO0lOlI1O))?{1'b1,IO0lIOOIl1IIO0l[4:2]}:
(IO0lIOOIl1IIO0l[1]&~IO0lIOOIl1IIO0l[0]&
((IO0lIIIO0lIO01l&~I1lO0l0IO1OlI1O[0]&I01lOOlI01I1lO0)|
(OI01lO01IllO10I&(I1lO0l0IO1OlI1O[0]|I01lOOlI01I1lO0|l10IOIlI0OOlI01|lIO10IIO0lOlI1O))))?
{2'b11,IO0lIOOIl1IIO0l[3:2]}:4'b1111;dff IIlI0OO1lIOIO0lI
(l10IOl10IOIIO0l,IO01lOIl01I1lO0,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[2]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[2])|
(O1lIOOOIl1lIO10&h_din[2])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[2]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[2])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[2]);assign oe_frame
=IO01lIlI0OlIO10;assign IlI0OIOIl0OlI1O[31:16]=IIO0llIO10OOIl1;assign OOIl1lIO10OOl1I
=
LCELL((O1lIOIOIl0OOIl1&IIO0lOI01lOI01l)|
(~IIO0lOI01lOI01l&LCELL(~(~h_retry_b|(~h_abort_b&~I01lOIO0lIlIO10)|(~h_bii_b&l0IO1I1lO0lIO10))))|
(~O1lIOIOIl0OOIl1&LCELL(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)));assign OIl01IIO0lIO01l[21]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[21])|
(O1lIOOOIl1lIO10&h_din[21])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[21]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[21])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[21]);assign OIl01OOIl1O01Il
=IlO01OlI1OOlI1O|l0IO1I01lOOI01l|O01IllO10Il0IO1|IOIl0OI01lOOl1I;assign IIO0llIO10OOIl1[15]=I1lO0O01IlIO0lI;assign I01lOl0IO1OlI01
=(~O01IlIlI0OOOIl1&(IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
(~lIO10IO0lIlO10I|(~lO10IOOIl1OlI1O&l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)));assign I1lO0IIO0lOIl01[31:2]
=(lIO10OI01lO01Il)?h_ain[31:2]:OlI1OlO10IlO10I[31:2];assign OI01ll10IOOOl1I=O01IlI01lOIlI0O+3'b001;assign I1lO0l10IOlO10I[24]
=I01lOIlO01OlI1O;assign l0IO1I1lO0lIO10=~h_rdyh_b;assign IOIl0I01lOOIl01=OlI1OlO10II01lO|(~IO01lOI01lO1lIO&OIl01OlI1OIIO0l);assign I01lOl0IO1IO0lI[28]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[28])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IIO0ll0IO1OOIl1[0]=h_wrin;assign OOIl1IO0lIIO0lI[16]
=bar0_setup[33]&~bar0_setup[16]&OOIl1I01lOlIO10[16];dff IOI01ll10IOl10IO(I1lO0OlI01l0IO1,I01lOlIO10IO0lI,clk,reset_b,1'b1);assign lO10IIO01lIlO01
=I1lO0l0IO1OlI1O[3]&~I1lO0l0IO1OlI1O[2]&I1lO0l0IO1OlI1O[1]&~I1lO0l0IO1OlI1O[0]&
lO10IOlI01OI01l&~IlO01IlO01IlO01[0]&~IlO01IlO01IlO01[1];assign I01lOl0IO1IO0lI[9]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[9])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));dffe4 IIIO0lIlO01OlI01
(O1lIOOIl01OlI01,lO10IO01IllIO10,clk,reset_b,1'b1,IIO0llIO10I1lO0);assign IlO01OOIl1I01lO[17]
=bar1_setup[33]&~bar1_setup[17]&IlO01l10IOIOIl0[17];assign IlO01l10IOOIl01=(lO10IOOl1IlO10I&OI01lOOl1IIOIl0);assign lO10IOOl1IOlI1O
=~(lO10IIOIl0IIO0l&IIO0lOI01lOI01l)&
~(O01IlO1lIOIO01l&IO01llIO10IOIl0)&
OI01lOOIl1OIl01;assign IlI0Ol10IOOI01l
=(I1lO0IIO0lI1lO0)?l10IOIOIl0IlO01[35:32]:cbein_b;assign IIO0lIO0lIOOl1I
=LCELL(IlI0OOOIl1OlI01&~lIO10IO01lIOIl0&~OlI01IO01lO01Il);assign OlI01IO0lII1lO0
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[4]:OIl01IlI0OO1lIO;assign IO01lIlI0OOI01l
=IIO0llIO10IOIl0&O1lIOO01IlIlO01&OOIl1OI01llO10I&IlO01IOIl0IIO0l;assign I1lO0IOIl0IOIl0[1:0]
=
(I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO&~I1lO0l0IO1OlI1O[3]&I1lO0l0IO1OlI1O[2]&I1lO0l0IO1OlI1O[1]&~I1lO0l0IO1OlI1O[0])?2'b00:
(I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO&I1lO0l0IO1OlI1O[3]&I1lO0l0IO1OlI1O[2]&~I1lO0l0IO1OlI1O[1]&~I1lO0l0IO1OlI1O[0])?2'b01:
(I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO&I1lO0l0IO1OlI1O[3]&I1lO0l0IO1OlI1O[2]&I1lO0l0IO1OlI1O[1]&~I1lO0l0IO1OlI1O[0])?2'b10:
(I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO)?2'b11:IO01lOI01llIO10[1:0];dff IOlI01O01IlIO0lI
(OlI1OI01lOOOl1I,O1lIOl10IOI01lO,clk,reset_b,1'b1);assign IOIl0OlI1OI01lO
=(l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)|lO10IOOl1II01lO|IlI0OI1lO0OI01l;assign OlI1OI01lOIIO0l
=(~(OOIl1IO01lOI01l&IO0lIOOIl1IIO0l[29]))&(IO0lIOOl1Il10IO|(O01IlO1lIOO1lIO));assign I01lOlIO10IlO01
=OlI01IO0lIOIl01&IO01lO1lIOOOl1I&OlI1OIlI0OIlO01;assign OIl01l10IOOlI01
=
(LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10&O01IlIlI0OOOIl1)|
LCELL(((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&h_retry_b)|
(IO01lI1lO0OlI01))|
(~O01IlIlI0OOOIl1&~IIO0lOI01lOI01l));assign IIO0lIO01lIO0lI
=(adin[4]^adin[5]^adin[6]^adin[7]);assign IO01lO1lIOl10IO=(lIO10lO10IIO01l|OIl01O01IlOIl01)&~OI01lIO0lIl0IO1;assign l10IOI1lO0l10IO
=~(OlI1OO1lIOI1lO0&IO0lIOOIl1IIO0l[24])&(OOl1IOOIl1OlI01|I01lOIlO01OlI1O);dff IOOl1IOOIl1l0IO1
(l0IO1I01lOO1lIO,OOIl1O1lIOIlO01,clk,reset_b,1'b1);dff IOOl1IOlI1OIO0lI(OOl1IOOIl1IO0lI,OlI1OO1lIOOIl01,clk,reset_b,1'b1);assign lIO10lIO10lIO10
=IlI0OOOIl1OlI01;dffe32 IIO0lIOIl01IOIl0(OlI01IO01ll10IO[31:0],lIO10OI01lIIO0l[31:0],clk,reset_b,1'b1,IO0lIIlO01OlI1O);assign OI01lIOIl0IO0lI
=~(lIO10OI01lO01Il|IO01llO10IOOIl1)&(((IIO0lOOl1IOlI1O|IlI0OOlI1OOlI01)&lIO10IO01lIOIl0)|O01IlOI01lOIl01);dff IOlI01O01IlOlI01
(OOl1IO01Ill10IO,OlI1OlIO10OlI1O,clk,reset_b,1'b1);dff IO1lIOI01lOIlI0O(IO0lIl10IOl0IO1,lIO10lO10IIO01l,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[13]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[13])|
(O1lIOOOIl1lIO10&h_din[13])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[13]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[13])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[13]);assign O01IlOI01lOOIl1
=IIO0llIO10IOIl0&O1lIOO01IlIlO01&OOIl1OI01llO10I&I01lOO1lIOIO01l;assign O1lIOO01Ill0IO1[7]=1'b0;BUF IlIO10IIO0llO10I
(OIl01OIl01I1lO0,lIO10l0IO1O1lIO);assign OIl01IIO0lIO01l[32]
=(O1lIOOOIl1lIO10&h_bein_b[0])|
(IIO0lIO0lIOOl1I&IlI0OOOIl1IO0lI[0])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[32]);dff IlIO10O01IlOOl1I
(irdyout_b,IIO0lI01lOIlO01,clk,1'b1,reset_b);assign IIO0llIO10OOIl1[2:0]=3'b000;assign IO01lO1lIOOOl1I=~trdyin_b;assign IO01lO1lIOO01Il
=(IIO0lOI01lOI01l&O1lIOOlI1OOI01l)|(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe8 Il0IO1IO01lOI01l
(l10IOIOIl0IlO01[15:8],adin[15:8],clk,reset_b,1'b1,OlI1OOI01lIO0lI);dff Il0IO1OI01lI01lO
(OlI1OI01lOl10IO,OOl1Il10IOOI01l,clk,reset_b,1'b1);assign OOIl1IO0lIIO0lI[24]
=bar0_setup[33]&~bar0_setup[24]&OOIl1I01lOlIO10[24];dff IIIO0ll0IO1OIl01(OIl01IOIl0O1lIO,lO10IOlI01lIO10,clk,reset_b,1'b1);assign IlO01I1lO0I1lO0
=(O1lIOI1lO0IlI0O&I01lOIO0lIlIO10)|
(O1lIOI1lO0IlI0O&~l0IO1I1lO0lIO10&h_abort_b);assign I01lOl0IO1IO0lI[17]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[17])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IO0lIl0IO1IlO01[2]
=
(IO01lO1lIOOOl1I&LCELL(IlI0OOOIl1OlI01&OIl01IIO0lIO01l[34]))|
LCELL((OOIl1IO01lIO01l&OIl01IIO0lIO01l[34])|
((lIO10OI01lO01Il)&IIO0ll0IO1OOIl1[2])|
((OlI1OI1lO0l10IO)&O01IlO1lIOlIO10[2])|
(((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0])&O1lIOOIl01OlI01[2]))|
IlO01I1lO0OIl01[2];assign IlO01OOIl1I01lO[25]
=bar1_setup[33]&~bar1_setup[25]&IlO01l10IOIOIl0[25];assign IIO0lOlI01O1lIO=LCELL(IlI0OOOIl1OlI01&~l10IOOlI1OOOIl1);dff IOI01lI1lO0IIO0l
(OlI1OlIO10IlI0O,OOl1IOIl01OOl1I,clk,reset_b,1'b1);assign I01lOOlI01IOIl0=(l10IOOIl01I01lO)?adin:I01lOl0IO1IO0lI;assign OlI1OOlI1OI1lO0
=LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10);dff Il0IO1l0IO1OOl1I(OOIl1OI01lI01lO,IlO01IOIl0O01Il,clk,reset_b,1'b1);assign l10IOIlI0OIO0lI
=(h_size==16'h0001)?1'b1:1'b0;assign h_burst_b=I01lOIO0lIlIO10;assign lIO10lIO10O1lIO
=LCELL(lO10Il0IO1IOIl0^O01IlOIl01IlO01^OI01lOlI01lO10I^IOIl0IlI0OIIO0l);BUF IIOIl0IO01lIOIl0(O01IlI01lOI01lO,OOIl1IO01lO1lIO);assign IOIl0O1lIOOlI1O
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign l10IOOOIl1OIl01
=~IIO0llIO10IOIl0|~O1lIOO01IlIlO01|~OOIl1OI01llO10I|OlI1OlO10IOlI1O[3]|
OlI1OlO10IOlI1O[2]|(OlI1OlO10IOlI1O[1]&OlI1OlO10IOlI1O[0]);BUF IIlO01O1lIOIlI0O
(OlI01IlO01OOl1I,OlI1OIlI0Ol0IO1);dff IIOIl0IO0lIIlI0O(OlI01OI01lIlO01,OIl01OIl01IOIl0,clk,reset_b,1'b1);BUF II1lO0IOIl0OIl01
(OlI1OOI01lOlI01,OIl01I1lO0IO0lI);assign IO0lIIOIl0O1lIO=(IlO01IlO01IlO01[7:2]==6'b010000)?1'b1:1'b0;dff IIOIl0OI01ll10IO
(lO10IIIO0lOOl1I,OIl01l10IOIlO01,clk,reset_b,1'b1);assign OlI1OOIl01I01lO=~(OI01ll0IO1IIO0l);assign OOl1IIIO0llO10I
=IO01lI1lO0OlI01&O01IlI1lO0lO10I;assign oe_ad=OI01lIIO0lIlO01;assign lO10Il10IOOIl01
=I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO;assign IlI0OOIl01OOl1I
=(OIl01IOIl0O1lIO&IOIl0lO10IIO01l)|(OlI01l0IO1OlI1O&~IO0lIOlI01I1lO0);assign O1lIOIlI0OOOIl1
=(IlI0OIIO0lI01lO&~OlI01OOl1IO1lIO[1]&~OlI01OOl1IO1lIO[0])?
~more_wb&IlO01OlI1OIlI0O[3]&IlO01OlI1OIlI0O[2]&IlO01OlI1OIlI0O[1]&IlO01OlI1OIlI0O[0]:
IlO01OlI1OIlI0O[3]&IlO01OlI1OIlI0O[2]&IlO01OlI1OIlI0O[1]&IlO01OlI1OIlI0O[0];dff IOOl1II1lO0O1lIO
(OIl01O01IlOIl01,OI01lOOl1IOOIl1,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[5]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[5])|
(O1lIOOOIl1lIO10&h_din[5])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[5]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[5])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[5]);assign oe_irdy
=I1lO0l10IOIlI0O;assign IO01lI1lO0l0IO1[7:0]=revision_id;assign l10IOIIO0lIlO01
=
LCELL((l10IOl10IOIIO0l&IO0lIIO01lI01lO&OOIl1O1lIOl0IO1)|
(l10IOl10IOIIO0l&~OOIl1O1lIOl0IO1)|
(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&~h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10)|
(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&~l10IOOOIl1IOIl0&~I01lOO1lIOlIO10&~lO10IIO01lIlO01&~O01IlI1lO0lO10I)|
((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&~h_retry_b)|
(IO01lI1lO0OlI01));assign OIl01IIO0lIO01l[24]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[24])|
(O1lIOOOIl1lIO10&h_din[24])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[24]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[24])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[24]);assign OOIl1lIO10IIO0l
=(lIO10OI01lO01Il&I1lO0OOl1IlIO10&(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O)&~IO0lIIO01lI01lO)|
(I1lO0OlI01l0IO1&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)&~IO0lIIO01lI01lO)|
(OOl1Il0IO1OI01l&~IO0lIIO01lI01lO)|
(OlI1OI1lO0l10IO&~I1lO0l10IOIlI0O);assign IIO0llIO10OOIl1[12]
=lO10IIIO0lO01Il;assign I01lOIO01lI01lO
=((IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
~O01IlIlI0OOOIl1&lIO10IO0lIlO10I&~(l0IO1I1lO0lIO10&~I01lOIO0lIlIO10&O1lIOI1lO0IlI0O));assign OI01ll10IOO01Il[1:0]
=
(~OOIl1OlI01OlI1O[3]&~OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0]&~OlI01IO01ll10IO[32])?2'b00:
(~OOIl1OlI01OlI1O[3]&~OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0]&~OlI01IO01ll10IO[33])?2'b01:
(~OOIl1OlI01OlI1O[3]&~OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0]&~OlI01IO01ll10IO[34])?2'b10:
(~OOIl1OlI01OlI1O[3]&~OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0]&~OlI01IO01ll10IO[35])?2'b11:OlI1OlO10IlO10I[1:0];dff IIIO0lOOl1IlO10I
(OIl01OlI1OOOl1I,OI01lIlO01lIO10,clk,reset_b,1'b1);assign I1lO0l10IOlO10I[15:0]=IIO0lIIO0lOOl1I[15:0];assign status14
=IIO0llIO10OOIl1[14];BUF Il0IO1IO0lIOlI01(IlI0OOlI1Ol0IO1,IOIl0O1lIOI01lO);assign I01lOl0IO1IO0lI[25]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[25])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IO01llIO10OOIl1
=IIO0lOOl1IOlI1O&lIO10IO01lIOIl0&OOIl1OlI01OlI1O[3]&OOIl1OlI01OlI1O[2]&~OOIl1OlI01OlI1O[0];assign OOIl1IO0lIIO0lI[2:1]=2'b00;dff IOlI1OOI01ll0IO1
(O1lIOI1lO0lO10I,lIO10OI01lO01Il,clk,1'b1,reset_b);assign O01IllIO10IO0lI
=((I1lO0l0IO1OlI1O==4'b0110)|
(I1lO0l0IO1OlI1O==4'b1100)|
(I1lO0l0IO1OlI1O==4'b1110))?1'b1:1'b0;assign I01lOl0IO1IO0lI[6]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[6])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));dffe IO1lIOI01lOOlI1O
(IOIl0lO10IIO01l,h_wrin,clk,reset_b,1'b1,IlI0OI1lO0O1lIO);assign IlO01OOIl1I01lO[3]
=bar1_setup[33]&bar1_setup[34]&bar1_setup[32];assign l10IOO01IlI01lO
=(IO0lIIlO01OlI1O&O1lIOIOIl0OIl01&IO0lIOOIl1OOl1I)|(l0IO1IlI0OIlI0O&~OlI1OIlI0OOlI01);assign IO0lIIO01lI01lO
=O1lIOI1lO0IlI0O|IlI0OIIO0lI01lO;assign O01IlOIl01IlO01
=lIO10OI01lIIO0l[4]^lIO10OI01lIIO0l[5]^lIO10OI01lIIO0l[6]^lIO10OI01lIIO0l[7];assign IO01lI1lO0IlO01=IO01llO10IOOIl1;assign IOIl0OI01lO01Il
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[1]&sel_23)?IO0lIOOIl1IIO0l[10]:OI01lO01IlI01lO;assign OlI01IO01lOOl1I
=(IO0lIIlO01I01lO&OOl1Il10IOO1lIO)|OIl01IOIl0O1lIO;dff II1lO0OlI1OO1lIO(oe_stop,I1lO0IOIl0OOIl1,clk,reset_b,1'b1);dff IO1lIOO1lIOO1lIO
(I1lO0OlI01IlO01,I01lOOI01lI1lO0,clk,reset_b,1'b1);assign IlO01l10IOI1lO0
=(IO01lO1lIOOOl1I&OlI01O1lIOI1lO0)|IIO0ll0IO1IOIl0|I01lOIO0lIIO01l;dff8 IlIO10O01IlO01Il
(OI01lOOIl1IOIl0,IIO0lIO01lIlO01,clk,reset_b,1'b1);assign O01IlI1lO0I01lO
=((IO01llO10II1lO0|O01IlO1lIOOI01l)&I1lO0IIO0lIOIl0)?16'h0001:
(I1lO0IIO0lIOIl0&~l0IO1OI01lOlI1O)?h_size:
(~IO01llO10II1lO0&l0IO1OI01lOlI1O&~O01IlO1lIOOI01l)?16'hffff:
(~IO01llO10II1lO0&O01IlO1lIOOI01l&OI01lOOIl1OOIl1)?16'h0000:
(~IO01llO10II1lO0&O01IlO1lIOOI01l)?16'h0001:
(IO0lIOlI01I1lO0)?16'h0000:
(OI01lOOIl1OOIl1)?IOIl0lO10IO1lIO:
OI01ll0IO1O01Il;assign lIO10I01lOI1lO0
=OIl01l10IOOlI01|OlI01lIO10OlI1O|IlI0OO01Ill10IO;assign IlO01OIl01O1lIO=(adin[16]^adin[17]^adin[18]^adin[19]);assign lIO10IlO01OOIl1
=((OIl01O01IlOIl01|OlI01OI01lIO0lI)&~OI01lIO0lIl0IO1&~IlI0OOIl01l10IO)|
(lIO10lO10IIO01l&h_abort_b)|
(O1lIOOOIl1O1lIO&OI01lIIO0lIlO01&I01lOO1lIOlIO10);assign IIO0lIO0lIO01Il
=(IlO01IlO01IlO01[7:2]==6'b000100)?1'b1:1'b0;dff II01lOIlO01IlI0O(I1lO0IlO01IIO0l,IlO01OOIl1lO10I,clk,reset_b,1'b1);assign IOIl0OI01lIIO0l
=(OI01lOOIl1IOIl0[7:0]==8'h08)?1'b1:1'b0;assign lIO10OlI01OOl1I
=(O1lIOOIl01IO0lI&OOl1IOOl1Il0IO1&((OlI01IO0lIOOIl1&~parin)|(~OlI01IO0lIOOIl1&parin)));dffe8 IIO01lIO0lIIIO0l
(adout[15:8],OIl01IIO0lIO01l[15:8],clk,1'b1,reset_b,l10IOl10IOl10IO);assign OOl1IOOIl1OlI01=IO0lIIlO01OlI1O&OlI01OlI01l0IO1;assign OlI1OlIO10OlI1O
=(I01lOOlI01OOIl1&~IO0lIIO01lI01lO)?IlO01OOIl1IlI0O:OOl1IO01Ill10IO;assign lO10IIO0lIl10IO
=
(LCELL(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10)&IIO0lOI01lOI01l)|
(IIO0lOI01lOI01l&O1lIOIOIl0OOIl1&LCELL(~((lO10IOOIl1OlI1O|~h_bii_b|O1lIOIlI0OOOIl1)&l0IO1I1lO0lIO10)&(lIO10lO10IIO01l&h_retry_b&h_abort_b)));assign OIl01IIO0lIO01l[16]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[16])|
(O1lIOOOIl1lIO10&h_din[16])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[16]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[16])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[16]);assign OOIl1IO0lIOlI01
=(OOl1IIIO0lIlI0O&OlI1OIlI0OIlO01)|OlI1OO1lIOIOIl0;assign O1lIOO01Ill0IO1[4]=OIl01IlI0OO1lIO;BUF IIOIl0IO01lOIl01
(IO01lI01lOl0IO1,OOIl1OOl1IOOIl1);assign OIl01IIO0lIO01l[35]
=(O1lIOOOIl1lIO10&h_bein_b[3])|
(IIO0lIO0lIOOl1I&IlI0OOOIl1IO0lI[3])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[35]);assign IOIl0lO10IlIO10
=(~OIl01IOIl0O1lIO&~IO01llO10IOOIl1&~O01IlI01lOIlI0O[2]);assign IIO0lO1lIOl10IO[7:0]=OI01lOOIl1IOIl0;assign OI01lOOl1IIOIl0
=~gnt_b;assign IO0lIl10IOIO0lI=l0IO1O1lIOOlI01&(h_abort_b|I01lOIO0lIlIO10);dffe24 IOI01lOIl01IlI0O
(h_aout[31:8],IlO01IlI0OOOl1I[31:8],clk,reset_b,1'b1,OlI01I01lOl10IO);assign lIO10OlI01O01Il[1]
=(h_mio&h_wrin)?(h_cmd[1]&OIl01IlI0OO1lIO):h_cmd[1];assign OOIl1IO0lIIO0lI[21]
=bar0_setup[33]&~bar0_setup[21]&OOIl1I01lOlIO10[21];dff IIlO01IlI0OO01Il(IO0lIIlO01OlI1O,IOIl0OlI1OlO10I,clk,reset_b,1'b1);dff IO1lIOlO10Il0IO1
(lO10IOlI01OI01l,IOIl0I1lO0OIl01,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[14]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[14])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlO01I1lO0OIl01[0]
=CASCADE(~((IlI0OOOIl1OlI01&IO01lO1lIOOOl1I)|OOIl1IO01lIO01l)&
~(lIO10OI01lO01Il))&
~(OlI1OI1lO0l10IO)&
LCELL(~((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0]))&
IOIl0I01lOIOIl0[0];assign IlO01OOIl1I01lO[22]
=bar1_setup[33]&~bar1_setup[22]&IlO01l10IOIOIl0[22];assign OI01lIO0lIIlO01
=(LCELL(OIl01IOIl0O1lIO&IOIl0lO10IIO01l)|
LCELL(IIO0lOlI01O1lIO&~OOl1IIIO0lIlI0O&(~IO01lO1lIOOOl1I|IlI0OOIl01O01Il))|
(IO01llO10IOOIl1&OOIl1OlI01OlI1O[0]));BUF IOlI1OOlI01IO0lI
(O01IlO1lIOIO01l,OIl01IlI0OOI01l);dffe4 IIO0lIIOIl0lIO10(l10IOIOIl0IlO01[35:32],cbein_b,clk,reset_b,1'b1,I1lO0OOIl1O1lIO);assign l10IOl10IOl10IO
=CASCADE(IlI0OOOIl1OlI01|
(IIO0lOI01lOI01l&IO0lIIIO0lO1lIO)|
lO10Il0IO1OIl01)&
(IO01lO1lIOOOl1I|(IIO0lOI01lOI01l&IO0lIIIO0lO1lIO)|lO10Il0IO1OIl01);dff IOI01lIOIl0IlO01
(OI01lO01IlI01lO,IOIl0OI01lO01Il,clk,reset_b,1'b1);assign IIO0llIO10IOIl0
=~OlI1OlO10IOlI1O[15]&~OlI1OlO10IOlI1O[14]&~OlI1OlO10IOlI1O[13]&~OlI1OlO10IOlI1O[12];assign OlI01OOl1IOI01l
=lIO10lO10IIO01l&l0IO1I1lO0lIO10&~O01IlIlI0OOOIl1&(~O1lIOIOIl0OOIl1|~IIO0lOI01lOI01l);dff IOOl1IOOIl1IlO01
(parout,OlI01OI01lOlI01,clk,1'b1,reset_b);assign I1lO0l0IO1lO10I=(IlI0OIIO0lI01lO|IIO0lO1lIOO01Il)&~lIO10IO0lIlO10I;assign I1lO0l0IO1I01lO
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign OOIl1IO01llIO10
=~(IO01lO1lIOOOl1I&OlI1OIlI0OIlO01)&lIO10OlI01IIO0l;assign OOl1IIO0lII01lO
=LCELL((lIO10lO10IIO01l&l0IO1I1lO0lIO10&(lO10IOOIl1OlI1O|~h_bii_b))|
(IO01lI1lO0OlI01)|
(~IOIl0OlI1OIlI0O))|
(IIO0lOI01lOI01l&LCELL((lIO10lO10IIO01l&l0IO1I1lO0lIO10&O1lIOIlI0OOOIl1)|
(OIl01O01IlOIl01)|
(IlI0OIIO0lI01lO&O1lIOIlI0OOOIl1&~O01IlIlI0OOOIl1)));dff IIlO01I01lOIOIl0
(IlO01I1lO0OOIl1,I01lOlIO10l0IO1,clk,reset_b,1'b1);BUF IOlI01IlO01O01Il(O1lIOIlI0OIOIl0,I1lO0OOIl1OI01l);assign O01IlI01lOOlI1O
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OlI01OlI01IO0lI&~l0IO1OIl01l10IO[1])?IO0lIOOIl1IIO0l[15:8]:OI01ll0IO1l10IO;assign OIl01l10IOIlO01
=OlI01lIO10lO10I|IlI0OOIl01IIO0l|OlI01OlI01l0IO1;assign O01IlIlI0OI1lO0=~IOIl0OlI1OIlI0O&OI01lIO0lIl0IO1&IIO0lOI01lOI01l;dff IOIl01IlI0OIO01l
(perrout_b,I01lOIO01lIlI0O,clk,1'b1,reset_b);dffe8 Il10IOO1lIOOOIl1
(lIO10OI01lIIO0l[23:16],OIl01IIO0lIO01l[23:16],clk,reset_b,1'b1,lIO10lIO10OI01l);assign OOl1IIlO01I1lO0
=bar0_setup[33]&lIO10IO0lII01lO&
((bar0_setup[32]&I01lOlO10IIlO01&IlO01OOIl1IlI0O)|(~bar0_setup[32]&l10IOO01IllO10I&I1lO0IlO01OOl1I));assign OI01lIIO0ll0IO1
=CASCADE(~(IlI0OOIl01OOl1I|IIO0lOI01llIO10|O1lIOIOIl0IOIl0))&~(l0IO1IlI0OIlI0O&~IO0lIOlI01I1lO0);assign IlO01IlI0OOOl1I[1:0]
=2'b00;dff Il0IO1OlI01OlI1O(IIO0lO1lIOO01Il,IlO01O01IllIO10,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[8]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[8])|
(O1lIOOOIl1lIO10&h_din[8])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[8]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[8])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[8]);BUF IlO10IOIl01O1lIO
(I01lOIO01llO10I,OOl1IOOl1IIlO01);assign IlO01IOIl0OOl1I
=(IlO01IlO01IlO01[7:2]==6'b000000)?OOl1IIlO01OOIl1:
(IlO01IlO01IlO01[7:2]==6'b000001)?IlI0OIOIl0OlI1O:
(IlO01IlO01IlO01[7:2]==6'b000010)?IO01lI1lO0l0IO1:
(IlO01IlO01IlO01[7:2]==6'b000011)?IIO0lO1lIOl10IO:
(IlO01IlO01IlO01[7:2]==6'b000100)?OOIl1IO0lIIO0lI:
(IlO01IlO01IlO01[7:2]==6'b000101)?IlO01OOIl1I01lO:
(IlO01IlO01IlO01[7:2]==6'b001011)?I1lO0l0IO1IlI0O:
(IlO01IlO01IlO01[7:2]==6'b001111)?O1lIOOOIl1OI01l:
(IlO01IlO01IlO01[7:2]==6'b010000)?I1lO0l10IOlO10I:
32'h00000000;assign OIl01OOIl1IIO0l
=OOl1IIO01lI1lO0;assign OIl01IIO0lIO01l[27]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[27])|
(O1lIOOOIl1lIO10&h_din[27])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[27]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[27])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[27]);assign l10IOIOIl0IO0lI
=~I01lOOI01lOIl01;assign IIO0llIO10OOIl1[8]=OI01lOOl1II1lO0;assign IIO0lIO0lIl10IO
=((IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
~O01IlIlI0OOOIl1&lIO10IO0lIlO10I&~(l0IO1I1lO0lIO10&~I01lOIO0lIlIO10&O1lIOI1lO0IlI0O));dffe8 IIIO0lO01IlO1lIO
(l0IO1O1lIOIO0lI[7:0],I01lOOlI01IOIl0[7:0],clk,reset_b,1'b1,IlO01l10IOI1lO0);assign OI01lIlO01lIO10
=lO10IO01IlOI01l&gnt_b&~OIl01IOIl0O1lIO&~IO01llO10IOOIl1&~(OOIl1OlI01OlI1O[3]&OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0]);assign OOIl1IO0lIIO0lI[29]
=bar0_setup[33]&~bar0_setup[29]&OOIl1I01lOlIO10[29];assign status11=IIO0llIO10OOIl1[11];BUF IIlI0OI01lOOI01l
(OOl1Il10IOlIO10,IlO01I1lO0I1lO0);assign I01lOl0IO1IO0lI[22]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[22])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlO01IOIl0l10IO[3:0]
=(lIO10OI01lO01Il&I1lO0OOl1IlIO10)?IIO0ll0IO1OOIl1[3:0]:
(OlI1OI1lO0l10IO)?O01IlO1lIOlIO10[3:0]:OOIl1OlI01OlI1O[3:0];assign IlO01OOIl1I01lO[30]
=bar1_setup[33]&~bar1_setup[30]&IlO01l10IOIOIl0[30];dff II1lO0OOIl1lIO10(IlI0OOlI1OOlI01,IlI0OOOIl1OlI01,clk,reset_b,1'b1);dff IIlO01OI01lOOl1I
(lO10IO01IlIO01l,l0IO1lIO10IIO0l,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[3]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[3])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign lO10Il0IO1OIl01
=LCELL(lIO10lIO10IO01l|(IO0lIIIO0lO1lIO&O01IlIlI0OOOIl1));dff IIIO0lIIO0ll10IO
(l10IOO01IllO10I,l0IO1OlI1OOlI01,clk,reset_b,1'b1);dff IOlI01l0IO1lO10I(IOIl0I1lO0I1lO0,OI01ll10IOIIO0l,clk,reset_b,1'b1);assign I01lOIO0lIlIO10
=IOIl0O1lIOlO10I&~lIO10lO10IIO01l&~(O1lIOI1lO0IlI0O&~lO10IO01IlIO01l);assign IO0lIIO0lIIO01l
=lIO10OI01lIIO0l[16]^lIO10OI01lIIO0l[17]^lIO10OI01lIIO0l[18]^lIO10OI01lIIO0l[19];BUF II01lOO01IlOOIl1
(OOIl1OlI01lO10I,lO10IOlI01IO01l);dff IOOIl1IlO01IO01l(lO10IIIO0lO01Il,IO0lIIlO01lO10I,clk,reset_b,1'b1);BUF IIlO01OlI1OI01lO
(lIO10OlI01IIO0l,l10IOOIl01lO10I);dff IOlI01l10IOOlI1O(OI01lIO0lIl0IO1,OlI1OOIl01I01lO,clk,1'b1,reset_b);dff II1lO0I1lO0OlI1O
(O01IlOlI1OIO01l,OIl01OOIl1l10IO,clk,reset_b,1'b1);assign lIO10OI01ll10IO
=(IO01lO1lIOOOl1I&OlI01O1lIOI1lO0)|IlO01IlI0OIIO0l|O01IlI01lOI01lO;dff16 IIlI0OO1lIOOlI01
(IIO0lIIO0lOOl1I[15:0],O1lIOOlI1OlIO10[15:0],clk,reset_b,1'b1);assign OOl1IIIO0lOlI1O
=~OI01ll0IO1O01Il[15]&~OI01ll0IO1O01Il[14]&~OI01ll0IO1O01Il[13]&~OI01ll0IO1O01Il[12];assign l0IO1O1lIOl0IO1
=(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1)|
(IlI0OI1lO0lIO10)|
(~OI01lIO0lIl0IO1|~IOIl0OlI1OIlI0O);assign lIO10IO0lIOlI1O
=(adin[28]^adin[29]^adin[30]^adin[31]);assign OIl01I1lO0IO0lI=OI01lOOl1IIOIl0&framein_b&irdyin_b&IlO01OlI1OlO10I;assign OOl1IOlI01O01Il[23:16]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IIO0lIO0lIO01Il&~l0IO1OIl01l10IO[2])?IO0lIOOIl1IIO0l[23:16]:OOIl1I01lOlIO10[23:16];dff Il10IOI01lOOOl1I
(lIO10IO01lIOIl0,IO01lO1lIOOOl1I,clk,reset_b,1'b1);assign l10IOIlI0OOlI01=(prefetch_limit==2'b01)?1'b1:1'b0;assign IIO0lIO0lIIIO0l
=CASCADE(IO0lIIIO0lOI01l|IlO01OIl01OI01l)&((OlI01IO0lIOOIl1&~parin)|(~OlI01IO0lIOOIl1&parin));assign OIl01IIO0lIO01l[0]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[0])|
(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[0])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[0]))|
((IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[0])|
(O1lIOOOIl1lIO10&h_din[0]));assign OOl1IO01IlOOl1I
=
(~OI01lIlO01O1lIO|trdyin_b)&
(~OI01lIlO01O1lIO|LCELL((OI01lIlO01O1lIO&~O1lIOl10IOlO10I)&~(OlI1OIlI0OIlO01&l10IOOlI1OOOIl1)))&
(~OI01lIlO01O1lIO|stopin_b);assign OOl1IIlO01OOIl1[31:16]
=device_id;assign OI01lOOl1IOOIl1=(lIO10lO10IIO01l&~IIO0lOI01lOI01l&~O01IlIlI0OOOIl1)|(OIl01O01IlOIl01&~IIO0lOI01lOI01l);assign OIl01IIO0lIO01l[19]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[19])|
(O1lIOOOIl1lIO10&h_din[19])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[19]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[19])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[19]);assign lO10Il10IOOOIl1
=~I1lO0IlO01O01Il&O01IlI01lOIlI0O[1]&O01IlI01lOIlI0O[0]&OlI1OIlI0OIlO01;assign O1lIOO01Ill0IO1[1]=I01lOlO10IIlO01;BUF IOOl1IOIl01O01Il
(IO01llIO10IOIl0,l0IO1O1lIOOlI01);dffe IIlI0OlO10IO01Il(lO10IOOIl1lO10I,h_mio,clk,1'b1,reset_b,OIl01IOIl0O1lIO);assign lO10IIlO01l0IO1[1]
=~I1lO0IlO01O01Il&
CASCADE((IOIl0lO10IlIO10&OI01ll10IOOOl1I[1])|(IO0lIO01IlIOIl0&O01IlI01lOIlI0O[1]));assign O1lIOOOIl1OI01l[7:0]
=IO0lIO01IlOOIl1;assign IIO0lOI01lOI01l=~irdyin_b;assign IO01lOI01lO1lIO
=I1lO0IIO0lI1lO0|(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)|(~h_abort_b&~I01lOIO0lIlIO10);assign I01lOl0IO1IO0lI[30]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[30])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IIO0ll0IO1OOIl1[2]=h_mio;assign OOIl1IO0lIIO0lI[18]
=bar0_setup[33]&~bar0_setup[18]&OOIl1I01lOlIO10[18];dff IlIO10OOl1IOlI01(lO10IOOl1IlO10I,OlI01IO01lIIO0l,clk,reset_b,1'b1);assign I01lOO1lIOlIO10
=((I1lO0l0IO1OlI1O==4'b0110)|
(I1lO0l0IO1OlI1O==4'b1100)|
(I1lO0l0IO1OlI1O==4'b1110)|
(I1lO0l0IO1OlI1O==4'b0010))?1'b1:1'b0;assign I01lOl0IO1IO0lI[11]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[11])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign O01IlOI01lIOIl0
=OOl1IO01IlOOl1I|((lIO10OI01lO01Il|I1lO0IIO0lIOIl0|I1lO0OlI01l0IO1|OOl1Il0IO1OI01l|lO10IOOl1IlO10I|OOIl1l0IO1IIO0l)&O01IlOlI1OlIO10);assign IlO01OOIl1I01lO[19]
=bar1_setup[33]&~bar1_setup[19]&IlO01l10IOIOIl0[19];assign OOIl1I01lOIO01l
=(OlI1OI1lO0l10IO|
((IO0lIIO01lI01lO|~(~gnt_b&framein_b&irdyin_b))&LCELL(OOl1Il0IO1OI01l|lO10IOOl1IlO10I)));assign OIl01IlI0OOI01l
=(IIO0lIO01ll0IO1&IOIl0O1lIOlO10I);assign O01IlI01lOlO10I
=LCELL((l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)|lO10IOOl1II01lO|IlI0OI1lO0OI01l);assign OlI01OI01ll0IO1
=(IlI0OOIl01OOl1I|IIO0lOI01llIO10|O1lIOIOIl0IOIl0)|(l0IO1IlI0OIlI0O&~IO0lIOlI01I1lO0);assign I1lO0IO0lII1lO0
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[1]:I01lOlO10IIlO01;assign IlO01IOIl0IIO0l
=~OlI1OlO10IOlI1O[3]&~OlI1OlO10IOlI1O[2]&~OlI1OlO10IOlI1O[1]&OlI1OlO10IOlI1O[0];assign OOl1IOIl01OOl1I
=IlO01OIl01OI01l?parin:OlI1OlIO10IlI0O;dff IlIO10l0IO1IO01l(IlI0OOOIl1l0IO1,OI01lOOl1IOIl01,clk,reset_b,1'b1);assign O01IlIlI0OOIl01
=(IlI0OIIO0lI01lO|IIO0lO1lIOO01Il)&~lIO10IO0lIlO10I;assign OOl1Il0IO1IO01l
=~(IOIl0O1lIOOlI1O&IO0lIOOIl1IIO0l[27])&(OI01lIIO0lOlI01|(IIO0lIO01lOlI01));assign IlO01I1lO0IOIl0
=(IO0lIIlO01I01lO&OOl1Il10IOO1lIO)|
(IO0lIIlO01I01lO&~(IO01lO1lIOOOl1I&OlI1OIlI0OIlO01));dff Il0IO1IO01llIO10
(stopout_b,IO0lIOOl1IOOl1I,clk,1'b1,reset_b);dff IlIO10O01IlIIO0l(IlI0OIOIl0lO10I,IIO0lIO0lIIIO0l,clk,reset_b,1'b1);BUF IO1lIOlO10IOlI01
(I01lOOOl1IIIO0l,OlI01l0IO1IlI0O);assign O1lIOOlI1OlIO10[7:0]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IO0lIIOIl0O1lIO&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[7:0]:IIO0lIIO0lOOl1I[7:0];assign l0IO1lO10IO01Il
=IO0lIIlO01OlI1O&IIO0lOI01lIO01l;dff IIO0lIIOIl0IO01l(OI01lO01IllO10I,O01IllO10IIlO01,clk,reset_b,1'b1);assign O1lIOI1lO0OlI1O
=CASCADE(l10IOOOIl1I1lO0&O1lIOOIl01IO0lI&IlO01OIl01OI01l)&((OlI01IO0lIOOIl1&~parin)|(~OlI01IO0lIOOIl1&parin));dffe32 IOI01lI1lO0OOl1I
(OlI01O1lIOOIl01,h_din,clk,reset_b,1'b1,OlI01OI01ll0IO1);dff IIIO0lIIO0lIIO0l
(OlI01OlI01l0IO1,IlI0OIlI0OIlI0O,clk,reset_b,1'b1);dff2 IlIO10l10IOO1lIO
(IOIl0I01lOI1lO0[1:0],OlI01OOl1IO1lIO[1:0],clk,reset_b,1'b1);dff IOI01lOlI1OOOIl1
(IO01lI1lO0OlI01,OIl01OOIl1IIO0l,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[11]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[11])|
(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[11])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[11]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[11])|
(O1lIOOOIl1lIO10&h_din[11]);BUF IIOIl0IO0lIOlI1O
(O01IllO10Il0IO1,lO10Il10IOOOIl1);assign O1lIOO01Ill0IO1[9]=1'b0;dff II01lOO01IlIOIl0
(OIl01OlI1OIIO0l,IOIl0I01lOOIl01,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[30]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[30])|
(O1lIOOOIl1lIO10&h_din[30])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[30]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[30])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[30]);dff Il10IOlO10IIlI0O
(O1lIOl10IOlO10I,IIO0lI01lOIlO01,clk,1'b1,reset_b);assign IIO0llIO10OOIl1[4]=1'b0;assign I1lO0OOl1IlIO10=~h_adsh_b;assign OlI1OOI01lIO0lI
=(IIO0lOI01lOI01l&OIl01OIl01I1lO0)|(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe8 IIlO01O1lIOOlI1O
(l0IO1O1lIOIO0lI[31:24],I01lOOlI01IOIl0[31:24],clk,reset_b,1'b1,lIO10OI01ll10IO);dffe IIO01llIO10OIl01
(IO0lIOOIl1OOl1I,IOIl0O1lIOIlI0O,clk,reset_b,1'b1,IlI0OI1lO0O1lIO);assign OOIl1IO0lIIO0lI[26]
=bar0_setup[33]&~bar0_setup[26]&OOIl1I01lOlIO10[26];dff IOlI01IlO01IIO0l(lIO10OI01lO01Il,l0IO1lO10IOOl1I,clk,1'b1,reset_b);assign OOIl1l0IO1OOl1I
=(~IO01llIO10IOIl0&IlI0OOlI1Ol0IO1)|IIO0lOOl1IIlI0O;assign I01lOl0IO1IO0lI[19]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[19])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IO0lIl0IO1IlO01[3]
=
(IO01lO1lIOOOl1I&LCELL(IlI0OOOIl1OlI01&OIl01IIO0lIO01l[35]))|
LCELL((OOIl1IO01lIO01l&OIl01IIO0lIO01l[35])|
((lIO10OI01lO01Il)&IIO0ll0IO1OOIl1[3])|
((OlI1OI1lO0l10IO)&O01IlO1lIOlIO10[3])|
(((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0])&O1lIOOIl01OlI01[3]))|
IlO01I1lO0OIl01[3];assign IlO01OOIl1I01lO[27]
=bar1_setup[33]&~bar1_setup[27]&IlO01l10IOIOIl0[27];assign lO10IOlI01lIO10
=(I1lO0IIO0lIOIl0&OI01lOOl1IIOIl0&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10));dff IlIO10OOl1IIlO01
(OIl01OlI1Ol10IO,OlI01OOl1IOI01l,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[0]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[0])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IOIl0IlI0OO01Il
=LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10);dff IIO01lIO01ll0IO1(OIl01IlI0OO1lIO,OlI01IO0lII1lO0,clk,reset_b,1'b1);BUF IO1lIOIlI0OOIl01
(IlI0Ol10IOlIO10,OlI01IO01lOOl1I);assign IlO01lO10IO1lIO[4:0]=(framein_b)?5'b00001:(5'b10000-{1'b0,lO10Il10IOIOIl0[3:0]});assign I01lOI01lOI01lO
=lIO10OI01lIIO0l[28]^lIO10OI01lIIO0l[29]^lIO10OI01lIIO0l[30]^lIO10OI01lIIO0l[31];BUF IOIl01O1lIOOOl1I
(l10IOOlI1OOIl01,IOIl0OlI1OI01lO);dff Il10IOlO10II01lO(I1lO0O01IlIO0lI,OlI01IO0lIIOIl0,clk,reset_b,1'b1);BUF IlO10Il10IOI1lO0
(OlI01IO0lIOIl01,OIl01IOIl0IO01l);dff IO1lIOOI01lOOIl1(OI01lIIO0lOlI01,O01IlIlI0OI1lO0,clk,reset_b,1'b1);dff IO01IlOlI01OOIl1
(OI01lO01IlOlI1O,O01IllO10IOlI01,clk,reset_b,1'b1);BUF IOOl1IOIl01IIO0l(IOIl0lIO10O1lIO,I1lO0OOl1IIO01l);assign OlI01OlI01IO0lI
=(IlO01IlO01IlO01[7:2]==6'b000011)?1'b1:1'b0;assign lIO10IO01lOOIl1
=~OI01ll0IO1O01Il[3]&~OI01ll0IO1O01Il[2]&~OI01ll0IO1O01Il[1];assign IO0lIOlI01OIl01
=~OI01lIO0lIl0IO1&(O1lIOIOIl0OOIl1|(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O))&
~(((lIO10lO10IIO01l|(IlI0OIIO0lI01lO&IOIl0OlI1OIlI0O))&~h_abort_b&~I01lOIO0lIlIO10)|
((OIl01O01IlOIl01|(IIO0lO1lIOO01Il&IOIl0OlI1OIlI0O))&IlI0OOIl01l10IO));assign IOIl0I01lOOOIl1
=LCELL(IO01llO10IIOIl0^I1lO0OlI01IlO01^l0IO1IlI0OlO10I^lO10IIIO0lIIO0l);assign OlI01lIO10I01lO
=I01lOOOl1IIIO0l&((~OOl1IIIO0lIlI0O&~IO01lO1lIOOOl1I)|l0IO1I01lOIO01l);dffe II1lO0OIl01l0IO1
(IO01lI01lOOlI01,OOl1IIlO01I1lO0,clk,reset_b,1'b1,lO10Il10IOOIl01);dff IOlI01OlI01IlO01
(O1lIOIOIl0IOIl0,OlI01lIO10IlI0O,clk,reset_b,1'b1);assign lO10Il10IOIOIl0[3:0]
=(I01lOOlI01OOIl1&l10IOl10IOIIO0l)?I01lOOOl1IOOl1I[3:0]:IlO01OlI1OIlI0O[3:0];dff IIIO0lOOl1II01lO
(I1lO0OlI01OlI01,l10IOl10IOIIO0l,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[3]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[3])|
(O1lIOOOIl1lIO10&h_din[3])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[3]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[3])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[3]);dff IIO01lIO01lIO0lI
(I1lO0l10IOIlI0O,l0IO1lIO10OOl1I,clk,reset_b,1'b1);assign IlI0OIOIl0OlI1O[15:0]=O1lIOO01Ill0IO1;assign O1lIOl10IOIlI0O
=((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&h_retry_b)|(IlI0OIIO0lI01lO&OOIl1lIO10OOl1I);assign OIl01IIO0lIO01l[22]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[22])|
(O1lIOOOIl1lIO10&h_din[22])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[22]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[22])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[22]);dff IOOIl1IlO01OI01l
(frameout_b,OIl01OOIl1O01Il,clk,1'b1,reset_b);assign IIO0llIO10OOIl1[14]=l0IO1IlI0OI01lO;assign l10IOlO10IOlI1O
=(OIl01OlI1OIIO0l&l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10);assign OOl1IO01IlIIO0l[31:2]
=(l10IOI1lO0IIO0l)?IO01lIlI0OIO01l[31:2]:I1lO0IIO0lOIl01[31:2];assign I01lOIO0lIOI01l
=O01IlI01lOIlI0O[1]&O01IlI01lOIlI0O[0]&~I1lO0IlO01O01Il&~OIl01IOIl0O1lIO&~IO01llO10IOOIl1;assign I1lO0l10IOlO10I[23:17]
=7'b0000000;assign h_cache_size[7:0]=OI01lOOIl1IOIl0[7:0];dff IIO01lOlI01O1lIO
(IIO0lIO01ll0IO1,OOIl1l0IO1OOl1I,clk,1'b1,reset_b);assign I01lOl0IO1IO0lI[27]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[27])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign lO10IIOIl0OOl1I
=IlI0OOlI1OOlI01&lIO10IO01lIOIl0&OOIl1OlI01OlI1O[3]&OOIl1OlI01OlI1O[2]&OOIl1OlI01OlI1O[1]&OOIl1OlI01OlI1O[0];assign OOIl1IO0lIIO0lI[15:4]
=12'h000;dff IIOIl0lIO10OI01l(OOIl1l0IO1IIO0l,IlO01OIl01IO01l,clk,reset_b,1'b1);assign O01IlI1lO0lO10I
=I1lO0l0IO1OlI1O[3]&~I1lO0l0IO1OlI1O[2]&I1lO0l0IO1OlI1O[1]&I1lO0l0IO1OlI1O[0]&
lO10IOlI01OI01l&~IlO01IlO01IlO01[0]&~IlO01IlO01IlO01[1];assign I01lOl0IO1IO0lI[8]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[8])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlI0OI1lO0O1lIO
=lIO10OI01lO01Il&I1lO0OOl1IlIO10;assign IlO01OOIl1I01lO[16]=bar1_setup[33]&~bar1_setup[16]&IlO01l10IOIOIl0[16];assign I01lOlIO10IO0lI
=((lIO10OI01lO01Il&I1lO0OOl1IlIO10&(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O))|
((I1lO0IIO0lIOIl0|I1lO0OlI01l0IO1)&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)))&(~O01IlOlI1OlIO10|IO0lIIO01lI01lO);assign OlI01I01lOl10IO
=~lO10IOOl1IOlI1O;assign h_beout_b[3:0]=OlI1OI1lO0O01Il[3:0];assign O1lIOOOIl1lIO10
=LCELL(OIl01IOIl0O1lIO|(IlI0OOOIl1OlI01&(lIO10IO01lIOIl0|OlI01IO01lO01Il))|(lIO10lO10IIO01l));assign I01lOIO0lIO1lIO
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[6]:IlO01IOIl0O01Il;assign OOl1IOlI01l10IO
=OlI1OlO10IOlI1O-16'h0001;assign h_mrd_cmd[1:0]=IO01lOI01llIO10[1:0];dff IIlI0OIlI0OI01lO
(OOl1Il0IO1lIO10,OOIl1lIO10O01Il,clk,reset_b,1'b1);assign IO0lIOOl1IO01Il
=(l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)|lO10IOOl1II01lO|IlI0OI1lO0OI01l;assign IlI0OOOIl1IlO01
=(~(I1lO0l0IO1I01lO&IO0lIOOIl1IIO0l[30]))&(OOl1IIlO01OIl01|(l0IO1IlI0OI01lO));dff16 IO01IllIO10OlI01
(OI01ll0IO1O01Il,O01IlI1lO0I01lO,clk,1'b1,reset_b);assign OlI01lIO10OlI1O
=((LCELL(IlI0OIIO0lI01lO&I1lO0OlI01OlI01&~lO10IOOIl1OlI1O&~O1lIOIlI0OOOIl1)&O1lIOIOIl0OOIl1)|
(LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10)&IIO0lOI01lOI01l&O1lIOIOIl0OOIl1));assign O1lIOl10IOI01lO
=(adin[8]^adin[9]^adin[10]^adin[11]);assign I1lO0OOIl1OI01l
=(lIO10lO10IIO01l&O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O&h_abort_b)|
(OOl1IIO01lI1lO0&lO10IIO01lIlO01)|
(IO01lI1lO0OlI01&lO10IIO01lIlO01)|
((OIl01IOIl0O1lIO|IO01llO10IOOIl1)&OOIl1OlI01OlI1O[0]);dff16 IOOl1II1lO0OI01l
(OOIl1I01lOlIO10[31:16],OOl1IOlI01O01Il[31:16],clk,1'b1,reset_b);assign OOIl1O1lIOIlO01
=((OlI01O1lIOI1lO0|IlI0OOOIl1OlI01)&IO01lO1lIOOOl1I&IO01lIlI0OOI01l&~l10IOOlI1OOOIl1)|
(IO0lIIlO01OlI1O&lO10IIIO0lOOl1I)|
(lIO10OI01lO01Il&I1lO0OOl1IlIO10&~(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O));assign OOIl1IO0lIl0IO1
=(lIO10lO10IIO01l&l0IO1I1lO0lIO10)|(IlI0OIIO0lI01lO&~O01IlIlI0OOOIl1&IIO0lOI01lOI01l);assign OlI1OO1lIOOOIl1
=(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe4 IOlI1OOI01lIlO01
(OlI01IO01ll10IO[35:32],lIO10OI01lIIO0l[35:32],clk,reset_b,1'b1,IO0lIIlO01OlI1O);assign IO01lI01lOIlO01[15:0]
=lIO10OI01lO01Il?16'h0000:
(OlI1OI1lO0l10IO&~O01IlOI01lOIl01)?OOIl1OOl1IIOIl0[15:0]+16'h0001:OOIl1OOl1IIOIl0[15:0];assign IlO01IlO01IlO01[31:0]
=(I01lOOlI01OOIl1&l10IOl10IOIIO0l)?IO0lIOOIl1IIO0l[31:0]:IO0lIl10IOOlI01[31:0];assign OOl1Il0IO1O1lIO
=
(I01lOI01lOlO10I&~O1lIOIOIl0OOIl1)|
(lIO10lO10IIO01l&((l0IO1I1lO0lIO10&~O1lIOIOIl0OOIl1)|(~O01IlIlI0OOOIl1&~O1lIOIOIl0OOIl1)))|
(OIl01O01IlOIl01&~O1lIOIOIl0OOIl1)|
(O1lIOOOIl1O1lIO&~O1lIOIOIl0OOIl1)|
(OlI01OI01lIO0lI&~O1lIOIOIl0OOIl1)|
(lIO10lO10IIO01l&(~h_retry_b|~h_abort_b)&~O1lIOIOIl0OOIl1)|
(IlI0OIIO0lI01lO&~O1lIOIOIl0OOIl1&(~O01IlIlI0OOOIl1|~IOIl0OlI1OIlI0O));assign OIl01IIO0lIO01l[14]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[14])|
(O1lIOOOIl1lIO10&h_din[14])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[14]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[14])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[14]);assign OlI1OIlI0OIlO01
=LCELL(OlI01O1lIOI1lO0|IlI0OOOIl1OlI01);assign O1lIOO01Ill0IO1[6]=O1lIOOIl01IO0lI;BUF IOIl01O1lIOIIO0l
(IlI0OIlI0OOlI1O,OlI01OlI01OlI01);assign OIl01IIO0lIO01l[33]
=(O1lIOOOIl1lIO10&h_bein_b[1])|
(IIO0lIO0lIOOl1I&IlI0OOOIl1IO0lI[1])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[33]);dff3 IOIl01IlI0OlIO10
(O01IlI01lOIlI0O,lO10IIlO01l0IO1,clk,reset_b,1'b1);assign IIO0lO1lIOl10IO[31:16]=16'b0000000000000000;assign OOl1IIIO0lIlI0O
=~stopin_b;assign I1lO0OOIl1O1lIO=(IIO0lOI01lOI01l&IO01lI01lOl0IO1)|(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe8 IlO10II1lO0OOIl1
(l10IOIOIl0IlO01[23:16],adin[23:16],clk,reset_b,1'b1,OOl1IIIO0lI01lO);dff4 IlO10IIOIl0O01Il
(OOIl1OlI01OlI1O,IlO01IOIl0l10IO,clk,reset_b,1'b1);assign OOIl1IO0lIIO0lI[23]
=bar0_setup[33]&~bar0_setup[23]&OOIl1I01lOlIO10[23];dff IO1lIOlO10IIO0lI(OlI01O1lIOI1lO0,O01IlIlI0OIOIl0,clk,reset_b,1'b1);assign IlO01OIl01lIO10
=(IO01llIO10IOIl0&OlI1OIO01lOOl1I)|OOl1Il10IOlIO10;assign I01lOl0IO1IO0lI[16]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[16])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlO01I1lO0OIl01[1]
=CASCADE(~((IlI0OOOIl1OlI01&IO01lO1lIOOOl1I)|OOIl1IO01lIO01l)&
~(lIO10OI01lO01Il))&
~(OlI1OI1lO0l10IO)&
LCELL(~((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0]))&
IOIl0I01lOIOIl0[1];assign IlO01OOIl1I01lO[24]
=bar1_setup[33]&~bar1_setup[24]&IlO01l10IOIOIl0[24];assign O1lIOIOIl0I1lO0=LCELL(OlI01O1lIOI1lO0&~l10IOOlI1OOOIl1);dff2 IIOIl0lIO10IO01l
(IO01lOI01llIO10[1:0],I1lO0IOIl0IOIl0[1:0],clk,reset_b,1'b1);assign h_dout=l0IO1O1lIOIO0lI;assign OOl1IOOl1IOlI01
=LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10);dff IlO10IOIl01lIO10(O1lIOOIl01IO0lI,OOIl1OI01lI01lO,clk,reset_b,1'b1);assign OI01ll10IOIIO0l
=((~(O01IlO1lIOOI01l&((I1lO0OOl1IlIO10&lIO10OI01lO01Il)|I1lO0IIO0lIOIl0|OIl01IOIl0O1lIO)))&
~(IO01llO10II1lO0&(I1lO0IIO0lIOIl0|OIl01IOIl0O1lIO))&
(~(~IO01llO10II1lO0&I01lOOlI01OIl01))&
((~IO01llO10II1lO0&~I01lOOlI01OIl01)|IOIl0I1lO0I1lO0))?1'b1:1'b0;assign IIO0lIlO01IO0lI
=IlI0OIIO0lI01lO&~IOIl0OlI1OIlI0O;assign OIl01O01IlI1lO0
=LCELL(IO0lIIO0lIIO01l^OlI1OOlI1OOIl01^OOl1IOOl1IIO0lI^I01lOI01lOI01lO);assign lO10IOOl1II01lO
=LCELL(I01lOI01lOlO10I&(~IO0lIIO01lI01lO|(~OIl01OlI1OIIO0l&l0IO1I1lO0lIO10&~I01lOIO0lIlIO10))&~OlI01O1lIOI1lO0);assign lO10IO01IlO1lIO
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign lO10IIlO01IO0lI
=~IIO0llIO10IOIl0|~O1lIOO01IlIlO01|~OOIl1OI01llO10I|OlI1OlO10IOlI1O[3]|
OlI1OlO10IOlI1O[2]|OlI1OlO10IOlI1O[1];BUF II01lOOOIl1OOl1I
(IlI0OI1lO0lIO10,OlI1OIlI0Ol0IO1);dff IIO0lIOlI1OOOl1I(OOl1IOOl1Il0IO1,OlI1OO1lIOOOIl1,clk,reset_b,1'b1);BUF Il0IO1IO0lIIO0lI
(OOl1IIOIl0OlI1O,OlI01lIO10I01lO);assign OlI1OO1lIOI1lO0=OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IO0lIIOIl0O1lIO&~l0IO1OIl01l10IO[3];dff IIO0lIIOIl0OI01l
(IIO0lOI01lIO01l,OlI01lIO10lO10I,clk,reset_b,1'b1);dff IO01IllIO10IlO01(devselout_b,OlI1OOIl01I01lO,clk,1'b1,reset_b);assign lO10Il0IO1I1lO0
=O1lIOOIl01IO0lI&((OlI01O1lIOI1lO0&IO01lO1lIOOOl1I)|
LCELL(((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&h_retry_b)|
(IlI0OIIO0lI01lO&IIO0lOI01lOI01l)|
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I)|
(IO01lI1lO0OlI01&O01IlI1lO0lO10I)|
(IO01lO1lIOIIO0l)));dffe8 IIlO01IlI0Ol10IO
(lIO10OI01lIIO0l[7:0],OIl01IIO0lIO01l[7:0],clk,reset_b,1'b1,I01lOIO01lOlI1O);assign lIO10IO0lII01lO
=(~(IlO01IlO01IlO01[31]^OOIl1I01lOlIO10[31])|bar0_setup[31])&
(~(IlO01IlO01IlO01[30]^OOIl1I01lOlIO10[30])|bar0_setup[30])&
(~(IlO01IlO01IlO01[29]^OOIl1I01lOlIO10[29])|bar0_setup[29])&
(~(IlO01IlO01IlO01[28]^OOIl1I01lOlIO10[28])|bar0_setup[28])&
(~(IlO01IlO01IlO01[27]^OOIl1I01lOlIO10[27])|bar0_setup[27])&
(~(IlO01IlO01IlO01[26]^OOIl1I01lOlIO10[26])|bar0_setup[26])&
(~(IlO01IlO01IlO01[25]^OOIl1I01lOlIO10[25])|bar0_setup[25])&
(~(IlO01IlO01IlO01[24]^OOIl1I01lOlIO10[24])|bar0_setup[24])&
(~(IlO01IlO01IlO01[23]^OOIl1I01lOlIO10[23])|bar0_setup[23])&
(~(IlO01IlO01IlO01[22]^OOIl1I01lOlIO10[22])|bar0_setup[22])&
(~(IlO01IlO01IlO01[21]^OOIl1I01lOlIO10[21])|bar0_setup[21])&
(~(IlO01IlO01IlO01[20]^OOIl1I01lOlIO10[20])|bar0_setup[20])&
(~(IlO01IlO01IlO01[19]^OOIl1I01lOlIO10[19])|bar0_setup[19])&
(~(IlO01IlO01IlO01[18]^OOIl1I01lOlIO10[18])|bar0_setup[18])&
(~(IlO01IlO01IlO01[17]^OOIl1I01lOlIO10[17])|bar0_setup[17])&
(~(IlO01IlO01IlO01[16]^OOIl1I01lOlIO10[16])|bar0_setup[16]);assign OIl01l10IOl0IO1
=OIl01IOIl0O1lIO&IOIl0lO10IIO01l&IOIl0I1lO0I1lO0&~O01IlO1lIOOI01l&~IO01llO10II1lO0;assign OOIl1OlI01IlI0O[31:2]
=
(O1lIOI1lO0IlI0O&l0IO1I1lO0lIO10&~I01lOIO0lIlIO10)?(IlO01IlI0OOOl1I[31:2]+30'h00000001):IlO01IlI0OOOl1I[31:2];dff IIO01llIO10I1lO0
(OlI01OI01lIO0lI,IIO0lI01lOl0IO1,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[6]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[6])|
(O1lIOOOIl1lIO10&h_din[6])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[6]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[6])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[6]);dff II1lO0l10IOI01lO
(OI01lIlO01O1lIO,OIl01OOIl1O01Il,clk,1'b1,reset_b);assign I1lO0l0IO1IlI0O[31:16]=subsystem_id;assign I01lOOI01lIOIl0
=(IIO0lO1lIOO01Il&IIO0lOI01lOI01l)|(O1lIOOOIl1O1lIO&O1lIOIOIl0OOIl1)|l10IOIIO0lIlO01;assign OIl01IIO0lIO01l[25]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[25])|
(O1lIOOOIl1lIO10&h_din[25])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[25]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[25])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[25]);assign IlO01O01IlIO01l
=
CASCADE(~((lIO10OI01lO01Il&~I1lO0OOl1IlIO10)|
(OlI1OIlI0OIlO01&l10IOOlI1OOOIl1)|
(OIl01IOIl0O1lIO&(~IOIl0I1lO0I1lO0|O01IlO1lIOOI01l|IO01llO10II1lO0))|
(I1lO0OlI01l0IO1&IO0lIIO01lI01lO)|
((I1lO0IIO0lIOIl0|I1lO0OlI01l0IO1)&O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)|
(OOl1Il0IO1OI01l&IO0lIIO01lI01lO)|
(IO01llO10IOOIl1&IO01lIlI0OOI01l)))&
~(OlI1OIlI0OIlO01&OOl1IIIO0lIlI0O)&
~(OlI1OIlI0OIlO01&IO01lO1lIOOOl1I&LCELL(OIl01OlI1OOOl1I|O01IlOI01lOOIl1|
((~IOIl0lO10IIO01l|OI01lOOIl1OOIl1)&O01IlO1lIOOI01l&~IO01llO10II1lO0)));assign IIO0llIO10OOIl1[11]
=IIO0lIO01lOlI01;assign lIO10l0IO1O1lIO
=((IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
~O01IlIlI0OOOIl1&lIO10IO0lIlO10I&~(l0IO1I1lO0lIO10&~I01lOIO0lIlIO10&O1lIOI1lO0IlI0O));assign OOl1IO01IlIIO0l[0]
=(lIO10OI01lO01Il&I1lO0OOl1IlIO10)?(h_ain[0]&~h_mio):
(OOl1Il0IO1OI01l)?OI01ll10IOO01Il[0]:OlI1OlO10IlO10I[0];assign lIO10IO0lIIlI0O
=(OI01lIlO01O1lIO)?OI01ll0IO1l10IO:
(~OI01lIlO01O1lIO&~lO10IO01IlOI01l)?l10IOIOIl0l0IO1-8'b00000001:8'b00000000;assign OOIl1IO0lIIO0lI[31]
=bar0_setup[33]&~bar0_setup[31]&OOIl1I01lOlIO10[31];assign status13=IIO0llIO10OOIl1[13];BUF IlO10IOlI1OOlI1O
(IIO0lOOl1IIlI0O,IO0lIOOIl1O01Il);assign I01lOl0IO1IO0lI[24]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[24])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign OOl1Il10IOOI01l
=~lIO10OI01lO01Il&(IO01llIO10OOIl1|OlI1OI01lOl10IO);assign OOIl1IO0lIIO0lI[0]=bar0_setup[33]&~bar0_setup[32];dff IOOl1IIOIl0IlI0O
(OlI01IO01lO01Il,OIl01IOIl0O1lIO,clk,reset_b,1'b1);assign I1lO0IlO01OOl1I
=((I1lO0l0IO1OlI1O==4'b0010)|(I1lO0l0IO1OlI1O==4'b0011))?1'b1:1'b0;assign I01lOl0IO1IO0lI[5]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[5])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign lIO10lIO10IO01l
=(OIl01IOIl0O1lIO&IOIl0lO10IIO01l)|(OOl1IIO01lI1lO0&lO10IIO01lIlO01)|IO01llO10IOOIl1|lO10IOOl1IlO10I|I1lO0IIO0lIOIl0;assign IlO01OOIl1I01lO[2:1]
=2'b00;dffe IlIO10IlO01IOIl0(l0IO1OI01lOlI1O,lO10IIIO0ll10IO,clk,reset_b,1'b1,lIO10OI01lO01Il);assign h_wrout
=IO0lIIO01lI01lO|(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0);assign OI01lOlI01lO10I
=lIO10OI01lIIO0l[8]^lIO10OI01lIIO0l[9]^lIO10OI01lIIO0l[10]^lIO10OI01lIIO0l[11];BUF IOOIl1l0IO1l10IO
(IIO0ll0IO1IOIl0,I1lO0l0IO1lO10I);dff IIOIl0IO0lIlO10I(OI01lOOl1II1lO0,IO01llO10IOIl01,clk,reset_b,1'b1);assign I1lO0IIO0lOOIl1
=(~(IO01lO1lIOOOl1I&OlI1OIlI0OIlO01)&IO0lIIlO01I01lO)|
(lO10IOOl1IIlI0O&IO01lO1lIOOOl1I&OlI1OIlI0OIlO01)|IlI0Ol10IOlIO10;dff IlIO10IlO01I1lO0
(O01IlIlI0OOOIl1,IO0lIl0IO1IO0lI,clk,1'b1,reset_b);dff IOOIl1OOl1II1lO0(l0IO1IlI0OlO10I,l10IOIOIl0OlI01,clk,reset_b,1'b1);assign I01lOlIO10OlI01
=(IO01lO1lIOOOl1I&OlI01O1lIOI1lO0)|O1lIOOIl01IlO01|l10IOOlI1OOIl01;dff8 IOIl01OI01lO1lIO
(OI01ll0IO1l10IO,O01IlI01lOOlI1O,clk,reset_b,1'b1);assign IOIl0lO10IO1lIO=OI01ll0IO1O01Il-16'h0001;assign IO0lIl0IO1IO0lI
=~lIO10I01lOI1lO0;assign I01lOOI01lI1lO0=(adin[20]^adin[21]^adin[22]^adin[23]);assign lIO10IO01lOIl01
=O1lIOIOIl0OOIl1&OOIl1IO0lIIlO01;assign O1lIOOlI1OO1lIO=(IlO01IlO01IlO01[7:2]==6'b000101)?1'b1:1'b0;assign IlO01OOIl1lO10I
=(IO0lIIlO01OlI1O&lO10IIIO0lOOl1I&~(O1lIOIOIl0OIl01&IO0lIOOIl1OOl1I))|
(lIO10OI01lO01Il&I1lO0OOl1IlIO10&~(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O))|
(l10IOl10IOIIO0l&h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10)|
(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0)|
(lIO10lO10IIO01l)|
(OIl01O01IlOIl01)|
(OlI01OI01lIO0lI)|
(IO0lIIO01lI01lO);assign OlI1OO1lIOOIl01
=(OI01lOOIl1IOIl0[7:0]==8'h10)?1'b1:1'b0;assign IO01lI01lOIO0lI
=CASCADE(l10IOOOIl1I1lO0&O1lIOOIl01IO0lI&IlO01OIl01OI01l)&((OlI01IO0lIOOIl1&~parin)|(~OlI01IO0lIOOIl1&parin));dffe8 II1lO0OOIl1IO01l
(adout[23:16],OIl01IIO0lIO01l[23:16],clk,1'b1,reset_b,lIO10lIO10OI01l);dff IOOIl1OOl1IOIl01
(IO01lIlI0OlIO10,IO0lIl0IO1l0IO1,clk,reset_b,1'b1);assign lO10IOOIl1OlI1O=OlI01OOl1IO1lIO[0]&OlI1OlIO10OlI1O;assign O01IlOlI1OOI01l
=
(~O1lIOIOIl0OOIl1&(~l0IO1I1lO0lIO10&O01IlIlI0OOOIl1)&(lIO10lO10IIO01l&h_abort_b&h_retry_b));assign OIl01IIO0lIO01l[17]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[17])|
(O1lIOOOIl1lIO10&h_din[17])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[17]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[17])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[17]);assign OOl1IOOl1IIlO01
=(OlI1OIlI0OIlO01&O01IlO1lIOOI01l&~IO01llO10II1lO0&(~IOIl0lO10IIO01l|OI01lOOIl1OOIl1))|
(OlI1OIlI0OIlO01&(OIl01OlI1OOOl1I|O01IlOI01lOOIl1));assign O1lIOO01Ill0IO1[3]
=1'b0;BUF IIO0lII1lO0IO0lI(I1lO0O01IlIlO01,I01lOl0IO1OlI01);dff32 IOIl01I01lOIO0lI
(OlI1OlO10IlO10I[31:0],OOl1IO01IlIIO0l[31:0],clk,reset_b,1'b1);assign IO0lIO01IlIOIl0
=(~OIl01IOIl0O1lIO&~IO01llO10IOOIl1&O01IlI01lOIlI0O[2]);assign O1lIOOOIl1OI01l[31:16]=16'b0000000000000000;assign OI01lOOIl1OOIl1
=~OI01lIIO0ll0IO1;assign OOl1IO01IlO01Il
=((l0IO1I1lO0lIO10|~h_abort_b)&~I01lOIO0lIlIO10)|(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l);dffe6 IIOIl0OlI01OOl1I
(h_aout[7:2],IlO01IlI0OOOl1I[7:2],clk,reset_b,1'b1,OlI01I01lOl10IO);assign lIO10OlI01O01Il[0]=h_cmd[0];assign OOIl1IO0lIIO0lI[20]
=bar0_setup[33]&~bar0_setup[20]&OOIl1I01lOlIO10[20];dff II01lOIIO0lO1lIO(OlI1OI1lO0l10IO,IO0lIOOl1IIIO0l,clk,reset_b,1'b1);assign OI01lIO01lIO01l
=(I01lOI01lOlO10I)?cbein_b:I1lO0l0IO1OlI1O;assign I01lOl0IO1IO0lI[13]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[13])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IO0lIl0IO1IlO01[0]
=
(IO01lO1lIOOOl1I&LCELL(IlI0OOOIl1OlI01&OIl01IIO0lIO01l[32]))|
LCELL((OOIl1IO01lIO01l&OIl01IIO0lIO01l[32])|
((lIO10OI01lO01Il)&IIO0ll0IO1OOIl1[0])|
((OlI1OI1lO0l10IO)&O01IlO1lIOlIO10[0])|
(((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0])&O1lIOOIl01OlI01[0]))|
IlO01I1lO0OIl01[0];assign IlO01OOIl1I01lO[21]
=bar1_setup[33]&~bar1_setup[21]&IlO01l10IOIOIl0[21];assign IOIl0OlI1OlO10I
=OlI1OIlI0OIlO01&
((~IO01lO1lIOOOl1I&OOl1IIIO0lIlI0O)|
(l10IOOlI1OOOIl1)|
(IO01lO1lIOOOl1I&~OOl1IIIO0lIlI0O&~IO01lIlI0OOI01l&OI01lIlO01O1lIO)|
(IO01lO1lIOOOl1I&OOl1IIIO0lIlI0O&~IO01lIlI0OOI01l));BUF IOOl1IIOIl0I01lO
(OI01lOOIl1OIl01,OlI01IIO0lOOIl1);dffe4 IOlI1OIO0lIIOIl0(OlI1OI1lO0O01Il,IlI0Ol10IOOI01l,clk,reset_b,1'b1,l10IOOlI1OIOIl0);assign lIO10lIO10OI01l
=CASCADE(IlI0OOOIl1OlI01|
(IIO0lOI01lOI01l&OlI1OOlI1OI1lO0)|
O01IllO10IIO0lI)&
(IO01lO1lIOOOl1I|(IIO0lOI01lOI01l&OlI1OOlI1OI1lO0)|O01IllO10IIO0lI);assign OIl01OIl01OIl01
=(IlO01IlO01IlO01[7:2]==6'b000001)?1'b1:1'b0;assign O1lIOO01IlIlO01
=~OlI1OlO10IOlI1O[11]&~OlI1OlO10IOlI1O[10]&~OlI1OlO10IOlI1O[9]&~OlI1OlO10IOlI1O[8];assign h_discard=OIl01OlI1Ol10IO;dff II01lOIlO01lO10I
(oe_perr,l10IOI1lO0OOl1I,clk,reset_b,1'b1);assign l0IO1lO10IIIO0l=(IlI0OIIO0lI01lO|IIO0lO1lIOO01Il)&~lIO10IO0lIlO10I;assign O1lIOOOIl1IO01l
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign IlI0OOlI1OIO0lI
=l10IOOOIl1OIl01&O01IlO1lIOOI01l&~IO01llO10II1lO0;assign OlI1OIlI0OIO0lI
=(O1lIOIOIl0OOIl1&OOl1IIO0lII01lO)|
(I1lO0OOl1IO1lIO)|
((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&~h_retry_b)|
(lIO10lO10IIO01l&(~h_retry_b|~h_abort_b)&IIO0lOI01lOI01l&(O1lIOIOIl0OOIl1|(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)))|
(IlI0OIIO0lI01lO&~h_retry_b&(IIO0lOI01lOI01l|O01IlIlI0OOOIl1)&(O1lIOIOIl0OOIl1|(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)))|
(IlI0OIIO0lI01lO&~h_abort_b&~I01lOIO0lIlIO10&IIO0lOI01lOI01l&(O1lIOIOIl0OOIl1|(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)))|
LCELL((IIO0lOI01lOI01l&LCELL((IlI0OIIO0lI01lO&~h_bii_b&l0IO1I1lO0lIO10&IOIl0OlI1OIlI0O)|
(OIl01O01IlOIl01&IlI0OOIl01l10IO&O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)|
(IIO0lO1lIOO01Il&(O1lIOIOIl0OOIl1|(O01IlIlI0OOOIl1&IOIl0OlI1OIlI0O)))))|
(lIO10lO10IIO01l&O01IlIlI0OOOIl1&~IIO0lOI01lOI01l));dff II01lOl0IO1IlO01
(l10IOOIl01IlI0O,lIO10OlI01OOl1I,clk,reset_b,1'b1);BUF IIlI0OI01lOO1lIO(OOIl1IO0lIIlO01,lIO10IlO01OOIl1);assign IOIl0lO10IOI01l
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IlI0OIOIl0I01lO&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[7:0]:IO0lIO01IlOOIl1;assign OlI01lIO10lO10I
=~IO01lO1lIOOOl1I&OOl1IIIO0lIlI0O&~I1lO0IlO01O01Il;dff4 IOI01lOIl01lO10I
(IlO01OlI1OIlI0O[3:0],l0IO1I01lOlIO10[3:0],clk,reset_b,1'b1);assign l10IOI1lO0OOl1I
=(lO10Il0IO1I1lO0|O01IllO10IOlI01|OI01lO01IlOlI1O);dffe8 IlIO10OOl1Il0IO1
(lIO10OI01lIIO0l[31:24],OIl01IIO0lIO01l[31:24],clk,reset_b,1'b1,OIl01OIl01OOIl1);assign I1lO0l10IOOlI1O
=bar1_setup[33]&OIl01OlI1OO01Il&
((bar1_setup[32]&I01lOlO10IIlO01&IlO01OOIl1IlI0O)|(~bar1_setup[32]&l10IOO01IllO10I&I1lO0IlO01OOl1I));assign h_rdym_b
=OI01lIIO0ll0IO1;dff32 II01lOIlO01I01lO(IO0lIOOIl1IIO0l[31:0],adin[31:0],clk,reset_b,1'b1);dff IlO10IIOIl0l10IO
(O1lIOOOIl1O1lIO,I01lOOI01lIOIl0,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[9]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[9])|
(O1lIOOOIl1lIO10&h_din[9])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[9]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[9])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[9]);BUF IO01IlOI01lI1lO0
(IlO01OlI1OOlI1O,OOIl1IO0lIOlI01);assign O1lIOO01Ill0IO1[15:11]=5'b00000;dff IOOIl1l10IOOOl1I
(IlI0OOIl01l10IO,IIO0lOlI01OI01l,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[28]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[28])|
(O1lIOOOIl1lIO10&h_din[28])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[28]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[28])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[28]);dff II01lOl0IO1l0IO1
(reqout_b,l10IOIOIl0IO0lI,clk,1'b1,reset_b);assign IIO0llIO10OOIl1[7:6]=2'b10;assign OOIl1OOl1IOOIl1
=((IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
~O01IlIlI0OOOIl1&lIO10IO0lIlO10I&~(l0IO1I1lO0lIO10&~I01lOIO0lIlIO10&O1lIOI1lO0IlI0O));dffe8 IO1lIOIlI0OI1lO0
(l0IO1O1lIOIO0lI[15:8],I01lOOlI01IOIl0[15:8],clk,reset_b,1'b1,I01lOlIO10OlI01);dff4 IOlI1OIO01lIIO0l
(IOIl0I01lOIOIl0,IO0lIl0IO1IlO01,clk,reset_b,1'b1);assign OOIl1IO0lIIO0lI[28]
=bar0_setup[33]&~bar0_setup[28]&OOIl1I01lOlIO10[28];assign status8=IIO0llIO10OOIl1[8];assign IOIl0O1lIOI01lO
=(IIO0lIO01ll0IO1|(O1lIOI1lO0IlI0O&l0IO1I1lO0lIO10&~I01lOIO0lIlIO10));assign I01lOl0IO1IO0lI[21]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[21])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign OOIl1IO01lIO01l
=LCELL((OIl01IOIl0O1lIO|IO01llO10IOOIl1)&OOIl1OlI01OlI1O[0]);assign IlO01OOIl1I01lO[29]
=bar1_setup[33]&~bar1_setup[29]&IlO01l10IOIOIl0[29];assign l0IO1lO10IOOl1I
=CASCADE((lIO10OI01lO01Il&~I1lO0OOl1IlIO10)|
((I1lO0IIO0lIOIl0|I1lO0OlI01l0IO1)&O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)|
(IO0lIIlO01OlI1O&lO10IIIO0lOOl1I&~(O1lIOIOIl0OIl01&IO0lIOOIl1OOl1I)))|
((OlI01O1lIOI1lO0|IlI0OOOIl1OlI01)&~l10IOOlI1OOOIl1&IO01lO1lIOOOl1I&IO01lIlI0OOI01l)|
(OOIl1l0IO1IIO0l)|
(l0IO1IlI0OIlI0O&OlI1OIlI0OOlI01);dff II01lOIIO0llIO10
(O1lIOI1lO0I01lO,IIO0lIlO01IO0lI,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[2]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[2])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign O01IllO10IIO0lI
=LCELL(lIO10lIO10IO01l|(OlI1OOlI1OI1lO0&O01IlIlI0OOOIl1));dff IO1lIOO1lIOOI01l
(I01lOlO10IIlO01,I1lO0IO0lII1lO0,clk,reset_b,1'b1);dffe16 IIlI0OlO10IIIO0l
(OlI1OlO10IOlI1O[15:0],IO0lIl0IO1OlI01[15:0],clk,1'b1,reset_b,I1lO0IIO0lOOIl1);assign h_cs_b[0]
=I01lOIO0lIlIO10|~IO01lI01lOOlI01;assign OlI1OOlI1OOIl01
=lIO10OI01lIIO0l[20]^lIO10OI01lIIO0l[21]^lIO10OI01lIIO0l[22]^lIO10OI01lIIO0l[23];BUF Il10IOIlI0Ol0IO1
(IlO01IlI0OIIO0l,O01IlIlI0OOIl01);dff IIlO01I01lOOIl01(O01IlO1lIOO1lIO,OlI1OI01lOIIO0l,clk,reset_b,1'b1);BUF II01lOOOl1IO01Il
(IO0lIIlO01I01lO,IlI0OOlI1OIO0lI);dff IIlI0OlO10Il10IO(oe_devsel,IO01lOI01lOI01l,clk,reset_b,1'b1);dff Il0IO1lIO10l10IO
(IO01lO1lIOIIO0l,OOl1IIIO0llO10I,clk,reset_b,1'b1);dff IIO0lIl10IOIlO01(OI01lIIO0lIlO01,OIl01IOIl0OI01l,clk,reset_b,1'b1);dff IIIO0lOOIl1OlI1O
(lIO10l0IO1OI01l,OIl01lO10IOOIl1,clk,reset_b,1'b1);assign IO01lOlI1Ol10IO
=~OI01ll0IO1O01Il[11]&~OI01ll0IO1O01Il[10]&~OI01ll0IO1O01Il[9]&~OI01ll0IO1O01Il[8];assign OlI1OIlI0Ol0IO1
=(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1);assign OIl01OOIl1l10IO=(cbein_b[0]^cbein_b[1]^cbein_b[2]^cbein_b[3]);assign OlI01l0IO1IlI0O
=IlI0OOOIl1OlI01&~l10IOOlI1OOOIl1;assign IO01lIlI0OO1lIO[31:24]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&O1lIOOlI1OO1lIO&~l0IO1OIl01l10IO[3])?IO0lIOOIl1IIO0l[31:24]:IlO01l10IOIOIl0[31:24];dff IlIO10l0IO1lIO10
(OlI01l0IO1OlI1O,OIl01I1lO0OlI01,clk,reset_b,1'b1);assign lIO10IIO0lOlI1O=(prefetch_limit==2'b10)?1'b1:1'b0;dff IOlI01IIO0lOIl01
(I01lOI01lOlO10I,OOl1Il0IO1O1lIO,clk,1'b1,reset_b);assign OIl01IIO0lIO01l[1]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[1])|
(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[1])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[1]))|
((IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[1])|
(O1lIOOOIl1lIO10&h_din[1]));assign IO0lIl0IO1l0IO1
=OlI1OlO10IIlI0O|OOl1IO01IlOOl1I;assign OOl1IIlO01OOIl1[15:0]=vendor_id;assign IIO0lI01lOl0IO1
=
(lIO10lO10IIO01l&O1lIOIOIl0OOIl1&IIO0lOI01lOI01l&(lO10IOOIl1OlI1O|~h_bii_b)&l0IO1I1lO0lIO10)|
(lIO10lO10IIO01l&O1lIOIOIl0OOIl1&IIO0lOI01lOI01l&(~h_retry_b|~h_abort_b))|
(lIO10lO10IIO01l&O1lIOIOIl0OOIl1&IIO0lOI01lOI01l&O1lIOIlI0OOOIl1&l0IO1I1lO0lIO10)|
(lIO10lO10IIO01l&~IIO0lOI01lOI01l&O01IlIlI0OOOIl1)|
(OIl01O01IlOIl01&IIO0lOI01lOI01l&O1lIOIOIl0OOIl1)|
(OlI01OI01lIO0lI&O1lIOIOIl0OOIl1);assign OIl01IIO0lIO01l[20]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[20])|
(O1lIOOOIl1lIO10&h_din[20])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[20]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[20])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[20]);assign OI01lO01IlIlI0O
=(~framein_b|gnt_b|LCELL(~((I1lO0IIO0lIOIl0&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10))|lO10IOOl1IlO10I)))&OI01lIlO01O1lIO;assign O1lIOO01Ill0IO1[0]
=l10IOO01IllO10I;assign IIO0lOlI01OI01l=~IIO0lOI01lOI01l&((~h_abort_b&~I01lOIO0lIlIO10)|IlI0OOIl01l10IO);assign l10IOI1lO0IIO0l
=LCELL(OlI1OIlI0OIlO01&IO01lO1lIOOOl1I);assign lO10IIlO01l0IO1[2]
=~OIl01IOIl0O1lIO&~IO01llO10IOOIl1&
(I1lO0IlO01O01Il|(~O01IlI01lOIlI0O[2]&OI01ll10IOOOl1I[2])|O01IlI01lOIlI0O[2]);assign I1lO0l10IOlO10I[31:25]
=7'b0000000;assign O1lIOIOIl0OOIl1=~framein_b;assign OI01lIlO01IO01l=IO0lIl10IOIO0lI|(~OOl1IO01IlO01Il&lIO10IO0lIlO10I);assign I01lOl0IO1IO0lI[29]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[29])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IIO0ll0IO1OOIl1[1]=~lIO10OlI01O01Il[0];assign OOIl1IO0lIIO0lI[17]
=bar0_setup[33]&~bar0_setup[17]&OOIl1I01lOlIO10[17];dff IO01IlIO01lOlI1O(IO01llO10IOOIl1,IlO01l10IOOIl01,clk,reset_b,1'b1);assign l10IOOOIl1IOIl0
=((I1lO0l0IO1OlI1O==4'b0111)|
(I1lO0l0IO1OlI1O==4'b1111)|
(I1lO0l0IO1OlI1O==4'b0011))?1'b1:1'b0;assign I01lOl0IO1IO0lI[10]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[10])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));dff IOI01lOOIl1I1lO0
(IIO0llIO10I1lO0,IlI0OI1lO0O1lIO,clk,reset_b,1'b1);assign IlO01OOIl1I01lO[18]
=bar1_setup[33]&~bar1_setup[18]&IlO01l10IOIOIl0[18];assign OlI01IO01lIIO0l
=OOl1Il0IO1OI01l&~IO0lIIO01lI01lO&(framein_b&~gnt_b&irdyin_b);assign OlI01IIO0lOOIl1
=~((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&h_retry_b)&
~(O1lIOI1lO0IlI0O&I01lOIO0lIlIO10&h_retry_b);assign l10IOOlI1OIOIl0
=(IO01lO1lIOOOl1I&OlI01O1lIOI1lO0)|lO10IIlO01IlO01|O01IlI01lOlO10I;assign IlI0OIOIl0IlI0O=OOl1IIO01lI1lO0;assign IIO0llIO10OIl01
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[2]:IlI0Ol10IOIO01l;assign I01lOO1lIOIO01l
=~OlI1OlO10IOlI1O[3]&~OlI1OlO10IOlI1O[2]&OlI1OlO10IOlI1O[1]&~OlI1OlO10IOlI1O[0];assign h_par=OlI1OlIO10IlI0O;dff IOIl01lO10IOIl01
(IO0lIIlO01IlI0O,IIO0lIO01lIO0lI,clk,reset_b,1'b1);assign OI01lIIO0lIO0lI
=(l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)|lO10IOOl1II01lO|IlI0OI1lO0OI01l;assign IO0lIIlO01lO10I
=~(lO10IO01IlO1lIO&IO0lIOOIl1IIO0l[28])&(l0IO1lO10IO01Il|lO10IIIO0lO01Il);assign OIl01IOIl0IO01l
=lO10IIlO01IO0lI&(~IOIl0lO10IIO01l|OI01lOOIl1OOIl1)&~IO01llO10II1lO0&O01IlO1lIOOI01l;assign I1lO0IOIl0OOIl1
=(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1)|
(OlI01IlO01OOl1I)|
(~OI01lIO0lIl0IO1|~IOIl0OlI1OIlI0O);assign OI01lOOl1IOIl01
=(adin[0]^adin[1]^adin[2]^adin[3]);BUF IOOIl1O01IlOlI1O(l0IO1I01lOIO01l,IlI0OlO10IOOl1I);assign OIl01lO10IOOIl1
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IO0lIIOIl0O1lIO&~l0IO1OIl01l10IO[2])?IO0lIOOIl1IIO0l[16]:lIO10l0IO1OI01l;assign IO0lIOOl1Il10IO
=IO0lIIlO01OlI1O&O1lIOIOIl0OIl01;dff IOlI1OIO0lIOIl01(IO0lIIIO0lIO01l,IOIl0OI01lIIO0l,clk,reset_b,1'b1);assign OOIl1lIO10l10IO
=~O1lIOI1lO0OlI1O;dffe4 IIOIl0lIO10lIO10(IlI0OOOIl1IO0lI,h_bein_b,clk,reset_b,1'b1,OlI01OI01ll0IO1);dff IO1lIOOlI1OIO01l
(O01IlOI01lOIl01,OI01lIOIl0IO0lI,clk,reset_b,1'b1);dff4 IOIl01lO10II1lO0(l0IO1OIl01l10IO,cbein_b,clk,reset_b,1'b1);dff IIIO0lIlO01l0IO1
(I01lOOlI01OOIl1,I01lOI01lOlO10I,clk,1'b1,reset_b);assign OIl01IIO0lIO01l[12]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[12])|
(O1lIOOOIl1lIO10&h_din[12])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[12]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[12])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[12]);BUF IIO0lIOOIl1l10IO
(IOIl0OI01lOOl1I,OI01lO01IlIlI0O);assign O1lIOO01Ill0IO1[8]=l10IOOOIl1I1lO0;BUF Il10IOIlI0OIlO01
(l10IOI1lO0O01Il,I01lOIO01lI01lO);assign OIl01IIO0lIO01l[31]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[31])|
(O1lIOOOIl1lIO10&h_din[31])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[31]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[31])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[31]);assign IIO0lI01lOIlO01
=CASCADE(~(OIl01IOIl0O1lIO)&
~(IO01llO10IOOIl1)&
~(OlI1OIlI0OIlO01&~OI01lIlO01O1lIO&~IO01lO1lIOOOl1I)&
~(OlI1OIlI0OIlO01&~OI01lIlO01O1lIO&IO01lO1lIOOOl1I))&
~(OlI1OIlI0OIlO01&~l10IOOlI1OOOIl1&~IO01lO1lIOOOl1I&~OOl1IIIO0lIlI0O);assign IIO0llIO10OOIl1[3]
=sel_23&~h_inta_b;assign I1lO0IlO01O01Il=~devselin_b;assign OOl1IIIO0lI01lO
=(IIO0lOI01lOI01l&IlI0OIlI0OOlI1O)|(OlI01O1lIOI1lO0&IO01lO1lIOOOl1I);dffe8 II01lOOOl1Il10IO
(l10IOIOIl0IlO01[7:0],adin[7:0],clk,reset_b,1'b1,IO0lIO01IlOIl01);dff II1lO0OIl01IO0lI
(I1lO0O01Ill0IO1,l0IO1OI01lIlI0O,clk,reset_b,1'b1);assign OOIl1IO0lIIO0lI[25]
=bar0_setup[33]&~bar0_setup[25]&OOIl1I01lOlIO10[25];dff IIlI0OI1lO0IO01l(I1lO0IIO0lIOIl0,l0IO1OlI1OIlO01,clk,reset_b,1'b1);assign OOIl1IlO01O1lIO
=(IIO0lIO01ll0IO1&(h_abort_b|I01lOIO0lIlIO10))|
(O1lIOI1lO0IlI0O&l0IO1I1lO0lIO10&h_abort_b);assign I01lOl0IO1IO0lI[18]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[18])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IlO01I1lO0OIl01[2]
=CASCADE(~((IlI0OOOIl1OlI01&IO01lO1lIOOOl1I)|OOIl1IO01lIO01l)&
~(lIO10OI01lO01Il))&
~(OlI1OI1lO0l10IO)&
LCELL(~((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0]))&
IOIl0I01lOIOIl0[2];assign IlO01OOIl1I01lO[26]
=bar1_setup[33]&~bar1_setup[26]&IlO01l10IOIOIl0[26];assign IlI0OOIl01O01Il=LCELL(~IO01lIlI0OOI01l&~OI01lIlO01O1lIO);dff IO01IlIO01llO10I
(h_drcmt_b,IOIl0IO01lOOIl1,clk,1'b1,reset_b);assign l10IOOIl01I01lO=~I1lO0IIO0lI1lO0&~IlI0OI1lO0OI01l;assign IO0lIIIO0lO1lIO
=LCELL(lIO10lO10IIO01l&l0IO1I1lO0lIO10);dff II1lO0I1lO0IlI0O(IlO01IOIl0O01Il,I01lOIO0lIO1lIO,clk,reset_b,1'b1);assign lO10IIIO0ll10IO
=(h_size==16'h0000)?1'b1:1'b0;assign OOIl1l0IO1O01Il
=l10IOl10IOIIO0l&~IO0lIIO01lI01lO&h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10&IIO0lOI01lOI01l;assign l10IOl10IOO01Il
=LCELL(cbein_b[0]^cbein_b[1]^cbein_b[2]^cbein_b[3]);BUF IOlI01OOl1IlIO10(lIO10OOl1IIO0lI,IO0lIOOl1IO01Il);assign OIl01IOIl0lIO10
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign I1lO0O01IlOlI01
=O01IlO1lIOOI01l|(~lIO10OI01lO01Il&IO01llO10II1lO0);BUF IOOIl1IIO0ll0IO1(lO10IOOIl1IlI0O,OlI1OIlI0Ol0IO1);dff IOI01lIOIl0l0IO1
(OIl01OIl01IOIl0,lIO10lIO10lIO10,clk,reset_b,1'b1);BUF IIO01lOI01lIO01l(IO0lIO01IlI1lO0,lIO10IO01lOIl01);assign IlI0OIOIl0I01lO
=(IlO01IlO01IlO01[7:2]==6'b001111)?1'b1:1'b0;assign OlI1OIlI0OOlI01
=OOl1IIIO0lOlI1O&IO01lOlI1Ol10IO&I1lO0OOl1IOI01l&lIO10IO01lOOIl1;assign OI01ll0IO1IIO0l
=IOIl0OIl01IO01l|IO0lIOlI01OIl01|OlI1OIlI0Ol0IO1;assign OlI01IO0lIOOIl1=LCELL(OI01lIlO01OI01l^IOIl0I01lOOOIl1^O01IlOlI1OIO01l);assign OIl01IOIl0OI01l
=IOIl0lIO10O1lIO|IO0lIO01IlI1lO0|OlI1OOI01lOlI01|OOl1IIOIl0OlI1O;dffe Il0IO1OlI01IlI0O
(l0IO1lO10Il10IO,I1lO0l10IOOlI1O,clk,reset_b,1'b1,lO10Il10IOOIl01);assign OIl01I1lO0OlI01=IlI0OOOIl1OlI01&IO01lO1lIOOOl1I;assign l0IO1I01lOlIO10[3:0]
=(OOIl1IO0lIl0IO1)?(IlO01OlI1OIlI0O[3:0]+4'b0001):lO10Il10IOIOIl0[3:0];dff IOlI1OIO01lO01Il
(lIO10lO10IIO01l,l0IO1IlI0OOlI1O,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[4]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[4])|
(O1lIOOOIl1lIO10&h_din[4])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[4]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[4])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[4]);assign l0IO1lIO10OOl1I
=(((I1lO0IIO0lIOIl0&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10))|lO10IOOl1IlO10I)&OI01lOOl1IIOIl0)|OIl01IOIl0O1lIO|IO01llO10IOOIl1|~O1lIOl10IOlO10I;assign IO01lI1lO0l0IO1[31:8]
=class_code;assign IlO01O01IllIO10
=
(IlI0OIIO0lI01lO&(~h_retry_b|(~h_abort_b&~I01lOIO0lIlIO10)|(~h_bii_b&l0IO1I1lO0lIO10))&~IIO0lOI01lOI01l&O1lIOIOIl0OOIl1)|
(IIO0lO1lIOO01Il&~IIO0lOI01lOI01l);assign OIl01IIO0lIO01l[23]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[23])|
(O1lIOOOIl1lIO10&h_din[23])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[23]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[23])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[23]);dff IIlO01I01lOOOIl1
(lIO10O1lIOI01lO,l10IOIOIl0IO0lI,clk,1'b1,reset_b);assign IIO0llIO10OOIl1[13]=O01IlO1lIOO1lIO;assign l0IO1O1lIOOlI01
=(IIO0lOI01lOI01l&I1lO0O01IlIlO01)|(l0IO1OI01llO10I);assign IO01lIlI0OIO01l[31:2]
=
(lO10IOOIl1lO10I&l0IO1O1lIOIlO01&OOl1IOOIl1IO0lI)?{OlI1OlO10IlO10I[31:6],(OlI1OlO10IlO10I[5:2]+4'b0001)}:
(lO10IOOIl1lO10I&l0IO1O1lIOIlO01&IO0lIIIO0lIO01l)?{OlI1OlO10IlO10I[31:5],(OlI1OlO10IlO10I[4:2]+3'b001)}:
(lO10IOOIl1lO10I&l0IO1O1lIOIlO01&OI01lO01IllO10I)?{OlI1OlO10IlO10I[31:4],(OlI1OlO10IlO10I[3:2]+2'b01)}:
(OlI1OlO10IlO10I[31:2]+30'h00000001);dff8 IIlI0OOlI1OIlO01
(l10IOIOIl0l0IO1,lIO10IO0lIIlI0O,clk,1'b1,reset_b);assign I1lO0l10IOlO10I[16]=lIO10l0IO1OI01l;assign status15
=IIO0llIO10OOIl1[15];dff II1lO0IOIl0I1lO0(O1lIOI1lO0IlI0O,IlO01OIl01lIO10,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[26]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[26])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign l0IO1OI01lIlI0O
=~lIO10OI01lO01Il&(lO10IIOIl0OOl1I|I1lO0O01Ill0IO1);assign OOIl1IO0lIIO0lI[3]=bar0_setup[33]&bar0_setup[34]&bar0_setup[32];dff IIO0lIOIl01OOIl1
(l0IO1IlI0OIlI0O,l10IOO01IlI01lO,clk,reset_b,1'b1);assign IlO01OOIl1IlI0O
=((I1lO0l0IO1OlI1O==4'b0110)|
(I1lO0l0IO1OlI1O==4'b1100)|
(I1lO0l0IO1OlI1O==4'b1110)|
(I1lO0l0IO1OlI1O==4'b0111)|
(I1lO0l0IO1OlI1O==4'b1111))?1'b1:1'b0;assign I01lOl0IO1IO0lI[7]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[7])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign lO10IO01IllIO10
=(~IOIl0lO10IIO01l&~(O01IlO1lIOOI01l|IO01llO10II1lO0|I01lOOlI01OIl01))?4'b0000:h_bein_b;assign IlO01OOIl1I01lO[15:4]=12'h000;assign IlO01OIl01IO01l
=lIO10OI01lO01Il&I1lO0OOl1IlIO10&~(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O);assign h_adsm_b=IOIl0O1lIOlO10I;assign lO10Il0IO1IOIl0
=lIO10OI01lIIO0l[0]^lIO10OI01lIIO0l[1]^lIO10OI01lIIO0l[2]^lIO10OI01lIIO0l[3];assign OOl1IIlO01IOIl0
=lO10IOOl1IlO10I|I1lO0IIO0lIOIl0;assign lO10IIlO01OlI01
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[1])?IO0lIOOIl1IIO0l[8]:l10IOOOIl1I1lO0;assign l0IO1OlI1Ol0IO1
=OlI01IO0lIOIl01|OlI1OIlI0OIlO01;dff IIO01lIO0lIO01Il(IOIl0OlI1OIlI0O,IO0lIOOl1IOOl1I,clk,1'b1,reset_b);dff IIIO0lIIO0lO01Il
(IO01llO10IIOIl0,IlO01OIl01O1lIO,clk,reset_b,1'b1);assign OOIl1IO01lO1lIO
=(l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)|lO10IOOl1II01lO|IlI0OI1lO0OI01l;assign OlI01IO0lIIOIl0
=(~(O1lIOOOIl1IO01l&IO0lIOOIl1IIO0l[31]))&(IlI0OIOIl0lO10I|(I1lO0O01IlIO0lI));dff IOI01lOIl01OlI1O
(IO0lIOlI01I1lO0,lIO10IO01lI1lO0,clk,reset_b,1'b1);assign IlI0OO01Ill10IO
=(CASCADE(LCELL(IlI0OIIO0lI01lO&~I1lO0OlI01OlI01&h_bii_b&IOIl0OlI1OIlI0O&
(h_abort_b|I01lOIO0lIlIO10))&
((O1lIOIOIl0OOIl1&~O1lIOIlI0OOOIl1)|O01IlIlI0OOOIl1))&
((~IIO0lOI01lOI01l&~OIl01OlI1OIIO0l)|LCELL((O01IlIlI0OOOIl1|~lIO10IO0lIlO10I)&~OIl01OlI1OIIO0l)|LCELL(l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10)));assign OOIl1lIO10O01Il
=(adin[12]^adin[13]^adin[14]^adin[15]);assign I1lO0OOl1IIO01l=(IIO0lOlI01lIO10&~IIO0lOI01lOI01l)|O1lIOIlI0OIOIl0;dff16 IIO01ll0IO1OOIl1
(IlO01l10IOIOIl0[31:16],IO01lIlI0OO1lIO[31:16],clk,1'b1,reset_b);assign h_done_b=~l0IO1I01lOO1lIO;assign O01IllO10IIlO01
=(OI01lOOIl1IOIl0[7:0]==8'h04)?1'b1:1'b0;assign I01lOlIO10l0IO1=(O1lIOOIl01IO0lI&OlI01OI01lIlO01&~perrin_b);dffe8 IOOl1IIOIl0lO10I
(adout[7:0],OIl01IIO0lIO01l[7:0],clk,1'b1,reset_b,I01lOIO01lOlI1O);assign IlI0OIlI0OIlI0O
=(OOIl1OOl1IIOIl0[15:0]>=IIO0lIIO0lOOl1I[15:0])?lIO10l0IO1OI01l:1'b0;assign OlI01OOl1IO1lIO[1:0]
=(I01lOOlI01OOIl1&~IO0lIIO01lI01lO)?IO0lIOOIl1IIO0l[1:0]:IOIl0I01lOI1lO0[1:0];assign IO01lOIl01I1lO0
=
(I01lOI01lOlO10I&O1lIOIOIl0OOIl1)|
(~IIO0lOI01lOI01l&LCELL((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10)|
(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0)|
(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&(lO10IIO01lIlO01|O01IlI1lO0lO10I))));assign OIl01IIO0lIO01l[15]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[15])|
(O1lIOOOIl1lIO10&h_din[15])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[15]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[15])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[15]);assign IO0lIIIO0llIO10
=(OIl01IOIl0O1lIO&(~IOIl0I1lO0I1lO0|O01IlO1lIOOI01l))|(IO01llO10IOOIl1&IO01lIlI0OOI01l);assign O1lIOO01Ill0IO1[5]=1'b0;BUF IOlI01OOl1IIO01l
(O1lIOOlI1OOI01l,IIO0lIO0lIl10IO);assign OIl01IIO0lIO01l[34]
=(O1lIOOOIl1lIO10&h_bein_b[2])|
(IIO0lIO0lIOOl1I&IlI0OOOIl1IO0lI[2])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[34]);dff IOlI01IIO0lIOIl0
(l10IOOlI1OOOIl1,I01lOIO0lIOI01l,clk,reset_b,1'b1);assign IIO0lO1lIOl10IO[15:8]=OI01ll0IO1l10IO;assign O01IlOlI1OlIO10
=~gnt_b&framein_b&irdyin_b;assign I1lO0IIO0lI1lO0=(OIl01OlI1OIIO0l&l0IO1I1lO0lIO10&O1lIOI1lO0IlI0O&~I01lOIO0lIlIO10);dffe8 IO01IllIO10l0IO1
(l10IOIOIl0IlO01[31:24],adin[31:24],clk,reset_b,1'b1,IO01lO1lIOO01Il);assign IOIl0O1lIOIlI0O=h_cmd[1]&~h_cmd[0]&~h_mio;assign OOIl1IO0lIIO0lI[22]
=bar0_setup[33]&~bar0_setup[22]&OOIl1I01lOlIO10[22];dff IOOIl1OlI01I01lO(IlI0OOOIl1OlI01,OI01lIO0lIIlO01,clk,reset_b,1'b1);dff4 IIIO0ll10IOOOIl1
(I1lO0l0IO1OlI1O,OI01lIO01lIO01l,clk,reset_b,1'b1);assign I01lOl0IO1IO0lI[15]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[15])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IO0lIl0IO1IlO01[1]
=
(IO01lO1lIOOOl1I&LCELL(IlI0OOOIl1OlI01&OIl01IIO0lIO01l[33]))|
LCELL((OOIl1IO01lIO01l&OIl01IIO0lIO01l[33])|
((lIO10OI01lO01Il)&IIO0ll0IO1OOIl1[1])|
((OlI1OI1lO0l10IO)&O01IlO1lIOlIO10[1])|
(((IO01llO10IOOIl1|OIl01IOIl0O1lIO)&~OOIl1OlI01OlI1O[0])&O1lIOOIl01OlI01[1]))|
IlO01I1lO0OIl01[1];assign IlO01OOIl1I01lO[23]
=bar1_setup[33]&~bar1_setup[23]&IlO01l10IOIOIl0[23];assign O01IlIlI0OIOIl0
=(LCELL(OIl01IOIl0O1lIO&~IOIl0lO10IIO01l)|
LCELL(O1lIOIOIl0I1lO0&~OOl1IIIO0lIlI0O&(~IO01lO1lIOOOl1I|IlI0OOIl01O01Il))|
(IO01llO10IOOIl1&~OOIl1OlI01OlI1O[0]));BUF IIO0lIOIl01OIl01
(lO10IIOIl0IIO0l,lIO10OlI01l10IO);assign h_aout[1:0]=2'b00;assign I01lOIO01lOlI1O
=CASCADE(IlI0OOOIl1OlI01|
(IIO0lOI01lOI01l&IOIl0IlI0OO01Il)|
l0IO1I1lO0IO01l)&
(IO01lO1lIOOOl1I|(IIO0lOI01lOI01l&IOIl0IlI0OO01Il)|l0IO1I1lO0IO01l);dff IO01IlOlI01IOIl0
(l10IOOOIl1I1lO0,lO10IIlO01OlI01,clk,reset_b,1'b1);assign IO0lIl0IO1OlI01
=((IO01llO10II1lO0|O01IlO1lIOOI01l)&OIl01IOIl0O1lIO)?16'h0001:
(~IO01llO10II1lO0&~O01IlO1lIOOI01l&OIl01IOIl0O1lIO&~l0IO1OI01lOlI1O)?h_size:
(~IO01llO10II1lO0&l0IO1OI01lOlI1O&~O01IlO1lIOOI01l)?16'hffff:
(OOIl1IO01llIO10)?16'h0003:
(IlO01I1lO0IOIl0)?16'h0002:
(I01lOlIO10IlO01)?16'h0001:
OOl1IOlI01l10IO;assign h_burst_cont
=O1lIOI1lO0IlI0O|(IlI0OIIO0lI01lO&~O1lIOI1lO0I01lO);assign OlI01OI01lOlI01=(lIO10lIO10O1lIO^OIl01O01IlI1lO0^l10IOl10IOO01Il);assign IlI0OI1lO0OI01l
=((IO0lIIlO01OlI1O&O1lIOIOIl0OIl01)|l0IO1IlI0OIlI0O)&IO0lIOOIl1OOl1I;assign OOIl1IO01lOI01l
=LCELL(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[3]);assign l10IOOIl01lO10I
=~OI01lOOIl1OOIl1&IOIl0lO10IIO01l&l10IOOOIl1OIl01&O01IlO1lIOOI01l&~IO01llO10II1lO0;assign IO01lOlI1OO01Il
=(l10IOl10IOIIO0l&IO0lIIO01lI01lO&OOIl1O1lIOl0IO1)|
(l10IOl10IOIIO0l&~h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10);dff IOOIl1IlO01lIO10
(IO0lIIIO0lOI01l,IOIl0IlI0Ol10IO,clk,reset_b,1'b1);BUF IlO10IOOIl1I01lO(IIO0lOlI01lIO10,IO01lO1lIOl10IO);assign IIO0lIO01lIlO01
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OlI01OlI01IO0lI&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[7:0]:OI01lOOIl1IOIl0;dff IOlI1OIO0lIOOIl1
(O1lIOIOIl0OIl01,IlI0OOIl01IIO0l,clk,reset_b,1'b1);assign IO01lOI01lOI01l
=(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1)|
(lO10IOOIl1IlI0O)|
(~OI01lIO0lIl0IO1|~IOIl0OlI1OIlI0O);assign I01lOIO01lIlI0O
=~(O01IllO10IOlI01&((OlI01IO0lIOOIl1&~parin)|(~OlI01IO0lIOOIl1&parin)));dffe8 II01lOIIO0lOI01l
(lIO10OI01lIIO0l[15:8],OIl01IIO0lIO01l[15:8],clk,reset_b,1'b1,l10IOl10IOl10IO);assign OIl01OlI1OO01Il
=(~(IlO01IlO01IlO01[31]^IlO01l10IOIOIl0[31])|bar1_setup[31])&
(~(IlO01IlO01IlO01[30]^IlO01l10IOIOIl0[30])|bar1_setup[30])&
(~(IlO01IlO01IlO01[29]^IlO01l10IOIOIl0[29])|bar1_setup[29])&
(~(IlO01IlO01IlO01[28]^IlO01l10IOIOIl0[28])|bar1_setup[28])&
(~(IlO01IlO01IlO01[27]^IlO01l10IOIOIl0[27])|bar1_setup[27])&
(~(IlO01IlO01IlO01[26]^IlO01l10IOIOIl0[26])|bar1_setup[26])&
(~(IlO01IlO01IlO01[25]^IlO01l10IOIOIl0[25])|bar1_setup[25])&
(~(IlO01IlO01IlO01[24]^IlO01l10IOIOIl0[24])|bar1_setup[24])&
(~(IlO01IlO01IlO01[23]^IlO01l10IOIOIl0[23])|bar1_setup[23])&
(~(IlO01IlO01IlO01[22]^IlO01l10IOIOIl0[22])|bar1_setup[22])&
(~(IlO01IlO01IlO01[21]^IlO01l10IOIOIl0[21])|bar1_setup[21])&
(~(IlO01IlO01IlO01[20]^IlO01l10IOIOIl0[20])|bar1_setup[20])&
(~(IlO01IlO01IlO01[19]^IlO01l10IOIOIl0[19])|bar1_setup[19])&
(~(IlO01IlO01IlO01[18]^IlO01l10IOIOIl0[18])|bar1_setup[18])&
(~(IlO01IlO01IlO01[17]^IlO01l10IOIOIl0[17])|bar1_setup[17])&
(~(IlO01IlO01IlO01[16]^IlO01l10IOIOIl0[16])|bar1_setup[16]);assign OlI01lIO10IlI0O
=OlI01O1lIOI1lO0&IO01lO1lIOOOl1I&~IO0lIOlI01I1lO0&~(O01IlO1lIOOI01l&OI01lOOIl1OOIl1)&~l10IOOlI1OOOIl1;assign IlO01IlI0OOOl1I[31:2]
=(l10IOl10IOIIO0l&~IO0lIIO01lI01lO)?IlO01IlO01IlO01[31:2]:O1lIOOIl01l0IO1[31:2];dff II1lO0OIl01OlI01
(IlI0OIIO0lI01lO,O1lIOl10IOIlI0O,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[7]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[7])|
(O1lIOOOIl1lIO10&h_din[7])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[7]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[7])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[7]);BUF Il0IO1lIO10O01Il
(OlI1OO1lIOIOIl0,IO0lIIIO0llIO10);assign I1lO0l0IO1IlI0O[15:0]=subvendor_id;assign lIO10O1lIOlO10I
=LCELL(l10IOl10IOIIO0l&(O01IlI1lO0lO10I|lO10IIO01lIlO01))&~IO0lIIO01lI01lO&IIO0lOI01lOI01l;assign OIl01IIO0lIO01l[26]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[26])|
(O1lIOOOIl1lIO10&h_din[26])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[26]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[26])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[26]);assign I01lOOI01lOIl01
=IlO01O01IlIO01l&(OOIl1lIO10IIO0l|~lIO10O1lIOI01lO);assign IIO0llIO10OOIl1[10:9]=2'b01;assign OlI01OlI01OlI01
=((IlI0OIIO0lI01lO|(IIO0lO1lIOO01Il&~IlI0OOIl01l10IO))&
~O01IlIlI0OOOIl1&lIO10IO0lIlO10I&~(l0IO1I1lO0lIO10&~I01lOIO0lIlIO10&O1lIOI1lO0IlI0O));assign OOl1IO01IlIIO0l[1]
=(lIO10OI01lO01Il&I1lO0OOl1IlIO10)?((h_ain[1]&~h_mio)|(h_cacheline&h_mio)):
(OOl1Il0IO1OI01l)?OI01ll10IOO01Il[1]:OlI1OlO10IlO10I[1];assign lO10IO01IlOI01l
=(l10IOIOIl0l0IO1==8'b00000000)?1'b1:1'b0;assign OOIl1IO0lIIO0lI[30]=bar0_setup[33]&~bar0_setup[30]&OOIl1I01lOlIO10[30];assign status12
=IIO0llIO10OOIl1[12];BUF IOlI01IlO01l10IO(OlI1OIO01lOOl1I,OOIl1IlO01O1lIO);assign I01lOl0IO1IO0lI[23]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[23])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign O01IlO1lIOlIO10[3:0]
=I1lO0O01Ill0IO1?4'b0111:
OlI1OI01lOl10IO?4'b0110:OOIl1OlI01OlI1O[3:0];assign IlO01OOIl1I01lO[31]
=bar1_setup[33]&~bar1_setup[31]&IlO01l10IOIOIl0[31];dff IIO01lIO0lIOOl1I(IIO0lOOl1IOlI1O,OlI01O1lIOI1lO0,clk,reset_b,1'b1);dff IOOIl1O01IlIlI0O
(IOIl0O1lIOlO10I,lO10IOOl1IOlI1O,clk,1'b1,reset_b);assign I01lOl0IO1IO0lI[4]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[4])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign l0IO1I1lO0IO01l
=LCELL(lIO10lIO10IO01l|(IOIl0IlI0OO01Il&O01IlIlI0OOOIl1));assign IlO01OOIl1I01lO[0]=bar1_setup[33]&~bar1_setup[32];dffe IOIl01I1lO0IlO01
(I01lOOlI01OIl01,l10IOIlI0OIO0lI,clk,reset_b,1'b1,lIO10OI01lO01Il);assign l0IO1lIO10IIO0l
=~h_retry_b|(~h_rdyh_b&~h_bii_b&~I01lOIO0lIlIO10);assign IOIl0IlI0OIIO0l
=lIO10OI01lIIO0l[12]^lIO10OI01lIIO0l[13]^lIO10OI01lIIO0l[14]^lIO10OI01lIIO0l[15];BUF IIlO01lO10IOI01l
(O1lIOOIl01IlO01,l0IO1lO10IIIO0l);dff IIO0lIOlI1OIIO0l(IIO0lIO01lOlI01,OOl1Il0IO1IO01l,clk,reset_b,1'b1);dff IOOIl1IIO0lIO0lI
(IO01llO10II1lO0,I1lO0O01IlOlI01,clk,reset_b,1'b1);dff IOIl01I01lOOlI01(oe_trdy,l0IO1O1lIOl0IO1,clk,reset_b,1'b1);dff IIO01lIO01lOlI01
(lO10IIIO0lIIO0l,lIO10IO0lIOlI1O,clk,reset_b,1'b1);assign l10IOOIl01OlI1O
=(IO01lO1lIOOOl1I&OlI01O1lIOI1lO0)|OOIl1OlI01lO10I|lIO10OOl1IIO0lI;dff8 IOlI01IIO0lI1lO0
(IO0lIO01IlOOIl1,IOIl0lO10IOI01l,clk,reset_b,1'b1);assign lIO10IO01lI1lO0
=((~IO01llO10II1lO0&O01IlO1lIOOI01l&OI01lOOIl1OOIl1)|(IO0lIOlI01I1lO0)|
(OI01lOOIl1OOIl1&OlI1OIlI0OOlI01&OI01ll0IO1O01Il[0]))&~lIO10OI01lO01Il;dff IlO10II1lO0IOIl0
(trdyout_b,IO0lIl0IO1IO0lI,clk,1'b1,reset_b);assign l10IOIOIl0OlI01=(adin[24]^adin[25]^adin[26]^adin[27]);assign OIl01I1lO0l0IO1
=lIO10OI01lO01Il|I1lO0IIO0lIOIl0|I1lO0OlI01l0IO1|lO10IOOl1IlO10I|OOl1Il0IO1OI01l|OOIl1l0IO1IIO0l;assign OOl1IOlI01O01Il[31:24]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IIO0lIO0lIO01Il&~l0IO1OIl01l10IO[3])?IO0lIOOIl1IIO0l[31:24]:OOIl1I01lOlIO10[31:24];assign h_boff_b
=~(I1lO0IlO01IIO0l|(l10IOl10IOIIO0l&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10));assign I01lOOlI01I1lO0=(prefetch_limit==2'b00)?1'b1:1'b0;assign IOIl0IlI0Ol10IO
=((OlI01O1lIOI1lO0&IO01lO1lIOOOl1I)|
LCELL(((l10IOl10IOIIO0l&~IO0lIIO01lI01lO&OOIl1O1lIOl0IO1&l10IOOOIl1IOIl0&IIO0lOI01lOI01l)&h_retry_b)|
(IlI0OIIO0lI01lO&IIO0lOI01lOI01l))|
LCELL((OOl1IIO01lI1lO0&O01IlI1lO0lO10I)|
(IO01lI1lO0OlI01&O01IlI1lO0lO10I)|
(IO01lO1lIOIIO0l)));dffe8 IlIO10IlO01OIl01
(adout[31:24],OIl01IIO0lIO01l[31:24],clk,1'b1,reset_b,OIl01OIl01OOIl1);assign OlI1OlO10IIlI0O
=
(CASCADE((framein_b&irdyin_b&
LCELL((lIO10OI01lO01Il&I1lO0OOl1IlIO10&(IlI0Ol10IOIO01l|IOIl0O1lIOIlI0O)&~IO0lIIO01lI01lO)|
((OOl1Il0IO1OI01l|(I1lO0OlI01l0IO1&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10)))&~IO0lIIO01lI01lO)))|
LCELL((I1lO0IIO0lIOIl0&~(O1lIOI1lO0lO10I&I1lO0OOl1IlIO10))|lO10IOOl1IlO10I))&~gnt_b);dff32 IIlI0OOI01lOlI1O
(OOIl1OI01lIlI0O,IlO01IOIl0OOl1I,clk,reset_b,1'b1);assign l0IO1IlI0OOlI1O=lO10IIO0lIl10IO|O01IlOlI1OOI01l;assign OIl01IIO0lIO01l[18]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[18])|
(O1lIOOOIl1lIO10&h_din[18])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[18]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[18])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[18]);assign I1lO0IlO01l10IO
=IO01lO1lIOOOl1I&I01lOIO01llO10I;assign O1lIOO01Ill0IO1[2]=IlI0Ol10IOIO01l;BUF IOlI1OlIO10I01lO
(l0IO1OI01llO10I,l10IOlO10IOlI1O);dffe IOlI01l0IO1I01lO(l0IO1O1lIOIlO01,h_cacheline,clk,reset_b,1'b1,OIl01IOIl0O1lIO);assign lO10IIlO01l0IO1[0]
=~I1lO0IlO01O01Il&
CASCADE((IOIl0lO10IlIO10&OI01ll10IOOOl1I[0])|(IO0lIO01IlIOIl0&O01IlI01lOIlI0O[0]));assign O1lIOOOIl1OI01l[15:8]
=interrupt_pin;assign O01IlO1lIOOI01l=~h_blast_b;assign OlI1OlO10II01lO=I1lO0OOIl1O1lIO&(h_abort_b|I01lOIO0lIlIO10);assign I01lOl0IO1IO0lI[31]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[31])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));assign IIO0ll0IO1OOIl1[3]
=(lIO10OlI01O01Il[1]|(lIO10OlI01O01Il[0]&h_mio));assign OOIl1IO0lIIO0lI[19]=bar0_setup[33]&~bar0_setup[19]&OOIl1I01lOlIO10[19];dff Il10IOOlI1OI1lO0
(OOl1Il0IO1OI01l,OOIl1I01lOIO01l,clk,reset_b,1'b1);assign IOIl0I1lO0OIl01=(I01lOI01lOlO10I)?idsel:lO10IOlI01OI01l;assign I01lOl0IO1IO0lI[12]
=LCELL((I1lO0IIO0lI1lO0&l10IOIOIl0IlO01[12])|(~I1lO0IIO0lI1lO0&IlI0OI1lO0OI01l));dff4 IO01IlIO0lIO1lIO
(cbeout_b,IO0lIl0IO1IlO01,clk,1'b1,reset_b);assign IlO01OOIl1I01lO[20]=bar1_setup[33]&~bar1_setup[20]&IlO01l10IOIOIl0[20];assign IO0lIOOl1IIIO0l
=(IO0lIIlO01OlI1O&~lO10IIIO0lOOl1I);assign lIO10OlI01l10IO
=(l10IOl10IOIIO0l&~IO0lIIO01lI01lO&h_retry_b&OOIl1O1lIOl0IO1&I01lOO1lIOlIO10);assign lO10IIlO01IlO01
=LCELL(((IlI0OIIO0lI01lO|IIO0lO1lIOO01Il)&~lIO10IO0lIlO10I)|(l10IOl10IOIIO0l&~IO0lIIO01lI01lO));assign OIl01OIl01OOIl1
=CASCADE(IlI0OOOIl1OlI01|
(IIO0lOI01lOI01l&OOl1IOOl1IOlI01)|
OI01lOlI01I01lO)&
(IO01lO1lIOOOl1I|(IIO0lOI01lOI01l&OOl1IOOl1IOlI01)|OI01lOlI01I01lO);assign l0IO1OlI1OOlI01
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&OIl01OIl01OIl01&~l0IO1OIl01l10IO[0])?IO0lIOOIl1IIO0l[0]:l10IOO01IllO10I;assign OOIl1OI01llO10I
=~OlI1OlO10IOlI1O[7]&~OlI1OlO10IOlI1O[6]&~OlI1OlO10IOlI1O[5]&~OlI1OlO10IOlI1O[4];assign IOIl0IO01lOOIl1
=~(((I01lOI01lOlO10I&IO0lIl10IOl0IO1)|lIO10lO10IIO01l|OIl01O01IlOIl01|OlI01OI01lIO0lI)&
~O1lIOIOIl0OOIl1&IIO0lOI01lOI01l&~O01IlIlI0OOOIl1);dff Il10IOI01lOIIO0l
(serrout_b,OOIl1lIO10l10IO,clk,1'b1,reset_b);assign lO10IOlI01IO01l=(IlI0OIIO0lI01lO|IIO0lO1lIOO01Il)&~lIO10IO0lIlO10I;assign IO01llO10IOIl01
=
CASCADE(~(OIl01IOIl0lIO10&IO0lIOOIl1IIO0l[24]))&(IlO01I1lO0OOIl1|l10IOOIl01IlI0O|(OI01lOOl1II1lO0));assign OlI1OI01lOO01Il
=~OI01lOOIl1OOIl1&IOIl0lO10IIO01l;assign IO0lIOOl1IOOl1I=~OlI1OIlI0OIO0lI;dff Il10IOlO10IlO10I
(OOl1IIlO01OIl01,IO01lI01lOIO0lI,clk,reset_b,1'b1);BUF IIIO0ll0IO1I1lO0(IlO01OlI1OlO10I,OIl01I1lO0l0IO1);assign O1lIOOlI1OlIO10[15:8]
=
(OOl1IIO01lI1lO0&O01IlI1lO0lO10I&IO0lIIOIl0O1lIO&~l0IO1OIl01l10IO[1])?IO0lIOOIl1IIO0l[15:8]:IIO0lIIO0lOOl1I[15:8];assign IlI0OOIl01IIO0l
=l10IOOlI1OOOIl1;dff30 IIOIl0OlI01IIO0l(O1lIOOIl01l0IO1[31:2],OOIl1OlI01IlI0O[31:2],clk,reset_b,1'b1);assign IlO01OIl01OI01l
=(I01lOOlI01OOIl1&l10IOl10IOIIO0l&~IO0lIIO01lI01lO);dffe4 IO01IlIO01lIlI0O
(lIO10OI01lIIO0l[35:32],OIl01IIO0lIO01l[35:32],clk,reset_b,1'b1,OIl01OIl01OOIl1);assign OOIl1O1lIOl0IO1
=(OOl1IIlO01I1lO0|I1lO0l10IOOlI1O|lO10IIO01lIlO01|O01IlI1lO0lO10I);dff16 IIlI0OIlI0OlO10I
(OOIl1OOl1IIOIl0[15:0],IO01lI01lOIlO01[15:0],clk,reset_b,1'b1);dff32 Il10IOI01lOO01Il
(IO0lIl10IOOlI01[31:0],IlO01IlO01IlO01[31:0],clk,reset_b,1'b1);dff IO01IlIO0lIOI01l
(OOl1IIO01lI1lO0,lIO10O1lIOlO10I,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[10]
=CASCADE((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[10])|
(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[10])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[10]))|
(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[10])|
(O1lIOOOIl1lIO10&h_din[10]);BUF IOI01lIOIl0OlI01
(l0IO1I01lOOI01l,I1lO0IlO01l10IO);assign O1lIOO01Ill0IO1[10]=OI01lO01IlI01lO;dff IIlO01lO10IlIO10
(lIO10IO0lIlO10I,OI01lIlO01IO01l,clk,reset_b,1'b1);assign OIl01IIO0lIO01l[29]
=((IlI0OIOIl0IlI0O&OOIl1OI01lIlI0O[29])|
(O1lIOOOIl1lIO10&h_din[29])|(OOl1IIlO01IOIl0&OlI1OlO10IlO10I[29]))|
CASCADE(IIO0lIO0lIOOl1I&OlI01O1lIOOIl01[29])|
(IO01lI1lO0IlO01&OlI01IO01ll10IO[29]);assign oe_req
=reset_b;assign IIO0llIO10OOIl1[5]=run_66mhz;assign intaout_b=~((~sel_23&~h_inta_b)|(sel_23&~h_inta_b&~OI01lO01IlI01lO));
function LCELL;
input val;
begin
LCELL=val;
end
endfunction
function CASCADE;
input val;
begin
CASCADE=val;
end
endfunction
endmodule
