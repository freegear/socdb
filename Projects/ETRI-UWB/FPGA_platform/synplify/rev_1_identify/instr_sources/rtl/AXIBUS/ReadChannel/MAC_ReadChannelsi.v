// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  MAC_ReadChannelsi(

    SelMAP1,

    //Global signal
    ACLK    ,
    ARESETn ,

    //Read address channel
//ENABLE_ID
    ARIDm2si    ,
    ARADDRm2si  ,
    ARLENm2si   ,
    ARSIZEm2si  ,
    ARBURSTm2si ,
//ENABLE_LOCK
    ARLOCKm2si  ,
//ENABLE_CACHE
    ARCACHEm2si ,
//ENABLE_PROT
    ARPROTm2si  ,

    ARVALIDm2si ,
    ARREADYsi2m ,

    //Read data channel
//ENABLE_ID
    RIDsi2m     ,
    RRESPsi2m   ,
    RVALIDsi2m  ,
    RDATAsi2m   ,
    RREADYm2si  ,
    RLASTsi2m   ,

    
    //For Master interface slave Number = 3
    //Read address channel
    ARIDsi2mi3    ,
    ARADDRsi2mi3  ,
    ARLENsi2mi3   ,
    ARSIZEsi2mi3  ,
    ARBURSTsi2mi3 ,
    ARLOCKsi2mi3  ,
    ARCACHEsi2mi3 ,
    ARPROTsi2mi3  ,
    
    //For Master interface slave Number = 6
    //Read address channel
    ARIDsi2mi6    ,
    ARADDRsi2mi6  ,
    ARLENsi2mi6   ,
    ARSIZEsi2mi6  ,
    ARBURSTsi2mi6 ,
    ARLOCKsi2mi6  ,
    ARCACHEsi2mi6 ,
    ARPROTsi2mi6  ,
    
    //For Master interface slave Number = 7
    //Read address channel
    ARIDsi2mi7    ,
    ARADDRsi2mi7  ,
    ARLENsi2mi7   ,
    ARSIZEsi2mi7  ,
    ARBURSTsi2mi7 ,
    ARLOCKsi2mi7  ,
    ARCACHEsi2mi7 ,
    ARPROTsi2mi7  ,

//Default Slave Number = 8    
    //For Master interface slave Number = 8
    //Read address channel
    ARIDsi2mi8    ,
    ARADDRsi2mi8  ,
    ARLENsi2mi8   ,
    ARSIZEsi2mi8  ,
    ARBURSTsi2mi8 ,
    ARLOCKsi2mi8  ,
    ARCACHEsi2mi8 ,
    ARPROTsi2mi8  ,
////////////////////////////

    ARVALIDsi2mi ,
    ARREADYmi2si ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    
    //Slave3
    //Read data channel
    //____________________________________
    RIDmi32si     ,
    RRESPmi32si   ,
    RDATAmi32si   ,

    
    //Slave6
    //Read data channel
    //____________________________________
    RIDmi62si     ,
    RRESPmi62si   ,
    RDATAmi62si   ,

    
    //Slave7
    //Read data channel
    //____________________________________
    RIDmi72si     ,
    RRESPmi72si   ,
    RDATAmi72si   ,


//Default Slave Number = 8    
    //Slave8
    //Read data channel
    //____________________________________
    RIDmi82si     ,
    RRESPmi82si   ,
    RDATAmi82si   ,

////////////////////////////

    RVALIDmi2si  ,
    RREADYsi2mi  ,
    RLASTmi2si
);

parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 4;
parameter SLAVE_NUM= 9;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

    input   SelMAP1;

    input   ACLK;
    input   ARESETn;

    //Read Address channel
    input   [ADDR_WID-1:0]     ARADDRm2si;
    input   [ARLEN_WID-1:0]    ARLENm2si;
    input   [ARSIZE_WID-1:0]   ARSIZEm2si;  
    input   [ARBURST_WID-1:0]  ARBURSTm2si; 
//ENABLE_ID
    input   [MASTERID_WID-1:0] ARIDm2si;    
//ENABLE_LOCK
    input   [ARLOCK_WID-1:0]   ARLOCKm2si;  
//ENABLE_CACHE
    input   [ARCACHE_WID-1:0]  ARCACHEm2si; 
//ENABLE_PROT
    input   [ARPROT_WID-1:0]   ARPROTm2si;  

    input   ARVALIDm2si; 
    output  ARREADYsi2m; 

    //Read data channel
//ENABLE_ID
    output   [MASTERID_WID-1:0]RIDsi2m;     
    output   [RRESP_WID-1:0]   RRESPsi2m;   
    output   [BUS_WID-1:0]     RDATAsi2m;
    output   RVALIDsi2m;  
    input    RREADYm2si;  
    output   RLASTsi2m;   

    //For Master interface SlaveNum = 3
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi3;    
    output  [ADDR_WID-1:0] ARADDRsi2mi3;  
    output  [ARLEN_WID-1:0] ARLENsi2mi3;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi3;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi3; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi3;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi3; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi3;  

    //For Master interface SlaveNum = 6
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi6;    
    output  [ADDR_WID-1:0] ARADDRsi2mi6;  
    output  [ARLEN_WID-1:0] ARLENsi2mi6;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi6;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi6; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi6;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi6; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi6;  

    //For Master interface SlaveNum = 7
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi7;    
    output  [ADDR_WID-1:0] ARADDRsi2mi7;  
    output  [ARLEN_WID-1:0] ARLENsi2mi7;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi7;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi7; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi7;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi7; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi7;  


//Default Slave Number = 8    //For Master interface SlaveNum = 8
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi8;    
    output  [ADDR_WID-1:0] ARADDRsi2mi8;  
    output  [ARLEN_WID-1:0] ARLENsi2mi8;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi8;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi8; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi8;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi8; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi8;  

////////////////////////////

    output  [SLAVE_NUM-1:0]ARVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]ARREADYmi2si; 

    //From SI(slave interface)
    
    //Slave3
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi32si;     
    input   [RRESP_WID-1:0] RRESPmi32si;   
    input   [BUS_WID-1:0]   RDATAmi32si;

    
    //Slave6
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi62si;     
    input   [RRESP_WID-1:0] RRESPmi62si;   
    input   [BUS_WID-1:0]   RDATAmi62si;

    
    //Slave7
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi72si;     
    input   [RRESP_WID-1:0] RRESPmi72si;   
    input   [BUS_WID-1:0]   RDATAmi72si;


//Default Slave Number = 8    
    //Slave8
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi82si;     
    input   [RRESP_WID-1:0] RRESPmi82si;   
    input   [BUS_WID-1:0]   RDATAmi82si;

////////////////////////////

    input   [SLAVE_NUM-1:0] RVALIDmi2si;  
    input   [SLAVE_NUM-1:0] RLASTmi2si;  
    output  [SLAVE_NUM-1:0] RREADYsi2mi;    


    wire [SLAVE_WID :0] CtlData2writech;

    //SLAVE 3
    assign  ARIDsi2mi3 = ARIDm2si;    
    assign  ARADDRsi2mi3 = ARADDRm2si;  
    assign  ARLENsi2mi3 = ARLENm2si;   
    assign  ARSIZEsi2mi3 = ARSIZEm2si;  
    assign  ARBURSTsi2mi3 = ARBURSTm2si; 
    assign  ARLOCKsi2mi3 = ARLOCKm2si;  
    assign  ARCACHEsi2mi3 = ARCACHEm2si; 
    assign  ARPROTsi2mi3 = ARPROTm2si;  

    //SLAVE 6
    assign  ARIDsi2mi6 = ARIDm2si;    
    assign  ARADDRsi2mi6 = ARADDRm2si;  
    assign  ARLENsi2mi6 = ARLENm2si;   
    assign  ARSIZEsi2mi6 = ARSIZEm2si;  
    assign  ARBURSTsi2mi6 = ARBURSTm2si; 
    assign  ARLOCKsi2mi6 = ARLOCKm2si;  
    assign  ARCACHEsi2mi6 = ARCACHEm2si; 
    assign  ARPROTsi2mi6 = ARPROTm2si;  

    //SLAVE 7
    assign  ARIDsi2mi7 = ARIDm2si;    
    assign  ARADDRsi2mi7 = ARADDRm2si;  
    assign  ARLENsi2mi7 = ARLENm2si;   
    assign  ARSIZEsi2mi7 = ARSIZEm2si;  
    assign  ARBURSTsi2mi7 = ARBURSTm2si; 
    assign  ARLOCKsi2mi7 = ARLOCKm2si;  
    assign  ARCACHEsi2mi7 = ARCACHEm2si; 
    assign  ARPROTsi2mi7 = ARPROTm2si;  

    //SLAVE 8
    assign  ARIDsi2mi8 = ARIDm2si;    
    assign  ARADDRsi2mi8 = ARADDRm2si;  
    assign  ARLENsi2mi8 = ARLENm2si;   
    assign  ARSIZEsi2mi8 = ARSIZEm2si;  
    assign  ARBURSTsi2mi8 = ARBURSTm2si; 
    assign  ARLOCKsi2mi8 = ARLOCKm2si;  
    assign  ARCACHEsi2mi8 = ARCACHEm2si; 
    assign  ARPROTsi2mi8 = ARPROTm2si;  



//Read address channel
//____________________________________________________________________

//ARVALID MUX 
reg [SLAVE_NUM-1:0]ARVALIDsi2mi; 

//MUX TYPE 00 was Generated 
always @(CtlData2writech  or 
         ARVALIDm2si  )
begin

    if(CtlData2writech [SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2writech [SLAVE_WID-1:0])
        //synopsys parallel_case full_case
            4'd3:   
            begin
                 ARVALIDsi2mi[3] <= ARVALIDm2si ;
                 ARVALIDsi2mi[6] <= 1'b0;
                 ARVALIDsi2mi[7] <= 1'b0;
                 ARVALIDsi2mi[8] <= 1'b0;
            end
            4'd6:   
            begin
                 ARVALIDsi2mi[3] <= 1'b0;
                 ARVALIDsi2mi[6] <= ARVALIDm2si ;
                 ARVALIDsi2mi[7] <= 1'b0;
                 ARVALIDsi2mi[8] <= 1'b0;
            end
            4'd7:   
            begin
                 ARVALIDsi2mi[3] <= 1'b0;
                 ARVALIDsi2mi[6] <= 1'b0;
                 ARVALIDsi2mi[7] <= ARVALIDm2si ;
                 ARVALIDsi2mi[8] <= 1'b0;
            end
            default:
            begin
                ARVALIDsi2mi[3] <= 1'b0;
                ARVALIDsi2mi[6] <= 1'b0;
                ARVALIDsi2mi[7] <= 1'b0;
                ARVALIDsi2mi[8] <= ARVALIDm2si ;
            end
        endcase
    end
    else
    begin
        ARVALIDsi2mi[3] <= 1'b0;
        ARVALIDsi2mi[6] <= 1'b0;
        ARVALIDsi2mi[7] <= 1'b0;
        ARVALIDsi2mi[8] <= 1'b0;
    end
end


reg ARREADYsi2m;

//ARREADY Demux
always @(CtlData2writech or ARREADYmi2si)
begin
    if(CtlData2writech[SLAVE_WID])
    begin
        case(CtlData2writech[SLAVE_WID-1:0])
        // synopsys parallel_case full_case
            4'd3:   ARREADYsi2m <= ARREADYmi2si[3]; 
            4'd6:   ARREADYsi2m <= ARREADYmi2si[6]; 
            4'd7:   ARREADYsi2m <= ARREADYmi2si[7]; 
            4'd8:   ARREADYsi2m <= ARREADYmi2si[8]; 
            default:
                ARREADYsi2m <= 1'b0;
        endcase
    end
    else
        ARREADYsi2m <= 1'b0;
end

reg [SLAVE_WID-1:0] SlaveNum;

//ADDRESS Decoder
//____________________________________________________________________

//Slave Number 3
wire Slave3MAX0En = (ARADDRm2si >= 32'h60000000) ? 1'b1:1'b0;
wire Slave3MIN0En = (32'h70000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave3_0En = Slave3MAX0En & Slave3MIN0En;

//Slave Number 6
wire Slave6MAX0En = (ARADDRm2si >= 32'h0) ? 1'b1:1'b0;
wire Slave6MIN0En = (32'h20000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave6_0En = Slave6MAX0En & Slave6MIN0En;

//Slave Number 7
wire Slave7MAX0En = (ARADDRm2si >= 32'h20000000) ? 1'b1:1'b0;
wire Slave7MIN0En = (32'h30000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave7_0En = Slave7MAX0En & Slave7MIN0En;


//Slave Number 3
wire Slave3MAX1En = (ARADDRm2si >= 32'h60000000) ? 1'b1:1'b0;
wire Slave3MIN1En = (32'h70000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave3_1En = Slave3MAX1En & Slave3MIN1En;

//Selection mux
wire Slave3En = (SelMAP1) ? Slave3_1En : Slave3_0En;

//Slave Number 6
wire Slave6MAX1En = (ARADDRm2si >= 32'h20000000) ? 1'b1:1'b0;
wire Slave6MIN1En = (32'h40000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave6_1En = Slave6MAX1En & Slave6MIN1En;

//Selection mux
wire Slave6En = (SelMAP1) ? Slave6_1En : Slave6_0En;

//Slave Number 7
wire Slave7MAX1En = (ARADDRm2si >= 32'h0) ? 1'b1:1'b0;
wire Slave7MIN1En = (32'h10000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave7_1En = Slave7MAX1En & Slave7MIN1En;

//Selection mux
wire Slave7En = (SelMAP1) ? Slave7_1En : Slave7_0En;



wire Slave8En = 
                !Slave3En &
                !Slave6En &
                !Slave7En ;

always @(
         Slave3En or
         Slave6En or
         Slave7En or
         Slave8En  
        )
begin
    case(1'b1) //synopsys parallel_case
        Slave3En:   SlaveNum <= 4'd3;
        Slave6En:   SlaveNum <= 4'd6;
        Slave7En:   SlaveNum <= 4'd7;
        Slave8En:   SlaveNum <= 4'd8;
        default:   SlaveNum <= {4{1'd0}};
    endcase
end

//STATE_END

//____________________________________________________________________

//Read data channel
//____________________________________________________________________

reg   [MASTERID_WID-1:0]RIDsi2m;     
reg   [RRESP_WID-1:0]   RRESPsi2m;   
reg   RVALIDsi2m;  
reg   RLASTsi2m;
reg   [SLAVE_NUM-1:0]   RREADYsi2mi;    
reg   [BUS_WID-1:0]     RDATAsi2m;

//Data Arbiter
reg   [SLAVE_WID-1:0] CtlData2readch; 

//Response Arbiter
//Arbiter was Generated TYPE00
reg   EnArbiter;

always @(
         RVALIDmi2si or
         CtlData2readch
        )
begin
    case(CtlData2readch)
        //synopsys parallel_case full_case
        4'd3:    EnArbiter <= RVALIDmi2si[3];
        4'd6:    EnArbiter <= RVALIDmi2si[6];
        4'd7:    EnArbiter <= RVALIDmi2si[7];
        4'd8:    EnArbiter <= RVALIDmi2si[8];
        default: EnArbiter <= 1'b0;
    endcase
end

always  @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        CtlData2readch <= 0;
    end
    else if(!EnArbiter)
    begin
          if(RVALIDmi2si[3]) CtlData2readch <= 4'd3;
          else if(RVALIDmi2si[6]) CtlData2readch <= 4'd6;
          else if(RVALIDmi2si[7]) CtlData2readch <= 4'd7;
          else if(RVALIDmi2si[8]) CtlData2readch <= 4'd8;
    end
end



//MUX TYPE 01 was Generated 
always @(CtlData2readch[SLAVE_WID-1:0]  or 
         RREADYm2si  )
begin

   case(CtlData2readch[SLAVE_WID-1:0] )
   //synopsys parallel_case full_case
        4'd3:   
            begin
                 RREADYsi2mi[3] <= RREADYm2si ;
                 RREADYsi2mi[6] <= 1'b0;
                 RREADYsi2mi[7] <= 1'b0;
                 RREADYsi2mi[8] <= 1'b0;
            end
        4'd6:   
            begin
                 RREADYsi2mi[3] <= 1'b0;
                 RREADYsi2mi[6] <= RREADYm2si ;
                 RREADYsi2mi[7] <= 1'b0;
                 RREADYsi2mi[8] <= 1'b0;
            end
        4'd7:   
            begin
                 RREADYsi2mi[3] <= 1'b0;
                 RREADYsi2mi[6] <= 1'b0;
                 RREADYsi2mi[7] <= RREADYm2si ;
                 RREADYsi2mi[8] <= 1'b0;
            end
         default:
            begin
                RREADYsi2mi[3] <= 1'b0;
                RREADYsi2mi[6] <= 1'b0;
                RREADYsi2mi[7] <= 1'b0;
                RREADYsi2mi[8] <= RREADYm2si ;
            end
   endcase
end


    always @(//1
             RRESPmi32si or    
             RRESPmi62si or    
             RRESPmi72si or    
             RRESPmi82si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            4'd3:   RRESPsi2m  <= RRESPmi32si;
            4'd6:   RRESPsi2m  <= RRESPmi62si;
            4'd7:   RRESPsi2m  <= RRESPmi72si;
            4'd8:   RRESPsi2m  <= RRESPmi82si;
            default:     RRESPsi2m  <= 0;
        endcase
    end


    always @(//2
             RIDmi32si or    
             RIDmi62si or    
             RIDmi72si or    
             RIDmi82si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            4'd3:   RIDsi2m  <= RIDmi32si;
            4'd6:   RIDsi2m  <= RIDmi62si;
            4'd7:   RIDsi2m  <= RIDmi72si;
            4'd8:   RIDsi2m  <= RIDmi82si;
            default:     RIDsi2m  <= 0;
        endcase
    end


    always @(//3
             RDATAmi32si or    
             RDATAmi62si or    
             RDATAmi72si or    
             RDATAmi82si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            4'd3:   RDATAsi2m  <= RDATAmi32si;
            4'd6:   RDATAsi2m  <= RDATAmi62si;
            4'd7:   RDATAsi2m  <= RDATAmi72si;
            4'd8:   RDATAsi2m  <= RDATAmi82si;
            default:     RDATAsi2m  <= 0;
        endcase
    end


    always @(//4
             RVALIDmi2si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            4'd3:   RVALIDsi2m  <= RVALIDmi2si[3];
            4'd6:   RVALIDsi2m  <= RVALIDmi2si[6];
            4'd7:   RVALIDsi2m  <= RVALIDmi2si[7];
            4'd8:   RVALIDsi2m  <= RVALIDmi2si[8];
            default:     RVALIDsi2m  <= 0;
        endcase
    end


    always @(//5
             RLASTmi2si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            4'd3:   RLASTsi2m  <= RLASTmi2si[3];
            4'd6:   RLASTsi2m  <= RLASTmi2si[6];
            4'd7:   RLASTsi2m  <= RLASTmi2si[7];
            4'd8:   RLASTsi2m  <= RLASTmi2si[8];
            default:     RLASTsi2m  <= 0;
        endcase
    end

RDCH_MAC_PermitCtl 
    U1PermitCtl(

    .ACLK       (ACLK)      ,
    .ARESETn    (ARESETn)   ,
    .SlaveNum   (SlaveNum)  ,

    .SID        (ARIDm2si),
    .AREADY     (ARREADYsi2m),
    .AVALID     (ARVALIDm2si),    

    .WID        ({MASTERID_WID{1'b0}}),
    .WREADY     (1'b0),
    .WVALID     (1'b0),
    .WLAST      (1'b0),

    .LID        (RIDsi2m),
    .LAST       (RLASTsi2m),
    .READY      (RREADYm2si),
    .RVALID     (RVALIDsi2m),

    .CtlData2datach  (),
    .CtlData2writech (CtlData2writech)

    );
   
endmodule
//Code_END
