@E8lFkRDCLmg_)ILQXwN 5LRR(W_[1P_dWR,RLMU_Pplw_,YtR6RL_$mP]Rd,R_L(Mjwts,7YRdRL_$up,LRRdp_uw
2;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0LMU_Pplw_;Yt
HRRM0bkR_L6m]P$dR;
RbHMkL0R(w_Mt7jsYR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;
bRRNlsNCs0CR6L4_Ge[lnO	ahz_BB.XRd=R.R;
RsbNN0lCCLsR4e6_[OGl	zna_Z	 z=ZRR4'Ljjj44jjjjjjjj4j444jj44j444j4jR4j;R

RosCR4rL6[_eG	lOn_azhXB.BRR:4RR9Lmd_)/LR*$R#MC0E#RH##_$M##sD0C$D=C"so0H#C"s#RR*/;R

RsIHCLRr4e6_[OGl	zna_.hBX:BRR9.RR_LcmQ)L;R

RINDNR$#@b@5F8#CoLCR(W_[1P_dWL2RCMoH
RRRR5HVLMU_Pplw_RYt2CRLoRHM
RRRRHRRVL5R(w_Mt7jsY
R2RRRRRRRRLmd_)=LRR6L4_Ge[lnO	a	z_ ZZz;R
RRRRRCCD#R5HVR_L6m]P$d
R2RRRRRRRRLmd_)=LRRd{L_$up,cRL_Lm)Q
};RRRRC
M8RMRC8R

R#N#HRoMLmc_)RLQ=dRL_Lm)r4RL6[_eG	lOn_azhXB.BRR:.;R9
R
RNH##oLMRdp_uwRR=Lmd_)4Lr9C;
MF8l8CkD
l

FD8kC0R[NHo_Ms0CVCNORR5
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_L(F_17d,PW
RRRRRRRRRRRRRRRR(RL_xUi_sdI,R
RRRRRRRRRRRRRRLRRnP_M_BjB,R
RRRRRRRRRRRRRRLRRdp_uwR,
RRRRRRRRRRRRRRRRL_44U_ixAYJx),sL
RRRRRRRRRRRRRRRR4RLji_Uxi_sDXs0,R
RRRRRRRRRRRRRRLRR4Uj_iVx_w[V#XR,
RRRRRRRRRRRRRRRRLUg_i.x_o0sw,R
RRRRRRRRRRRRRRLRR4Mj_PI_$igvlXR,
RRRRRRRRRRRRRRRRLMg_PT_FIwVY,R
RRRRRRRRRRRRRRLRRgP_M_JOpo,mw
RRRRRRRRRRRRRRRRURL__MPZ0lBY
2;RMRHbRk0R_Ldu;pw
FRRkk0b0(RL_xUi_sdI;R
RFbk0kL0RnP_M_BjB;R
RFbk0kL0R4U4_iAx_J)xYs
L;RkRF00bkRjL4_xUi_Dsis;0X
FRRkk0b04RLji_Uxw_VVX#[;R
RFbk0kL0Rgi_Uxo_.s;w0
FRRkk0b04RLjP_M_i$IvXlg;R
RFbk0kL0RgP_M_IFTV;Yw
FRRkk0b0gRL__MPOopJm
w;RkRF00bkR_LUMZP_lYB0;R
RFbk0kL0Rdi_udR;
R0FkbRk0LF(_1d7_P
W;
IRRHRsCHM8C0$HV_	ODRR/*#0$MEHC##$R#MC_	C4b=R/R*R
;
RHRIsHCR80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88*R/RM#$0#ECH##R$	M_C=Cb4/R*R
;
RHRIsLCR(i_UxI_dsR;
RsIHCnRL__MPj;BB
IRRHRsCLUg_i.x_o0sw;R
RICHsR4L4_xUi_xAJYL)s;R
RICHsRjL4_xUi_Dsis;0X
IRRHRsCL_4jU_ixV#wV[
X;RHRIsLCRUP_M_BZl0
Y;RHRIsLCR4Mj_PI_$igvlXR;
RsIHCgRL__MPFVTIY
w;RHRIsLCRgP_M_JOpo;mw
ARRzRwtOLD	k5VR
RRRR53QRCH8MV0H$D_O	l_0b,R2
RRRR53mRCH8MV0H$D_O	2R2;R
RAq1BhQ_e)Xa c0R[Nbo_s4HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RR)  1a5RRR_L6POF1d,R2
RRRRu3z7 qaRL5RgP_M_IFTVRYw2R,
R3RR1w]Qa5RRR_LUMZP_lYB0R
2,RRRR3B7)iRRR58RHCHM0VO$_D0	_l2bR,R
RR1R3 RpRRRR5LMg_Pp_OJwomR
2,RRRR3Qa7RRRR5nRL__MPjRBB2R,
R3RRBaquzR) 54RLjP_M_i$IvXlgRR22/#*R$EM0C##HRM#$_bMFsCkM=*4R/
R;RCR8VsbNN[lR0_NoblsH4a3KqBt_]hqQR4=R;R
RAq1BhQ_e)Xa c0R[Nbo_s.HlRR5
R3RRaR7mR5RRR_LduRpw2R,
R3RRzqu7a5 RRjL4_xUi_DsisR0X2R,
R3RR1w]Qa5RRR_LgU_ix.wos0,R2
RRRR)37BRiRRH5R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88,R2
RRRR 31pRRRRL5R4Uj_iVx_w[V#X,R2
RRRR73aQRRRRL5R(i_UxI_ds,R2
RRRRq3Bu)az RR5L_44U_ixAYJx)RsL2/2R*$R#MC0E#RH##_$MMsFbk=MC4/R*RR;
RV8CbNNsl0R[Nbo_s.Hl3qKat]_BqRQh=;R.
NRR#o#HMdRL_duiRH=R80CMH_V$O;D	
NRR#o#HM(RL_7F1_WdPRH=R80CMH_V$O.D	__MFO_D	LVkVCMs_CCC88
;
ClM8FD8kCl

FD8kC4RLnO_)lJH_D_Gg$l]b(5$R
RRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRLud_i
d,RRRRRRRRRRRRRRRRR_Lnu_p$Q
w,RRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRgRL_wup_	aKs
[,RRRRRRRRRRRRRRRRR_L(Mjwts,7Y
RRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRnRL_l4zk,ag
RRRRRRRRRRRRRRRR6RL_$mP]
d,RRRRRRRRRRRRRRRRR.L4_Lm)QNIX Lw_8
2;RkRF00bkR:rdjL9R4Md_Pplw_.VGsTLk;R
RFbk0kr0Rj9:jR4L4_sk)Ok_gsLXA;R
RFbk0kL0Rdp_uwR;
R0FkbRk0L_4.mQ)LI XNw8_L;R
RHkMb0LRRgp_uwK_a	;s[
HRRM0bkRnRL_$up_;Qw
HRRM0bkR6RL_$mP]
d;RMRHbRk0R_L(Mjwts;7Y
HRRM0bkRnRL_#8Z0;dg
HRRM0bkRnRL_l4zk;ag
HRRM0bkRdRL_dui;R
RsRCorj6:94RLjZ_8#g0d_d w;R
RsRCorj6:9gRL_$mP]#d_N
p;RHRIsrCRc9:jRdL4_LPFwY.X __0a
 ;
NRRD$IN#@R@5FRb#oC8CnRL_#8Z0Rdg2R
RLHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRR4RLjZ_8#g0d_d wRL=RgP_m$_]d#;Np
RRRR8CM
CRRM
8
RDRNI#N$R5@@bCF#8RoCLud_iRd2LHCoMR
RRVRH5nRL_l4zkRag2CRLo
HMRRRRRVRH5LR!(w_Mt7jsYRR2LHCoMR
RRRRRRVRH56RL_$mP]2dRRoLCHRM
RRRRRRRRR_Lgm]P$dN_#pRR={_Lnu_p$QRw,L_4dPwFL. XY_a0_ ;R}
RRRRRRRR8CM
RRRRCRRMR8
RCRRMR8
R8CM
R
RNH##oLMR4Pd_F.LwX_Y 0 _aRL=RgP_m$_]d#rNp69:4;R
RNH##oLMR4Md_Pplw_.VGsTLkRL=R48j_Zd#0gw_ d:rc4
9;R#RN#MHoR4L4_sk)Ok_gsLXAR=RRRjL4_#8Z0_dg rwdj9:j;R
RNH##oLMR4m._)ILQXwN _RL8RL=R48j_Zd#0gw_ d9r6;R
RNH##oLMRdp_uwRR=L4n_zalkgRR?Lmg_Pd$]_p#NrRj9:gRL_wup_	aKs
[;ClM8FD8kCl

FD8kCFROlLl_D	FO5R
ROlFl.OHHCH_DMH	_H_OCj
,RRHRHOOC.F_llD	HM_OHHC2_jRR/*#0$MEHC##$R#MH_EC"s=E8Ns"/R*RR;
R0FkbRk0rgj:9FROlHl.H_OCD	HM_OHHC;_j
HRRM0bkR:rjjH9RH.OCOlFl_MDH	H_HOjC_;


RHRIsrCRd9:jRdL4_lMPwVp_GL.sk
T;RHRIsrCRj9:jR4L4_sk)Ok_gsLXA;R
RICHsR:rjjL9R4k4_)_sOWwYm[
Z;RHRIsrCRj9:jR_Lnu_pwQ
w;RHRIsLCRdi_udL,R(i_UxI_dsL,RnP_M_BjB,nRL_wup_,AJRcL4_wup_$i74 _Jd,dxR.L4_Lm)QNIX Lw_8L,Rgp_uwK_a	;s[
IRRHRsC0_8F#RHo/#*R$EM0C##HRM#$_C	CbR=4*;/R
IRRHRsCLMg_Pp_OJwom,gRL__MPFVTIYRw,L_4jM$P_IlivgRX,LMU_Pl_ZB;0Y
IRRHRsCL_4jU_ixV#wV[RX,L_4jU_ixssiD0RX,L_44U_ixAYJx),sLR_LgU_ix.wos0
;
`8HVC1VRQpvzqmaQhM
HHN0HDR
RfHbD10FVBDNLCHQM085HCHM0V[$_0_No0,O	RCH8MV0H$0_[N0o_lR#,HM8C0$HV_N[0o8_0HH,R80CMH_V$[o0N_F082`;
CHM8VR

R#N#HRoMLun_pQw_w9rjRH=RH.OCOlFl_MDH	H_HOjC_;R
RNH##oOMRF.llHCHO_MDH	H_HOjC_R{=RRdL4_lMPwVp_GL.skRT,L_44kO)s_sgkXrALjR9,LMn_PB_jBL,RgP_M_IFTV,YwRjL4__MP$vIil,gXR_LUMZP_lYB0,dRL_duiR
};R#RN#MHoRcL4_wup_$i74 _JdRdx=LR|np_uww_Q;R
RNH##oLMRgp_uwK_a	Rs[=LR54m._)ILQXwN _2L8?F08_o#H:cL4_wup_$i74 _Jd;dx
NRR#o#HM4RL4)_ksgO_kAsXLRR=5_LgMOP_pmJowL2?4k4_)_sOWwYm[4Z:';Lj
R
R[o0N_0HMCNsVO[CR0HNoRR5
R3RRLud_iRdRRRRRR5RRLud_i,d2
RRRR(3L_7F1_WdPRRRRR(5L_7F1_WdP2R,
R3RRLU(_idx_IRsRR5RRLU(_idx_I,s2
RRRRn3L__MPjRBBRRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRRRRRRLR5np_uwJ_A2R,
R3RRL_44U_ixAYJx)RsL54L4_xUi_xAJYL)s2R,
R3RRL_4jU_ixssiD0RXR5jL4_xUi_Dsis20X,R
RRLR34Uj_iVx_w[V#X5RRL_4jU_ixV#wV[,X2
RRRRg3L_xUi_s.owR0RRg5L_xUi_s.ow,02
RRRR43LjP_M_i$IvXlgRLR54Mj_PI_$igvlX
2,RRRR3_LgMFP_TYIVwRRR5_LgMFP_TYIVw
2,RRRR3_LgMOP_pmJowRRR5_LgMOP_pmJow
2,RRRR3_LUMZP_lYB0RRRR5_LUMZP_lYB02
2;
LRR4)n_O_lHJgDG_b$]lR($L)(_O_lHJ5DR
RRRR43LdP_Ml_wpVsG.L5kTL_4dMwPlpG_V.ksLT
2,RRRR34L4_sk)Ok_gsLXARLR54k4_)_sOWwYm[,Z2
RRRRd3L_duiRRRRRRRRRLR5(1_F7P_dW
2,RRRR3_Lnu_p$QRwRRRRRR(5L_xUi_sdI2R,
R3RRLud_pRwRRRRRRRRR5_Lnu_pwA,J2
RRRRg3L_wup_	aKsR[RRLR5gp_uwK_a	2s[,R
RRLR3(w_Mt7jsYRRRR5RRL_44U_ixAYJx)2sL,R
RRLR3nZ_8#g0dRRRRR5RRL_4jU_ixssiD0,X2
RRRRn3L_l4zkRagRRRRRLR54Uj_iVx_w[V#X
2,RRRR3_L6m]P$dRRRRRRRRg5L_xUi_s.ow,02
RRRR43L.)_mLXQIN_ wL58RL_4.mQ)LI XNw8_L2
2;
LRRg)_mLXQINR wLmg_)GL_h7$IRR5
R3RRL[(_Wd1_PRWRRRRR5_Ldu2id,R
RRLR3UP_Ml_wpY5tRL_4.mQ)LI XNw8_L2R,
R3RRLm6_Pd$]RRRR5_LUMZP_lYB02R,
R3RRLM(_wstj7RYRRLR54Mj_PI_$igvlX
2,RRRR3_LduRp$RRRRRn5L__MPj2BB,R
RRLR3dp_uwRRRR5RR0_8F#2HoR
2;
8CMlkF8D
C
lkF8DLCR((_e4JmKxLR5d)_FA
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmd_FRA,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LcmNiK,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR.6_H,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLH._nR,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L.HRW,RR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.RL_,H RRR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRcY_FE
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmc_YjEjR
2;RMRHbRk0LFd_);Aj
HRRM0bkR_Ldm;FA
HRRM0bkR_LcmNiK;R
RHkMb0.RL_;H6
HRRM0bkR_L.H
n;RMRHbRk0LH._WR;
RbHMkL0R. _H;R
RFbk0kL0RcY_FE
j;RkRF00bkR_LcmjYEjR;
Rp1)B 4nR_LUm]P$do7YRR5
R3RR7RRR5_LdFj)A2R,
R3RRBR R5_Ldm2FA,R
RRBR3p5iRLmc_i2KN,R
RRqR3j5RRLH._6
2,RRRR3Rq4R.5L_2Hn,R
RRqR3.5RRLH._W
2,RRRR3RqdR.5L_2H ,R
RRTR3R5RRLFc_Y2Ej,R
RRTR3456RLmc_YjEj2;R2
M
C88lFk
DC
8lFkRDCL_44[0wKpYPYg5JELmc_i,KNRRH,F
2;RNRbsCNl0RCsLmc_)RJO=;R4
HRRM0bkR_LcmNiK;R
RHkMb0;RH
FRRkk0b0;RF
HRRMo0CC[sR;R
RsRCor_LcmO)JR4:R9nRL_s$Fj;u7
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoH
RRRR_Ln$jFsu47r9=R<R
H;RRRRV5Fs[RR=.[;RRR<=Lmc_);JOR=[RR+[RR
42RRRRRnRL_s$Fjru7[<9R=nRL_s$Fjru7[RR-4
9;RMRC8R
RNH##oFMRRL=RnF_$s7jur_LcmO)J9C;
MF8l8CkD
F
l8CkDRjL4_WMYhhagIRLp5R
RLmc_i,KN
LRR6F_P1,Od
LRR(1_u$BH_kR,
R_L6HO1WBR,
R_Lc1OY#,R
RLM(_YIWh7
Y,R(RL_$u1H#Dg,R
RL_4jMhYWaIghL;p2
R
RbNNslCC0sgRL_aMz_DoBY=vRR;4n
HRRM0bkRcRL_KmiNL,R6F_P1,OdR_L(uH1$_,BkR_L6HO1WBR;
RbHMkR0Rrj4:9cRL_#1YOR;
RbHMkR0Rr_LgM_zaoYBDvRR-4RR:jL9R(Y_MW7hIYR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRLRrgz_MaB_oDRYv-RR4:9RjRjL4_WMYhhagI;Lp
sRRCRoRR(RL_$u1H#Dg;R

RsbNN0lCCLsR($_WjdM_gRRRRRRR='RdLjjj;R
RbNNslCC0sURL_UY(s1C_DRRRR=RRRLd'j;j4
bRRNlsNCs0CRdL4_o0EMJYcB_ztA=CRRLd'j;4j
bRRNlsNCs0CR4L4_XLx_aJ1Bz(OR.=R'jLj;R
RbNNslCC0sgRL_XLx_i4#nRzRR.=R'4Lj;R
RbNNslCC0sURL_o7DY)(UBRRRR.=R'jL4;R
RbNNslCC0s4RLjI_64pnkaugTRRR=.4'L4R;
RosCR:rj.L9RnL_Mag0d,nRL_aGL0;dg
sRRCroRLMg_zoa_BvDYR4-RRj:R9(RL_EMYQ#dg;R
RsRCoLM6__.xO,cRL_6M_QR;
RosCR_LguH1$DNg#.R;
RosCRjL4_$u1H#DgG,wAR4L4_$u1H#Dgtu.X,4RL41_u$gHD#AGwaR;
RsIHCnRL_aMz_;VL
NRRD$IN#@R@5#bFCC8oR_LcmNiK2R
RRgRL_$u1H#DgN<.R=6RL_WH1O&BRR_L(uH1$_;Bk
R
RNH##oLMRnz_MaL_VR5=RLM(_YdEQg=#R=(RL_WMYhYI72
;
R#RN#MHoRjL4_WMYhhagIRLp=(RL_EMYQ#dg;R

RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:LM(_z.a_gRj
RHRRV65L_xM_O|.RR_L6POF1dR2
RRRRR_L(MQYEdRg#<'=RL
j;RRRRCCD#R5HVLMc__26Q
RRRRLRR(Y_MEgQd#=R<R_L(MQYEdRg#+;R4
CRRMR8
RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:Lmn_OV_ZLR
RRRRRLMn_Lda0g=R<R_LnG0Lad
g;RRRRRVRH5_L6POF1d
R2RRRRRRRRLMn_Lda0g=R<R_L(WM$j_;dg
CRRMR8
RINDNR$#@L@5nL_Mag0dRRFsLug_1D$Hg.#NRRFsLMn_zVa_LsRFR_L6HO1WBsRFR_Lc1OY#2R
RLHCoMRR:Lmn_On_$sR
RRnRL_aGL0Rdg<L=RnL_Mag0d;R
RR4RL41_u$gHD#Xt.u=R<R
j;RRRRL_4juH1$DGg#w<AR=;Rj
RRRR_LcMQ_6RR<=jR;
RLRR6__MxRO.<j=R;R
RRNRO#LC5nL_Mag0d2R
RR(RL_jW$Mg_dRL:RCMoH
RRRRLRR6__MxRO.<4=R;R
RRRRRHLV561_HW2OB
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RCRRMR8
RLRRU(_YU_sC1:DR
RRRRORRN5#CL1c_Y2#O
RRRRLRR4L4_xJX_1(aBO:zR
RRRRRRRR5HVLug_1D$Hg.#N2R
RRRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRRRRRL_4juH1$DGg#w<AR=;R4
RRRRRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRRMRC8DRC#RC
RRRRRRRRRLRRc__M6<QR=;R4
RRRRLRRgx_LX#_4iRnz:R
RRRRRRVRH5_LguH1$DNg#.R2
RRRRRRRRR5HVLMn_zVa_LR2
RRRRRRRRRLRR4uj_1D$Hgw#GA=R<R
4;RRRRRRRRRDRC#LCRCMoH
RRRRRRRRRRRR_LcMQ_6RR<=4R;
RRRRRRRRRLRRnL_Gag0dRR<=L_4d0MEoYBcJzAt_CR;
RRRRRRRRR8CM
RRRRLRR46j_Ik4npTaguRR:LHCoMR
RRRRRRcRL_6M_Q=R<R
4;RRRRRRRRHLV5nz_MaL_V2CRLo
HMRRRRRRRRR4RL41_u$gHD#Xt.u=R<R
4;RRRRRRRRR6RL_xM_O<.R=;R4
RRRRRRRR8CMR#CDCVRH5g!L_$u1H#DgN
.2RRRRRRRRR6RL_xM_O<.R=;R4
RRRRCRRMR8
RRRRR_LU7YDo(BU)RL:RCMoH
RRRRRRRR_LcMQ_6RR<=4R;
RRRRRHRRVn5L_aMz_2VLRoLCHRM
RRRRRRRRR4L4_$u1H#Dgtu.XRR<=4R;
RRRRRRRRR_L6MO_x.=R<R
4;RRRRRRRRCRM8CCD#R5HVLug_1D$Hg.#N2R
RRRRRRRRRLM6__.xORR<=4R;
RRRRR8CM
RRRR8RRCkVND:0R
RRRRRRRRR;
RRRRR8CMOCN#
RRRRdL4_o0EMJYcB_ztA:CRRoLCHRM
RRRRR_LcMQ_6RR<=4R;
RRRRR5HVLMn_zVa_LL2RCMoH
RRRRRRRRjL4_$u1H#DgGRwA<4=R;R
RRRRRR6RL_xM_O<.R=;R4
RRRRRRRR_LnG0Lad<gR=URL_UY(s1C_DR;
RRRRR8CM
RRRR8CM
RRRRV8CN0kDRR:
RRRRRR;
RCRRMN8O#RC
R8CM
R
RNNDI$@#R@F5b#oC8CcRL_KmiNL2RCMoHRL:Rc1_u$RH
RHRRVLR56F_P1ROd|!|RLH6_1BWO2CRLo
HMRRRRR(RL_$u1H#DgRR<=jR;
RRRRR4L4_$u1H#DgGawARR<=jR;
RCRRMC8RDR#CLHCoMR
RRRRRLu(_1D$Hg<#R=4RL41_u$gHD#Xt.uR;
RRRRR4L4_$u1H#DgGawARR<=L_4juH1$DGg#w
A;RRRRRNRO#5CRL1c_Y2#ORR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRR4L4_XLx_aJ1Bz(O:RR
RRRRRLRR(1_u$gHD#=R<R4L4_$u1H#DgGawA;R
RRRRRLLg_x4X_#zin:R
RRRRRR(RL_$u1H#DgRR<=L_44uH1$DGg#w;Aa
RRRR8RRCkVND
0:RRRRRRRR;R
RRRRRCOM8N
#CRRRRC
M8RMRC8M
C88lFk
DC
8lFkRDCLmg_.V$$_.VtR,5HR;F2
HRRM0bkRRrj:9RdR
H;RkRF00bkR
F;
NRR#o#HMRRF=rRHj&9RR4Hr9RR&H9r.RH&Rr;d9
8CMlkF8D
C
lkF8DLCR4B6_)atOB_kNC_]cGLP5ci_mKRN,HF,R2R;
RbHMkL0Rci_mK
N;RMRHbRk0r:jRR9gUR
H;RkRF00bkR
F;RHRIsLCRcO_AW
h;RHRIsrCRjRR:gRU9LBg_ZI1jVlY_;R
RICHsRRrj:gRg94RL6Z_B1VjIY__lwHEV(R;
RsIHCjRrR.:RcL9RgZ_B1VjIY;_M
IRRHRsCr:jRR9.(R6L4_1BZjYIV_wM_E(VH;R
RICHsRRrj:9RnR_LgBjZ1I_VY8R;
RsIHCjRrR(:R94RL6Z_B1VjIY__8wHEV(R;
RsIHCjRrR4:R9gRL_1BZjYIV_
e;RHRIsrCRjRR:dL9R4B6_ZI1jVeY__VwEH
(;RHRIsrCRjRR:4L9R4Bd_ZI1jVeY__gw];R
RsRCor:jRRR49L_4cBjZ1I_VYe]_wg
l;R#RN#MHoR_LgBjZ1I_VYlRR=HR;
R#N#HRoMFRR=LAc_O;Wh
NRR#o#HM4RL6Z_B1VjIY__lwHEV(Rrj:URg9RR=LBg_ZI1jVlY_;R
RNH##oLMR4B6_ZI1jVlY__VwEHg(rgRR:gRg9='R4L
4;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5gR
RRRR53HL_46BjZ1I_VYlE_wVrH(jRR:d,92R53FLBg_ZI1jVMY_r2j92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLN
R5RRRR3LH54B6_ZI1jVlY__VwEHc(rR(:R9R2,3LF5gZ_B1VjIYr_M4292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFjL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(RrU:4R49R2,3LF5gZ_B1VjIYr_M.292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMFQL_RR5
R3RRH45L6Z_B1VjIY__lwHEV(.r4R4:R6,92R53FLBg_ZI1jVMY_r2d92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLU
R5RRRR3LH54B6_ZI1jVlY__VwEH4(rnRR:42g9,FR35_LgBjZ1I_VYM9rc2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_5OR
RRRR53HL_46BjZ1I_VYlE_wVrH(.:jRR9.d23,RFg5L_1BZjYIV_6Mr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__JDFMGLR_15R
RRHR356L4_1BZjYIV_wl_E(VHrR.c:(R.9R2,3LF5gZ_B1VjIYr_Mn292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq Jn__GDMF4L_RR5
R3RRH45L6Z_B1VjIY__lwHEV(Ur.Rd:R4,92R53FLBg_ZI1jVMY_r2(92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nJM_DG_FLw
R5RRRR3LH54B6_ZI1jVlY__VwEHd(r.RR:d269,FR35_LgBjZ1I_VYM9rU2
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _DJ_MLGF_58R
RRRR53HL_46BjZ1I_VYlE_wVrH(d:nRR9dg23,RFg5L_1BZjYIV_gMr9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLn_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(jrcRc:Rd,92R53FLBg_ZI1jVMY_r94j2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RN(5R
RRHR356L4_1BZjYIV_wl_E(VHrRcc:(Rc9R2,3LF5gZ_B1VjIYr_M42492R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5XR
RRRR53HL_46BjZ1I_VYlE_wVrH(c:URR96423,RFg5L_1BZjYIV_4Mr.292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_w
R5RRRR3LH54B6_ZI1jVlY__VwEH6(r.RR:6269,FR35_LgBjZ1I_VYMdr49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGL6_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(nr6R6:Rg,92R53FLBg_ZI1jVMY_r94c2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNg5R
RRHR356L4_1BZjYIV_wl_E(VHrRnj:dRn9R2,3LF5gZ_B1VjIYr_M42692R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLN5uR
RRRR53HL_46BjZ1I_VYlE_wVrH(n:cRR9n(23,RFg5L_1BZjYIV_4Mrn292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFNL_Y
R5RRRR3LH54B6_ZI1jVlY__VwEHn(rURR:(249,FR35_LgBjZ1I_VYM(r49;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLB_NRR5
R3RRH45L6Z_B1VjIY__lwHEV(.r(R(:R6,92R53FLBg_ZI1jVMY_r94U2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_RNN5R
RRHR356L4_1BZjYIV_wl_E(VHrR(n:gR(9R2,3LF5gZ_B1VjIYr_M42g92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj5nR
RRRR53HL_46BjZ1I_VYlE_wVrH(U:jRR9Ud23,RFg5L_1BZjYIV_.Mrj292;R
RLmg_.V$$_.VtRUL._$m.$VV_tv._H4Tq Jn__GDMFjL_(
R5RRRR3LH54B6_ZI1jVlY__VwEHU(rcRR:U2(9,FR35_LgBjZ1I_VYM4r.9;22
LRRg._m$_$VVRt.L_.Um$.$Vt_V.H_vT q4n__JDFMGLX_jRR5
R3RRH45L6Z_B1VjIY__lwHEV(UrURg:R4,92R53FLBg_ZI1jVMY_r9..2
2;RgRL_$m.$VV_tL.R.mU_.V$$_.Vt_TvHqn4 _DJ_MLGF_Rjw5R
RRHR356L4_1BZjYIV_wl_E(VHrRg.:6Rg9R2,3LF5gZ_B1VjIYr_M.2d92R;
R_Lgm$.$Vt_V..RLU._m$_$VV_t.vqHT4_ nJM_DG_FLj56R
RRRR53HL_46BjZ1I_VYlE_wVrH(g:nRR9gg23,RFg5L_1BZjYIV_.Mrc292;R
RNH##oLMR4B6_ZI1jVMY__VwEHj(rR.:Rc=9RR_LgBjZ1I_VYMR;
R#N#HRoML_46BjZ1I_VYME_wVrH(.:6RR9.(Rd=R'4L44R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLg
R5RRRR3LH54B6_ZI1jVMY__VwEHj(rRd:R9R2,3LF5gZ_B1VjIYr_8j292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMFNL_RR5
R3RRH45L6Z_B1VjIY__MwHEV(Rrc:9R(23,RFg5L_1BZjYIV_48r9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_j5R
RRHR356L4_1BZjYIV_wM_E(VHr:URR94423,RFg5L_1BZjYIV_.8r9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__sDFMGLR_Q5R
RRHR356L4_1BZjYIV_wM_E(VHrR4.:6R49R2,3LF5gZ_B1VjIYr_8d292;R
RLmg_.V$$_.VtR(L._$m.$VV_tv._H4Tq sn__GDMFUL_RR5
R3RRH45L6Z_B1VjIY__MwHEV(nr4R4:Rg,92R53FLBg_ZI1jV8Y_r2c92R;
R_Lgm$.$Vt_V..RL(._m$_$VV_t.vqHT4_ nsM_DG_FLO
R5RRRR3LH54B6_ZI1jVMY__VwEH.(rjRR:.2d9,FR35_LgBjZ1I_VY89r62
2;RgRL_$m.$VV_tL.R.m(_.V$$_.Vt_TvHqn4 _Ds_MLGF_51R
RRRR53HL_46BjZ1I_VYME_wVrH(.:cRR9.(23,RFg5L_1BZjYIV_n8r9;22
NRR#o#HM4RL6Z_B1VjIY__8wHEV(Rrj:9RnRL=RgZ_B1VjIY;_8
NRR#o#HM4RL6Z_B1VjIY__8wHEV(Rr(:9R(R4=R';L4
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__EDFMGLR_g5R
RRHR356L4_1BZjYIV_w8_E(VHr:jRR2d9,FR35dL4_1BZjYIV_we_]jgr9;22
LRRg._m$_$VVRt.L_.(m$.$Vt_V.H_vT q4n__EDFMGLR_N5R
RRHR356L4_1BZjYIV_w8_E(VHr:cRR2(9,FR35dL4_1BZjYIV_we_]4gr9;22
NRRD$IN#@R@5#bFCC8oR_LcmNiK2CRLo
HMRRRRL_4cBjZ1I_VYe]_wg<lR=4RLdZ_B1VjIY__ew;]g
CRRMR8
R#N#HRoMLBg_ZI1jVeY_RL=R4Bc_ZI1jVeY__gw]lR;
R#N#HRoML_46BjZ1I_VYeE_wVrH(jRR:4=9RR_LgBjZ1I_VYeR;
R#N#HRoML_46BjZ1I_VYeE_wVrH(.RR:d=9RRL.'4
4;RgRL_$m.$VV_tL.R.m6_.V$$_.Vt_TvHqn4 _DZ_MLGF5R
RRHR356L4_1BZjYIV_we_E(VH23,RFc5L_WAOh;22
8CMlkF8D
C
lkF8DLCR4u4_1D$HgV#4	
a5RcRL_KmiNR,
R_L([_W1d,PW
LRR6i_ud,Op
LRRdp_u$R,
R_Ldu,pw
LRR6P_m$,]d
LRRnZ_.#J0d,R
RLP6_Fd1O,R
RLH6_1BWO,R
RLu(_1D$Hg
#,R4RLjY_MWghahpIL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L6uOidpR;
RbHMkL0Rdp_u$R;
R0FkbRk0Lud_p
w;RMRHbRk0Lm6_Pd$];R
RHkMb0jRrR4:RgRn9L.n_Zd#0JR;
RbHMkL0R6F_P1;Od
HRRM0bkR_L6HO1WBR;
R0FkbRk0Lu(_1D$Hg
#;RkRF00bkRgr.Rj:R94RLjY_MWghahpIL;R
RICHsR_L(m]P$d;gk
IRRHRsCr:4RR9ggR_L6Mtwx0R;
RsIHCjRrRg:RgL9Rnw_Mxwt0;R
RsRCoRRr4:gRg9gRL_tuV$#I7F
L;RHRIsLCR(z_kaBjKcR;
RosCRdRr4RR:jL9RnF_$s7ju;R
RICHsRdRr4RR:4L9R(F_$s7jukR;
RsIHCjRrR.:RgL9Rgz_Maw$u0;7p
IRRHRsCr:jRRR49LM(_zuadI
Y;RHRIsLCR(z_MaBjKcR;
RsIHCgRL_a.ZtcQVN
g;RHRIsrCRjRR:49g(RjL4_#.Z0	dJN;UA
IRRHRsCr:jRR(4g94RL.Z_.qJ]BvXs4 
D;RCRsorRRjRR:49gnR4L4_q.Z]sAgmEgX;R
RICHsRRrj:URg9nRL_a.Zt;QV
NRR#o#HM(RL_$mP]kdgRL=R6P_m$R]d&6RL_duiO
p;R#RN#MHoR_LnMtwx0jwr9RR=Lud_p
$;R#RN#MHoRjL4_#.Z0	dJNrUAjRR:49gnRL=RnZ_.#J0d;R
RNH##oLMR4.._ZBq]J4vsXr DjRR:49gnRL=R4.4_ZAq]ggsmX
E;R#RN#MHoRjL4_#.Z0	dJNrUA4Rg(:gR4U4R-9RR=';Lj
NRR#o#HM4RL.Z_.qJ]BvXs4 4Drg:(RRU4gR9-4R'=RL
j;RDRNI#N$R5@@bCF#8RoCLmc_i2KN
RRRR4L4_q.Z]sAgmEgXRL=RnZ_.#J0d;R

R_L(em(4KRJxL4U_poLOiR_)5R
RRLR3d)_FARjR5_LnMtwx0jwr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA9r42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD9r42R,
R3RRLFc_YREj5_Ln.tZaQjVr9
2,RRRR3_LcmjYEjLR56w_Mxrt04R922
;
R(RL_4e(mxKJR_LU4OpLo1i_RR5
R3RRLFd_)RAjRn5L_xMwtr0w4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr9
2,RRRR3_LcFjYERn5L_a.ZtrQV4,92
RRRRc3L_EmYj5jRLM6_w0xtr2.9R
2;
LRR((_e4JmKxURL_L4pO_oiQ
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA9rc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD9rc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6,92
RRRRc3L_EFYjLR5nZ_.aVtQr2.9,R
RRLR3cY_mERjj5_L6Mtwx09rd2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5JR
RRRRd3L_AF)j5RRLMn_w0xtw9rd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDr9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r2(9,R
RRLR3cY_FE5jRL.n_ZQatV9rd2R,
R3RRLmc_YjEjR65L_xMwtc0r922R;R

R_L(em(4KRJxL4U_poLOij_TRR5
R3RRLFd_)RAjRn5L_xMwtr0wc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 gDr9
2,RRRR3_LcFjYERn5L_a.ZtrQVc,92
RRRRc3L_EmYj5jRLM6_w0xtr269R
2;
LRR((_e4JmKxURL_L4pO_oiz
R5RRRR3_LdFj)ARLR5nw_Mxwt0r269,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr269,R
RRLR3cY_mERjj5_L6Mtwx09rn2;R2
R
RLe(_(K4mJLxRUp_4LiOo_5qR
RRRRd3L_AF)j5RRLMn_w0xtw9rn2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D42.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D42d9,R
RRLR3cY_FE5jRL.n_ZQatV9rn2R,
R3RRLmc_YjEjR65L_xMwt(0r922R;R

R_L(em(4KRJxL4U_poLOiR_K5R
RRLR3d)_FARjR5_LnMtwx0(wr9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r94c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA4269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9462R,
R3RRLFc_YREj5_Ln.tZaQ(Vr9
2,RRRR3_LcmjYEjLR56w_Mxrt0UR922
;
R(RL_4e(mxKJR_LU4OpLoMi_RR5
R3RRLFd_)RAjRn5L_xMwtr0wU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr94n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr49
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr94(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r49
2,RRRR3_LcFjYERn5L_a.ZtrQVU,92
RRRRc3L_EmYj5jRLM6_w0xtr2g9R
2;
LRR((_e4JmKxURL_L4pO_oie
R5RRRR3_LdFj)ARLR5nw_Mxwt0r2g9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr49
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr49
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr2g9,R
RRLR3cY_mERjj5_L6Mtwx0jr4922R;R

R_L(em(4KRJxL4g_poLOil_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .Drj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Dr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr94j2R,
R3RRLmc_YjEjR65L_xMwt40r4R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9442R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U.Ar.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D.2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U.Ard,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4r49
2,RRRR3_LcmjYEjLR56w_Mxrt042.9R
2;
LRR((_e4JmKxgRL_L4pO_oi158R
RRRRd3L_AF)j5RRLMn_w0xtw.r49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA.2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9.c2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA.269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9.62R,
R3RRLFc_YREj5_Ln.tZaQ4Vr.,92
RRRRc3L_EmYj5jRLM6_w0xtr94d2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1e5R
RRLR3d)_FARjR5_LnMtwx04wrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9.n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9.(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r.9
2,RRRR3_LcFjYERn5L_a.ZtrQV42d9,R
RRLR3cY_mERjj5_L6Mtwx0cr4922R;R

R_L(em(4KRJxL4g_poLOiD_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 .DrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 .Drg,92
RRRRc3L_EFYjLR5nZ_.aVtQr94c2R,
R3RRLmc_YjEjR65L_xMwt40r6R922
;
R(RL_4e(mxKJR_Lg4OpLo1i_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9462R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd249,R
RRLR3cY_FE5jRL.n_ZQatV6r49
2,RRRR3_LcmjYEjLR56w_Mxrt042n9R
2;
LRR((_e4JmKxgRL_L4pO_oi156R
RRRRd3L_AF)j5RRLMn_w0xtwnr49
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAd2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9d.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAd2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9dd2R,
R3RRLFc_YREj5_Ln.tZaQ4Vrn,92
RRRRc3L_EmYj5jRLM6_w0xtr94(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_R1C5R
RRLR3d)_FARjR5_LnMtwx04wr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9dc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrd9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9d62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rd9
2,RRRR3_LcFjYERn5L_a.ZtrQV42(9,R
RRLR3cY_mERjj5_L6Mtwx0Ur4922R;R

R_L(em(4KRJxL4g_poLOi1_1RR5
R3RRLFd_)RAjRn5L_xMwtr0w42U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnrd9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 dDrn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(rd9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 dDr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr94U2R,
R3RRLmc_YjEjR65L_xMwt40rgR922
;
R(RL_4e(mxKJR_Lg4OpLo1i_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r94g2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UdArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dd2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UdArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgr49
2,RRRR3_LcmjYEjLR56w_Mxrt0.2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9c42R,
R3RRLFc_YREj5_Ln.tZaQ.Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9.42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQM5R
RRLR3d)_FARjR5_LnMtwx0.wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9c.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rc9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9cd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrc9
2,RRRR3_LcFjYERn5L_a.ZtrQV.249,R
RRLR3cY_mERjj5_L6Mtwx0.r.922R;R

R_L(em(4KRJxL4g_poLOi8_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcrc9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 cDrc,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6rc9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 cDr6,92
RRRRc3L_EFYjLR5nZ_.aVtQr9..2R,
R3RRLmc_YjEjR65L_xMwt.0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoQi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UcArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dc2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UcAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAc2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9cU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAc2g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9cg2R,
R3RRLFc_YREj5_Ln.tZaQ.Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9.62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQb5R
RRLR3d)_FARjR5_LnMtwx0.wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96j2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9642R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r69
2,RRRR3_LcFjYERn5L_a.ZtrQV.269,R
RRLR3cY_mERjj5_L6Mtwx0nr.922R;R

R_L(em(4KRJxL4g_poLOi6_QRR5
R3RRLFd_)RAjRn5L_xMwtr0w.2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r69
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 6Dr.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr69
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 6Drd,92
RRRRc3L_EFYjLR5nZ_.aVtQr9.n2R,
R3RRLmc_YjEjR65L_xMwt.0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoQi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9.(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U6Arc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D62c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U6Ar6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D6269,R
RRLR3cY_FE5jRL.n_ZQatV(r.9
2,RRRR3_LcmjYEjLR56w_Mxrt0.2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiQ51R
RRRRd3L_AF)j5RRLMn_w0xtwUr.9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA62n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r96n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA62(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r96(2R,
R3RRLFc_YREj5_Ln.tZaQ.VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9.g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RQJ5R
RRLR3d)_FARjR5_LnMtwx0.wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr96U2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr69
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr96g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr69
2,RRRR3_LcFjYERn5L_a.ZtrQV.2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrd922R;R

R_L(em(4KRJxL4g_poLOil_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrj,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4rn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDr4,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dj2R,
R3RRLmc_YjEjR65L_xMwtd0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UnAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dn2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UnArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ58R
RRRRd3L_AF)j5RRLMn_w0xtw.rd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUAn2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9nc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUAn269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9n62R,
R3RRLFc_YREj5_Ln.tZaQdVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9dd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJe5R
RRLR3d)_FARjR5_LnMtwx0dwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9nn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrn9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9n(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rn9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2d9,R
RRLR3cY_mERjj5_L6Mtwx0crd922R;R

R_L(em(4KRJxL4g_poLOiD_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUrn9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 nDrU,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgrn9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 nDrg,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dc2R,
R3RRLmc_YjEjR65L_xMwtd0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoJi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9d62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(Arj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Ar4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(249,R
RRLR3cY_FE5jRL.n_ZQatV6rd9
2,RRRR3_LcmjYEjLR56w_Mxrt0d2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiJ56R
RRRRd3L_AF)j5RRLMn_w0xtwnrd9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA(2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r9(.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA(2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r9(d2R,
R3RRLFc_YREj5_Ln.tZaQdVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9d(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RJC5R
RRLR3d)_FARjR5_LnMtwx0dwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9(c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9(62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r(9
2,RRRR3_LcFjYERn5L_a.ZtrQVd2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urd922R;R

R_L(em(4KRJxL4g_poLOi1_JRR5
R3RRLFd_)RAjRn5L_xMwtr0wd2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 (Drn,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 (Dr(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9dU2R,
R3RRLmc_YjEjR65L_xMwtd0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoJi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9dg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U(ArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D(2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U(Arg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrd9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRlj5R
RRLR3d)_FARjR5_LnMtwx0cwrj,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2j9,R
RRLR3cY_mERjj5_L6Mtwx04rc922R;R

R_L(em(4KRJxL4g_poLOiM_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUAr.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUArd,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR8j5R
RRLR3d)_FARjR5_LnMtwx0cwr.,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9Uc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6rU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2.9,R
RRLR3cY_mERjj5_L6Mtwx0drc922R;R

R_L(em(4KRJxL4g_poLOie_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UUArn,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr DU2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UUAr(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr DU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiTRDj5R
RRLR3d)_FARjR5_LnMtwx0cwrc,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUrU9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9Ug2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgrU9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2c9,R
RRLR3cY_mERjj5_L6Mtwx06rc922R;R

R_L(em(4KRJxL4g_poLOib_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArj,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr4,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg249,R
RRLR3cY_FE5jRL.n_ZQatV6rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR6j5R
RRLR3d)_FARjR5_LnMtwx0cwrn,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9g.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.rg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdrg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2n9,R
RRLR3cY_mERjj5_L6Mtwx0(rc922R;R

R_L(em(4KRJxL4g_poLOiC_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9c(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArc,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgAr6,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg269,R
RRLR3cY_FE5jRL.n_ZQatV(rc9
2,RRRR3_LcmjYEjLR56w_Mxrt0c2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiTR1j5R
RRLR3d)_FARjR5_LnMtwx0cwrU,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr9gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnrg9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr9g(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(rg9
2,RRRR3_LcFjYERn5L_a.ZtrQVc2U9,R
RRLR3cY_mERjj5_L6Mtwx0grc922R;R

R_L(em(4KRJxL4g_poLOiJ_Tj
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9cg2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	UgArU,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr Dg2U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	UgArg,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr Dg2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrc9
2,RRRR3_LcmjYEjLR56w_Mxrt062j9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49j42R,
R3RRLFc_YREj5_Ln.tZaQ6Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9642;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzM5R
RRLR3d)_FARjR5_LnMtwx06wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4j9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drj2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arj2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4j9
2,RRRR3_LcFjYERn5L_a.ZtrQV6249,R
RRLR3cY_mERjj5_L6Mtwx0.r6922R;R

R_L(em(4KRJxL4g_poLOi8_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAjr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49jc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49j62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDjr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr96.2R,
R3RRLmc_YjEjR65L_xMwt60rdR922
;
R(RL_4e(mxKJR_Lg4OpLozi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arj2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4j9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4j9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drj2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr69
2,RRRR3_LcmjYEjLR56w_Mxrt062c9R
2;
LRR((_e4JmKxgRL_L4pO_oiz5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49jU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDjr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAjr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49jg2R,
R3RRLFc_YREj5_Ln.tZaQ6Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9662;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rzb5R
RRLR3d)_FARjR5_LnMtwx06wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar4249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4449
2,RRRR3_LcFjYERn5L_a.ZtrQV6269,R
RRLR3cY_mERjj5_L6Mtwx0nr6922R;R

R_L(em(4KRJxL4g_poLOi6_zRR5
R3RRLFd_)RAjRn5L_xMwtr0w62n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA4r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D494.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA494d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD4r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr96n2R,
R3RRLmc_YjEjR65L_xMwt60r(R922
;
R(RL_4e(mxKJR_Lg4OpLozi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r96(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar42c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc449
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6449
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr4269,R
RRLR3cY_FE5jRL.n_ZQatV(r69
2,RRRR3_LcmjYEjLR56w_Mxrt062U9R
2;
LRR((_e4JmKxgRL_L4pO_oiz51R
RRRRd3L_AF)j5RRLMn_w0xtwUr69
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA494n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD4r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA4r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D494(2R,
R3RRLFc_YREj5_Ln.tZaQ6VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr96g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RzJ5R
RRLR3d)_FARjR5_LnMtwx06wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU449
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr42U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar42g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg449
2,RRRR3_LcFjYERn5L_a.ZtrQV62g9,R
RRLR3cY_mERjj5_L6Mtwx0jrn922R;R

R_L(em(4KRJxL4g_poLOil_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.j2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nj2R,
R3RRLmc_YjEjR65L_xMwtn0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar.2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4.9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4.9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr.2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiq58R
RRRRd3L_AF)j5RRLMn_w0xtw.rn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49.c2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD.r4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA.r46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49.62R,
R3RRLFc_YREj5_Ln.tZaQnVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9nd2;R2
R
RLe(_(K4mJLxRgp_4LiOo_Rqe5R
RRLR3d)_FARjR5_LnMtwx0nwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4.9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr.2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar.2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4.9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2d9,R
RRLR3cY_mERjj5_L6Mtwx0crn922R;R

R_L(em(4KRJxL4g_poLOiD_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA.r4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49.U2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49.g2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD.r4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nc2R,
R3RRLmc_YjEjR65L_xMwtn0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoqi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9n62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd249,R
RRLR3cY_FE5jRL.n_ZQatV6rn9
2,RRRR3_LcmjYEjLR56w_Mxrt0n2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiq56R
RRRRd3L_AF)j5RRLMn_w0xtwnrn9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49d.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDdr4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAdr4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49dd2R,
R3RRLFc_YREj5_Ln.tZaQnVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9n(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RqC5R
RRLR3d)_FARjR5_LnMtwx0nwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4d9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drd2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ard269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64d9
2,RRRR3_LcFjYERn5L_a.ZtrQVn2(9,R
RRLR3cY_mERjj5_L6Mtwx0Urn922R;R

R_L(em(4KRJxL4g_poLOi1_qRR5
R3RRLFd_)RAjRn5L_xMwtr0wn2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAdr4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49dn2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49d(2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDdr4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9nU2R,
R3RRLmc_YjEjR65L_xMwtn0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoqi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9ng2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ard2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4d9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4d9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drd2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrn9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2j9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5lR
RRRRd3L_AF)j5RRLMn_w0xtwjr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49c42R,
R3RRLFc_YREj5_Ln.tZaQ(Vrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9(42;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKM5R
RRLR3d)_FARjR5_LnMtwx0(wr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4c9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drc2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arc2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4c9
2,RRRR3_LcFjYERn5L_a.ZtrQV(249,R
RRLR3cY_mERjj5_L6Mtwx0.r(922R;R

R_L(em(4KRJxL4g_poLOi8_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAcr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49cc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49c62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDcr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(.2R,
R3RRLmc_YjEjR65L_xMwt(0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoKi_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9(d2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arc2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4c9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4c9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drc2(9,R
RRLR3cY_FE5jRL.n_ZQatVdr(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2c9R
2;
LRR((_e4JmKxgRL_L4pO_oiK5DR
RRRRd3L_AF)j5RRLMn_w0xtwcr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49cU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDcr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAcr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49cg2R,
R3RRLFc_YREj5_Ln.tZaQ(Vrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9(62;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKb5R
RRLR3d)_FARjR5_LnMtwx0(wr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar6249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r4469
2,RRRR3_LcFjYERn5L_a.ZtrQV(269,R
RRLR3cY_mERjj5_L6Mtwx0nr(922R;R

R_L(em(4KRJxL4g_poLOi6_KRR5
R3RRLFd_)RAjRn5L_xMwtr0w(2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA6r4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D496.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA496d2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD6r4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9(n2R,
R3RRLmc_YjEjR65L_xMwt(0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoKi_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9((2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar62c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc469
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr6469
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr6269,R
RRLR3cY_FE5jRL.n_ZQatV(r(9
2,RRRR3_LcmjYEjLR56w_Mxrt0(2U9R
2;
LRR((_e4JmKxgRL_L4pO_oiK51R
RRRRd3L_AF)j5RRLMn_w0xtwUr(9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA496n2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD6r4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA6r4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D496(2R,
R3RRLFc_YREj5_Ln.tZaQ(VrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9(g2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RKJ5R
RRLR3d)_FARjR5_LnMtwx0(wrg,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrU469
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr62U9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar62g9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rg469
2,RRRR3_LcFjYERn5L_a.ZtrQV(2g9,R
RRLR3cY_mERjj5_L6Mtwx0jrU922R;R

R_L(em(4KRJxL4g_poLOil_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2j9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4j,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nj2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49n42R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr44,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uj2R,
R3RRLmc_YjEjR65L_xMwtU0r4R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_M
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U42R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arn2.9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX r.4n9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrd4n9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drn2d9,R
RRLR3cY_FE5jRL.n_ZQatV4rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2.9R
2;
LRR((_e4JmKxgRL_L4pO_oiM58R
RRRRd3L_AF)j5RRLMn_w0xtw.rU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49nc2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDnr4c,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAnr46,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49n62R,
R3RRLFc_YREj5_Ln.tZaQUVr.,92
RRRRc3L_EmYj5jRLM6_w0xtr9Ud2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMe5R
RRLR3d)_FARjR5_LnMtwx0Uwrd,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrn4n9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drn2n9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arn2(9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r(4n9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2d9,R
RRLR3cY_mERjj5_L6Mtwx0crU922R;R

R_L(em(4KRJxL4g_poLOiD_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2c9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAnr4U,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49nU2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49ng2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDnr4g,92
RRRRc3L_EFYjLR5nZ_.aVtQr9Uc2R,
R3RRLmc_YjEjR65L_xMwtU0r6R922
;
R(RL_4e(mxKJR_Lg4OpLoMi_b
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9U62R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2j9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rj4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr44(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(249,R
RRLR3cY_FE5jRL.n_ZQatV6rU9
2,RRRR3_LcmjYEjLR56w_Mxrt0U2n9R
2;
LRR((_e4JmKxgRL_L4pO_oiM56R
RRRRd3L_AF)j5RRLMn_w0xtwnrU9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49(.2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XD(r4.,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NA(r4d,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49(d2R,
R3RRLFc_YREj5_Ln.tZaQUVrn,92
RRRRc3L_EmYj5jRLM6_w0xtr9U(2;R2
R
RLe(_(K4mJLxRgp_4LiOo_RMC5R
RRLR3d)_FARjR5_LnMtwx0Uwr(,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrc4(9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Dr(2c9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Ar(269,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r64(9
2,RRRR3_LcFjYERn5L_a.ZtrQVU2(9,R
RRLR3cY_mERjj5_L6Mtwx0UrU922R;R

R_L(em(4KRJxL4g_poLOi1_MRR5
R3RRLFd_)RAjRn5L_xMwtr0wU2U9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NA(r4n,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49(n2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49((2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XD(r4(,92
RRRRc3L_EFYjLR5nZ_.aVtQr9UU2R,
R3RRLmc_YjEjR65L_xMwtU0rgR922
;
R(RL_4e(mxKJR_Lg4OpLoMi_J
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9Ug2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Ar(2U9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rU4(9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUrg4(9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Dr(2g9,R
RRLR3cY_FE5jRL.n_ZQatVgrU9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2j9R
2;
LRR((_e4JmKxgRL_L4pO_oie5lR
RRRRd3L_AF)j5RRLMn_w0xtwjrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49Uj2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4j,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr44,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49U42R,
R3RRLFc_YREj5_Ln.tZaQgVrj,92
RRRRc3L_EmYj5jRLM6_w0xtr9g42;R2
R
RLe(_(K4mJLxRgp_4LiOo_ReM5R
RRLR3d)_FARjR5_LnMtwx0gwr4,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUr.4U9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4DrU2.9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4ArU2d9,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX rd4U9
2,RRRR3_LcFjYERn5L_a.ZtrQVg249,R
RRLR3cY_mERjj5_L6Mtwx0.rg922R;R

R_L(em(4KRJxL4g_poLOi8_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2.9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAUr4c,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49Uc2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49U62R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDUr46,92
RRRRc3L_EFYjLR5nZ_.aVtQr9g.2R,
R3RRLmc_YjEjR65L_xMwtg0rdR922
;
R(RL_4e(mxKJR_Lg4OpLoei_e
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9gd2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4ArU2n9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rn4U9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr(4U9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4DrU2(9,R
RRLR3cY_FE5jRL.n_ZQatVdrg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2c9R
2;
LRR((_e4JmKxgRL_L4pO_oie5DR
RRRRd3L_AF)j5RRLMn_w0xtwcrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49UU2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDUr4U,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAUr4g,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49Ug2R,
R3RRLFc_YREj5_Ln.tZaQgVrc,92
RRRRc3L_EmYj5jRLM6_w0xtr9g62;R2
R
RLe(_(K4mJLxRgp_4LiOo_Reb5R
RRLR3d)_FARjR5_LnMtwx0gwr6,92
RRRRd3L_AmFRLR5(P_m$g]dk
2,RRRR3_LcmNiKRLR5(W_[1P_dW
2,RRRR3_L.HR6RR45LjZ_.#J0d	ANUrj4g9
2,RRRR3_L.HRnRR45L.Z_.qJ]BvXs4 4Drg2j9,R
RRLR3.W_HR5RRL_4j.0Z#dNJ	U4Arg249,R
RRLR3. _HR5RRL_4..]ZqBsJv4DX r44g9
2,RRRR3_LcFjYERn5L_a.ZtrQVg269,R
RRLR3cY_mERjj5_L6Mtwx0nrg922R;R

R_L(em(4KRJxL4g_poLOi6_eRR5
R3RRLFd_)RAjRn5L_xMwtr0wg2n9,R
RRLR3dF_mA5RRLm(_Pd$]g,k2
RRRRc3L_KmiN5RRL[(_Wd1_P,W2
RRRR.3L_RH6RLR54.j_Zd#0JU	NAgr4.,92
RRRR.3L_RHnRLR54.._ZBq]J4vsXr D49g.2R,
R3RRLH._WRRR5jL4_#.Z0	dJNrUA49gd2R,
R3RRLH._ RRR5.L4_q.Z]vBJs 4XDgr4d,92
RRRRc3L_EFYjLR5nZ_.aVtQr9gn2R,
R3RRLmc_YjEjR65L_xMwtg0r(R922
;
R(RL_4e(mxKJR_Lg4OpLoei_C
R5RRRR3_LdFj)ARLR5nw_Mxwt0r9g(2R,
R3RRLmd_FRAR5_L(m]P$d2gk,R
RRLR3ci_mKRNR5_L([_W1d2PW,R
RRLR3.6_HR5RRL_4j.0Z#dNJ	U4Arg2c9,R
RRLR3.n_HR5RRL_4..]ZqBsJv4DX rc4g9
2,RRRR3_L.HRWRR45LjZ_.#J0d	ANUr64g9
2,RRRR3_L.HR RR45L.Z_.qJ]BvXs4 4Drg269,R
RRLR3cY_FE5jRL.n_ZQatV(rg9
2,RRRR3_LcmjYEjLR56w_Mxrt0g2U9R
2;
LRR((_e4JmKxgRL_L4pO_oie51R
RRRRd3L_AF)j5RRLMn_w0xtwUrg9
2,RRRR3_LdmRFAR(5L_$mP]kdg2R,
R3RRLmc_iRKNR(5L_1[W_WdP2R,
R3RRLH._6RRR5jL4_#.Z0	dJNrUA49gn2R,
R3RRLH._nRRR5.L4_q.Z]vBJs 4XDgr4n,92
RRRR.3L_RHWRLR54.j_Zd#0JU	NAgr4(,92
RRRR.3L_RH RLR54.._ZBq]J4vsXr D49g(2R,
R3RRLFc_YREj5_Ln.tZaQgVrU,92
RRRRc3L_EmYj5jRLM6_w0xtr9gg2;R2
R
RL_46BO)taNBk_cC]_RGPL.n_ZTtwg
R5RRRR3_LcmNiK5_LcmNiK23,RHn5L_a.Zt2QV,FR35_Lg.tZaQNVcg;22
NRR#o#HM(RL_akzjcKBRL=RgZ_.aVtQc;Ng
NRRD$IN#@R@5oMCCC8oR_L([_W1d2PW
RRRRLRRgV_ut7$I#RFL=6RL_xMwt
0;R#RN#MHoR_LnMtwx04wrRg:Rg=9RR_Lgu$VtIF7#L
;
R4RLjY_MWghahpILRdy5jL2Rci_MA5jR
RRRRc3L_KmiNc5L_KmiN
2,RRRR3_L6POF1d65L_1PFO,d2
RRRR(3L_$u1Hk_B5_L(kjzaK2Bc,R
RRLR361_HW5OBLH6_1BWO2R,
R3RRL1c_Y5#OLM(_zuadI,Y2
RRRR(3L_WMYhYI75_LgM$zau7w0p
2,RRRR3_L(uH1$D5g#LM(_zKajB,c2
RRRR43LjY_MWghahpIL5jL4_WMYhhagI2Lp2
;
R#RN#MHoR_L(uH1$DRg#=(RL_aMzjcKB;R

R#N#HRoMLMg_zua$wp07RL=RnF_$s7jurRd4:9R.;R
RNH##oLMR(z_MaIduYRRR=nRL_s$Fjru74RR:j
9;R#RN#MHoR_LduRpw=nRL_s$Fjru7j
9;RDRNI#N$R5@@bCF#8RoCL[(_Wd1_P
W2RRRRH5VRLu6_ipdORL&R6P_m$2]d
RRRRLRRnF_$s7juR{=RLMn_w0xtwgrg9L,R(F_$s7juk
};
NRR#o#HM(RL_s$Fjku7RL=RnF_$s7jurRd4:9R4;C

MF8l8CkD
F
l8CkDR_L(uxVws5hY
LRRci_mK
N,R6RL_1PFO
d,R6RL_WH1O
B,RgRL_$1p$s_ht
7,R(RL_$u1H#Dg,R
RL[(_Wd1_P
W,R(RL_KuiNk_g,R
RLud_p
$,R6RL_$mP]
d,RdRL_wup,R
RL_4jMhYWaIghL;p2
R
RHkMb0cRL_KmiNR;
RbHMkL0R6F_P1;Od
HRRM0bkR_L6HO1WBR;
RbHMkr0Rjg:4(L9Rgp_1$h$_s;t7
FRRkk0b0(RL_$u1H#Dg;R
RHkMb0(RL_1[W_WdP;R
RHkMb0(RL_KuiNk_g;R
RHkMb0dRL_$up;R
RHkMb06RL_$mP]
d;RkRF00bkR_Ldu;pw
FRRkk0b0.RrgRR:jL9R4Mj_YaWhgLhIpR;
RsIHC4RrR4:R9URL_$u1H#DgXR;
RsIHC4RrR4:R94RL4z_kaBjKcsowYR;
RsIHC.RrR4:R96RL_xMwt
0;RHRIsrCR.RR:4L9Rnw_Mxwt0;R
RICHsRRrj:gR4nL9R(Z_.#J0dtR;
RsIHC6RL_WH1O
B;
NRR#o#HM(RL_#.Z0tdJR{=RL1g_p_$$h7strjj:9L,Rgp_1$h$_srt749:4,gRL_$1p$s_ht.7r:,.9R_Lg1$p$_ths7:rdd,c9R_Lg1$p$_ths76rd:9nn,gRL_$1p$s_htn7r(g:n9
,RRRRRRRRRRRRRR_Lg1$p$_ths7jr(:9(.,gRL_$1p$s_ht(7rdn:(9L,Rgp_1$h$_srt7(U(:jR9,L1g_p_$$h7str:U4494.,gRL_$1p$s_ht47r44d:c,c9R_Lg1$p$_ths7cr46c:46R9,
RRRRRRRRRRRRgRL_$1p$s_ht47rc4n:c,n9R_Lg1$p$_ths7cr4(c:4UR9,L1g_p_$$h7strg4c:j469L,Rgp_1$h$_srt74:644964,gRL_$1p$s_ht47r64.:6,.9R_Lg1$p$_ths76r4d6:46R9,
RRRRRRRRRRRRgRL_$1p$s_ht47r64n:6,U9R_Lg1$p$_ths76r4gn:4jR9,L1g_p_$$h7str44n:.4n9L,Rgp_1$h$_srt74:nd49gc,gRL_$1p$s_ht47rg46:g,69R_Lg1$p$_ths7gr4ng:4n;9}
NRR#o#HMURL_$u1H#DgX9r4RL=R4k4_zKajBwcos4Yr9R;
R#N#HRoMLu(_1D$Hg=#RR_LUuH1$DXg#r;49
R
RNH##oLMRnw_Mxwt0rR49=dRL_$up;R
RNH##oLMRdp_uwRR=LM6_w0xtr;49
R
RL_44uH1$D4g#VR	aLu(_LDa0g5tR
RRRRc3L_KmiNLR5ci_mK,N2
RRRR(3L_1[W_WdPR(5L_1[W_WdP2R,
R3RRLu6_ipdOR(5L_KuiNk_g2R,
R3RRLud_p5$RLMn_w0xtw9r42R,
R3RRLud_p5wRLM6_w0xtr249,R
RRLR36P_m$R]d5_L6m]P$d
2,RRRR3_Ln.0Z#d5JRL.(_Zd#0J,t2
RRRR63L_1PFO5dRLP6_Fd1O2R,
R3RRLH6_1BWOR65L_WH1O,B2
RRRR(3L_$u1H#DgR45L4z_kaBjKcsowY9r42R,
R3RRL_4jMhYWaIghL5pRL_4jMhYWaIghL2p2;C

MF8l8CkD
F
l8CkDR_L(m$BAp5XBR_LcmNiK,(RL_$u1H#Dg,(RL_1[W_WdP,6RL_$mP]Rd,L8n_Zd#0gL,Rdp_u$L,RnV_M#w_V,4RLc8_4aIOp_ApVuH_d,4RLjY_MEgQd#0_w,4RL4q_PAJZd#XY_]L,R4k4_).sOX_VYXR],LH6_1BWO,gRL_Wmwh_agNRL,L_4.POF1dl_oNL#L,(RL_tMwjYs7,(RL_#MV_$dI,(RL_aMz_$dI,4RL.q_PAJZd#pY_$RE,L_4.kO)s.YXV_Ep$,4RL4z_MaJZdv	_0p;R2
bRRNlsNCs0CR_L(MZzaQRkY=;R4
bRRNlsNCs0CRdL4_lmOjaV_	nqU =ZRRLc'jjjj;R
RbNNslCC0s4RLdO_ml_jVqU(qnR)P='RcLjjj4R;
RsbNN0lCCLsR4md_OVlj_u]H(Pn)Rc=R'jLj4
j;RNRbsCNl0RCsL_4dmjOlV6_bA)anPRR=cj'Lj;44
bRRNlsNCs0CR.L4_lmOjTV_(JAUtRR=cj'L4;jj
bRRNlsNCs0CR(L4_lmOjaV_	zTOJeLTh=6RRLc'444j;R
RbNNslCC0sURL_chs_HgcbRR=6
;
RNRbsCNl0RCsLhU_sNc_URzbR6=R'jLjj;jj
bRRNlsNCs0CR_L(h_scYREURRR=6j'Lj4jj;R
RbNNslCC0sgRL_chs_1YFb=TRRL6'j4jjjR;
RsbNN0lCCLsR(s_hc[_NgRRR='R6L444j
4;RNRbsCNl0RCsL_..h_scY_EUi76UYh8w6P_Nh=KRRL6'jjj4jR;
RsbNN0lCCLsR.h._sYc_EiU_6YU786wh_. iIRR=6j'L4jjj;R
RbNNslCC0s4RL(s_hcE_YUa_Bht l_Rso='R6Lj4jj
j;
bRRNlsNCs0CR_LgeMx._ncXzRRR='R6Ljjjj
j;RNRbsCNl0RCsLeg_x_.MmYncR=RRRL6'jjjj4R;
RsbNN0lCCLsR4e4_x_.M4TenO=NRRL6'j4jjjR;
RsbNN0lCCLsRgx_e.qM_aRnARRR=6j'Ljj4j;R
RbNNslCC0sURL_.exMU_cDRRRR6=R'4Ljj;jj
R
RbNNslCC0s4RLj(_OjF ]]bnBRRR=4Lc'jjjjjjjjj4jjj
j;
HRRM0bkR_LcmNiK;R
RHkMb0(RL_$u1H#Dg;R
RHkMb0(RL_1[W_WdP;R
RHkMb06RL_$mP]
d;RMRHbRk0L8n_Zd#0gR;
RbHMkL0Rdp_u$R;
RbHMkL0RnV_M#w_V;R
RHkMb04RLc8_4aIOp_ApVuH_d;R
RHkMb04RLjY_MEgQd#0_w;R
RHkMb04RL4q_PAJZd#XY_]R;
RbHMkL0R4k4_).sOX_VYX
];RMRHbRk0LM(_wstj7
Y;RMRHbRk0L_44MZzad_Jv0;	p
FRRkk0b06RL_WH1O
B;RkRF00bkR_LgmhwWaNg_LR;
R0FkbRk0L_4.POF1dl_oNL#L;R
RFbk0kL0R(V_M#I_d$R;
R0FkbRk0LM(_zda_I
$;RkRF00bkR.L4_APqZ#dJY$_pER;
R0FkbRk0L_4.kO)s.YXV_Ep$;R

RosCR_LgmhwWaNg_LR;
RosCRUrL_chs_Hgcb:-4jL9RnO_mlWjs;R
RsRCoL_4.POF1dl_oNL#L;R
RsRCoLH6_1BWO;R

RosCR:rdjL9R4Md_qVxtw#v_pd#P;R
RsRCorjd:94RLjF_GzWj_vXs0;R
RsRCor_LUh_scgbcH-j4:9dRL_#MV;R
RsRCor_L(MZzaQRkY-:R4jL9Rdz_MaR;
RosCR_LnM_zaV
w;RCRsoURL_aMz_VaKGL,R4Md_zaa_K_VGpguY;R

RosCR(rL_aMzZYQkR4-R:Rj9LM(_YdEQg
#;RHRIsrCRLhU_sgc_c-Hb49:jR_LnM_V#Q
w;RHRIsrCRLM(_zQaZk-YRRj4:9nRL_aMz_;Qw
IRRHRsCLPU_qdAZJ;#Y
IRRHRsCL_4jMQYEdl_k[
A;RHRIsLCR4uj_1V6ZX[_IeR;
RsIHC(RL_$up_hnD;R
RsRCor_L(MZzaQRkY+RRc+URL_chs_Hgcb4+RR4-R:Rj9L_4.kO)s.YXV_hsL;R
R/#/R$bMF#R$#0MsN#0DNCV_FVR
RH0MHHRNDL_4dMtqxV_wv#Pp#dRR=L_4dmjOlVH_]u)(nPR;
RHHM0DHNR_LdMRza=LR'jR;
RR//#F$Mb##$RN0sMN#D0FC_MR

R#N#HRoML_4jMQYEdl_k[=ARRL5R(Y_MEgQd#=R=Rj'LR
2;R#RN#MHoRjL4_6u1Z_VXIR[e=RR5LMn_VQ#_w9r4R
2;
NRRD$IN#@R@5FRb#oC8CcRL_KmiNsRFR#bFCC8oRjL4_6u1Z_VXIR[e2R
RRVRH54RLj1_u6XZV_eI[RL2RCMoH
RRRRLRRdV_M#=R<R_LUh_scNbUz;R
RRRRRLMd_z<aR=;Rj
RRRR8CMR#CDCCRLo
HMRRRRRdRL_#MVRR<=LMn_VQ#_wR;
RRRRR_LdMRza<L=Rnz_Maw_Q;R
RC
M8RRR
RINDNR$#@R@5bCF#8RoCLmc_iRKN2R
RRVRH5URL_aMz_VaKG
R2RRRRR(RL_EMYQ#dgRR<=LMd_z
a;RRRRCCD#R5HVRdL4_aMz_VaKGu_pY2gR
RRRRLRR(Y_MEgQd#=R<RjL4_jO( ]]Fn;Bb
RRRR#CDCVRH5L5Rnz_Maw_VR&2R&!R5L_4jMQYEdl_k[2AR2R
RRRRRLM(_YdEQg<#R=(RL_EMYQ#dgR4-R;R

RINDNR$#@R@5bCF#8RoCLmc_iRKNFbsRF8#CoLCR4uj_1V6ZX[_IeR2
RHRRVL5R4uj_1V6ZX[_Ie
R2RRRRR4RLdq_MxwtVvp_##RPd<L=R4md_OVlj_qa	UZn ;R
RRDRC#RC
RRRRRdL4_xMqtvVw_##pP<dR=4RLjF_GzWj_vXs0;R

RINDN@$#@LR54Md_qVxtw#v_pd#PRRFsLMd_zFaRsdRL_#MVRRFsLu(_1D$HgF#Rs4RLjY_ME_QdkAl[RRFsLPU_qdAZJ2#YRoLCHRM
RLRR4Gj_F_zjW0vsX=R<RdL4_xMqtvVw_##pP
d;RRRRLMn_zVa_w=R<RL4'jR;
RLRRgw_mWgha_RNL<4=R';Lj
RRRR_L6HO1WB=R<RL4'jR;
RLRRUz_MaK_aV<GR='R4L
j;RRRRL_4dM_zaaGKV_Ypug=R<RL4'jR;
RLRRnO_mlWjsRR<=Leg_x_.MmYnc;R
RR4RL.F_P1_Odo#lNL<LR='R4L
j;
RRRR#ONCL5R4Md_qVxtw#v_pd#PR/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRRLRR4md_OVlj_qa	UZn :CRLo
HMRRRRRRRRL_4.POF1dl_oNL#LRR<=44'L;R
RRRRRR4RLjF_GzWj_vXs0RR<=L_4dmjOlV(_qq)UnPR;
RRRRRLRRnO_mlWjsRR<=Leg_x_.MczXn;R
RRRRRR4RLdz_MaK_aVpG_uRYg<4=R';L4
RRRRCRRMR8
RRRRRdL4_lmOjqV_(nqU)RP:LHCoMR
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLmn_OsljW=R<R_LgeMx._ncXzR;
RRRRRHRRVU5L_APqZ#dJYRR&5dRL_#MVrRj9|dRL_#MVrR.9|dRL_#MVrRd9|dRL_#MVr2c92CRLo
HMRRRRRRRRRnRL_aMz_RVw<4=R;R
RRRRRRRRRHRV5L_4jMQYEdl_k[2ARRoLCHRM
RRRRRRRRRLRRUz_MaK_aV<GR=;R4
RRRRRRRRRRRR_LnM_zaV<wR=;Rj
RRRRRRRRRRRR_LgmhwWaNg_L=R<R
j;RRRRRRRRRRRRL_4.POF1dl_oNL#LRR<=4R;
RRRRRRRRRORRN5#CR_LdMRV#2/R/RM#$F$b##NRbsDNDCOD_N
#CRRRRRRRRRRRRR(RL_chs_UYE:CRLo
HMRRRRRRRRRRRRRRRRL_4jGjFz_sWv0<XR=4RLdO_ml_jV](Hun;)P
RRRRRRRRRRRRRRRR_LgmhwWaNg_L=R<R
4;RRRRRRRRRRRRRRRRL_4.POF1dl_oNL#LRR<=j
;
RRRRRRRRRRRRRMRC8R
RRRRRRRRRRRRR8NCVk:D0RR;
RRRRRRRRRCRRMN8O#RC
RRRRRRRRR8CM
RRRRRRRR8CM
RRRRCRRMR8
RRRRRdL4_lmOj]V_Hnu()RP:LHCoMR
RRRRRRgRL_Wmwh_agN<LR='R4L
4;RRRRRRRRLH6_1BWORR<=44'L;R
RRRRRRVRH5(RL_$u1H#DgRR==44'LRL2RCMoH
RRRRRRRRHRRVL5R4Mj_YdEQ_[klA=R=RL4'4RR2LHCoMR
RRRRRRRRRR4RLjF_GzWj_vXs0RR<=L_4.mjOlV(_TAtUJ;R
RRRRRRRRRCRM8CCD#RoLCHRM
RRRRRRRRRLRR4Gj_F_zjW0vsX=R<RdL4_lmOjbV_6nAa)
P;RRRRRRRRRMRC8R
RRRRRRMRC8DRC#HCRVL5RdV_M#9rc2CRLoRHM/L/R(s_hc[_NgR
RRRRRRRRRL_4jGjFz_sWv0<XR=4RL(O_ml_jVaO	TzTJLe;h6
RRRRRRRR8CM
RRRRCRRMR8
RRRRRdL4_lmOjbV_6nAa)RP:LHCoMR
RRRRRRnRL_lmOjRsW<L=Rgx_e.qM_a;nA
RRRRRRRR_LgmhwWaNg_L=R<RL4'4R;
RRRRRLRRnz_Maw_VRR<=44'L;R
RRRRRRVRH54RLjY_ME_QdkAl[RR==44'LRL2RCMoH
RRRRRRRRLRR4Gj_F_zjW0vsX=R<R.L4_lmOjTV_(JAUtR;
RRRRRCRRMR8
RRRRR8CM
RRRRLRR4m._OVlj_AT(U:JtRoLCHRM
RRRRRLRRnO_mlWjsRR<=L_44eMx._n4eT;ON
RRRRCRRMR8
RRRRR(L4_lmOjaV_	zTOJeLThR6:LHCoMR
RRRRRRnRL_lmOjRsW<L=RUx_e.cM_U
D;RRRRRMRC8R
RRMRC8#ONCR
RC
M8
NRR#o#HM4RL.)_ksXO.VpY_$=ERR.L4_sk)OV.XYL_sh9rj;R

R#N#HRoMLu(_pn$_D=hRRcL4_a48O_pIpuVA_RdH?4RL.)_ksXO.VsY_Ljhr9RR:Lud_p
$;RDRNI#N$R5@@R#bFCC8oR_L([_W1dRPW2CRLo
HMRRRRHRV5L_4c4O8appI_V_Aud|HR|4RL4)_ksXO.VXY_]L2RCMoH
RRRRHRRVRR5LM(_wstj7
Y2RRRRRRRRL_4.kO)s.YXV_hsLR{=RLM(_YdEQgR#,L_4dMtqxV_wv#Pp#dL,RdV_M#L,R61_HW}OB;R
RRRRRCCD#RRHV5_L6m]P$dR2
RRRRRLRR4k._).sOX_VYsRLh=LR{4M4_zdaZJ0v_	Rp,L_4.kO)s.YXV_hsLr_L(MZzaQRkY+RRc+URL_chs_HgcbRR+4RR-49:4}R;
RCRRMR8
R8CM
LRRU)_M_J$lsytR524cR4RL4z_Ma_ta	JEW]
R5RRRR3_L([_W1dRPW5_L([_W1d2PW,R
RRLR3nV_M#w_VRn5L_#MV_2Vw,R
RRLR3nz_Maw_VR45LjY_MEgQd#0_w2R,
R3RRL_44PZqAdYJ#_RX]54L4_APqZ#dJY]_X2R,
R3RRL_4c4O8appI_V_Aud5HRL_4c4O8appI_V_Aud,H2
RRRR63L_$mP]RdRR65L_$mP],d2
RRRRn3L_#8Z0RdgRn5L_#8Z02dg,R
RRLR3dp_u$RRRRLR5(p_u$D_nh
2,RRRR3_LnmjOlsRWR5_LnmjOls,W2
RRRRd3L_#MVRRRRRn5L_#MV_2Qw,R
RRLR3dz_MaRRRRLR5nz_Maw_Q2R,
R3RRLPU_qdAZJR#YRRRR5_LUPZqAdYJ#2R,
R3RRLM(_wstj7RYRR5RRLM(_wstj7,Y2
RRRR(3L_#MV_$dIRRRRR(5L_#MV_$dI2R,
R3RRLM(_zda_IR$RR5RRLM(_zda_I,$2
RRRR43L.q_PAJZd#pY_$RERR5RRL_4.PZqAdYJ#_Ep$2R,
R3RRLun_1V6ZXRRRRLR54uj_1V6ZX[_Ie;22
M
C88lFk
DC
8lFkRDCL_4.mhwWaIg_v8C 5(RL_1[W_WdP,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(i_uKgN_kR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLm6_Pd$],R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRdp_u$R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
w,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L(Htp#V,Wp
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRURL_q[q_BiDmR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4dPOF1dG_V.ksLTR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLmU_Pd$]_RYt2
;
RNRbsCNl0RCsL.6_)l#jR6=R;R

RbHMkL0R(W_[1P_dWR;
RbHMkL0R(i_uKgN_kR;
RbHMkL0R6P_m$;]d
HRRM0bkR_Ldu;p$
FRRkk0b0dRL_wup;R
RHkMb0LRr6)_.#:jl4L9R(p_H#WtVpR;
RbHMkL0RUq_[qD_iB
m;RkRF00bkRdL4_1PFOVd_GL.sk
T;RkRF00bkR_LUm]P$dt_Y;R

RosCR6rL_#.)jjl:9nRL_s$Fj;u7
IRRHRsCr_L6.j)#l9:4R_L($jFsu;7k
sRRCLoR4Pd_Fd1O_.VGsTLk;R
RsRCoLmU_Pd$]_;Yt
R
RNH##oLMRdp_uwRR=L$n_Fusj79rj;R

RINDNR$#@L@56P_m$R]dFLsR(i_uKgN_kL2RCMoH
RRRRdL4_1PFOVd_GL.sk<TR='R4L
j;RRRRLmU_Pd$]_RYt<4=R';Lj
RRRR5HVR_L(uNiK_Rgk2CRLo
HMRRRRRVRH5LR!6P_m$R]d2R
RRRRRR4RLdF_P1_OdVsG.LRkT<4=R';L4
RRRRCRRD
#CRRRRRRRRLmU_Pd$]_RYt<4=R';L4
RRRR8CM
CRRM
8
RDRNI#N$R5@@R#bFCC8oR_L([_W1dRPW2CRLo
HMRRRRHRV5Lu(_i_KNg2kRRoLCHRM
RRRRR5HVR6!L_$mP]2dRRoLCHRM
RRRRRLRRnF_$s7jur_L6.j)#l9:4RR<=LH(_pV#tW
p;RRRRRRRRL$n_Fusj79rjRR<=L[U_qiq_D;Bm
RRRRCRRMC8RD
#CRRRRRRRRL$n_Fusj7=R<Rd{L_$up,(RL_s$Fjku7}R;
RCRRMR8
R8CM
R
RNH##oLMR(F_$s7jukRR=L$n_Fusj76rL_#.)j:lRR;49
8CMlkF8D
C

8lFkRDCtCCMs)HOqNvslD_LFRO	58sN8Rs,L_.#0,O	R08NNk_F0I,RNs88,CRIM#,RO,D	R08NNM_H,sRIH_0CCLMND2CR;M
HbRk0L_.#0;O	
bHMkr0R4-4RRj4:9NRs8;8s
0FkbRk0r-gRRj4:9NR80FN_k
0;HkMb0CRIM#,RO;D	
bHMkr0R4-4RRj4:9NRI8;8s
bHMkr0RgRR-49:jR08NNM_H;M
HbRk0I0sHCM_CNCLD;H
IssCR_NCMLI,R_NCML
;
R#RN#MHoRCs_MRNL=RR!I;CM
NRR#o#HM_RICLMNRI=RsCH0_NCMLRDC&CRIMR;
Rv)qA_4n11g_g$R#MD_LF_O	sRNl5R
RRqR37q7)5NRI8R8s2
,RRRRR3q7Q5RRR8NN0_rHMURR-4j:R9,R2RR
RR7R3m2q5,RR
R
RRRRRR37q7)RA5s8N8s,R2RR
RR7R3QRA5R'RUL2jR,RR
R3RR75mAR8RRN_0NFrk0URR-4j:R9,R2RR
RRRR
R3RR7qQu58RRN_0NHgMrR4-R:RU92
,RRRRR3u7mq,52RR
RR7R3Q5uAR'R4L2jR,RR
R3RR7Amu58RRN_0NFrk0gRR-49:URR2,
RRRRR
RRWR3 Rq5RL4'4,R2RR
RR1R315)qRL4'j,R2RR
RR R3hRq5RCI_MRNL2
,RRRRR3iBpq#5RORD	2
,RRRRR3AW 54RR'RLj2
,RRRRR3)11A45R'RLj2
,RRRRR3A h5sRR_NCML,R2RR
RRBR3p5iAR#L._	0OR;22RM
C88lFk
DC
8lFkRDCs1NlDCHOs_NlLODF	RR5s8N8sL,R.0#_OR	,8NN0_0Fk,NRI8,8sRMIC,OR#DR	,8NN0_RHM2H;
M0bkR#L._	0O;M
HbRk0r:4djs9RNs88;k
F00bkR:rUj89RN_0NF;k0
bHMkI0RCRM,#	OD;M
HbRk0r:4djI9RNs88;M
HbRk0rjU:9NR80HN_M
;
ICHsR:rUj89RFjk0;C
tMHCsOv)qs_NlLODF	CRtMHCsOv)qQ0M#jRR538sN8ss5Ns88r:4jj,92RR
RR.3L#O_0	.5L#O_0	
2,R3RRI5CMI2CM,R
RRN380FN_k805Fjk02R,
RIR3Ns8858IN84srj9:j2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH,M2
RRR3HIs0CC_MDNLCR55I8N8sdr4:944RR==dj'8R222;I

HRsCrjU:9FR8k;04
MtCCOsH)sqvNLl_D	FORMtCCOsH)QqvM4#0R35Rs8N8sN5s8r8s4jj:9R2,
RRR3#L._	0O5#L._	0O2R,
RIR3CIM5C,M2
RRR308NNk_F0F58k204,R
RRN3I858sI8N8sjr4:2j9,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5I5RNs88r:4d4R49=d=R'R842;22
H
IsrCRU9:jRk8F0
.;tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0.5sR3Ns8858sN84srj9:j2
,RR3RRL_.#05O	L_.#02O	,R
RRC3IMC5IM
2,R3RR8NN0_0Fk5k8F0,.2
RRR38IN8Is5Ns88r:4jj,92
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_H2R,
RIR3sCH0_NCML5DC5NRI8r8s44d:4=9R='Rd82.R2
2;
sIHCURr:Rj980Fkdt;
CsMCHqO)vlsN_FLDOt	RCsMCHqO)v#QM05dRRN3s858ss8N8sjr4:2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k080Fkd
2,R3RRI8N8sN5I8r8s4jj:9
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_2HM,R
RRs3IH_0CCLMND5C5R8IN84srd4:49=R=R8d'd2R22
;
ICHsR:rUj89RFck0;C
tMHCsOv)qs_NlLODF	CRtMHCsOv)qQ0M#cRR538sN8ss5Ns88r:4jj,92RR
RR.3L#O_0	.5L#O_0	
2,R3RRI5CMI2CM,R
RRN380FN_k805Fck02R,
RIR3Ns8858IN84srj9:j2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH,M2
RRR3HIs0CC_MDNLCR55I8N8sdr4:944RR==dc'8R222;I

HRsCrjU:9FR8k;06
MtCCOsH)sqvNLl_D	FORMtCCOsH)QqvM6#0R35Rs8N8sN5s8r8s4jj:9R2,
RRR3#L._	0O5#L._	0O2R,
RIR3CIM5C,M2
RRR308NNk_F0F58k206,R
RRN3I858sI8N8sjr4:2j9,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M
2,R3RRI0sHCM_CNCLD5I5RNs88r:4d4R49=d=R'R862;22
H
IsrCRU9:jRk8F0
n;tCCMs)HOqNvslD_LFRO	tCCMs)HOqMvQ#R0n5sR3Ns8858sN84srj9:j2
,RR3RRL_.#05O	L_.#02O	,R
RRC3IMC5IM
2,R3RR8NN0_0Fk5k8F0,n2
RRR38IN8Is5Ns88r:4jj,92
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_H2R,
RIR3sCH0_NCML5DC5NRI8r8s44d:4=9R='Rd82nR2
2;
sIHCURr:Rj980Fk(t;
CsMCHqO)vlsN_FLDOt	RCsMCHqO)v#QM05(RRN3s858ss8N8sjr4:2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR3MIC5MIC2R,
R8R3N_0NF5k080Fk(
2,R3RRI8N8sN5I8r8s4jj:9
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_2HM,R
RRs3IH_0CCLMND5C5R8IN84srd4:49=R=R8d'(2R22s;
CroRU9:jR08NNk_F0R;
NNDI$@#@Rs5RNs88RRFs80FkjsRFRk8F0F4RsFR8kR0.F8sRFdk0RRFs80FkcsRFRk8F0F6RsFR8kR0nF8sRF(k0RL2RCMoH
RRROCN#Rs5RNs88r:4d4R492/R/RM#$F$b##NRbsDNDCOD_N
#CRRRRR8d'jRR:R08NNk_F0RR=80FkjR;
RRRRd4'8RR:R8NN0_0FkR8=RF4k0;R
RRdRR'R8.:8RRN_0NFRk0=FR8k;0.
RRRR'Rd8:dRRNR80FN_k=0RRk8F0
d;RRRRR8d'cRR:R08NNk_F0RR=80FkcR;
RRRRd6'8RR:R8NN0_0FkR8=RF6k0;R
RRdRR'R8n:8RRN_0NFRk0=FR8k;0n
RRRR'Rd8:(RRNR80FN_k=0RRk8F0
(;RCRRMN8O#RC
CRM8/D/NI#N$
8CMlkF8D
C
lkF8DsCRNLl_D	FORs5RNs88,.RL#O_0	8,RN_0NF,k0R8IN8Rs,I,CNRD#O	8,RN_0NH2MR;M
HbRk0L_.#0;O	
bHMkr0R4:dRRRj9s8N8sF;
kk0b04Rrg:nRRRj98NN0_0Fk;M
HbRk0I,CNRD#O	H;
M0bkRdr4Rj:R9NRI8;8s
bHMkr0R4Rgn:9RjR08NNM_H;H
IsrCR4:g(j89RN_0NF_k00;lb
N
slH1DONCslD_LFRO	s1NlDCHOQ0M#jRR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlbURR:j,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMURR:j292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#4RR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4:(RR2g9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrR4(:9Rg2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0.5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bnr.R4:RU,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM.:nRR94U2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0d5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0b6rdR.:R(,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMd:6RR9.(2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0c5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bcrcRd:Rn,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMc:cRR9dn2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R065sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bdr6Rc:R6,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM6:dRR9c62
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0n5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0b.rnR6:Rc,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMn:.RR96c2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0(5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0b4r(Rn:Rd,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM(:4RR9nd2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0U5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bjrUR(:R.,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMU:jRR9(.2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#R0g5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bgrURU:R4,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHMU:gRR9U42
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#j04R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_lgbrURR:g2j9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_HrRgU:jRg9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#04RR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4Rj(:gRg9
2,R3RRI8N8sN5I8r8s4-cRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mrj:(RR9gg2
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#.04R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4br4:nRRU4j9
2,R3RRI8N8sN5I8r8s4-cRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mr4:nRRU4j9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0dRR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4R.6:4R4(,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4R.6:4R4(292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45cRRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrc4dR4:R.2n9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hrc4dR4:R.2n92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R465sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0bcr4dRR:49d62R,
RIR3Ns8858IN84srcRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_Mcr4dRR:49d62
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#n04R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4br6:.RRc4c9
2,R3RRI8N8sN5I8r8s4-cRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4Mr6:.RRc4c9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM4#0(RR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4Rn4:6R4d,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM8NN0_rHM4Rn4:6R4d292;N
slH1DONCslD_LFRO	s1NlDCHOQ0M#45URRN3s858ss8N8sdr4Rj:R9R2,
RRR3#L._	0O5#L._	0O2R,
R8R3N_0NF5k08NN0_0Fk_b0lrj4(R4:Rn2.9,R
RRN3I858sI8N8scr4R4-R:9Rj2R,
RIR3CIM5C,N2
RRR3D#O	O5#D,	2
RRR308NNM_H508NNM_Hrj4(R4:Rn2.92s;
NDl1HsOCNLl_D	FORlsN1ODHC#QM0R4g5sR3Ns8858sN84srdRR:j,92RR
RR.3L#O_0	.5L#O_0	
2,R3RR8NN0_0Fk508NNk_F0l_0b(r4gRR:49(42R,
RIR3Ns8858IN84srcRR-4j:R9
2,R3RRI5CMI2CN,R
RRO3#D#	5O2D	,R
RRN380HN_MN580HN_M(r4gRR:49(42
2;s1NlDCHOs_NlLODF	NRslH1DOMCQ#j0.R35Rs8N8sN5s8r8s4:dRR2j9,RR
RLR3.0#_OL	5.0#_O,	2
RRR308NNk_F0N580FN_k00_l4brU:URRj4U9
2,R3RRI8N8sN5I8r8s4-cRRR4:j,92
RRR3MIC5NIC2R,
R#R3O5D	#	OD2R,
R8R3N_0NH8M5N_0NH4MrU:URRj4U9;22
lsN1ODHClsN_FLDOs	RNDl1HQOCM.#04RR538sN8ss5Ns88rR4d:9Rj2
,RR3RRL_.#05O	L_.#02O	,R
RRN380FN_k805N_0NF_k00rlb4Rg(:UR4g,92
RRR38IN8Is5Ns88rR4c-:R4R2j9,R
RRC3IMC5IN
2,R3RR#	OD5D#O	
2,R3RR8NN0_5HM{L4'j8,RN_0NH4Mrg:nRRg4U92}2;N
R#o#HMNR80FN_k=0RR08NNk_F0l_0bgr4nRR:j
9;ClM8FD8kCl

FD8kC(RL_Wmwh#ag5cRL_KmiNR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(i_uKgN_kR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR6P_m$,]d
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L6POF1dR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR(w_mWghapR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRRgw_mWgha_RNL2
;
RMRHbRk0Lmc_i;KN
HRRM0bkR_L([_W1d;PW
HRRM0bkR_L(uNiK_;gk
HRRM0bkR_L6m]P$dR;
R0FkbRk0Lud_p
w;RMRHbRk0LP6_Fd1O;R
RHkMb04Rrg:nRRRj9Lm(_waWhg
p;RMRHbRk0Lmg_waWhgL_N;R

RosCRdr4Rj:R9gRL_lP_xYB7XR#,L.g__Blx7#YX,URL_wwZwYpX R;
RsIHC4RrdRR:jL9R4Pj__Blx7#YX0R;
RsIHC4Rrg:nRRRj9LP(_wuW_D
v;RHRIsLCR4mj_FIxwh)_ipR;
RsIHC4RLcF_P1_Od#	s.wx]T;R
RICHsR_LgmwFxINh_LR;
RosCR_L..
F;RCRso4RL4w_.#gt_kAsXLR;
RosCR4L4_#Pwtk_gsLXA;R
RsRCoL[U_qiq_D;Bm
sRRCroR4Rg(:9RjR_L(M_YKA;wv
IRRHRsCr(4gRj:R9URL_KMY_vAwtR;
RosCRgr4gRR:jL9R(._m$_$VwR;
RosCR4r6Rj:R9(RL_$m.$tV_;R
RsRCorR46:9RjR_L(m$.$V;_I
sRRCroRdRR:jL9R(._m$_$VCR;
RosCR_L(m$.$Vj_ ;R

RR//#F$Mb##$RN0sMN#D0FC_VRV
RHHM0DHNR_LgPx_lBX7Y#RR=5'~RL;j2
HRRMHH0NLDRg__.l7xBYRX#=~R5Rj'L2R;
RR//#F$Mb##$RN0sMN#D0FC_MR

RlsN_FLDOL	RdF_1W
R5RRRR3#L._	0ORLR5(W_[1P_dW
2,RRRR3D#O	RRRRLR5ci_mK,N2
RRRRN3s8R8sR5RRLPg__Blx7#YX2R,
R3RRI8N8sRRRRg5L_l._xYB7X,#2
RRRRN380HN_M5RRLm(_waWhg,p2
RRRRN380FN_k50RLP(_wuW_D,v2
RRRRC3INRRRR5RRL.._F;22
R
RL_4.mhwWaIg_v8C R4y5cL2R4m4_waWhg4_XC5]R
RRRR(3L_1[W_WdPR(5L_1[W_WdP2R,
R3RRLu(_i_KNg5kRLu(_i_KNg,k2
RRRR63L_$mP]5dRLm6_Pd$]2R,
R3RRLud_p5$RL_4jmwFxIih_),p2
RRRRd3L_wupRd5L_wup2R,
R3RRLH(_pV#tW5pRLwU_ZpwwX2Y ,R
RRLR3Uq_[qD_iB5mRL[U_qiq_D2Bm,R
RRLR34Pd_Fd1O_.VGsTLkR45LcF_P1_Od#	s.wx]T2R,
R3RRLmU_Pd$]_RYt5_LgmwFxINh_L22R;R

RINDNR$#@L@5gw_mWgha_2NLRoLCHRM
RLRR4.4_w_#tgXksA<LR='R4L
j;RRRRL.._F=R<RL4'jR;
RHRRVL5Rgw_mWgha_RNL2CRLo
HMRRRRR.RL_R.F<4=R';L4
RRRRLRR4.4_w_#tgXksA<LR='R4L
4;RRRRC
M8RMRC8R

RINDNR$#@L@5UY_MKw_AvFtRsgRL_xmFw_IhNRL2LHCoMR
RR4RL4w_P#gt_kAsXL=R<RL4'jR;
RHRRVR55Lmg_FIxwhL_NR&2R&RR5LMU_YAK_wrvt49g(R
22RRRRR4RL4w_P#gt_kAsXL=R<RL4'4R;
R8CM
R
RNNDI$@#R@F5b#oC8CcRL_KmiNRR2LHCoMR
RRVRH56RL_1PFO2dRRoLCHRM
RRRRR_Lg.x_lBX7Y#=R<Rj'L;R
RRRRRLwU_ZpwwXRY <'=RL
j;RRRRRURL_q[q_BiDm=R<RL4'jR;
RCRRMC8RDR#CHRV5L_44.tw#_sgkXRAL2CRLo
HMRRRRRURL_wwZwYpX =R<R_Lg.x_lBX7Y#R;
RRRRR5HVR_Lg.x_lBX7Y#=R=Rd4nU2dRRoLCHRM
RRRRRLRRg__.l7xBYRX#<'=RL
j;RRRRRRRRL[U_qiq_DRBm<4=R';L4
RRRRCRRMC8RD
#CRRRRRRRRL.g__Blx7#YXRR<=L.g__Blx7#YXR4+R;R
RRMRC8R
RC
M8
NRRD$IN#@R@5#bFCC8oR_L([_W1dRPW2CRLo
HMRRRRHRV5L_4cPOF1ds_#.]	wT2xR
RRRRLRRg__Pl7xBYRX#<'=RL
j;RRRRCCD#R5HVR4L4_#Pwtk_gsLXARL2RCMoH
RRRRHRRVL5Rg__Pl7xBYRX#=4=RnddURR2
RRRRRLRRg__Pl7xBYRX#<'=RL
j;RRRRRDRC#RC
RRRRRLRRg__Pl7xBYRX#<L=R4Pj__Blx7#YX0RR+4R;
RCRRMR8
R8CM
R
RNH##oLMR4Pj__Blx7#YX0RR=LPg__Blx7#YX;R
RNH##oLMRUY_MKw_AvRtRRL=R(Y_MKw_AvR;
R#N#HRoML_4jmwFxIih_)=pRR_L(m$.$Vj_ ;R
RNNDI$@#R@F5b#oC8C(RL_1[W_WdPRL2RCMoH
RRRR5HVRcL4_1PFO#d_sw.	]RTx2CRLo
HMRRRRR(RL_KMY_vAwrRj9<4=R';L4
RRRRLRR(Y_MKw_Avgr4(RR:4<9R=LR'jR;
RCRRMC8RDR#CHRV5Lmg_FIxwhL_NRR2
RRRRR_L(M_YKARwv<{=RLMU_YAK_wrvt4Rgn:9Rj,URL_KMY_vAwtgr4(;9}
CRRM
8
RDRNI#N$R5@@LP(_wuW_DFvRs(RL_KMY_vAw2CRLo
HMRRRRLm(_.V$$_4wrg:nRRRj9=(RL_WPw_vuDRL&R(Y_MKw_Avgr4(RR:4
9;RRRRLm(_.V$$_4wrgR(9='R4L
j;RRRRLm(_.V$$_4wrgRU9='R4L
j;RRRRLm(_.V$$_4wrgRg9='R4L
j;RRRRLm(_.V$$_jtr9RR=Lm(_.V$$_jwr9|R|R_L(m$.$Vr_w4|9R|(RL_$m.$wV_rR.9|L|R(._m$_$Vw9rd;R
RR(RL_$m.$tV_rR49=(RL_$m.$wV_rRc9|L|R(._m$_$Vw9r6RR||Lm(_.V$$_nwr9|R|R_L(m$.$Vr_w(
9;RRRRLm(_.V$$_.tr9RR=Lm(_.V$$_Uwr9|R|R_L(m$.$Vr_wg|9R|(RL_$m.$wV_r94jRR||Lm(_.V$$_4wr4
9;RRRRLm(_.V$$_dtr9RR=Lm(_.V$$_4wr.|9R|(RL_$m.$wV_r94dRR||Lm(_.V$$_4wrc|9R|(RL_$m.$wV_r946;R
RR(RL_$m.$tV_rRc9=(RL_$m.$wV_r94nRR||Lm(_.V$$_4wr(|9R|(RL_$m.$wV_r94URR||Lm(_.V$$_4wrg
9;RRRRLm(_.V$$_6tr9RR=Lm(_.V$$_.wrj|9R|(RL_$m.$wV_r9.4RR||Lm(_.V$$_.wr.|9R|(RL_$m.$wV_r9.d;R
RR(RL_$m.$tV_rRn9=(RL_$m.$wV_r9.cRR||Lm(_.V$$_.wr6|9R|(RL_$m.$wV_r9.nRR||Lm(_.V$$_.wr(
9;RRRRLm(_.V$$_(tr9RR=Lm(_.V$$_.wrU|9R|(RL_$m.$wV_r9.gRR||Lm(_.V$$_dwrj|9R|(RL_$m.$wV_r9d4;R
RR(RL_$m.$tV_rRU9=(RL_$m.$wV_r9d.RR||Lm(_.V$$_dwrd|9R|(RL_$m.$wV_r9dcRR||Lm(_.V$$_dwr6
9;RRRRLm(_.V$$_gtr9RR=Lm(_.V$$_dwrn|9R|(RL_$m.$wV_r9d(RR||Lm(_.V$$_dwrU|9R|(RL_$m.$wV_r9dg;R
RR(RL_$m.$tV_r94jRL=R(._m$_$Vwjrc9|R|R_L(m$.$Vr_wcR49|L|R(._m$_$Vw.rc9|R|R_L(m$.$Vr_wc;d9
RRRR_L(m$.$Vr_t4R49=(RL_$m.$wV_r9ccRR||Lm(_.V$$_cwr6|9R|(RL_$m.$wV_r9cnRR||Lm(_.V$$_cwr(
9;RRRRLm(_.V$$_4tr.=9RR_L(m$.$Vr_wcRU9|L|R(._m$_$Vwgrc9|R|R_L(m$.$Vr_w6Rj9|L|R(._m$_$Vw4r69R;
RLRR(._m$_$Vtdr49RR=Lm(_.V$$_6wr.|9R|(RL_$m.$wV_r96dRR||Lm(_.V$$_6wrc|9R|(RL_$m.$wV_r966;R
RR(RL_$m.$tV_r94cRL=R(._m$_$Vwnr69|R|R_L(m$.$Vr_w6R(9|L|R(._m$_$VwUr69|R|R_L(m$.$Vr_w6;g9
RRRR_L(m$.$Vr_t4R69=(RL_$m.$wV_r9njRR||Lm(_.V$$_nwr4|9R|(RL_$m.$wV_r9n.RR||Lm(_.V$$_nwrd
9;RRRRLm(_.V$$_4trn=9RR_L(m$.$Vr_wnRc9|L|R(._m$_$Vw6rn9|R|R_L(m$.$Vr_wnRn9|L|R(._m$_$Vw(rn9R;
RLRR(._m$_$Vt(r49RR=Lm(_.V$$_nwrU|9R|(RL_$m.$wV_r9ngRR||Lm(_.V$$_(wrj|9R|(RL_$m.$wV_r9(4;R
RR(RL_$m.$tV_r94URL=R(._m$_$Vw.r(9|R|R_L(m$.$Vr_w(Rd9|L|R(._m$_$Vwcr(9|R|R_L(m$.$Vr_w(;69
RRRR_L(m$.$Vr_t4Rg9=(RL_$m.$wV_r9(nRR||Lm(_.V$$_(wr(|9R|(RL_$m.$wV_r9(URR||Lm(_.V$$_(wrg
9;RRRRLm(_.V$$_.trj=9RR_L(m$.$Vr_wURj9|L|R(._m$_$Vw4rU9|R|R_L(m$.$Vr_wUR.9|L|R(._m$_$VwdrU9R;
RLRR(._m$_$Vt4r.9RR=Lm(_.V$$_Uwrc|9R|(RL_$m.$wV_r9U6RR||Lm(_.V$$_Uwrn|9R|(RL_$m.$wV_r9U(;R
RR(RL_$m.$tV_r9..RL=R(._m$_$VwUrU9|R|R_L(m$.$Vr_wURg9|L|R(._m$_$Vwjrg9|R|R_L(m$.$Vr_wg;49
RRRR_L(m$.$Vr_t.Rd9=(RL_$m.$wV_r9g.RR||Lm(_.V$$_gwrd|9R|(RL_$m.$wV_r9gcRR||Lm(_.V$$_gwr6
9;RRRRLm(_.V$$_.trc=9RR_L(m$.$Vr_wgRn9|L|R(._m$_$Vw(rg9|R|R_L(m$.$Vr_wgRU9|L|R(._m$_$Vwgrg9R;
RLRR(._m$_$Vt6r.9RR=Lm(_.V$$_4wrjRj9|L|R(._m$_$Vwjr44|9R|(RL_$m.$wV_r.4j9|R|R_L(m$.$Vr_w49jd;R
RR(RL_$m.$tV_r9.nRL=R(._m$_$Vwjr4c|9R|(RL_$m.$wV_r64j9|R|R_L(m$.$Vr_w49jnRR||Lm(_.V$$_4wrj;(9
RRRR_L(m$.$Vr_t.R(9=(RL_$m.$wV_rU4j9|R|R_L(m$.$Vr_w49jgRR||Lm(_.V$$_4wr4Rj9|L|R(._m$_$Vw4r44
9;RRRRLm(_.V$$_.trU=9RR_L(m$.$Vr_w494.RR||Lm(_.V$$_4wr4Rd9|L|R(._m$_$Vw4r4c|9R|(RL_$m.$wV_r6449R;
RLRR(._m$_$Vtgr.9RR=Lm(_.V$$_4wr4Rn9|L|R(._m$_$Vw4r4(|9R|(RL_$m.$wV_rU449|R|R_L(m$.$Vr_w494g;R
RR(RL_$m.$tV_r9djRL=R(._m$_$Vw.r4j|9R|(RL_$m.$wV_r44.9|R|R_L(m$.$Vr_w49..RR||Lm(_.V$$_4wr.;d9
RRRR_L(m$.$Vr_tdR49=(RL_$m.$wV_rc4.9|R|R_L(m$.$Vr_w49.6RR||Lm(_.V$$_4wr.Rn9|L|R(._m$_$Vw.r4(
9;RRRRLm(_.V$$_dtr.=9RR_L(m$.$Vr_w49.URR||Lm(_.V$$_4wr.Rg9|L|R(._m$_$Vwdr4j|9R|(RL_$m.$wV_r44d9R;
RLRR(._m$_$Vtdrd9RR=Lm(_.V$$_4wrdR.9|L|R(._m$_$Vwdr4d|9R|(RL_$m.$wV_rc4d9|R|R_L(m$.$Vr_w49d6;R
RR(RL_$m.$tV_r9dcRL=R(._m$_$Vwdr4n|9R|(RL_$m.$wV_r(4d9|R|R_L(m$.$Vr_w49dURR||Lm(_.V$$_4wrd;g9
RRRR_L(m$.$Vr_tdR69=(RL_$m.$wV_rj4c9|R|R_L(m$.$Vr_w49c4RR||Lm(_.V$$_4wrcR.9|L|R(._m$_$Vwcr4d
9;RRRRLm(_.V$$_dtrn=9RR_L(m$.$Vr_w49ccRR||Lm(_.V$$_4wrcR69|L|R(._m$_$Vwcr4n|9R|(RL_$m.$wV_r(4c9R;
RLRR(._m$_$Vt(rd9RR=Lm(_.V$$_4wrcRU9|L|R(._m$_$Vwcr4g|9R|(RL_$m.$wV_rj469|R|R_L(m$.$Vr_w4964;R
RR(RL_$m.$tV_r9dURL=R(._m$_$Vw6r4.|9R|(RL_$m.$wV_rd469|R|R_L(m$.$Vr_w496cRR||Lm(_.V$$_4wr6;69
RRRR_L(m$.$Vr_tdRg9=(RL_$m.$wV_rn469|R|R_L(m$.$Vr_w496(RR||Lm(_.V$$_4wr6RU9|L|R(._m$_$Vw6r4g
9;RRRRLm(_.V$$_ctrj=9RR_L(m$.$Vr_w49njRR||Lm(_.V$$_4wrnR49|L|R(._m$_$Vwnr4.|9R|(RL_$m.$wV_rd4n9R;
RLRR(._m$_$Vt4rc9RR=Lm(_.V$$_4wrnRc9|L|R(._m$_$Vwnr46|9R|(RL_$m.$wV_rn4n9|R|R_L(m$.$Vr_w49n(;R
RR(RL_$m.$tV_r9c.RL=R(._m$_$Vwnr4U|9R|(RL_$m.$wV_rg4n9|R|R_L(m$.$Vr_w49(jRR||Lm(_.V$$_4wr(;49
RRRR_L(m$.$Vr_tcRd9=(RL_$m.$wV_r.4(9|R|R_L(m$.$Vr_w49(dRR||Lm(_.V$$_4wr(Rc9|L|R(._m$_$Vw(r46
9;RRRRLm(_.V$$_ctrc=9RR_L(m$.$Vr_w49(nRR||Lm(_.V$$_4wr(R(9|L|R(._m$_$Vw(r4U|9R|(RL_$m.$wV_rg4(9R;
RLRR(._m$_$Vt6rc9RR=Lm(_.V$$_4wrURj9|L|R(._m$_$VwUr44|9R|(RL_$m.$wV_r.4U9|R|R_L(m$.$Vr_w49Ud;R
RR(RL_$m.$tV_r9cnRL=R(._m$_$VwUr4c|9R|(RL_$m.$wV_r64U9|R|R_L(m$.$Vr_w49UnRR||Lm(_.V$$_4wrU;(9
RRRR_L(m$.$Vr_tcR(9=(RL_$m.$wV_rU4U9|R|R_L(m$.$Vr_w49UgRR||Lm(_.V$$_4wrgRj9|L|R(._m$_$Vwgr44
9;RRRRLm(_.V$$_ctrU=9RR_L(m$.$Vr_w49g.RR||Lm(_.V$$_4wrgRd9|L|R(._m$_$Vwgr4c|9R|(RL_$m.$wV_r64g9R;
RLRR(._m$_$Vtgrc9RR=Lm(_.V$$_4wrgRn9|L|R(._m$_$Vwgr4(|9R|(RL_$m.$wV_rU4g9|R|R_L(m$.$Vr_w49gg;R
RR(RL_$m.$tV_r96jR4=R';Lj
RRRR_L(m$.$Vr_t6R49='R4L
j;RRRRLm(_.V$$_jIr9RR=Lm(_.V$$_jtr9|R|R_L(m$.$Vr_t4|9R|(RL_$m.$tV_rR.9|L|R(._m$_$Vt9rd;R
RR(RL_$m.$IV_rR49=(RL_$m.$tV_rRc9|L|R(._m$_$Vt9r6RR||Lm(_.V$$_ntr9|R|R_L(m$.$Vr_t(
9;RRRRLm(_.V$$_.Ir9RR=Lm(_.V$$_Utr9|R|R_L(m$.$Vr_tg|9R|(RL_$m.$tV_r94jRR||Lm(_.V$$_4tr4
9;RRRRLm(_.V$$_dIr9RR=Lm(_.V$$_4tr.|9R|(RL_$m.$tV_r94dRR||Lm(_.V$$_4trc|9R|(RL_$m.$tV_r946;R
RR(RL_$m.$IV_rRc9=(RL_$m.$tV_r94nRR||Lm(_.V$$_4tr(|9R|(RL_$m.$tV_r94URR||Lm(_.V$$_4trg
9;RRRRLm(_.V$$_6Ir9RR=Lm(_.V$$_.trj|9R|(RL_$m.$tV_r9.4RR||Lm(_.V$$_.tr.|9R|(RL_$m.$tV_r9.d;R
RR(RL_$m.$IV_rRn9=(RL_$m.$tV_r9.cRR||Lm(_.V$$_.tr6|9R|(RL_$m.$tV_r9.nRR||Lm(_.V$$_.tr(
9;RRRRLm(_.V$$_(Ir9RR=Lm(_.V$$_.trU|9R|(RL_$m.$tV_r9.gRR||Lm(_.V$$_dtrj|9R|(RL_$m.$tV_r9d4;R
RR(RL_$m.$IV_rRU9=(RL_$m.$tV_r9d.RR||Lm(_.V$$_dtrd|9R|(RL_$m.$tV_r9dcRR||Lm(_.V$$_dtr6
9;RRRRLm(_.V$$_gIr9RR=Lm(_.V$$_dtrn|9R|(RL_$m.$tV_r9d(RR||Lm(_.V$$_dtrU|9R|(RL_$m.$tV_r9dg;R
RR(RL_$m.$IV_r94jRL=R(._m$_$Vtjrc9|R|R_L(m$.$Vr_tcR49|L|R(._m$_$Vt.rc9|R|R_L(m$.$Vr_tc;d9
RRRR_L(m$.$Vr_I4R49=(RL_$m.$tV_r9ccRR||Lm(_.V$$_ctr6|9R|(RL_$m.$tV_r9cnRR||Lm(_.V$$_ctr(
9;RRRRLm(_.V$$_4Ir.=9RR_L(m$.$Vr_tcRU9|L|R(._m$_$Vtgrc9|R|R_L(m$.$Vr_t6Rj9|L|R(._m$_$Vt4r69R;
RLRR(._m$_$VIdr49RR=4j'L;R
RR(RL_$m.$IV_r94cR4=R';Lj
RRRR_L(m$.$Vr_I4R69='R4L
j;RRRRLm(_.V$$_jCr9RR=Lm(_.V$$_jIr9|R|R_L(m$.$Vr_I4|9R|(RL_$m.$IV_rR.9|L|R(._m$_$VI9rd;R
RR(RL_$m.$CV_rR49=(RL_$m.$IV_rRc9|L|R(._m$_$VI9r6RR||Lm(_.V$$_nIr9|R|R_L(m$.$Vr_I(
9;RRRRLm(_.V$$_.Cr9RR=Lm(_.V$$_UIr9|R|R_L(m$.$Vr_Ig|9R|(RL_$m.$IV_r94jRR||Lm(_.V$$_4Ir4
9;RRRRLm(_.V$$_dCr9RR=Lm(_.V$$_4Ir.|9R|(RL_$m.$IV_r94dRR||Lm(_.V$$_4Irc|9R|(RL_$m.$IV_r946;R
RR(RL_$m.$ V_jRR=Lm(_.V$$_jCr9|R|R_L(m$.$Vr_C4|9R|(RL_$m.$CV_rR.9|L|R(._m$_$VC9rd;R
RC
M8
8CMlkF8D
C
lkF8DLCR4M._Pplw_4DNG5$]RdL4_lMPwVp_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RL4)_ksgO_kAsXLR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNT_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpN)_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpN]_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNb_LR,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LgMwPlpNu_L
j,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_paN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pxN
L,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRgRL_lMPw_pQN2LR;R

RsbNN0lCCLsRUH_h_UmNg=.RR
c;RNRbsCNl0RCsL_4dmOFKAWX_G)zniRR=cj'Lj;jj
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=pRRLc'j4jj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)A='RcL4jjjR;
RsbNN0lCCLsR4md_FAKOXG_Wz[n)Rc=R'jLj4
4;RNRbsCNl0RCsL_4dmOFKAWX_G)znK=jRRLc'jj4j;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)h='RcLjj44R;
RsbNN0lCCLsR4md_FAKOXG_Wz0n)Rc=R'4Lj4
j;RNRbsCNl0RCsL_4dmOFKAWX_G)znBRR=cj'L4;44
R
RHkMb0LRrUH_h_UmNg4.:94RLdP_Ml_wpVsG.L;kT
HRRM0bkR4L4_sk)Ok_gsLXA;R
RFbk0kL0RgP_MlTwp_;NL
FRRkk0b0gRL_lMPw_p)N
L;RkRF00bkR_LgMwPlpN]_LR;
R0FkbRk0LMg_PplwbL_N;R
RFbk0kL0RgP_Mluwp_jNL;R
RFbk0kL0RgP_Mlawp_;NL
FRRkk0b0gRL_lMPw_pxN
L;RkRF00bkR_LgMwPlpNQ_LR;
RosCR_LgMwPlpNT_LR;
RosCR_LgMwPlpN)_LR;
RosCR_LgMwPlpN]_LR;
RosCR_LgMwPlpNb_LR;
RosCR_LgMwPlpNu_L
j;RCRsogRL_lMPw_paN
L;RCRsogRL_lMPw_pxN
L;RCRsogRL_lMPw_pQN
L;
R
RNNDI$@#R@LR54Md_Pplw_.VGsTLkRRFsL_44kO)s_sgkX2ALRoLCHRM
RLRRgP_MlTwp_RNL<4=R';Lj
RRRR_LgMwPlpN)_L=R<RL4'jR;
RLRRgP_Ml]wp_RNL<4=R';Lj
RRRR_LgMwPlpNb_L=R<RL4'jR;
RLRRgP_Mluwp_jNLRR<=4j'L;R
RRgRL_lMPw_paN<LR='R4L
j;RRRRLMg_PplwxL_NRR<=4j'L;R
RRgRL_lMPw_pQN<LR='R4L
j;RRRRH5VRL_44kO)s_sgkXRAL=4=R'2L4RoLCHRM
RRRRR#ONCL5R4Md_Pplw_.VGsTLkR/2R/$R#M#Fb$b#RNDsND_CDOCN#
RRRRRRRRdL4_KmFO_AXWnGz)Ri:LMg_PplwTL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)pR_LgMwPlpN)_L=R<RL4'4R;
RRRRRLRR4md_FAKOXG_WzAn):gRL_lMPw_p]N<LR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)zn[L:RgP_Mlbwp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz):KjR_LgMwPlpNu_L<jR='R4L
4;RRRRRRRRL_4dmOFKAWX_G)znhL:RgP_Mlawp_RNL<4=R';L4
RRRRRRRRdL4_KmFO_AXWnGz)R0:LMg_PplwxL_NRR<=44'L;R
RRRRRR4RLdF_mKXOA_zWGn:)BR_LgMwPlpNQ_L=R<RL4'4R;
RRRRR8CMOCN#
RRRR8CM
CRRMC8
MF8l8CkD
F
l8CkDR_L(u_pwn5DhRdL4_lMPwVp_GL.sk
T,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
 ,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
w,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
P,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL
8,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4ju_pwA7oVL,7j
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,L]
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRjL4_wup_VAo7,LM
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_LduRpw2
;
RNRbsCNl0RCsLhU_HN_mURg.=;Rc
bRRNlsNCs0CRdL4_KmFO_AXWnGz)=iRRLc'jjjj;R
RbNNslCC0s4RLdF_mKXOA_zWGnR)p='RcLjjj4R;
RsbNN0lCCLsR4md_FAKOXG_WzAn)Rc=R'jLj4
j;RNRbsCNl0RCsL_4dmOFKAWX_G)zn[RR=cj'Lj;44
bRRNlsNCs0CRdL4_KmFO_AXWnGz)RKj='RcLjj4jR;
RsbNN0lCCLsR4md_FAKOXG_Wzhn)Rc=R'4Ljj
4;RNRbsCNl0RCsL_4dmOFKAWX_G)zn0RR=cj'L4;4j
R
RbNNslCC0s4RLdF_mKXOA_zWGnR)B='RcL4j44
;
RbHMkr0RLhU_HN_mU:g.4L9R4Md_Pplw_.VGsTLk;H
RM0bkR4RLjp_uwo_AV 7L;H
RM0bkR4RLjp_uwo_AVw7L;H
RM0bkR4RLjp_uwo_AVP7L;H
RM0bkR4RLjp_uwo_AV87L;H
RM0bkR4RLjp_uwo_AV77LjR;
HkMb0LRR4uj_pAw_oLV7]R;
HkMb0LRR4uj_pAw_oLV7MR;
Fbk0kL0Rdp_uwR;
sRCoLud_p
w;
NRRD$IN#@R@54RLdP_Ml_wpVsG.LRkTFRs
RRRRRRRRRLRR4uj_pAw_oLV7 sRF
RRRRRRRRRRRRjL4_wup_VAo7RLwFRs
RRRRRRRRRLRR4uj_pAw_oLV7PsRF
RRRRRRRRRRRRjL4_wup_VAo7RL8FRs
RRRRRRRRRLRR4uj_pAw_oLV77FjRsR
RRRRRRRRRR4RLjp_uwo_AV]7LR
FsRRRRRRRRRRRRL_4ju_pwA7oVL2MRRoLCHRM
RORRN5#CRdL4_lMPwVp_GL.sk2TRRR//#F$Mb##$RsbNNCDDDN_O#RC
RRRRRdL4_KmFO_AXWnGz)Ri:Lud_p<wR=4RLjp_uwo_AV 7L;R
RRRRRL_4dmOFKAWX_G)znpL:Rdp_uw=R<RjL4_wup_VAo7;Lw
RRRRLRR4md_FAKOXG_WzAn):dRL_wupRR<=L_4ju_pwA7oVL
P;RRRRR4RLdF_mKXOA_zWGn:)[R_LduRpw<L=R4uj_pAw_oLV78R;
RRRRRdL4_KmFO_AXWnGz):KjR_LduRpw<L=R4uj_pAw_oLV77
j;RRRRR4RLdF_mKXOA_zWGn:)hR_LduRpw<L=R4uj_pAw_oLV7]R;
RRRRRdL4_KmFO_AXWnGz)R0:Lud_p<wR=4RLjp_uwo_AVM7L;R
RRRRRL_4dmOFKAWX_G)znBL:Rdp_uw=R<RjL4_wup_VAo7;L 
RRRR8RRCkVNDR0:RRRRRRRRRRRRLud_p<wR='R4L
j;RRRRCOM8N
#CRMRC8M
C88lFk
DC
8lFkRDCLkd_i5sR
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4L4_sk)Ok_gsLXA,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLdP_Ml_wpVsG.L,kT
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,p$
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_Ldu,pw
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR_L(u_p$u,Dv
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_$u1HVAo7LL_8R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4u._1.$HXwVY_,L8
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRcL4_Wmwh	agE]WJ_,dH
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRdL4_$u1HVAo7ZL_c
7,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4duH1$.YXVwc_Z7R,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4m6_waWhgW	EJ)]_g
	,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.MTzaA7oVL8_L,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLc8_4aIOp_ApVuH_d,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLdz_MaoTAV_7LZ,c7
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR6L4_EMYQ#dgI vC8o_v,R
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRR4RLnY_MEgQd#CIv q8_(
U,RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_44PZqAdYJ#_,X]
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRR.L4_APqZ#dJY$_pER,
RRRRRRRRRRRRRRRRRRRRRRRRRRRRRLRR4k4_).sOX_VYX
],RRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.kO)s.YXV_Ep$2*R/RM#$0#ECH##R$EM_H=Cs"sEN8*"R/
R;
bRRNlsNCs0CR_LUhmH_N.UgRc=R;R
RHkMb04RL4)_ksgO_kAsXLR;
RbHMkr0RLhU_HN_mU:g.4L9R4Md_Pplw_.VGsTLk;R
RHkMb0dRL_$up;R
RFbk0kL0Rdp_uwR;
R0FkbRk0Lu(_pu$_D
v;RkRF00bkR.L4_$u1HVAo7LL_8R;
R0FkbRk0L_4.uH1$.YXVw8_L;R
RFbk0kL0R4mc_waWhgW	EJd]_HR;
R0FkbRk0L_4.MTzaA7oVL8_L;R
RFbk0kL0R44c_8paOIV_pAdu_HR;
R0FkbRk0L_46MQYEdIg#v8C _;vo
FRRkk0b04RL4q_PAJZd#XY_]R;
R0FkbRk0L_44kO)s.YXV_;X]
HRRM0bkRdL4_$u1HVAo7ZL_c
7;RMRHbRk0L_4duH1$.YXVwc_Z7R;
RbHMkL0R4m6_waWhgW	EJ)]_g
	;RMRHbRk0L_4dMTzaA7oVLc_Z7R;
RbHMkL0R4Mn_YdEQgv#IC_ 8q;(U
HRRM0bkR.L4_APqZ#dJY$_pER;
RbHMkL0R4k._).sOX_VYp;$E
R
RICHsR_L(u_pwQ;wv
R
RICHsRcL4_AMYjBKK__w0N,xqRnL4_$u1HVAo7LL_8o_VlL,R4mU_waWhgW	EJd]_HB_4eL,R4Mg_YdEQgv#IC_ 8vxo_7RG,L_46PZqAdYJ#__X]I;H$
IRRHRsCL_46kO)s.YXV__X]I;H$
IRRHRsCL_4U4O8appI_V_Aud4H_B
e;
LRR4M._Pplw_4DNGR$]L_4jMOP#At_s#5pR
RRRR3RRL_44kO)s_sgkXRALRRRR54RL4)_ksgO_kAsXL,R2
RRRR3RRL_4dMwPlpG_V.ksLTRRRRRR5L_4dMwPlpG_V.ksLT,R2
RRRR3RRLMg_PplwTL_NRL5R4Mc_YKAjKwB_0x_Nq,R2
RRRR3RRLMg_Pplw)L_NRL5R4un_1A$HoLV7__L8VRol2R,
RRRRRg3L_lMPw_p]N5LRRUL4_Wmwh	agE]WJ__dH4RBe2R,
RRRRRg3L_lMPw_pbN5LRRnL4_$u1HV.XYLw_8o_Vl,R2
RRRR3RRLMg_PplwuL_NjRR5L_4gMQYEdIg#v8C __voxR7G2R,
RRRRRg3L_lMPw_paN5LRR6L4_APqZ#dJY]_X_$IHR
2,RRRRRLR3gP_Mlxwp_RNL54RL6)_ksXO.VXY_]H_I$,R2
RRRR3RRLMg_PplwQL_NRL5R44U_8paOIV_pAdu_HB_4e2R2;R

R_L(u_pwnRDhL_4.u_pwn_DhUP0YRR5
RRRRR43LdP_Ml_wpVsG.LRkTR5RRRdL4_lMPwVp_GL.sk2TR,R
RRRRR3jL4_wup_VAo7RL 54RLdz_MaoTAV_7LZRc72R,
RRRRR43Ljp_uwo_AVw7LRL5R4ud_1A$HoLV7_7ZcR
2,RRRRRLR34uj_pAw_oLV7PRR5L_46mhwWaEg	W_J])Rg	2R,
RRRRR43Ljp_uwo_AV87LRL5R4ud_1.$HXwVY_7ZcR
2,RRRRRLR34uj_pAw_oLV775jRRnL4_EMYQ#dgI vC8(_qU,R2
RRRR3RRL_4ju_pwA7oVL5]RR.L4_APqZ#dJY$_pE,R2
RRRR3RRL_4ju_pwA7oVL5MRR.L4_sk)OV.XY$_pE,R2
RRRR3RRLud_pRwRRRRRRRR5Lu(_pQw_w2vR2
;
R#RN#MHoR_LduRpwRRRRR=RRR_L(u_pwQRwv&4RL4)_ksgO_kAsXLR;
R#N#HRoMLu(_pu$_DRvRRRRRRRR=Lud_p
$;R#RN#MHoR.L4_$u1HVAo7LL_8RRR=4RLn1_u$oHAV_7LLV8_o
l;R#RN#MHoR.L4_$u1HV.XYLw_8RRR=4RLn1_u$XH.V_YwLV8_o
l;R#RN#MHoRcL4_Wmwh	agE]WJ_RdH=4RLUw_mWgha	JEW]H_d_e4B;R
RNH##oLMR4M._zAaToLV7_RL8RRRR=4RLcY_MAKjKB0_w_qNx;R
RNH##oLMR4M6_YdEQgv#IC_ 8vRoRR=RRRgL4_EMYQ#dgI vC8o_v_Gx7;R
RNH##oLMR4P4_qdAZJ_#YXR]RR=RRR6L4_APqZ#dJY]_X_$IH;R
RNH##oLMR4k4_).sOX_VYXR]RR=RRR6L4_sk)OV.XY]_X_$IH;R
RNH##oLMR44c_8paOIV_pAdu_HRRRRRR=L_4U4O8appI_V_Aud4H_B
e;ClM8FD8kCl

FD8kCURL__M)$slJtL5R(W_[1P_dWR,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_#MV_,Vw
RRRRRRRRRRRRRRRRRRRRRRRRRRRLMn_zVa_wR,
RRRRRRRRRRRRRRRRRRRRRRRRR4RL4q_PAJZd#XY_]R,
RRRRRRRRRRRRRRRRRRRRRRRRR4RLc8_4aIOp_ApVuH_d,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_L6m]P$dR,
RRRRRRRRRRRRRRRRRRRRRRRRRnRL_#8Z0,dg
RRRRRRRRRRRRRRRRRRRRRRRRRRRLud_p
$,RRRRRRRRRRRRRRRRRRRRRRRRRLRRnO_mlWjs,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LdM,V#
RRRRRRRRRRRRRRRRRRRRRRRRRRRLMd_z
a,RRRRRRRRRRRRRRRRRRRRRRRRRLRRUq_PAJZd#
Y,RRRRRRRRRRRRRRRRRRRRRRRRRLRR(w_Mt7jsYR,
RRRRRRRRRRRRRRRRRRRRRRRRR(RL_#MV_$dI,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_L(M_zad,I$
RRRRRRRRRRRRRRRRRRRRRRRRRRRL_4.PZqAdYJ#_Ep$,R
RRRRRRRRRRRRRRRRRRRRRRRRRR_LnuZ16V2XR;R
RbNNslCC0s(RL_aMzZYQkR4=R;R
RbNNslCC0sURL_chs_HgcbRR=6R;
RsbNN0lCCLsRUs_hcU_NzRbR='R6Ljjjj
j;
HRRM0bkR_L([_W1d;PW
HRRM0bkR_LnM_V#V
w;RMRHbRk0LMn_zVa_wR;
RbHMkL0R4P4_qdAZJ_#YX
];RMRHbRk0L_4c4O8appI_V_Aud
H;RMRHbRk0Lm6_Pd$];R
RHkMb0nRL_#8Z0;dg
HRRM0bkR_Ldu;p$
HRRM0bkR_L(Mjwts;7Y
HRRM0bkRLrRUs_hcc_gH4b-:9jRR_LnmjOls
W;RMRHbRk0Lun_1V6ZXR;
R0FkbRk0rURL_chs_Hgcb:-4jRR9LMd_V
#;RkRF00bkRLrR(z_MakZQY:-4jRR9LMd_z
a;RkRF00bkR_LUPZqAdYJ#;R
RFbk0kL0R(V_M#I_d$R;
R0FkbRk0LM(_zda_I
$;RkRF00bkR.L4_APqZ#dJY$_pE
;
RCRsoLRrUs_hcc_gH-bRRj4:94RLjV_M#g_v	sYV;R
RICHsRUrL_chs_HgcbRR-49:4R4L4_#MV_	vgY]Vs;R
RsRCor_L(MZzaQRkY-:R4jL9R4Mj_zva_gV	YsR;
RsIHCLRr(z_MakZQYRR-49:4R4L4_aMz_	vgY]Vs;R
RsRCoL_46PZqAdYJ#_dkL);lC
IRRHRsCr_LUh_scgbcH-j4:96RL_#MV_
a;RHRIsrCRLM(_zQaZk4Y-:Rj9LM6_zaa_;R
RICHsRjL4_APqZ#dJY;_A
sRRCroRR_LUh_scgbcH-j4:RL9RdV_M#R;
RosCRLrR(z_MakZQY:-4jRR9LMd_z
a;RCRsoURL_APqZ#dJY
;
R#RN#MHoR_L6M_V#aRR=L_4jM_V#vYg	VLsrUs_hcc_gH4b-:;j9
NRR#o#HM6RL_aMz_=aRRjL4_aMz_	vgYrVsLM(_zQaZk-YRRj4:9R;
R#N#HRoML_4jPZqAdYJ#_=ARR6L4_APqZ#dJYL_kdC)l;R
RNH##oLMR(V_M#I_d$RR=L_4jM_V#vYg	Vjsr9R;
R#N#HRoMLM(_zda_I=$RRjL4_aMz_	vgYrVsj
9;R#RN#MHoR.L4_APqZ#dJY$_pERR=L_46PZqAdYJ#_dkL);lC
R
RNNDI$@#R@b5RF8#CoLCRnZ_8#g0dRL2RCMoH
RRRR5HVR_LnM_V#V2wRRoLCHRM
RRRRR_LdMRV#<L=R6V_M#;_a
RRRR8CM
CRRM
8
RDRNI#N$R5@@R#bFCC8oR_Ln80Z#d2gRRoLCHRM
RHRRVL5Rnz_Maw_VRL2RCMoH
RRRRLRRdz_Ma=R<R_L6M_zaaR;
RCRRMR8
R8CM
R
RNNDI$@#R@b5RF8#CoLCRnZ_8#g0dRRFsbCF#8RoCLun_1V6ZXRR2LHCoMR
RRVRH5nRL_6u1ZRVX2R
RRRRRLPU_qdAZJR#Y<4=R';Lj
RRRR#CDCVRH54RL4q_PAJZd#XY_]RR2LHCoMR
RRRRRLPU_qdAZJR#Y<L=R4Pj_qdAZJ_#YAR;
RCRRMR8
R8CM
R
RNNDI$@#R@b5RF8#CoLCR(W_[1P_dWRR2LHCoMR
RRVRH5nRL_#MV_RVw|L|R44c_8paOIV_pAdu_HRR2LHCoMR
RRRRRHRV5LM(_wstj72YR
RRRRRRRRjL4_#MV_	vgYrVsLhU_sgc_cRHb-:R4j<9R=nRL_lmOj;sW
RRRRCRRDR#CHRV5Lm6_Pd$]RR2
RRRRRLRR4Mj_Vv#_gV	Ys=R<Rd{L_$up,4RL4V_M#g_v	sYV]
};RRRRC
M8RRRRHRV5LMn_zVa_w&R&R_L6m]P$dRR2LHCoMR
RRRRRL_4jM_zavYg	V<sR=LR{dp_u$L,R4M4_zva_gV	Ys;]}
RRRR8CM
RRRR5HVR4L4_APqZ#dJY]_XRR&&Lm6_Pd$]RL2RCMoH
RRRRLRR4P6_qdAZJ_#Yk)Ldl<CR=dRL_$up;R
RRMRC8R
RC
M8R#RN#MHoR4L4_#MV_	vgY]VsRL=R4Mj_Vv#_gV	YsUrL_chs_HgcbRR-4RR:4
9;R#RN#MHoR4L4_aMz_	vgY]VsRL=R4Mj_zva_gV	Ys(rL_aMzZYQkR4-RR4:R9C;
MF8l8CkD
F
l8CkDR_Ld4R.l5R
RLmc_i,KN
LRR(W_[1P_dWR,
R_L(uNiK_,gk
LRR6P_m$,]d
LRRdp_u$R,
RdL4_6kpQ0dBFu_[w
A,R4RL.z_MaoTAV_7LL
8,R4RLc8_4aIOp_ApVuH_d,R
RL_46MQYEdIg#v8C _,vo
LRR4P4_qdAZJ_#YX
],R4RL4)_ksXO.VXY_]R,
R_L(Mjwts,7Y
LRRdp_uwR,
R_L6mxOauR,
RdL4_aMzTVAo7ZL_c
7,R4RLnY_MEgQd#CIv q8_(
U,R4RL.q_PAJZd#pY_$
E,R4RL.)_ksXO.VpY_$
E,R4RL4F_P1sOdNXwNwR,
R_LgmhwWaNg_LR,
RjL4_WmwhDags,0C
LRRgp_1$h$_s2t7;R

RbHMkL0Rci_mK
N;RMRHbRk0L[(_Wd1_P
W;RMRHbRk0Lu(_i_KNg
k;RMRHbRk0Lm6_Pd$];R
RHkMb0dRL_$up;R
RHkMb04RLdp_k6BQd0[F_u;wA
HRRM0bkR_L(Mjwts;7Y
HRRM0bkR.L4_aMzTVAo7LL_8R;
RbHMkL0R44c_8paOIV_pAdu_HR;
RbHMkL0R4M6_YdEQgv#IC_ 8v
o;RMRHbRk0L_44PZqAdYJ#_;X]
HRRM0bkR4L4_sk)OV.XY]_X;R
RFbk0kL0Rdp_uwR;
R0FkbRk0Lm6_Ouax;R
RFbk0kL0R4Md_zAaToLV7_7Zc;R
RFbk0kL0R4Mn_YdEQgv#IC_ 8q;(U
FRRkk0b04RL.q_PAJZd#pY_$
E;RkRF00bkR.L4_sk)OV.XY$_pER;
R0FkbRk0L_44POF1dwsNN;Xw
FRRkk0b0gRL_Wmwh_agN
L;RkRF00bkR:rj49gnRjL4_WmwhDags;0C
HRRM0bkR:rj49g(R_Lg1$p$_ths7
;
RHRIsLCR4P6_Fd1OsNNwXIw_H
$;RHRIsLCR61_HW;OB
IRRHRsCL_4jkjzaKoBcw
s;RHRIsrCR.:gRRRj9L_4jMhYWaIghL
p;RCRso.RrgRR:jL9R4Mc_YaWhgLhIpd_L1
;
R#RN#MHoR_L6mxOauRR=4j'L;R

R#N#HRoML_44POF1dwsNNRXw=4RL6F_P1sOdNXwNwH_I$
;
R#RN#MHoR4L4_aMzZvdJ_p0	RL=R4Mc_YaWhgLhIpd_L19rj;R

R#N#HRoML_4jmhwWasgD0=CRRg{L_$1p$s_htj7rRj:R9L,Rgp_1$h$_srt74RR:4R9,L1g_p_$$h7str:.RR,.9R_Lg1$p$_ths7Rrd:cRd9L,Rgp_1$h$_srt7d:6RR9nn,gRL_$1p$s_htn7r(RR:n,g9RR
RRRRRRRRRRLRRgp_1$h$_srt7(:jRR9(.,gRL_$1p$s_ht(7rdRR:(,n9R_Lg1$p$_ths7(r(RU:RjR9,L1g_p_$$h7strRU4:4R4.R9,L1g_p_$$h7strd44R4:Rc,c9R_Lg1$p$_ths7cr46RR:49c6,RR
RRRRRRRRRRRRL1g_p_$$h7strn4cR4:Rc,n9R_Lg1$p$_ths7cr4(RR:49cU,gRL_$1p$s_ht47rc:gRRj469L,Rgp_1$h$_srt74R64:6R44R9,L1g_p_$$h7str.46R4:R6,.9R_Lg1$p$_ths76r4dRR:4966,RR
RRRRRRRRRRRRL1g_p_$$h7strn46R4:R6,U9R_Lg1$p$_ths76r4gRR:49nj,gRL_$1p$s_ht47rn:4RR.4n9L,Rgp_1$h$_srt74Rnd:gR4cR9,L1g_p_$$h7str64gR4:Rg,69R_Lg1$p$_ths7gr4nRR:49gn}R;
RINDNR$#@R@5bCF#8RoCL[(_Wd1_P2WRRoLCHRM
RHRRVL5R44c_8paOIV_pAdu_H|R|R4L4_sk)OV.XY]_X2CRLo
HMRRRRRVRHRL5R(w_Mt7jsYR2
RRRRRLRR4Mc_YaWhgLhIpd_L1RR=L_4jMhYWaIghL
p;RRRRRDRC#HCRVLR56P_m$2]d
RRRRRRRRcL4_WMYhhagI_LpLRd1=LR{dp_u$L,R4Mc_YaWhgLhIpd_L1gr.:}49;R
RRMRC8R
RC
M8R(RL_AmB$BpXR4y5cL2R6z_MaRta5R
RRLR3ci_mKLN5ci_mK,N2
RRRR(3L_$u1H#Dg5jL4_akzjcKBo2ws,R
RRLR3(W_[1P_dW(5L_1[W_WdP2R,
R3RRLm6_Pd$]5_L6m]P$d
2,RRRR3_Ln80Z#dLg54kd_pd6QB_0F[Auw2R,
R3RRLud_pL$5dp_u$
2,RRRR3_LnM_V#VLw54M._zAaToLV7_2L8,R
RRLR344c_8paOIV_pAdu_H45Lc8_4aIOp_ApVuH_d2R,
R3RRL_4jMQYEd_g#wL054M6_YdEQgv#IC_ 8v,o2
RRRR43L4q_PAJZd#XY_]45L4q_PAJZd#XY_]
2,RRRR34L4_sk)OV.XY]_X54L4_sk)OV.XY]_X2R,
R3RRLH6_1BWO5_L6HO1WB
2,RRRR3_LgmhwWaNg_Lg5L_Wmwh_agN,L2
RRRR43L.F_P1_Odo#lNLLL54P6_Fd1OsNNwXIw_H,$2
RRRR(3L_tMwjYs75_L(Mjwts27Y,R
RRLR3(V_M#I_d$45Ldz_MaoTAV_7LZ2c7,R
RRLR3(z_MaI_d$45LnY_MEgQd#CIv q8_(,U2
RRRR43L.q_PAJZd#pY_$LE54P._qdAZJ_#Yp2$E,R
RRLR34M4_zdaZJ0v_	Lp54M4_zdaZJ0v_	,p2
RRRR43L.)_ksXO.VpY_$LE54k._).sOX_VYp2$E2
;
R(RL_wuVxYshR_LcuxVwRR5
R3RRLmc_i5KNLmc_i2KN,R
RRLR36F_P15OdL_46POF1dwsNN_XwI2H$,R
RRLR361_HW5OBLH6_1BWO2R,
R3RRL1g_p_$$h7st5_Lg1$p$_ths7
2,RRRR3_L(uH1$D5g#L_4jkjzaKoBcw,s2
RRRR(3L_1[W_WdP5_L([_W1d2PW,R
RRLR3(i_uKgN_k(5L_KuiNk_g2R,
R3RRLud_pL$5dp_u$
2,RRRR3_L6m]P$d65L_$mP],d2
RRRR43LjY_MWghahpIL5jL4_WMYhhagI2Lp,R
RRLR3dp_uwd5L_wup2
2;
8CMlkF8D
C
lkF8DDCR84HO_
j5RpRBij4jvk_m0
,RRpRBij.jvk_m0
,RRpRBiv6j_0mk,RR
R7]q71)_j
,RRqR]7_7)1R4,
]RRA1z)aj_1,RR
Rz]A)_1a1R4,
]RRua)m_,1jRR
R]mu)a4_1,RR
R7])q_aq1Rj,
]RR)a7qq4_1,RR
R ])q_7YQ1h_j
,RR)R] Yq7__Qh1R4,
]RR)u 1_,1jRR
R]1) u4_1,RR
R ]1pj_1,RR
R ]1p4_1,RR
RQ]1Z1 _j
,RR1R]Q_Z 1R4,
]RRah)q1j_1,RR
R)]aq_h11R4,
]RRWa7qqj_1,RR
R)]WQ_a 1Rj,
]RRWa)Q 4_1,RR
RiBp,RR
RDkbH_M	d
2;
bHMkB0Rpji4jmv_k
0;HkMb0pRBij.jvk_m0H;
M0bkRiBp6_jvm;k0
bHMkr0Rdj4:9qR]7_7)1
j;HkMb0dRr49:jR7]q71)_4H;
M0bkR:r.j]9RA1z)aj_1;M
HbRk0rj.:9AR]za)1_;14
bHMkr0Rd9:jR)]um1a_jH;
M0bkR:rdj]9Rua)m_;14
bHMkr0Rdj4:9)R]7qqa_;1j
bHMkr0Rdj4:9)R]7qqa_;14
bHMk]0R)7 qYh_Q_;1j
bHMk]0R)7 qYh_Q_;14
bHMkr0R49:jR ])11u_jH;
M0bkR:r4j]9R)u 1_;14
bHMk]0R1_ p1
j;HkMb01R] 1p_4H;
M0bkR:r.j]9R1 QZ_;1j
bHMkr0R.9:jRQ]1Z1 _4H;
M0bkR:r4j]9Rah)q1j_1;M
HbRk0rj4:9aR])1qh_;14
bHMkr0Rdj4:9WR]7qqa_;1j
bHMk]0RWa)Q j_1;M
HbRk0]QW)a1 _4H;
M0bkRiBp;k
F00bkR:rj49g(RDkbH_M	d
;
R#RN#MHoRDkbH_M	d9rjRB=Rpji4jmv_k
0;R#RN#MHoRDkbH_M	d9r4RB=Rpji.jmv_k
0;R#RN#MHoRDkbH_M	d9r.RB=Rpji6vk_m0R;
R#N#HRoMkHbDMd	_rdd:c=9RR7]q71)_jR;
R#N#HRoMkHbDMd	_r:d6nRn9=qR]7_7)1
4;R#RN#MHoRDkbH_M	d(rn:9ngR]=RA1z)aj_1;R
RNH##okMRbMDH	r_d((j:.=9RRz]A)_1a1
4;R#RN#MHoRDkbH_M	ddr(:9(nR]=Rua)m_;1j
NRR#o#HMbRkD	HM_(dr(j:U9RR=]mu)a4_1;R
RNH##okMRbMDH	r_dU44:4R.9=)R]7qqa_;1j
NRR#o#HMbRkD	HM_4dr44d:cRc9=)R]7qqa_;14
NRR#o#HMbRkD	HM_4drcR69=)R] Yq7__Qh1
j;R#RN#MHoRDkbH_M	dcr4n=9RR ])q_7YQ1h_4R;
R#N#HRoMkHbDMd	_r(4c:U4c9RR=]1) uj_1;R
RNH##okMRbMDH	r_d4:cg496jR]=R)u 1_;14
NRR#o#HMbRkD	HM_4dr6R49=1R] 1p_jR;
R#N#HRoMkHbDMd	_r.469RR=]p1 _;14
NRR#o#HMbRkD	HM_4dr64d:6R69=1R]Q_Z 1
j;R#RN#MHoRDkbH_M	d6r4n6:4U=9RRQ]1Z1 _4R;
R#N#HRoMkHbDMd	_rg46:j4n9RR=]qa)h11_jR;
R#N#HRoMkHbDMd	_r44n:.4n9RR=]qa)h11_4R;
R#N#HRoMkHbDMd	_rd4n:c4g9RR=]qW7a1q_jR;
R#N#HRoMkHbDMd	_r64g9RR=]QW)a1 _jR;
R#N#HRoMkHbDMd	_rn4g9RR=]QW)a1 _4R;
R#N#HRoMkHbDMd	_r(4g9RR=B;pi
8CMlkF8D
C
lkF8DHCRH_OCjR5
RlOFlH.HODC_H_M	HCHO_Rj,
HRRH.OCOlFl_MDH	H_HOjC_,RR
RHl8OH_DMR	2/#*R$EM0C##HRM#$_CEHsE="N"s8RR*/;R
RHkMb0jRr:Rg9OlFl.OHHCH_DMH	_H_OCjR;
R0FkbRk0rjj:9HRHOOC.F_llD	HM_OHHC;_j
HRRM0bkR:rj49g(RHl8OH_DM
	;
IRRHRsCLmc_i;KN
IRRHRsCLw(_YALw_Rw,Lw(_YALw_
t;RHRIsLCRcp_u$
w;RHRIsLCRU1_u$oHAYRt,LuU_1.$HX,YtRjL4_Wmwh	agE,w0R_L(uH1$d,I$R_LguH1$.GXvVR;
RsIHCgRL_WmwhvagGRV,L1U_FVWtW,YYR_LUmhwWatgY;R
RICHsRgr4n9:jRjL4_WmwhDags;0C
sRRCroRjg:4(l9R8_HOD	HM_osCRR/*#0$MEHC##$R#Ms_bCs#CP4C=R;*/
R
RNH##oLMR(Y_wL_wAtRR=44'L;R
RNH##oLMR(Y_wL_wAwRR=4j'L;R
RNH##oLMRci_mK=NRRHl8OH_DM4	rg;(9
NRRD$IN#@R@5_L(wwYLAR_wFlsR8_HOD	HM2CRLoRHM:8RlHDO_H_M	#kC0bR
RR8RlHDO_H_M	srCo49g(RR<=Lw(_YALw_
w;RMRC8R

RINDNR$#@b@5F8#CoLCRci_mKRN2LHCoMRR:lO8H_MDH	N_D0
OERRRRlO8H_MDH	C_soRrj:9RjRR<=lO8H_MDH	Rrj:9Rj;R
RR8RlHDO_H_M	srCo4RR:4<9R=8RlHDO_HrM	4RR:4
9;RRRRlO8H_MDH	C_soRr.:9R.RR<=lO8H_MDH	Rr.:9R.;R
RR8RlHDO_H_M	srCodRR:dRc9<l=R8_HOD	HMr:dRR9dc;R
RR8RlHDO_H_M	srCod:6RR9nnRR<=lO8H_MDH	6rdRn:Rn
9;RRRRlO8H_MDH	C_so(rnRn:Rg<9R=8RlHDO_HrM	n:(RR9ng;R
RR8RlHDO_H_M	srCo(:jRR9(.RR<=lO8H_MDH	jr(R(:R.
9;RRRRlO8H_MDH	C_sodr(R(:Rn<9R=8RlHDO_HrM	(:dRR9(n;R
RR8RlHDO_H_M	srCo(:(RR9UjRR<=lO8H_MDH	(r(RU:Rj
9;RRRRlO8H_MDH	C_so4rUR4:R4R.9<l=R8_HOD	HMrRU4:4R4.
9;RRRRlO8H_MDH	C_so4r4dRR:49ccRR<=lO8H_MDH	4r4dRR:49cc;R
RR8RlHDO_H_M	srCo4Rc6:cR46<9R=8RlHDO_HrM	4Rc6:cR46
9;RRRRlO8H_MDH	C_socr4nRR:49cnRR<=lO8H_MDH	cr4nRR:49cn;R
RR8RlHDO_H_M	srCo4Rc(:cR4U<9R=8RlHDO_HrM	4Rc(:cR4U
9;RRRRlO8H_MDH	C_socr4gRR:496jRR<=lO8H_MDH	cr4gRR:496j;R
RR8RlHDO_H_M	srCo4R64:6R44<9R=8RlHDO_HrM	4R64:6R44
9;RRRRlO8H_MDH	C_so6r4.RR:496.RR<=lO8H_MDH	6r4.RR:496.;R
RR8RlHDO_H_M	srCo4R6d:6R46<9R=8RlHDO_HrM	4R6d:6R46
9;RRRRlO8H_MDH	C_so6r4nRR:496URR<=lO8H_MDH	6r4nRR:496U;R
RR8RlHDO_H_M	srCo4R6g:nR4j<9R=8RlHDO_HrM	4R6g:nR4j
9;RRRRlO8H_MDH	C_sonr44RR:49n.RR<=lO8H_MDH	nr44RR:49n.;R
RR8RlHDO_H_M	srCo4Rnd:gR4c<9R=8RlHDO_HrM	4Rnd:gR4c
9;RRRRlO8H_MDH	C_sogr46RR:49g6RR<=lO8H_MDH	gr46RR:49g6;R
RR8RlHDO_H_M	srCo4Rgn:gR4n<9R=8RlHDO_HrM	4Rgn:gR4n
9;RMRC8R

R_Ld4R.lL4U_.Ql_wRpY5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR43Ldp_k6BQd0[F_uRwAROR5F.llHCHO_MDH	H_HOjC_r2n9,R
RRLR3(w_Mt7jsYRRR5lOFlH.HODC_H_M	HCHO_(jr9
2,RRRR3_L(uNiK_RgkRLR5U1_u$oHAY,t2
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pR$RRRRRRc5L_$upw
2,RRRR3_LduRpwRRRRRLR5(1_u$IHd$
2,RRRR3_L6mxOauRRRRLR5g1_u$XH.v2GV,R
RRLR34Md_zAaToLV7_7ZcR45Ldz_MaoTAV_7LZ2c7,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Mn_YdEQgv#IC_ 8qR(U5nL4_EMYQ#dgI vC8(_qU
2,RRRR36L4_EMYQ#dgI vC8o_vR45L6Y_MEgQd#CIv v8_o
2,RRRR3.L4_APqZ#dJY$_pELR54P._qdAZJ_#Yp2$E,R
RRLR34P4_qdAZJ_#YX5]RL_44PZqAdYJ#_2X],R
RRLR34k._).sOX_VYpR$E5.L4_sk)OV.XY$_pE
2,RRRR34L4_sk)OV.XY]_XR45L4)_ksXO.VXY_]
2,RRRR34L4_1PFONdswwNXRU5L_W1FtYVWY
2,RRRR3_LgmhwWaNg_LRRR5_LUmhwWatgY2R,
R3RRL_4jmhwWasgD0RCR5jL4_WmwhDags20C,R
RRLR3gp_1$h$_sRt7RlR58_HOD	HM_osC2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=R;*/
R
RLkd_iLsRUi_ksw_Qp5YR
RRRR43L4)_ksgO_kAsXL5RROlFl.OHHCH_DMH	_H_OCj9rc2R,
R3RRL_4dMwPlpG_V.ksLTOR5F.llHCHO_MDH	H_HOjC_rdj:9
2,RRRR3_LduRp$RF5OlHl.H_OCD	HM_OHHCr_j6,92
RRRRd3L_wupRHR5H.OCOlFl_MDH	H_HOjC_r2j9,R
RRLR3(p_u$D_uvLR5cp_u$,w2
RRRR43L.1_u$oHAV_7LL58RLuU_1A$Ho2Yt,R
RRLR34u._1.$HXwVY_RL85_LUuH1$.tXY2R,
R3RRL_4cmhwWaEg	W_J]d5HRL_4jmhwWaEg	w,02
RRRR43Ld1_u$oHAV_7LZRc75_L(uH1$d2I$,R
RRLR34ud_1.$HXwVY_7ZcRg5L_$u1Hv.XG,V2
RRRR43L6w_mWgha	JEW]g_)	LR5gw_mWghav2GV,R
RRLR34M._zAaToLV7_RL85.L4_aMzTVAo7LL_8
2,RRRR3cL4_a48O_pIpuVA_RdH5cL4_a48O_pIpuVA_2dH,R
RRLR34Md_zAaToLV7_7ZcRLR54Md_zAaToLV7_7Zc2R,
R3RRL_46MQYEdIg#v8C _Rvo56L4_EMYQ#dgI vC8o_v2R,
R3RRL_4nMQYEdIg#v8C _Uq(RLR54Mn_YdEQgv#IC_ 8q2(U,R
RRLR34P4_qdAZJ_#YXR]R54L4_APqZ#dJY]_X2R,
R3RRL_4.PZqAdYJ#_Ep$RLR54P._qdAZJ_#Yp2$E,R
RRLR34k4_).sOX_VYXR]R54L4_sk)OV.XY]_X2R,
R3RRL_4.kO)s.YXV_Ep$RLR54k._).sOX_VYp2$E
2RRRR/*#0$MEHC##$R#MF_MbMskCR=4*
/;R(RL_Wmwh#agR_Ld1RFW5R
RRLR3ci_mKRNRRRRR5_LcmNiK2R,
R3RRL[(_Wd1_PRWRRF5OlHl.H_OCD	HM_OHHCr_jg,92
RRRR(3L_KuiNk_gR5RRL_4jmhwWaEg	w,02
RRRR63L_$mP]RdRR5RROlFl.OHHCH_DMH	_H_OCj9rU2R,
R3RRLud_pRwRRRRRRg5L_WmwhvagG,V2
RRRR63L_1PFORdRR5RRL1U_FVWtW2YY,R
RRLR3(w_mWghapRRR5jL4_WmwhDags20C,R
RRLR3gw_mWgha_RNL5_LUmhwWatgY2R
R2*R/RM#$0#ECH##R$MM_FkbsM4C=RR*/;M
C88lFk
DC
