/*----------------------------------------------------------
	File Name   : gpio.h 
	Description : GPIO API
	Created by  : SHMT SOC Team
-----------------------------------------------------------*/
#ifndef _GPIO_H_
#define _GPIO_H_
/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        DEFINITION
///////////////////////////////////////////////////////// */

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */

void GPIOOutputEnable(unsigned oe);
void GPIOWrite(unsigned data);
unsigned GPIORead(void);
#endif
