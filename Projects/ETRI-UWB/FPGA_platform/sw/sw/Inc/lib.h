/*-------------------------------------------------------------------
File name   : lib.h

Description : middle level routines
---------------------------------------------------------------------- */
#ifndef __LIB_H__
#define __LIB_H__

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */

#include "sysinc.h"
#include "structDef.h"
#include "Commonmacro.h"

/*/////////////////////////////////////////////////////////
        DEFINITION
///////////////////////////////////////////////////////// */

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */

smtBoolean smtDelay100us(int time);

/*---------------------------------------------------------
        MEMORY
--------------------------------------------------------- */
/* ESMC */
smtBoolean smtMemoryWrite(smtUint32 addr, smtUint32 *data, smtUint32 length);
smtBoolean smtMemoryRead(smtUint32 addr, smtUint32 *data, smtUint32 length);

/*---------------------------------------------------------
        UART
--------------------------------------------------------- */

/*---------------------------------------------------------
        I2C
--------------------------------------------------------- */

/*---------------------------------------------------------
        TIMER & PWM
--------------------------------------------------------- */

/*---------------------------------------------------------
        GPIO
--------------------------------------------------------- */

/*---------------------------------------------------------
        VIC (Vectored Interrupt Controller)
--------------------------------------------------------- */


/*---------------------------------------------------------
        ADC
--------------------------------------------------------- */

/*---------------------------------------------------------
        POWER MANAGEMENT
--------------------------------------------------------- */

#endif /* __LIB_H__ */

