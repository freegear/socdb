/*----------------------------------------------------------
	File Name   : structDef.h
	Description : SDI V5 struct definition header file
	Created by  : SHMT SOC Team
-----------------------------------------------------------*/
#ifndef __STRUCTDEF_H__
#define __STRUCTDEF_H__

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */

#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        DEFINITION
///////////////////////////////////////////////////////// */

/*--------------------------------------------------------
        External sram
--------------------------------------------------------*/

/*--------------------------------------------------------
        UART
--------------------------------------------------------*/

/*--------------------------------------------------------
        I2C
--------------------------------------------------------*/

/*--------------------------------------------------------
        Timer & PWM
--------------------------------------------------------*/

/*--------------------------------------------------------
        WDT
--------------------------------------------------------*/

/*--------------------------------------------------------
        GPIO
--------------------------------------------------------*/

/*--------------------------------------------------------
        VIC
--------------------------------------------------------*/

/*--------------------------------------------------------
        ADC
--------------------------------------------------------*/

/*--------------------------------------------------------
        Power Management
--------------------------------------------------------*/

#endif  /* __STRUCTDEF_H__ */
