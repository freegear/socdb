/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File name		: global.h
	Description	: Firmware global variable header file
----------------------------------------------------------*/
#ifndef __GLOBAL_VAR_H__
#define __GLOBAL_VAR_H__

/*
/////////////////////////////////////////////////////////
	INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"
#include "structdef.h"

/*
/////////////////////////////////////////////////////////
	GLOBAL VARIABLE DECLARATION
///////////////////////////////////////////////////////// 
*/

#ifdef GLOBAL_DEFINE
#define GLOBAL_VAR
#else
#define GLOBAL_VAR  extern
#endif

/*---------------------------------------------------------
        MEMEORY
--------------------------------------------------------- */

/*---------------------------------------------------------
        UART
--------------------------------------------------------- */



/*---------------------------------------------------------
        TIMER & PWM
--------------------------------------------------------- */


/*---------------------------------------------------------
        WDT
--------------------------------------------------------- */


/*---------------------------------------------------------
        GPIO
--------------------------------------------------------- */


/*---------------------------------------------------------
        VIC
--------------------------------------------------------- */


/*---------------------------------------------------------
        ADC
--------------------------------------------------------- */


/*---------------------------------------------------------
        POWER MANAGEMENT
--------------------------------------------------------- */
// Global variable for the power management
GLOBAL_VAR PM_POWER gPwr;

#endif /* __GLOBAL_VAR_H__ */
