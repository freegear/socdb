/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File name		: norboot_code.h
	Description		: nor boot code
	Created by		: SHMT SOC Team
-----------------------------------------------------------*/
#ifndef __NOR_BOOT_CODE_H__
#define __NOR_BOOT_CODE_H__

/*
/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// 
*/
#include "sysinc.h"

smtUint32 norBootCode[] = 
{
			0xe59f00a8,    //0x00000000 :....    DCD    3852402856
            0xe59f10a8,    //0x00000004 :....    DCD    3852406952
            0xe59f20a8,    //0x00000008 :. ..    DCD    3852411048
            0xe59f30a8,    //0x0000000c :.0..    DCD    3852415144
            0xe59f40a8,    //0x00000010 :.@..    DCD    3852419240
            0xe59f50a8,    //0x00000014 :.P..    DCD    3852423336
            0xe5805000,    //0x00000018 :.P..    DCD    3850391552
            0xe3a05024,    //0x0000001c :$P..    DCD    3818934308
            0xe5845000,    //0x00000020 :.P..    DCD    3850653696
            0xe3a05e41,    //0x00000024 :A^..    DCD    3818937921
            0xe5835000,    //0x00000028 :.P..    DCD    3850588160
            0xe3a050a1,    //0x0000002c :.P..    DCD    3818934433
            0xe5815000,    //0x00000030 :.P..    DCD    3850457088
            0xe3a0577c,    //0x00000034 :|W..    DCD    3818936188
            0xe5936000,    //0x00000038 :.`..    DCD    3851640832
            0xe0066005,    //0x0000003c :.`..    DCD    3758514181
            0xe3560000,    //0x00000040 :..V.    DCD    3814064128
            0x1afffffb,    //0x00000044 :....    DCD    452984827
            0xee110f10,    //0x00000048 :....    DCD    3994095376
            0xe3c00d40,    //0x0000004c :@...    DCD    3821014336
            0xee010f10,    //0x00000050 :....    DCD    3993046800
            0xee110f10,    //0x00000054 :....    DCD    3994095376
            0xe3c00004,    //0x00000058 :....    DCD    3821010948
            0xee010f10,    //0x0000005c :....    DCD    3993046800
            0xe3a00000,    //0x00000060 :....    DCD    3818913792
            0xee070f17,    //0x00000064 :....    DCD    3993440023
            0xee110f10,    //0x00000068 :....    DCD    3994095376
            0xe3c00001,    //0x0000006c :....    DCD    3821010945
            0xee010f10,    //0x00000070 :....    DCD    3993046800
            0xe3a00000,    //0x00000074 :....    DCD    3818913792
            0xee080f17,    //0x00000078 :....    DCD    3993505559
            0xeaffffff,    //0x0000007c :....    DCD    3942645759
            0xe3c000df,    //0x00000080 :....    DCD    3821011167
            0xe3801013,    //0x00000084 :....    DCD    3816820755
            0xe12ff001,    //0x00000088 :../.    DCD    3778015233
            0xe3a0d462,    //0x0000008c :b...    DCD    3818968162
            0xe10f0000,    //0x00000090 :....    DCD    3775856640
            0xe3800080,    //0x00000094 :....    DCD    3816816768
            0xe12ff000,    //0x00000098 :../.    DCD    3778015232
            0xe10f0000,    //0x0000009c :....    DCD    3775856640
            0xe3800040,    //0x000000a0 :@...    DCD    3816816704
            0xe12ff000,    //0x000000a4 :../.    DCD    3778015232
            0xeb000006,    //0x000000a8 :....    DCD    3942645766
            0xe1a0f000,    //0x000000ac :....    DCD    3785420800
            0x40004000,    //0x000000b0 :.@.@    DCD    1073758208
            0x40004004,    //0x000000b4 :.@.@    DCD    1073758212
            0x40004008,    //0x000000b8 :.@.@    DCD    1073758216
            0x4000400c,    //0x000000bc :.@.@    DCD    1073758220
            0x40004010,    //0x000000c0 :.@.@    DCD    1073758224
            0x00037535,    //0x000000c4 :5u..    DCD    226613
            0xe92d4038,    //0x000000c8 :8@-.    DCD    3912056888
            0xe3a04000,    //0x000000cc :.@..    DCD    3818930176
            0xe354000c,    //0x000000d0 :..T.    DCD    3813933068
            0x2a00001a,    //0x000000d4 :...*    DCD    704643098
            0xea000001,    //0x000000d8 :....    DCD    3925868545
            0xe2844001,    //0x000000dc :.@..    DCD    3800317953
            0xeafffffa,    //0x000000e0 :....    DCD    3942645754
            0xe59f0064,    //0x000000e4 :d...    DCD    3852402788
            0xe5804008,    //0x000000e8 :.@..    DCD    3850387464
            0xe59f5060,    //0x000000ec :`P..    DCD    3852423264
            0xe3a00b80,    //0x000000f0 :....    DCD    3818916736
            0xe0800984,    //0x000000f4 :....    DCD    3766487428
            0xe59f1058,    //0x000000f8 :X...    DCD    3852406872
            0xe5810000,    //0x000000fc :....    DCD    3850436608
            0xe59f0054,    //0x00000100 :T...    DCD    3852402772
            0xe0800984,    //0x00000104 :....    DCD    3766487428
            0xe5810004,    //0x00000108 :....    DCD    3850436612
            0xe1a00001,    //0x0000010c :....    DCD    3785359361
            0xe5805008,    //0x00000110 :.P..    DCD    3850391560
            0xe3a00001,    //0x00000114 :....    DCD    3818913793
            0xe1c11000,    //0x00000118 :....    DCD    3787526144
            0xe581000c,    //0x0000011c :....    DCD    3850436620
            0xe3a00298,    //0x00000120 :....    DCD    3818914456
            0xe1c11000,    //0x00000124 :....    DCD    3787526144
            0xe5810010,    //0x00000128 :....    DCD    3850436624
            0xe1a00000,    //0x0000012c :....    DCD    3785359360
            0xe59f0020,    //0x00000130 : ...    DCD    3852402720
            0xe5900010,    //0x00000134 :....    DCD    3851419664
            0xe3100009,    //0x00000138 :....    DCD    3809476617
            0x0afffffb,    //0x0000013c :....    DCD    184549371
            0xeaffffe5,    //0x00000140 :....    DCD    3942645733
            0xe59f0010,    //0x00000144 :....    DCD    3852402704
            0xebffffd7,    //0x00000148 :....    DCD    3959422935
            0xe8bd8038,    //0x0000014c :8...    DCD    3904733240
            0x50002000,    //0x00000150 :. .P    DCD    1342185472
            0x3b580000,    //0x00000154 :..X;    DCD    995622912
            0x4000c000,    //0x00000158 :...@    DCD    1073790976
            0x60100000     //0x0000015c :...`    DCD    1611661312
};
#endif// __NOR_BOOT_CODE_H__