// ARM7TDMI.v shipped with DSM AT010-MS-28302-3A-00
//
// Verilog implementation of ARM7TDMI, generated by simwrap

// Elements of the code in this file are
// Copyright 1993-99, 2000-02 ARM Ltd,
// All rights reserved.

`timescale 1 ps / 1 ps

// Inout shell

module ARM7TDMI_inout (A,
  ABE,
  ABORT,
  ALE,
  APE,
  BIGEND,
  BL,
  BREAKPT,
  BUSDIS,
  BUSEN,
  COMMRX,
  COMMTX,
  CPA,
  CPB,
  D_xmgxread,
  D,
  DBE,
  DBGACK,
  DBGEN,
  DBGRQ,
  DBGRQI,
  DIN,
  DOUT,
  DRIVEBS,
  ECAPCLK,
  ECAPCLKBS,
  ECLK,
  EXTERN0,
  EXTERN1,
  HIGHZ,
  ICAPCLKBS,
  IR,
  ISYNC,
  LOCK,
  MAS,
  MCLK,
  nCPI,
  nENIN,
  nENOUT,
  nENOUTI,
  nEXEC,
  nFIQ,
  nHIGHZ,
  nIRQ,
  nM,
  nMREQ,
  nOPC,
  nRESET,
  nRW,
  nTDOEN,
  nTRANS,
  nTRST,
  nWAIT,
  PCLKBS,
  RANGEOUT0,
  RANGEOUT1,
  RSTCLKBS,
  SCREG,
  SDINBS,
  SDOUTBS,
  SEQ,
  SHCLK2BS,
  SHCLKBS,
  TAPSM,
  TBE,
  TBIT,
  TCK,
  TCK1,
  TCK2,
  TDI,
  TDO,
  TMS,
  r0,
  r1,
  r2,
  r3,
  r4,
  r5,
  r6,
  r7,
  r8,
  r9,
  r10,
  r11,
  r12,
  r13,
  r14,
  r15,
  r8fiq,
  r9fiq,
  r10fiq,
  r11fiq,
  r12fiq,
  r13fiq,
  r14fiq,
  r13irq,
  r14irq,
  r13svc,
  r14svc,
  r13abt,
  r14abt,
  r13und,
  r14und,
  cpsr,
  spsrfiq,
  spsrirq,
  spsrsvc,
  spsrabt,
  spsrund,
  icewp0addr,
  icewp0amask,
  icewp0data,
  icewp0dmask,
  icewp0ctl,
  icewp0cmask,
  icewp1addr,
  icewp1amask,
  icewp1data,
  icewp1dmask,
  icewp1ctl,
  icewp1cmask,
  icedbgctl,
  icedbgstatus,
  normal,
  scan,
  dclk,
  dbg,
  hghz,
  testBus,
  testDBus,
  enterDbg,
  leavingscan,
  leavingdclk,
  scan1Dbg,
  scan0Dbg,
  sc2updatedr,
  reads,
  mem,
  busen1,
  isync1,
  bl3,
  bl2,
  bl1,
  bl0,
  capture048,
  capture0148);

output [31:0] A;
input ABE;
input ABORT;
input ALE;
input APE;
input BIGEND;
input [3:0] BL;
input BREAKPT;
output BUSDIS;
input BUSEN;
output COMMRX;
output COMMTX;
input CPA;
input CPB;
input [31:0] D_xmgxread;
output [31:0] D;
input DBE;
output DBGACK;
input DBGEN;
input DBGRQ;
output DBGRQI;
input [31:0] DIN;
output [31:0] DOUT;
output DRIVEBS;
output ECAPCLK;
output ECAPCLKBS;
output ECLK;
input EXTERN0;
input EXTERN1;
output HIGHZ;
output ICAPCLKBS;
output [3:0] IR;
input ISYNC;
output LOCK;
output [1:0] MAS;
input MCLK;
output nCPI;
input nENIN;
output nENOUT;
output nENOUTI;
output nEXEC;
input nFIQ;
output nHIGHZ;
input nIRQ;
output [4:0] nM;
output nMREQ;
output nOPC;
input nRESET;
output nRW;
output nTDOEN;
output nTRANS;
input nTRST;
input nWAIT;
output PCLKBS;
output RANGEOUT0;
output RANGEOUT1;
output RSTCLKBS;
output [3:0] SCREG;
output SDINBS;
input SDOUTBS;
output SEQ;
output SHCLK2BS;
output SHCLKBS;
output [3:0] TAPSM;
input TBE;
output TBIT;
input TCK;
output TCK1;
output TCK2;
input TDI;
output TDO;
input TMS;
output [31:0] r0;
output [31:0] r1;
output [31:0] r2;
output [31:0] r3;
output [31:0] r4;
output [31:0] r5;
output [31:0] r6;
output [31:0] r7;
output [31:0] r8;
output [31:0] r9;
output [31:0] r10;
output [31:0] r11;
output [31:0] r12;
output [31:0] r13;
output [31:0] r14;
output [31:0] r15;
output [31:0] r8fiq;
output [31:0] r9fiq;
output [31:0] r10fiq;
output [31:0] r11fiq;
output [31:0] r12fiq;
output [31:0] r13fiq;
output [31:0] r14fiq;
output [31:0] r13irq;
output [31:0] r14irq;
output [31:0] r13svc;
output [31:0] r14svc;
output [31:0] r13abt;
output [31:0] r14abt;
output [31:0] r13und;
output [31:0] r14und;
output [31:0] cpsr;
output [31:0] spsrfiq;
output [31:0] spsrirq;
output [31:0] spsrsvc;
output [31:0] spsrabt;
output [31:0] spsrund;
output [31:0] icewp0addr;
output [31:0] icewp0amask;
output [31:0] icewp0data;
output [31:0] icewp0dmask;
output [8:0] icewp0ctl;
output [7:0] icewp0cmask;
output [31:0] icewp1addr;
output [31:0] icewp1amask;
output [31:0] icewp1data;
output [31:0] icewp1dmask;
output [8:0] icewp1ctl;
output [7:0] icewp1cmask;
output [2:0] icedbgctl;
output [4:0] icedbgstatus;
output normal;
output scan;
output dclk;
output dbg;
output hghz;
output testBus;
output testDBus;
output enterDbg;
output leavingscan;
output leavingdclk;
output scan1Dbg;
output scan0Dbg;
output sc2updatedr;
output reads;
output mem;
output busen1;
output isync1;
output bl3;
output bl2;
output bl1;
output bl0;
output capture048;
output capture0148;

reg [31:0] A;
reg BUSDIS;
reg COMMRX;
reg COMMTX;
reg [31:0] D;
reg DBGACK;
reg DBGRQI;
reg [31:0] DOUT;
reg DRIVEBS;
reg ECAPCLK;
reg ECAPCLKBS;
reg ECLK;
reg HIGHZ;
reg ICAPCLKBS;
reg [3:0] IR;
reg LOCK;
reg [1:0] MAS;
reg nCPI;
reg nENOUT;
reg nENOUTI;
reg nEXEC;
reg nHIGHZ;
reg [4:0] nM;
reg nMREQ;
reg nOPC;
reg nRW;
reg nTDOEN;
reg nTRANS;
reg PCLKBS;
reg RANGEOUT0;
reg RANGEOUT1;
reg RSTCLKBS;
reg [3:0] SCREG;
reg SDINBS;
reg SEQ;
reg SHCLK2BS;
reg SHCLKBS;
reg [3:0] TAPSM;
reg TBIT;
reg TCK1;
reg TCK2;
reg TDO;
reg [31:0] r0;
reg [31:0] r1;
reg [31:0] r2;
reg [31:0] r3;
reg [31:0] r4;
reg [31:0] r5;
reg [31:0] r6;
reg [31:0] r7;
reg [31:0] r8;
reg [31:0] r9;
reg [31:0] r10;
reg [31:0] r11;
reg [31:0] r12;
reg [31:0] r13;
reg [31:0] r14;
reg [31:0] r15;
reg [31:0] r8fiq;
reg [31:0] r9fiq;
reg [31:0] r10fiq;
reg [31:0] r11fiq;
reg [31:0] r12fiq;
reg [31:0] r13fiq;
reg [31:0] r14fiq;
reg [31:0] r13irq;
reg [31:0] r14irq;
reg [31:0] r13svc;
reg [31:0] r14svc;
reg [31:0] r13abt;
reg [31:0] r14abt;
reg [31:0] r13und;
reg [31:0] r14und;
reg [31:0] cpsr;
reg [31:0] spsrfiq;
reg [31:0] spsrirq;
reg [31:0] spsrsvc;
reg [31:0] spsrabt;
reg [31:0] spsrund;
reg [31:0] icewp0addr;
reg [31:0] icewp0amask;
reg [31:0] icewp0data;
reg [31:0] icewp0dmask;
reg [8:0] icewp0ctl;
reg [7:0] icewp0cmask;
reg [31:0] icewp1addr;
reg [31:0] icewp1amask;
reg [31:0] icewp1data;
reg [31:0] icewp1dmask;
reg [8:0] icewp1ctl;
reg [7:0] icewp1cmask;
reg [2:0] icedbgctl;
reg [4:0] icedbgstatus;
reg normal;
reg scan;
reg dclk;
reg dbg;
reg hghz;
reg testBus;
reg testDBus;
reg enterDbg;
reg leavingscan;
reg leavingdclk;
reg scan1Dbg;
reg scan0Dbg;
reg sc2updatedr;
reg reads;
reg mem;
reg busen1;
reg isync1;
reg bl3;
reg bl2;
reg bl1;
reg bl0;
reg capture048;
reg capture0148;
parameter
  whichlog = 0,
  JTAG_ID = 1057951503,
  MG_LOGFILE_NAME = "",
  MG_FORCED_DELAY = 0,
  MG_OBJECT = "$DIR_ARM7TDMI",
  MG_OMI_PATH = "",
  MG_MSG_TIME = 0,
  MG_MSG_INSTANCE = 0,
  MG_MSG_SEVERITY = "",
  MG_MSG_SUPPRESS = "",
  MG_MSG_V4_FORMAT = 0;

initial
  begin
    $mm("ARM7TDMI?locator=MG_OBJECT",A,
    ABE,
    ABORT,
    ALE,
    APE,
    BIGEND,
    BL,
    BREAKPT,
    BUSDIS,
    BUSEN,
    COMMRX,
    COMMTX,
    CPA,
    CPB,
    D_xmgxread,
    D,
    DBE,
    DBGACK,
    DBGEN,
    DBGRQ,
    DBGRQI,
    DIN,
    DOUT,
    DRIVEBS,
    ECAPCLK,
    ECAPCLKBS,
    ECLK,
    EXTERN0,
    EXTERN1,
    HIGHZ,
    ICAPCLKBS,
    IR,
    ISYNC,
    LOCK,
    MAS,
    MCLK,
    nCPI,
    nENIN,
    nENOUT,
    nENOUTI,
    nEXEC,
    nFIQ,
    nHIGHZ,
    nIRQ,
    nM,
    nMREQ,
    nOPC,
    nRESET,
    nRW,
    nTDOEN,
    nTRANS,
    nTRST,
    nWAIT,
    PCLKBS,
    RANGEOUT0,
    RANGEOUT1,
    RSTCLKBS,
    SCREG,
    SDINBS,
    SDOUTBS,
    SEQ,
    SHCLK2BS,
    SHCLKBS,
    TAPSM,
    TBE,
    TBIT,
    TCK,
    TCK1,
    TCK2,
    TDI,
    TDO,
    TMS,
    r0,
    r1,
    r2,
    r3,
    r4,
    r5,
    r6,
    r7,
    r8,
    r9,
    r10,
    r11,
    r12,
    r13,
    r14,
    r15,
    r8fiq,
    r9fiq,
    r10fiq,
    r11fiq,
    r12fiq,
    r13fiq,
    r14fiq,
    r13irq,
    r14irq,
    r13svc,
    r14svc,
    r13abt,
    r14abt,
    r13und,
    r14und,
    cpsr,
    spsrfiq,
    spsrirq,
    spsrsvc,
    spsrabt,
    spsrund,
    icewp0addr,
    icewp0amask,
    icewp0data,
    icewp0dmask,
    icewp0ctl,
    icewp0cmask,
    icewp1addr,
    icewp1amask,
    icewp1data,
    icewp1dmask,
    icewp1ctl,
    icewp1cmask,
    icedbgctl,
    icedbgstatus,
    normal,
    scan,
    dclk,
    dbg,
    hghz,
    testBus,
    testDBus,
    enterDbg,
    leavingscan,
    leavingdclk,
    scan1Dbg,
    scan0Dbg,
    sc2updatedr,
    reads,
    mem,
    busen1,
    isync1,
    bl3,
    bl2,
    bl1,
    bl0,
    capture048,
    capture0148);
  end

endmodule

// Timing shell

`celldefine
`delay_mode_path

module ARM7TDMI_timing (
A,
    ABE,
    ABORT,
    ALE,
    APE,
    BIGEND,
    BL,
    BREAKPT,
    BUSDIS,
    BUSEN,
    COMMRX,
    COMMTX,
    CPA,
    CPB,
    D,
    DBE,
    DBGACK,
    DBGEN,
    DBGRQ,
    DBGRQI,
    DIN,
    DOUT,
    DRIVEBS,
    ECAPCLK,
    ECAPCLKBS,
    ECLK,
    EXTERN0,
    EXTERN1,
    HIGHZ,
    ICAPCLKBS,
    IR,
    ISYNC,
    LOCK,
    MAS,
    MCLK,
    nCPI,
    nENIN,
    nENOUT,
    nENOUTI,
    nEXEC,
    nFIQ,
    nHIGHZ,
    nIRQ,
    nM,
    nMREQ,
    nOPC,
    nRESET,
    nRW,
    nTDOEN,
    nTRANS,
    nTRST,
    nWAIT,
    PCLKBS,
    RANGEOUT0,
    RANGEOUT1,
    RSTCLKBS,
    SCREG,
    SDINBS,
    SDOUTBS,
    SEQ,
    SHCLK2BS,
    SHCLKBS,
    TAPSM,
    TBE,
    TBIT,
    TCK,
    TCK1,
    TCK2,
    TDI,
    TDO,
    TMS,
    r0,
    r1,
    r2,
    r3,
    r4,
    r5,
    r6,
    r7,
    r8,
    r9,
    r10,
    r11,
    r12,
    r13,
    r14,
    r15,
    r8fiq,
    r9fiq,
    r10fiq,
    r11fiq,
    r12fiq,
    r13fiq,
    r14fiq,
    r13irq,
    r14irq,
    r13svc,
    r14svc,
    r13abt,
    r14abt,
    r13und,
    r14und,
    cpsr,
    spsrfiq,
    spsrirq,
    spsrsvc,
    spsrabt,
    spsrund,
    icewp0addr,
    icewp0amask,
    icewp0data,
    icewp0dmask,
    icewp0ctl,
    icewp0cmask,
    icewp1addr,
    icewp1amask,
    icewp1data,
    icewp1dmask,
    icewp1ctl,
    icewp1cmask,
    icedbgctl,
    icedbgstatus);

output [31:0] A;
input ABE;
input ABORT;
input ALE;
input APE;
input BIGEND;
input [3:0] BL;
input BREAKPT;
output BUSDIS;
input BUSEN;
output COMMRX;
output COMMTX;
input CPA;
input CPB;
inout [31:0] D;
input DBE;
output DBGACK;
input DBGEN;
input DBGRQ;
output DBGRQI;
input [31:0] DIN;
output [31:0] DOUT;
output DRIVEBS;
output ECAPCLK;
output ECAPCLKBS;
output ECLK;
input EXTERN0;
input EXTERN1;
output HIGHZ;
output ICAPCLKBS;
output [3:0] IR;
input ISYNC;
output LOCK;
output [1:0] MAS;
input MCLK;
output nCPI;
input nENIN;
output nENOUT;
output nENOUTI;
output nEXEC;
input nFIQ;
output nHIGHZ;
input nIRQ;
output [4:0] nM;
output nMREQ;
output nOPC;
input nRESET;
output nRW;
output nTDOEN;
output nTRANS;
input nTRST;
input nWAIT;
output PCLKBS;
output RANGEOUT0;
output RANGEOUT1;
output RSTCLKBS;
output [3:0] SCREG;
output SDINBS;
input SDOUTBS;
output SEQ;
output SHCLK2BS;
output SHCLKBS;
output [3:0] TAPSM;
input TBE;
output TBIT;
input TCK;
output TCK1;
output TCK2;
input TDI;
output TDO;
input TMS;
output [31:0] r0;
output [31:0] r1;
output [31:0] r2;
output [31:0] r3;
output [31:0] r4;
output [31:0] r5;
output [31:0] r6;
output [31:0] r7;
output [31:0] r8;
output [31:0] r9;
output [31:0] r10;
output [31:0] r11;
output [31:0] r12;
output [31:0] r13;
output [31:0] r14;
output [31:0] r15;
output [31:0] r8fiq;
output [31:0] r9fiq;
output [31:0] r10fiq;
output [31:0] r11fiq;
output [31:0] r12fiq;
output [31:0] r13fiq;
output [31:0] r14fiq;
output [31:0] r13irq;
output [31:0] r14irq;
output [31:0] r13svc;
output [31:0] r14svc;
output [31:0] r13abt;
output [31:0] r14abt;
output [31:0] r13und;
output [31:0] r14und;
output [31:0] cpsr;
output [31:0] spsrfiq;
output [31:0] spsrirq;
output [31:0] spsrsvc;
output [31:0] spsrabt;
output [31:0] spsrund;
output [31:0] icewp0addr;
output [31:0] icewp0amask;
output [31:0] icewp0data;
output [31:0] icewp0dmask;
output [8:0] icewp0ctl;
output [7:0] icewp0cmask;
output [31:0] icewp1addr;
output [31:0] icewp1amask;
output [31:0] icewp1data;
output [31:0] icewp1dmask;
output [8:0] icewp1ctl;
output [7:0] icewp1cmask;
output [2:0] icedbgctl;
output [4:0] icedbgstatus;

// (Potentially) unused ports:

wire normal;
wire scan;
wire dclk;
wire dbg;
wire hghz;
wire testBus;
wire testDBus;
wire enterDbg;
wire leavingscan;
wire leavingdclk;
wire scan1Dbg;
wire scan0Dbg;
wire sc2updatedr;
wire reads;
wire mem;
wire busen1;
wire isync1;
wire bl3;
wire bl2;
wire bl1;
wire bl0;
wire capture048;
wire capture0148;

// Delayed signal defs:

wire ABE_XMGXnegd;
wire ABORT_XMGXnegd;
wire ALE_XMGXnegd;
wire APE_XMGXnegd;
wire BIGEND_XMGXnegd;
wire [3:0] BL_XMGXnegd;
wire BREAKPT_XMGXnegd;
wire BUSEN_XMGXnegd;
wire CPA_XMGXnegd;
wire CPB_XMGXnegd;
wire [31:0] D_XMGXnegd;
wire DBE_XMGXnegd;
wire DBGEN_XMGXnegd;
wire DBGRQ_XMGXnegd;
wire [31:0] DIN_XMGXnegd;
wire EXTERN0_XMGXnegd;
wire EXTERN1_XMGXnegd;
wire ISYNC_XMGXnegd;
wire MCLK_XMGXnegd;
wire nENIN_XMGXnegd;
wire nFIQ_XMGXnegd;
wire nIRQ_XMGXnegd;
wire nRESET_XMGXnegd;
wire nTRST_XMGXnegd;
wire nWAIT_XMGXnegd;
wire TCK_XMGXnegd;
wire TDI_XMGXnegd;
wire TMS_XMGXnegd;

// Buffering for backannotation

wire [31:0] A_XMGXi;
pmos(A[0], A_XMGXi[0], 0);
pmos(A[1], A_XMGXi[1], 0);
pmos(A[2], A_XMGXi[2], 0);
pmos(A[3], A_XMGXi[3], 0);
pmos(A[4], A_XMGXi[4], 0);
pmos(A[5], A_XMGXi[5], 0);
pmos(A[6], A_XMGXi[6], 0);
pmos(A[7], A_XMGXi[7], 0);
pmos(A[8], A_XMGXi[8], 0);
pmos(A[9], A_XMGXi[9], 0);
pmos(A[10], A_XMGXi[10], 0);
pmos(A[11], A_XMGXi[11], 0);
pmos(A[12], A_XMGXi[12], 0);
pmos(A[13], A_XMGXi[13], 0);
pmos(A[14], A_XMGXi[14], 0);
pmos(A[15], A_XMGXi[15], 0);
pmos(A[16], A_XMGXi[16], 0);
pmos(A[17], A_XMGXi[17], 0);
pmos(A[18], A_XMGXi[18], 0);
pmos(A[19], A_XMGXi[19], 0);
pmos(A[20], A_XMGXi[20], 0);
pmos(A[21], A_XMGXi[21], 0);
pmos(A[22], A_XMGXi[22], 0);
pmos(A[23], A_XMGXi[23], 0);
pmos(A[24], A_XMGXi[24], 0);
pmos(A[25], A_XMGXi[25], 0);
pmos(A[26], A_XMGXi[26], 0);
pmos(A[27], A_XMGXi[27], 0);
pmos(A[28], A_XMGXi[28], 0);
pmos(A[29], A_XMGXi[29], 0);
pmos(A[30], A_XMGXi[30], 0);
pmos(A[31], A_XMGXi[31], 0);
pmos(ABE_XMGXi, ABE, 0);
pmos(ABORT_XMGXi, ABORT, 0);
pmos(ALE_XMGXi, ALE, 0);
pmos(APE_XMGXi, APE, 0);
pmos(BIGEND_XMGXi, BIGEND, 0);
wire [3:0] BL_XMGXi;
pmos(BL_XMGXi[0], BL[0], 0);
pmos(BL_XMGXi[1], BL[1], 0);
pmos(BL_XMGXi[2], BL[2], 0);
pmos(BL_XMGXi[3], BL[3], 0);
pmos(BREAKPT_XMGXi, BREAKPT, 0);
pmos(BUSDIS, BUSDIS_XMGXi, 0);
pmos(BUSEN_XMGXi, BUSEN, 0);
pmos(COMMRX, COMMRX_XMGXi, 0);
pmos(COMMTX, COMMTX_XMGXi, 0);
pmos(CPA_XMGXi, CPA, 0);
pmos(CPB_XMGXi, CPB, 0);
wire [31:0] D_XMGXread;
pmos(D_XMGXread[0], D[0], 0);
pmos(D_XMGXread[1], D[1], 0);
pmos(D_XMGXread[2], D[2], 0);
pmos(D_XMGXread[3], D[3], 0);
pmos(D_XMGXread[4], D[4], 0);
pmos(D_XMGXread[5], D[5], 0);
pmos(D_XMGXread[6], D[6], 0);
pmos(D_XMGXread[7], D[7], 0);
pmos(D_XMGXread[8], D[8], 0);
pmos(D_XMGXread[9], D[9], 0);
pmos(D_XMGXread[10], D[10], 0);
pmos(D_XMGXread[11], D[11], 0);
pmos(D_XMGXread[12], D[12], 0);
pmos(D_XMGXread[13], D[13], 0);
pmos(D_XMGXread[14], D[14], 0);
pmos(D_XMGXread[15], D[15], 0);
pmos(D_XMGXread[16], D[16], 0);
pmos(D_XMGXread[17], D[17], 0);
pmos(D_XMGXread[18], D[18], 0);
pmos(D_XMGXread[19], D[19], 0);
pmos(D_XMGXread[20], D[20], 0);
pmos(D_XMGXread[21], D[21], 0);
pmos(D_XMGXread[22], D[22], 0);
pmos(D_XMGXread[23], D[23], 0);
pmos(D_XMGXread[24], D[24], 0);
pmos(D_XMGXread[25], D[25], 0);
pmos(D_XMGXread[26], D[26], 0);
pmos(D_XMGXread[27], D[27], 0);
pmos(D_XMGXread[28], D[28], 0);
pmos(D_XMGXread[29], D[29], 0);
pmos(D_XMGXread[30], D[30], 0);
pmos(D_XMGXread[31], D[31], 0);
wire [31:0] D_XMGXi;
pmos(D[0], D_XMGXi[0], 0);
pmos(D[1], D_XMGXi[1], 0);
pmos(D[2], D_XMGXi[2], 0);
pmos(D[3], D_XMGXi[3], 0);
pmos(D[4], D_XMGXi[4], 0);
pmos(D[5], D_XMGXi[5], 0);
pmos(D[6], D_XMGXi[6], 0);
pmos(D[7], D_XMGXi[7], 0);
pmos(D[8], D_XMGXi[8], 0);
pmos(D[9], D_XMGXi[9], 0);
pmos(D[10], D_XMGXi[10], 0);
pmos(D[11], D_XMGXi[11], 0);
pmos(D[12], D_XMGXi[12], 0);
pmos(D[13], D_XMGXi[13], 0);
pmos(D[14], D_XMGXi[14], 0);
pmos(D[15], D_XMGXi[15], 0);
pmos(D[16], D_XMGXi[16], 0);
pmos(D[17], D_XMGXi[17], 0);
pmos(D[18], D_XMGXi[18], 0);
pmos(D[19], D_XMGXi[19], 0);
pmos(D[20], D_XMGXi[20], 0);
pmos(D[21], D_XMGXi[21], 0);
pmos(D[22], D_XMGXi[22], 0);
pmos(D[23], D_XMGXi[23], 0);
pmos(D[24], D_XMGXi[24], 0);
pmos(D[25], D_XMGXi[25], 0);
pmos(D[26], D_XMGXi[26], 0);
pmos(D[27], D_XMGXi[27], 0);
pmos(D[28], D_XMGXi[28], 0);
pmos(D[29], D_XMGXi[29], 0);
pmos(D[30], D_XMGXi[30], 0);
pmos(D[31], D_XMGXi[31], 0);
pmos(DBE_XMGXi, DBE, 0);
pmos(DBGACK, DBGACK_XMGXi, 0);
pmos(DBGEN_XMGXi, DBGEN, 0);
pmos(DBGRQ_XMGXi, DBGRQ, 0);
pmos(DBGRQI, DBGRQI_XMGXi, 0);
wire [31:0] DIN_XMGXi;
pmos(DIN_XMGXi[0], DIN[0], 0);
pmos(DIN_XMGXi[1], DIN[1], 0);
pmos(DIN_XMGXi[2], DIN[2], 0);
pmos(DIN_XMGXi[3], DIN[3], 0);
pmos(DIN_XMGXi[4], DIN[4], 0);
pmos(DIN_XMGXi[5], DIN[5], 0);
pmos(DIN_XMGXi[6], DIN[6], 0);
pmos(DIN_XMGXi[7], DIN[7], 0);
pmos(DIN_XMGXi[8], DIN[8], 0);
pmos(DIN_XMGXi[9], DIN[9], 0);
pmos(DIN_XMGXi[10], DIN[10], 0);
pmos(DIN_XMGXi[11], DIN[11], 0);
pmos(DIN_XMGXi[12], DIN[12], 0);
pmos(DIN_XMGXi[13], DIN[13], 0);
pmos(DIN_XMGXi[14], DIN[14], 0);
pmos(DIN_XMGXi[15], DIN[15], 0);
pmos(DIN_XMGXi[16], DIN[16], 0);
pmos(DIN_XMGXi[17], DIN[17], 0);
pmos(DIN_XMGXi[18], DIN[18], 0);
pmos(DIN_XMGXi[19], DIN[19], 0);
pmos(DIN_XMGXi[20], DIN[20], 0);
pmos(DIN_XMGXi[21], DIN[21], 0);
pmos(DIN_XMGXi[22], DIN[22], 0);
pmos(DIN_XMGXi[23], DIN[23], 0);
pmos(DIN_XMGXi[24], DIN[24], 0);
pmos(DIN_XMGXi[25], DIN[25], 0);
pmos(DIN_XMGXi[26], DIN[26], 0);
pmos(DIN_XMGXi[27], DIN[27], 0);
pmos(DIN_XMGXi[28], DIN[28], 0);
pmos(DIN_XMGXi[29], DIN[29], 0);
pmos(DIN_XMGXi[30], DIN[30], 0);
pmos(DIN_XMGXi[31], DIN[31], 0);
wire [31:0] DOUT_XMGXi;
pmos(DOUT[0], DOUT_XMGXi[0], 0);
pmos(DOUT[1], DOUT_XMGXi[1], 0);
pmos(DOUT[2], DOUT_XMGXi[2], 0);
pmos(DOUT[3], DOUT_XMGXi[3], 0);
pmos(DOUT[4], DOUT_XMGXi[4], 0);
pmos(DOUT[5], DOUT_XMGXi[5], 0);
pmos(DOUT[6], DOUT_XMGXi[6], 0);
pmos(DOUT[7], DOUT_XMGXi[7], 0);
pmos(DOUT[8], DOUT_XMGXi[8], 0);
pmos(DOUT[9], DOUT_XMGXi[9], 0);
pmos(DOUT[10], DOUT_XMGXi[10], 0);
pmos(DOUT[11], DOUT_XMGXi[11], 0);
pmos(DOUT[12], DOUT_XMGXi[12], 0);
pmos(DOUT[13], DOUT_XMGXi[13], 0);
pmos(DOUT[14], DOUT_XMGXi[14], 0);
pmos(DOUT[15], DOUT_XMGXi[15], 0);
pmos(DOUT[16], DOUT_XMGXi[16], 0);
pmos(DOUT[17], DOUT_XMGXi[17], 0);
pmos(DOUT[18], DOUT_XMGXi[18], 0);
pmos(DOUT[19], DOUT_XMGXi[19], 0);
pmos(DOUT[20], DOUT_XMGXi[20], 0);
pmos(DOUT[21], DOUT_XMGXi[21], 0);
pmos(DOUT[22], DOUT_XMGXi[22], 0);
pmos(DOUT[23], DOUT_XMGXi[23], 0);
pmos(DOUT[24], DOUT_XMGXi[24], 0);
pmos(DOUT[25], DOUT_XMGXi[25], 0);
pmos(DOUT[26], DOUT_XMGXi[26], 0);
pmos(DOUT[27], DOUT_XMGXi[27], 0);
pmos(DOUT[28], DOUT_XMGXi[28], 0);
pmos(DOUT[29], DOUT_XMGXi[29], 0);
pmos(DOUT[30], DOUT_XMGXi[30], 0);
pmos(DOUT[31], DOUT_XMGXi[31], 0);
pmos(DRIVEBS, DRIVEBS_XMGXi, 0);
pmos(ECAPCLK, ECAPCLK_XMGXi, 0);
pmos(ECAPCLKBS, ECAPCLKBS_XMGXi, 0);
pmos(ECLK, ECLK_XMGXi, 0);
pmos(EXTERN0_XMGXi, EXTERN0, 0);
pmos(EXTERN1_XMGXi, EXTERN1, 0);
pmos(HIGHZ, HIGHZ_XMGXi, 0);
pmos(ICAPCLKBS, ICAPCLKBS_XMGXi, 0);
wire [3:0] IR_XMGXi;
pmos(IR[0], IR_XMGXi[0], 0);
pmos(IR[1], IR_XMGXi[1], 0);
pmos(IR[2], IR_XMGXi[2], 0);
pmos(IR[3], IR_XMGXi[3], 0);
pmos(ISYNC_XMGXi, ISYNC, 0);
pmos(LOCK, LOCK_XMGXi, 0);
wire [1:0] MAS_XMGXi;
pmos(MAS[0], MAS_XMGXi[0], 0);
pmos(MAS[1], MAS_XMGXi[1], 0);
pmos(MCLK_XMGXi, MCLK, 0);
pmos(nCPI, nCPI_XMGXi, 0);
pmos(nENIN_XMGXi, nENIN, 0);
pmos(nENOUT, nENOUT_XMGXi, 0);
pmos(nENOUTI, nENOUTI_XMGXi, 0);
pmos(nEXEC, nEXEC_XMGXi, 0);
pmos(nFIQ_XMGXi, nFIQ, 0);
pmos(nHIGHZ, nHIGHZ_XMGXi, 0);
pmos(nIRQ_XMGXi, nIRQ, 0);
wire [4:0] nM_XMGXi;
pmos(nM[0], nM_XMGXi[0], 0);
pmos(nM[1], nM_XMGXi[1], 0);
pmos(nM[2], nM_XMGXi[2], 0);
pmos(nM[3], nM_XMGXi[3], 0);
pmos(nM[4], nM_XMGXi[4], 0);
pmos(nMREQ, nMREQ_XMGXi, 0);
pmos(nOPC, nOPC_XMGXi, 0);
pmos(nRESET_XMGXi, nRESET, 0);
pmos(nRW, nRW_XMGXi, 0);
pmos(nTDOEN, nTDOEN_XMGXi, 0);
pmos(nTRANS, nTRANS_XMGXi, 0);
pmos(nTRST_XMGXi, nTRST, 0);
pmos(nWAIT_XMGXi, nWAIT, 0);
pmos(PCLKBS, PCLKBS_XMGXi, 0);
pmos(RANGEOUT0, RANGEOUT0_XMGXi, 0);
pmos(RANGEOUT1, RANGEOUT1_XMGXi, 0);
pmos(RSTCLKBS, RSTCLKBS_XMGXi, 0);
wire [3:0] SCREG_XMGXi;
pmos(SCREG[0], SCREG_XMGXi[0], 0);
pmos(SCREG[1], SCREG_XMGXi[1], 0);
pmos(SCREG[2], SCREG_XMGXi[2], 0);
pmos(SCREG[3], SCREG_XMGXi[3], 0);
pmos(SDINBS, SDINBS_XMGXi, 0);
pmos(SDOUTBS_XMGXi, SDOUTBS, 0);
pmos(SEQ, SEQ_XMGXi, 0);
pmos(SHCLK2BS, SHCLK2BS_XMGXi, 0);
pmos(SHCLKBS, SHCLKBS_XMGXi, 0);
wire [3:0] TAPSM_XMGXi;
pmos(TAPSM[0], TAPSM_XMGXi[0], 0);
pmos(TAPSM[1], TAPSM_XMGXi[1], 0);
pmos(TAPSM[2], TAPSM_XMGXi[2], 0);
pmos(TAPSM[3], TAPSM_XMGXi[3], 0);
pmos(TBE_XMGXi, TBE, 0);
pmos(TBIT, TBIT_XMGXi, 0);
pmos(TCK_XMGXi, TCK, 0);
pmos(TCK1, TCK1_XMGXi, 0);
pmos(TCK2, TCK2_XMGXi, 0);
pmos(TDI_XMGXi, TDI, 0);
pmos(TDO, TDO_XMGXi, 0);
pmos(TMS_XMGXi, TMS, 0);

// Subexpressions for input check qualifying conditions

not(XMGXNTBbusen1, busen1);
not(XMGXNTBisync1, isync1);
not(XMGXNTBscan, scan);
and(XMGXbl3ANBreads, bl3, reads);
and(XMGXbl3ANBreadsANBNTBbusen1, XMGXbl3ANBreads, XMGXNTBbusen1);
and(XMGXbl2ANBreads, bl2, reads);
and(XMGXbl2ANBreadsANBNTBbusen1, XMGXbl2ANBreads, XMGXNTBbusen1);
and(XMGXbl1ANBreads, bl1, reads);
and(XMGXbl1ANBreadsANBNTBbusen1, XMGXbl1ANBreads, XMGXNTBbusen1);
and(XMGXbl0ANBreads, bl0, reads);
and(XMGXbl0ANBreadsANBNTBbusen1, XMGXbl0ANBreads, XMGXNTBbusen1);
and(XMGXbl3ANBcapture0148, bl3, capture0148);
and(XMGXbl3ANBcapture0148ANBNTBbusen1, XMGXbl3ANBcapture0148, XMGXNTBbusen1);
and(XMGXbl2ANBcapture0148, bl2, capture0148);
and(XMGXbl2ANBcapture0148ANBNTBbusen1, XMGXbl2ANBcapture0148, XMGXNTBbusen1);
and(XMGXbl1ANBcapture0148, bl1, capture0148);
and(XMGXbl1ANBcapture0148ANBNTBbusen1, XMGXbl1ANBcapture0148, XMGXNTBbusen1);
and(XMGXbl0ANBcapture0148, bl0, capture0148);
and(XMGXbl0ANBcapture0148ANBNTBbusen1, XMGXbl0ANBcapture0148, XMGXNTBbusen1);
and(XMGXbl3ANBreadsANBbusen1, XMGXbl3ANBreads, busen1);
and(XMGXbl2ANBreadsANBbusen1, XMGXbl2ANBreads, busen1);
and(XMGXbl1ANBreadsANBbusen1, XMGXbl1ANBreads, busen1);
and(XMGXbl0ANBreadsANBbusen1, XMGXbl0ANBreads, busen1);
and(XMGXbl3ANBcapture0148ANBbusen1, XMGXbl3ANBcapture0148, busen1);
and(XMGXbl2ANBcapture0148ANBbusen1, XMGXbl2ANBcapture0148, busen1);
and(XMGXbl1ANBcapture0148ANBbusen1, XMGXbl1ANBcapture0148, busen1);
and(XMGXbl0ANBcapture0148ANBbusen1, XMGXbl0ANBcapture0148, busen1);
and(XMGXnormalANBNTBisync1, normal, XMGXNTBisync1);
and(XMGXnormalANBisync1, normal, isync1);

reg hilMCLKXMGXnormal;   // high
reg hidMCLKXMGXnormal;

initial
begin
  hilMCLKXMGXnormal = 0;
  hidMCLKXMGXnormal = 0;
end

always @(posedge MCLK_XMGXi)
begin
  hilMCLKXMGXnormal = normal;
  hidMCLKXMGXnormal = hilMCLKXMGXnormal;
end

always @(negedge MCLK_XMGXi)
begin
  hilMCLKXMGXnormal = 0;
end

wire hisMCLKXMGXnormal = normal;
wire hihMCLKXMGXnormal = hidMCLKXMGXnormal;
wire hieMCLKXMGXnormal = hilMCLKXMGXnormal;

reg lolMCLKXMGXnormal;   // low
reg lodMCLKXMGXnormal;

initial
begin
  lolMCLKXMGXnormal = 0;
  lodMCLKXMGXnormal = 0;
end

always @(negedge MCLK_XMGXi)
begin
  lolMCLKXMGXnormal = normal;
  lodMCLKXMGXnormal = lolMCLKXMGXnormal;
end

always @(posedge MCLK_XMGXi)
begin
  lolMCLKXMGXnormal = 0;
end

wire losMCLKXMGXnormal = normal;
wire lohMCLKXMGXnormal = lodMCLKXMGXnormal;
wire loeMCLKXMGXnormal = lolMCLKXMGXnormal;

reg hilMCLKXMGXreads;   // high
reg hidMCLKXMGXreads;

initial
begin
  hilMCLKXMGXreads = 0;
  hidMCLKXMGXreads = 0;
end

always @(posedge MCLK_XMGXi)
begin
  hilMCLKXMGXreads = reads;
  hidMCLKXMGXreads = hilMCLKXMGXreads;
end

always @(negedge MCLK_XMGXi)
begin
  hilMCLKXMGXreads = 0;
end

wire hisMCLKXMGXreads = reads;
wire hihMCLKXMGXreads = hidMCLKXMGXreads;
wire hieMCLKXMGXreads = hilMCLKXMGXreads;

reg MCLK_XMGXcopy;

always @(MCLK_XMGXi)
begin
  MCLK_XMGXcopy <= #1 MCLK_XMGXi;
end

reg TCK_XMGXcopy;

always @(TCK_XMGXi)
begin
  TCK_XMGXcopy <= #1 TCK_XMGXi;
end

reg nRESET_XMGXcopy;

always @(nRESET_XMGXi)
begin
  nRESET_XMGXcopy <= #1 nRESET_XMGXi;
end

reg wllnRESETXMGXXMGXNTBscan;   // width low

initial
begin
  wllnRESETXMGXXMGXNTBscan = 0;
end

always @(XMGXNTBscan or posedge nRESET_XMGXcopy)
begin
  if (nRESET_XMGXcopy == 1)
    wllnRESETXMGXXMGXNTBscan = XMGXNTBscan;
end

wire wlwnRESETXMGXXMGXNTBscan = wllnRESETXMGXXMGXNTBscan;

reg nTRST_XMGXcopy;

always @(nTRST_XMGXi)
begin
  nTRST_XMGXcopy <= #1 nTRST_XMGXi;
end

reg notifierXMGX0;

always @(notifierXMGX0)
begin
  $display("Setup/hold violation on signal ABE, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX1;

always @(notifierXMGX1)
begin
  $display("Setup/hold violation on signal ABORT, reference falling MCLK (Tabts/Tabth)");
end
reg notifierXMGX2;

always @(notifierXMGX2)
begin
  $display("Setup/hold violation on signal ABORT, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX3;

always @(notifierXMGX3)
begin
  $display("Setup/hold violation on signal ALE, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX4;

always @(notifierXMGX4)
begin
  $display("Setup/HIGH/hold violation on signal APE, reference signal MCLK (Taps/Taph)");
end
reg notifierXMGX5;

always @(notifierXMGX5)
begin
  $display("Setup/hold violation on signal APE, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX6;

always @(notifierXMGX6)
begin
  $display("Setup/LOW/hold violation on signal BIGEND, reference signal MCLK (Tcts/Tcth)");
end
reg notifierXMGX7;

always @(notifierXMGX7)
begin
  $display("Setup/hold violation on signal BIGEND, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX8;

always @(notifierXMGX8)
begin
  $display("Setup/HIGH/hold violation on signal BL, reference signal MCLK (Tbyls/Tbylh)");
end
reg notifierXMGX9;

always @(notifierXMGX9)
begin
  $display("Setup/hold violation on signal BL, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX10;

always @(notifierXMGX10)
begin
  $display("Setup/hold violation on signal BREAKPT, reference rising MCLK (Tbrks/Tbrkh)");
end
reg notifierXMGX11;

always @(notifierXMGX11)
begin
  $display("Setup/hold violation on signal BREAKPT, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX12;

always @(notifierXMGX12)
begin
  $display("Setup/hold violation on signal BUSEN, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX13;

always @(notifierXMGX13)
begin
  $display("Setup/hold violation on signal CPA, reference rising MCLK (Tcps/Tcph)");
end
reg notifierXMGX14;

always @(notifierXMGX14)
begin
  $display("Setup/hold violation on signal CPA, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX15;

always @(notifierXMGX15)
begin
  $display("Setup/hold violation on signal CPB, reference rising MCLK (Tcps/Tcph)");
end
reg notifierXMGX16;

always @(notifierXMGX16)
begin
  $display("Setup/hold violation on signal CPB, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX17;

always @(notifierXMGX17)
begin
  $display("Setup/hold violation on signal D, reference falling MCLK (Tdis/Tdih)");
end
reg notifierXMGX18;

always @(notifierXMGX18)
begin
  $display("Setup/hold violation on signal D, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX19;

always @(notifierXMGX19)
begin
  $display("Setup/hold violation on signal DBE, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX20;

always @(notifierXMGX20)
begin
  $display("Setup/hold violation on signal DBGEN, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX21;

always @(notifierXMGX21)
begin
  $display("Setup/hold violation on signal DBGRQ, reference rising MCLK (Trqs/Trqh)");
end
reg notifierXMGX22;

always @(notifierXMGX22)
begin
  $display("Setup/hold violation on signal DBGRQ, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX23;

always @(notifierXMGX23)
begin
  $display("Setup/hold violation on signal DIN, reference falling MCLK (Tdisu/Tdihu)");
end
reg notifierXMGX24;

always @(notifierXMGX24)
begin
  $display("Setup/hold violation on signal DIN, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX25;

always @(notifierXMGX25)
begin
  $display("Setup/hold violation on signal EXTERN0, reference falling MCLK (Texts/Texth)");
end
reg notifierXMGX26;

always @(notifierXMGX26)
begin
  $display("Setup/hold violation on signal EXTERN0, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX27;

always @(notifierXMGX27)
begin
  $display("Setup/hold violation on signal EXTERN1, reference falling MCLK (Texts/Texth)");
end
reg notifierXMGX28;

always @(notifierXMGX28)
begin
  $display("Setup/hold violation on signal EXTERN1, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX29;

always @(notifierXMGX29)
begin
  $display("Setup/hold violation on signal ISYNC, reference falling MCLK (Tcts/Tcth)");
end
reg notifierXMGX30;

always @(notifierXMGX30)
begin
  $display("Setup/hold violation on signal ISYNC, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX31;

always @(notifierXMGX31)
begin
  $display("Setup/hold violation on signal nENIN, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX32;

always @(notifierXMGX32)
begin
  $display("Setup/hold violation on signal nFIQ, reference falling MCLK (Tis/Tim)");
end
reg notifierXMGX33;

always @(notifierXMGX33)
begin
  $display("Setup/hold violation on signal nFIQ, reference falling MCLK (Tsis/Tsih)");
end
reg notifierXMGX34;

always @(notifierXMGX34)
begin
  $display("Setup/hold violation on signal nFIQ, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX35;

always @(notifierXMGX35)
begin
  $display("Setup/hold violation on signal nIRQ, reference falling MCLK (Tis/Tim)");
end
reg notifierXMGX36;

always @(notifierXMGX36)
begin
  $display("Setup/hold violation on signal nIRQ, reference falling MCLK (Tsis/Tsih)");
end
reg notifierXMGX37;

always @(notifierXMGX37)
begin
  $display("Setup/hold violation on signal nIRQ, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX38;

always @(notifierXMGX38)
begin
  $display("Setup/hold violation on signal nRESET, reference rising MCLK (Trs/Trm)");
end
reg notifierXMGX39;

always @(notifierXMGX39)
begin
  $display("Setup/hold violation on signal nRESET, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX40;

always @(notifierXMGX40)
begin
  $display("Setup/hold violation on signal nTRST, reference rising TCK (Ttrsts/Tzero)");
end
reg notifierXMGX41;

always @(notifierXMGX41)
begin
  $display("Setup/HIGH/hold violation on signal nWAIT, reference signal MCLK (Tws/Twh)");
end
reg notifierXMGX42;

always @(notifierXMGX42)
begin
  $display("Setup/hold violation on signal nWAIT, reference rising TCK (Tbsss/Tbssh)");
end
reg notifierXMGX43;

always @(notifierXMGX43)
begin
  $display("Setup/hold violation on signal TDI, reference rising TCK (Tbsis/Tbsih)");
end
reg notifierXMGX44;

always @(notifierXMGX44)
begin
  $display("Setup/hold violation on signal TMS, reference rising TCK (Tbsis/Tbsih)");
end
reg notifierXMGX45;

always @(notifierXMGX45)
begin
  $display("Width high violation (Tmckh) on signal MCLK");
end
reg notifierXMGX46;

always @(notifierXMGX46)
begin
  $display("Width low violation (Tmckl) on signal MCLK");
end
reg notifierXMGX47;

always @(notifierXMGX47)
begin
  $display("Width high violation (Tbsch) on signal TCK");
end
reg notifierXMGX48;

always @(notifierXMGX48)
begin
  $display("Width low violation (Tbscl) on signal TCK");
end
reg notifierXMGX49;

always @(notifierXMGX49)
begin
  $display("Width low violation (Trstl) on signal nRESET");
end
reg notifierXMGX50;

always @(notifierXMGX50)
begin
  $display("Width low violation (Tbsr) on signal nTRST");
end
specify

// Input checks

$setuphold(posedge TCK &&& capture048, posedge ABE, 0, 0, notifierXMGX0,,,TCK_XMGXnegd, ABE_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge ABE, 0, 0, notifierXMGX0,,,TCK_XMGXnegd, ABE_XMGXnegd); // rising
$setuphold(negedge MCLK &&& mem, posedge ABORT, 0, 0, notifierXMGX1,,,MCLK_XMGXnegd, ABORT_XMGXnegd); // falling
$setuphold(negedge MCLK &&& mem, negedge ABORT, 0, 0, notifierXMGX1,,,MCLK_XMGXnegd, ABORT_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge ABORT, 0, 0, notifierXMGX2,,,TCK_XMGXnegd, ABORT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge ABORT, 0, 0, notifierXMGX2,,,TCK_XMGXnegd, ABORT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge ALE, 0, 0, notifierXMGX3,,,TCK_XMGXnegd, ALE_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge ALE, 0, 0, notifierXMGX3,,,TCK_XMGXnegd, ALE_XMGXnegd); // rising
$setuphold(posedge MCLK &&& hisMCLKXMGXnormal, APE, 0, 0, notifierXMGX4,,,MCLK_XMGXnegd, APE_XMGXnegd); // high
$hold(posedge MCLK &&& normal, APE, 1, notifierXMGX4); // high
$hold(APE &&& hieMCLKXMGXnormal, APE &&& hieMCLKXMGXnormal, 1, notifierXMGX4); // high
$hold(negedge MCLK &&& hihMCLKXMGXnormal, APE, 0, notifierXMGX4); // high
$setuphold(posedge TCK &&& capture048, posedge APE, 0, 0, notifierXMGX5,,,TCK_XMGXnegd, APE_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge APE, 0, 0, notifierXMGX5,,,TCK_XMGXnegd, APE_XMGXnegd); // rising
$setuphold(negedge MCLK &&& losMCLKXMGXnormal, BIGEND, 0, 0, notifierXMGX6,,,MCLK_XMGXnegd, BIGEND_XMGXnegd); // low
$hold(negedge MCLK &&& normal, BIGEND, 1, notifierXMGX6); // low
$hold(BIGEND &&& loeMCLKXMGXnormal, BIGEND &&& loeMCLKXMGXnormal, 1, notifierXMGX6); // low
$hold(posedge MCLK &&& lohMCLKXMGXnormal, BIGEND, 0, notifierXMGX6); // low
$setuphold(posedge TCK &&& capture048, posedge BIGEND, 0, 0, notifierXMGX7,,,TCK_XMGXnegd, BIGEND_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge BIGEND, 0, 0, notifierXMGX7,,,TCK_XMGXnegd, BIGEND_XMGXnegd); // rising
$setuphold(posedge MCLK &&& hisMCLKXMGXreads, BL[0], 0, 0, notifierXMGX8,,,MCLK_XMGXnegd, BL_XMGXnegd[0]); // high
$hold(posedge MCLK &&& reads, BL[0], 1, notifierXMGX8); // high
$hold(BL[0] &&& hieMCLKXMGXreads, BL[0] &&& hieMCLKXMGXreads, 1, notifierXMGX8); // high
$hold(negedge MCLK &&& hihMCLKXMGXreads, BL[0], 0, notifierXMGX8); // high
$setuphold(posedge MCLK &&& hisMCLKXMGXreads, BL[1], 0, 0, notifierXMGX8,,,MCLK_XMGXnegd, BL_XMGXnegd[1]); // high
$hold(posedge MCLK &&& reads, BL[1], 1, notifierXMGX8); // high
$hold(BL[1] &&& hieMCLKXMGXreads, BL[1] &&& hieMCLKXMGXreads, 1, notifierXMGX8); // high
$hold(negedge MCLK &&& hihMCLKXMGXreads, BL[1], 0, notifierXMGX8); // high
$setuphold(posedge MCLK &&& hisMCLKXMGXreads, BL[2], 0, 0, notifierXMGX8,,,MCLK_XMGXnegd, BL_XMGXnegd[2]); // high
$hold(posedge MCLK &&& reads, BL[2], 1, notifierXMGX8); // high
$hold(BL[2] &&& hieMCLKXMGXreads, BL[2] &&& hieMCLKXMGXreads, 1, notifierXMGX8); // high
$hold(negedge MCLK &&& hihMCLKXMGXreads, BL[2], 0, notifierXMGX8); // high
$setuphold(posedge MCLK &&& hisMCLKXMGXreads, BL[3], 0, 0, notifierXMGX8,,,MCLK_XMGXnegd, BL_XMGXnegd[3]); // high
$hold(posedge MCLK &&& reads, BL[3], 1, notifierXMGX8); // high
$hold(BL[3] &&& hieMCLKXMGXreads, BL[3] &&& hieMCLKXMGXreads, 1, notifierXMGX8); // high
$hold(negedge MCLK &&& hihMCLKXMGXreads, BL[3], 0, notifierXMGX8); // high
$setuphold(posedge TCK &&& capture048, posedge BL[0], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& capture048, negedge BL[0], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& capture048, posedge BL[1], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& capture048, negedge BL[1], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& capture048, posedge BL[2], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& capture048, negedge BL[2], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& capture048, posedge BL[3], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[3]); // rising
$setuphold(posedge TCK &&& capture048, negedge BL[3], 0, 0, notifierXMGX9,,,TCK_XMGXnegd, BL_XMGXnegd[3]); // rising
$setuphold(posedge MCLK &&& normal, posedge BREAKPT, 0, 0, notifierXMGX10,,,MCLK_XMGXnegd, BREAKPT_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, negedge BREAKPT, 0, 0, notifierXMGX10,,,MCLK_XMGXnegd, BREAKPT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture0148, posedge BREAKPT, 0, 0, notifierXMGX11,,,TCK_XMGXnegd, BREAKPT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture0148, negedge BREAKPT, 0, 0, notifierXMGX11,,,TCK_XMGXnegd, BREAKPT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge BUSEN, 0, 0, notifierXMGX12,,,TCK_XMGXnegd, BUSEN_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge BUSEN, 0, 0, notifierXMGX12,,,TCK_XMGXnegd, BUSEN_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, posedge CPA, 0, 0, notifierXMGX13,,,MCLK_XMGXnegd, CPA_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, negedge CPA, 0, 0, notifierXMGX13,,,MCLK_XMGXnegd, CPA_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge CPA, 0, 0, notifierXMGX14,,,TCK_XMGXnegd, CPA_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge CPA, 0, 0, notifierXMGX14,,,TCK_XMGXnegd, CPA_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, posedge CPB, 0, 0, notifierXMGX15,,,MCLK_XMGXnegd, CPB_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, negedge CPB, 0, 0, notifierXMGX15,,,MCLK_XMGXnegd, CPB_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge CPB, 0, 0, notifierXMGX16,,,TCK_XMGXnegd, CPB_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge CPB, 0, 0, notifierXMGX16,,,TCK_XMGXnegd, CPB_XMGXnegd); // rising
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[24], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[24]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[24], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[24]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[25], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[25]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[25], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[25]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[26], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[26]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[26], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[26]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[27], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[27]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[27], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[27]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[28], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[28]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[28], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[28]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[29], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[29]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[29], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[29]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[30], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[30]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[30], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[30]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, posedge D[31], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[31]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBNTBbusen1, negedge D[31], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[31]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[16], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[16]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[16], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[16]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[17], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[17]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[17], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[17]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[18], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[18]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[18], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[18]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[19], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[19]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[19], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[19]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[20], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[20]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[20], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[20]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[21], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[21]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[21], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[21]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[22], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[22]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[22], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[22]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, posedge D[23], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[23]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBNTBbusen1, negedge D[23], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[23]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[8], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[8]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[8], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[8]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[9], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[9]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[9], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[9]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[10], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[10]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[10], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[10]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[11], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[11]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[11], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[11]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[12], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[12]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[12], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[12]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[13], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[13]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[13], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[13]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[14], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[14]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[14], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[14]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, posedge D[15], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[15]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBNTBbusen1, negedge D[15], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[15]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[0], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[0]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[0], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[0]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[1], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[1]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[1], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[1]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[2], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[2]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[2], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[2]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[3], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[3]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[3], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[3]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[4], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[4]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[4], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[4]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[5], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[5]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[5], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[5]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[6], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[6]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[6], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[6]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, posedge D[7], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[7]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBNTBbusen1, negedge D[7], 0, 0, notifierXMGX17,,,MCLK_XMGXnegd, D_XMGXnegd[7]); // falling
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[24], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[24]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[24], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[24]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[25], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[25]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[25], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[25]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[26], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[26]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[26], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[26]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[27], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[27]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[27], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[27]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[28], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[28]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[28], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[28]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[29], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[29]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[29], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[29]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[30], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[30]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[30], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[30]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, posedge D[31], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[31]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBNTBbusen1, negedge D[31], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[31]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[16], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[16]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[16], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[16]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[17], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[17]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[17], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[17]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[18], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[18]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[18], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[18]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[19], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[19]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[19], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[19]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[20], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[20]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[20], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[20]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[21], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[21]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[21], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[21]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[22], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[22]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[22], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[22]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, posedge D[23], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[23]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBNTBbusen1, negedge D[23], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[23]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[8], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[8]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[8], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[8]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[9], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[9]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[9], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[9]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[10], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[10]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[10], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[10]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[11], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[11]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[11], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[11]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[12], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[12]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[12], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[12]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[13], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[13]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[13], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[13]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[14], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[14]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[14], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[14]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, posedge D[15], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[15]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBNTBbusen1, negedge D[15], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[15]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[0], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[0], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[1], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[1], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[2], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[2], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[3], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[3]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[3], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[3]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[4], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[4]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[4], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[4]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[5], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[5]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[5], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[5]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[6], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[6]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[6], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[6]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, posedge D[7], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[7]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBNTBbusen1, negedge D[7], 0, 0, notifierXMGX18,,,TCK_XMGXnegd, D_XMGXnegd[7]); // rising
$setuphold(posedge TCK &&& capture048, posedge DBE, 0, 0, notifierXMGX19,,,TCK_XMGXnegd, DBE_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge DBE, 0, 0, notifierXMGX19,,,TCK_XMGXnegd, DBE_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge DBGEN, 0, 0, notifierXMGX20,,,TCK_XMGXnegd, DBGEN_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge DBGEN, 0, 0, notifierXMGX20,,,TCK_XMGXnegd, DBGEN_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, posedge DBGRQ, 0, 0, notifierXMGX21,,,MCLK_XMGXnegd, DBGRQ_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, negedge DBGRQ, 0, 0, notifierXMGX21,,,MCLK_XMGXnegd, DBGRQ_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge DBGRQ, 0, 0, notifierXMGX22,,,TCK_XMGXnegd, DBGRQ_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge DBGRQ, 0, 0, notifierXMGX22,,,TCK_XMGXnegd, DBGRQ_XMGXnegd); // rising
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[24], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[24]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[24], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[24]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[25], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[25]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[25], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[25]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[26], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[26]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[26], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[26]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[27], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[27]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[27], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[27]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[28], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[28]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[28], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[28]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[29], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[29]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[29], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[29]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[30], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[30]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[30], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[30]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, posedge DIN[31], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[31]); // falling
$setuphold(negedge MCLK &&& XMGXbl3ANBreadsANBbusen1, negedge DIN[31], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[31]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[16], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[16]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[16], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[16]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[17], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[17]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[17], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[17]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[18], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[18]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[18], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[18]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[19], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[19]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[19], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[19]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[20], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[20]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[20], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[20]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[21], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[21]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[21], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[21]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[22], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[22]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[22], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[22]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, posedge DIN[23], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[23]); // falling
$setuphold(negedge MCLK &&& XMGXbl2ANBreadsANBbusen1, negedge DIN[23], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[23]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[8], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[8]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[8], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[8]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[9], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[9]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[9], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[9]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[10], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[10]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[10], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[10]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[11], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[11]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[11], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[11]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[12], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[12]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[12], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[12]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[13], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[13]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[13], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[13]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[14], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[14]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[14], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[14]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, posedge DIN[15], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[15]); // falling
$setuphold(negedge MCLK &&& XMGXbl1ANBreadsANBbusen1, negedge DIN[15], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[15]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[0], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[0]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[0], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[0]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[1], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[1]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[1], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[1]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[2], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[2]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[2], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[2]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[3], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[3]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[3], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[3]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[4], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[4]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[4], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[4]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[5], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[5]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[5], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[5]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[6], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[6]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[6], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[6]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, posedge DIN[7], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[7]); // falling
$setuphold(negedge MCLK &&& XMGXbl0ANBreadsANBbusen1, negedge DIN[7], 0, 0, notifierXMGX23,,,MCLK_XMGXnegd, DIN_XMGXnegd[7]); // falling
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[24], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[24]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[24], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[24]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[25], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[25]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[25], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[25]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[26], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[26]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[26], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[26]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[27], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[27]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[27], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[27]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[28], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[28]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[28], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[28]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[29], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[29]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[29], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[29]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[30], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[30]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[30], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[30]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, posedge DIN[31], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[31]); // rising
$setuphold(posedge TCK &&& XMGXbl3ANBcapture0148ANBbusen1, negedge DIN[31], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[31]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[16], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[16]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[16], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[16]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[17], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[17]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[17], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[17]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[18], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[18]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[18], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[18]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[19], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[19]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[19], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[19]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[20], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[20]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[20], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[20]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[21], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[21]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[21], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[21]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[22], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[22]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[22], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[22]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, posedge DIN[23], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[23]); // rising
$setuphold(posedge TCK &&& XMGXbl2ANBcapture0148ANBbusen1, negedge DIN[23], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[23]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[8], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[8]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[8], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[8]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[9], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[9]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[9], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[9]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[10], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[10]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[10], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[10]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[11], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[11]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[11], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[11]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[12], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[12]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[12], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[12]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[13], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[13]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[13], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[13]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[14], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[14]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[14], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[14]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, posedge DIN[15], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[15]); // rising
$setuphold(posedge TCK &&& XMGXbl1ANBcapture0148ANBbusen1, negedge DIN[15], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[15]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[0], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[0], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[0]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[1], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[1], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[1]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[2], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[2], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[2]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[3], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[3]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[3], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[3]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[4], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[4]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[4], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[4]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[5], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[5]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[5], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[5]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[6], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[6]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[6], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[6]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, posedge DIN[7], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[7]); // rising
$setuphold(posedge TCK &&& XMGXbl0ANBcapture0148ANBbusen1, negedge DIN[7], 0, 0, notifierXMGX24,,,TCK_XMGXnegd, DIN_XMGXnegd[7]); // rising
$setuphold(negedge MCLK &&& normal, posedge EXTERN0, 0, 0, notifierXMGX25,,,MCLK_XMGXnegd, EXTERN0_XMGXnegd); // falling
$setuphold(negedge MCLK &&& normal, negedge EXTERN0, 0, 0, notifierXMGX25,,,MCLK_XMGXnegd, EXTERN0_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge EXTERN0, 0, 0, notifierXMGX26,,,TCK_XMGXnegd, EXTERN0_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge EXTERN0, 0, 0, notifierXMGX26,,,TCK_XMGXnegd, EXTERN0_XMGXnegd); // rising
$setuphold(negedge MCLK &&& normal, posedge EXTERN1, 0, 0, notifierXMGX27,,,MCLK_XMGXnegd, EXTERN1_XMGXnegd); // falling
$setuphold(negedge MCLK &&& normal, negedge EXTERN1, 0, 0, notifierXMGX27,,,MCLK_XMGXnegd, EXTERN1_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge EXTERN1, 0, 0, notifierXMGX28,,,TCK_XMGXnegd, EXTERN1_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge EXTERN1, 0, 0, notifierXMGX28,,,TCK_XMGXnegd, EXTERN1_XMGXnegd); // rising
$setuphold(negedge MCLK &&& normal, posedge ISYNC, 0, 0, notifierXMGX29,,,MCLK_XMGXnegd, ISYNC_XMGXnegd); // falling
$setuphold(negedge MCLK &&& normal, negedge ISYNC, 0, 0, notifierXMGX29,,,MCLK_XMGXnegd, ISYNC_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge ISYNC, 0, 0, notifierXMGX30,,,TCK_XMGXnegd, ISYNC_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge ISYNC, 0, 0, notifierXMGX30,,,TCK_XMGXnegd, ISYNC_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge nENIN, 0, 0, notifierXMGX31,,,TCK_XMGXnegd, nENIN_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge nENIN, 0, 0, notifierXMGX31,,,TCK_XMGXnegd, nENIN_XMGXnegd); // rising
$setuphold(negedge MCLK &&& XMGXnormalANBNTBisync1, posedge nFIQ, 0, 0, notifierXMGX32,,,MCLK_XMGXnegd, nFIQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBNTBisync1, negedge nFIQ, 0, 0, notifierXMGX32,,,MCLK_XMGXnegd, nFIQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBisync1, posedge nFIQ, 0, 0, notifierXMGX33,,,MCLK_XMGXnegd, nFIQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBisync1, negedge nFIQ, 0, 0, notifierXMGX33,,,MCLK_XMGXnegd, nFIQ_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge nFIQ, 0, 0, notifierXMGX34,,,TCK_XMGXnegd, nFIQ_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge nFIQ, 0, 0, notifierXMGX34,,,TCK_XMGXnegd, nFIQ_XMGXnegd); // rising
$setuphold(negedge MCLK &&& XMGXnormalANBNTBisync1, posedge nIRQ, 0, 0, notifierXMGX35,,,MCLK_XMGXnegd, nIRQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBNTBisync1, negedge nIRQ, 0, 0, notifierXMGX35,,,MCLK_XMGXnegd, nIRQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBisync1, posedge nIRQ, 0, 0, notifierXMGX36,,,MCLK_XMGXnegd, nIRQ_XMGXnegd); // falling
$setuphold(negedge MCLK &&& XMGXnormalANBisync1, negedge nIRQ, 0, 0, notifierXMGX36,,,MCLK_XMGXnegd, nIRQ_XMGXnegd); // falling
$setuphold(posedge TCK &&& capture048, posedge nIRQ, 0, 0, notifierXMGX37,,,TCK_XMGXnegd, nIRQ_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge nIRQ, 0, 0, notifierXMGX37,,,TCK_XMGXnegd, nIRQ_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, posedge nRESET, 0, 0, notifierXMGX38,,,MCLK_XMGXnegd, nRESET_XMGXnegd); // rising
$setuphold(posedge MCLK &&& normal, negedge nRESET, 0, 0, notifierXMGX38,,,MCLK_XMGXnegd, nRESET_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, posedge nRESET, 0, 0, notifierXMGX39,,,TCK_XMGXnegd, nRESET_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge nRESET, 0, 0, notifierXMGX39,,,TCK_XMGXnegd, nRESET_XMGXnegd); // rising
$setuphold(posedge TCK, posedge nTRST, 0, 0, notifierXMGX40,,,TCK_XMGXnegd, nTRST_XMGXnegd); // rising
$setuphold(posedge TCK, negedge nTRST, 0, 0, notifierXMGX40,,,TCK_XMGXnegd, nTRST_XMGXnegd); // rising
$setuphold(posedge MCLK &&& hisMCLKXMGXnormal, nWAIT, 0, 0, notifierXMGX41,,,MCLK_XMGXnegd, nWAIT_XMGXnegd); // high
$hold(posedge MCLK &&& normal, nWAIT, 1, notifierXMGX41); // high
$hold(nWAIT &&& hieMCLKXMGXnormal, nWAIT &&& hieMCLKXMGXnormal, 1, notifierXMGX41); // high
$hold(negedge MCLK &&& hihMCLKXMGXnormal, nWAIT, 0, notifierXMGX41); // high
$setuphold(posedge TCK &&& capture048, posedge nWAIT, 0, 0, notifierXMGX42,,,TCK_XMGXnegd, nWAIT_XMGXnegd); // rising
$setuphold(posedge TCK &&& capture048, negedge nWAIT, 0, 0, notifierXMGX42,,,TCK_XMGXnegd, nWAIT_XMGXnegd); // rising
$setuphold(posedge TCK, posedge TDI, 0, 0, notifierXMGX43,,,TCK_XMGXnegd, TDI_XMGXnegd); // rising
$setuphold(posedge TCK, negedge TDI, 0, 0, notifierXMGX43,,,TCK_XMGXnegd, TDI_XMGXnegd); // rising
$setuphold(posedge TCK, posedge TMS, 0, 0, notifierXMGX44,,,TCK_XMGXnegd, TMS_XMGXnegd); // rising
$setuphold(posedge TCK, negedge TMS, 0, 0, notifierXMGX44,,,TCK_XMGXnegd, TMS_XMGXnegd); // rising
// Width checks

$width(posedge MCLK, 0, 0, notifierXMGX45);
$width(negedge MCLK, 0, 0, notifierXMGX46);
$width(posedge TCK, 0, 0, notifierXMGX47);
$width(negedge TCK, 0, 0, notifierXMGX48);
$width(negedge nRESET &&& wlwnRESETXMGXXMGXNTBscan, 0, 0, notifierXMGX49);
$width(negedge nTRST, 0, 0, notifierXMGX50);
// Output delays

if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[0] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[1] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[2] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[3] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[4] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[5] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[6] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[7] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[8] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[9] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[10] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[11] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[12] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[13] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[14] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[15] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[16] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[17] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[18] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[19] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[20] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[21] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[22] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[23] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[24] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[25] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[26] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[27] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[28] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[29] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[30] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (A[31] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[0] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[1] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[2] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[3] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[4] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[5] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[6] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[7] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[8] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[9] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[10] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[11] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[12] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[13] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[14] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[15] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[16] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[17] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[18] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[19] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[20] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[21] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[22] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[23] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[24] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[25] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[26] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[27] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[28] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[29] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[30] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (A[31] +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[0] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[1] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[2] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[3] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[4] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[5] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[6] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[7] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[8] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[9] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[10] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[11] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[12] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[13] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[14] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[15] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[16] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[17] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[18] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[19] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[20] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[21] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[22] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[23] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[24] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[25] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[26] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[27] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[28] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[29] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[30] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (A[31] +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[0] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[1] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[2] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[3] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[4] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[5] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[6] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[7] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[8] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[9] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[10] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[11] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[12] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[13] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[14] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[15] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[16] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[17] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[18] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[19] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[20] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[21] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[22] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[23] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[24] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[25] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[26] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[27] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[28] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[29] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[30] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (A[31] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[0] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[1] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[2] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[3] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[4] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[5] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[6] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[7] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[8] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[9] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[10] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[11] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[12] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[13] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[14] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[15] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[16] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[17] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[18] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[19] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[20] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[21] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[22] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[23] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[24] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[25] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[26] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[27] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[28] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[29] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[30] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (A[31] +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (A[0] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[1] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[2] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[3] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[4] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[5] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[6] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[7] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[8] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[9] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[10] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[11] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[12] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[13] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[14] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[15] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[16] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[17] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[18] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[19] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[20] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[21] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[22] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[23] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[24] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[25] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[26] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[27] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[28] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[29] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[30] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (A[31] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[0] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[1] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[2] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[3] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[4] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[5] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[6] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[7] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[8] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[9] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[10] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[11] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[12] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[13] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[14] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[15] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[16] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[17] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[18] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[19] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[20] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[21] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[22] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[23] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[24] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[25] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[26] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[27] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[28] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[29] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[30] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (A[31] : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[0] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[1] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[2] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[3] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[4] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[5] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[6] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[7] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[8] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[9] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[10] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[11] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[12] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[13] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[14] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[15] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[16] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[17] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[18] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[19] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[20] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[21] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[22] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[23] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[24] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[25] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[26] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[27] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[28] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[29] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[30] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (A[31] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[0] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[1] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[2] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[3] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[4] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[5] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[6] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[7] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[8] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[9] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[10] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[11] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[12] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[13] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[14] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[15] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[16] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[17] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[18] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[19] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[20] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[21] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[22] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[23] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[24] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[25] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[26] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[27] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[28] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[29] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[30] +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (A[31] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[0] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[1] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[2] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[3] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[4] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[5] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[6] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[7] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[8] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[9] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[10] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[11] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[12] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[13] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[14] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[15] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[16] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[17] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[18] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[19] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[20] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[21] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[22] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[23] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[24] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[25] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[26] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[27] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[28] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[29] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[30] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (A[31] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[0] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[1] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[2] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[3] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[4] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[5] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[6] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[7] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[8] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[9] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[10] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[11] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[12] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[13] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[14] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[15] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[16] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[17] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[18] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[19] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[20] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[21] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[22] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[23] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[24] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[25] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[26] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[27] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[28] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[29] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[30] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (A[31] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[0] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[1] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[2] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[3] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[4] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[5] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[6] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[7] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[8] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[9] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[10] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[11] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[12] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[13] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[14] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[15] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[16] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[17] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[18] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[19] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[20] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[21] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[22] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[23] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[24] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[25] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[26] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[27] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[28] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[29] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[30] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (A[31] +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[0] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[1] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[2] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[3] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[4] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[5] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[6] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[7] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[8] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[9] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[10] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[11] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[12] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[13] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[14] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[15] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[16] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[17] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[18] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[19] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[20] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[21] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[22] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[23] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[24] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[25] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[26] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[27] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[28] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[29] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[30] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (A[31] +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (A[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[3] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[4] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[5] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[6] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[7] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[8] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[9] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[10] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[11] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[12] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[13] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[14] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[15] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[16] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[17] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[18] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[19] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[20] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[21] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[22] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[23] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[24] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[25] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[26] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[27] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[28] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[29] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[30] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (A[31] +: nTRST)) = 0;
if (~TCK) (negedge TCK *> (BUSDIS +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (BUSDIS +: nTRST)) = 0;
if (MCLK & normal) (posedge MCLK *> (COMMRX +: MCLK)) = 0;
if (~TCK & scan) (negedge TCK *> (COMMRX +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (COMMRX +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (COMMRX +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (COMMRX +: nTRST)) = 0;
if (MCLK & normal) (posedge MCLK *> (COMMTX +: MCLK)) = 0;
if (~TCK & scan) (negedge TCK *> (COMMTX +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (COMMTX +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (COMMTX +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (COMMTX +: nTRST)) = 0;
if (MCLK & normal) (posedge MCLK *> (DBGACK +: MCLK)) = 0;
if (~TCK & scan) (negedge TCK *> (DBGACK +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (DBGACK +: nRESET)) = 0;
if (TCK & (scan | leavingscan | scan0Dbg | dclk)) (posedge TCK *> (DBGACK +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (DBGACK +: nTRST)) = 0;
(DBGEN *> DBGACK) = 0;
(DBGRQ *> DBGRQI) = 0;
(DBGEN *> DBGRQI) = 0;
if (~TCK & (scan | leavingscan | dbg)) (negedge TCK *> (DBGRQI +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (DBGRQI +: nTRST)) = 0;
if (TCK & (scan | leavingscan | scan0Dbg | dclk)) (posedge TCK *> (DBGRQI +: TCK)) = 0;
if (~TCK) (negedge TCK *> (DRIVEBS +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (DRIVEBS +: nTRST)) = 0;
(TCK *> ECAPCLK) = 0;
(TCK *> ECAPCLKBS) = 0;
if (~dclk) (MCLK *> ECLK) = 0;
if (dclk | leavingdclk) (TCK *> ECLK) = 0;
if (~TCK & (scan | scan1Dbg)) (negedge TCK *> (ECLK +: TCK)) = 0;
if (~nRESET) (negedge nRESET *> (ECLK +: nRESET)) = 0;
if (~TCK) (negedge TCK *> (HIGHZ +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (HIGHZ +: nTRST)) = 0;
(TCK *> ICAPCLKBS) = 0;
if (~TCK) (negedge TCK *> (IR[0] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (IR[1] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (IR[2] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (IR[3] +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (IR[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (IR[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (IR[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (IR[3] +: nTRST)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (LOCK +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (LOCK +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (LOCK +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (LOCK +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (LOCK +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (LOCK : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (LOCK : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (LOCK +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (LOCK +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (LOCK +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (LOCK +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (LOCK +: nTRST)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (MAS[0] +: ABE)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (MAS[1] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (MAS[0] +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (MAS[1] +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (MAS[0] +: ALE)) = 0;
if (ALE & ~scan) (posedge ALE *> (MAS[1] +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (MAS[0] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (MAS[1] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (MAS[0] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (MAS[1] +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (MAS[0] : TBE)) = 0;
if (~TBE & testBus) (negedge TBE => (MAS[1] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (MAS[0] : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (MAS[1] : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (MAS[0] +: TCK)) = 0;
if (~TCK & hghz) (negedge TCK *> (MAS[1] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (MAS[0] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (MAS[1] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (MAS[0] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (MAS[1] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (MAS[0] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (MAS[1] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (MAS[0] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (MAS[1] +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (MAS[0] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (MAS[1] +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (MAS[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (MAS[1] +: nTRST)) = 0;
if (~(scan | leavingscan)) (BREAKPT *> nCPI) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nCPI +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nCPI +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nCPI +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nCPI +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nCPI +: nTRST)) = 0;
if (~(scan | leavingscan) | scan1Dbg) (DBE *> nENOUT) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nENOUT +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nENOUT +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (nENOUT +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nENOUT +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nENOUT +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nENOUT +: nTRST)) = 0;
if (~(scan | leavingscan)) (DBE *> nENOUTI) = 0;
if (~MCLK & normal) (negedge MCLK *> (nENOUTI +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nENOUTI +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (nENOUTI +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nENOUTI +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (nENOUTI +: nTRST)) = 0;
if (~(scan | leavingscan)) (BREAKPT *> nEXEC) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nEXEC +: MCLK)) = 0;
if (TCK & (scan | leavingscan | scan1Dbg)) (posedge TCK *> (nEXEC +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk | scan1Dbg | scan)) (negedge TCK *> (nEXEC +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nEXEC +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nEXEC +: nTRST)) = 0;
if (~TCK) (negedge TCK *> (nHIGHZ +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (nHIGHZ +: nTRST)) = 0;
if (MCLK & normal) (posedge MCLK *> (nM[0] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (nM[1] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (nM[2] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (nM[3] +: MCLK)) = 0;
if (MCLK & normal) (posedge MCLK *> (nM[4] +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nM[0] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nM[1] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nM[2] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nM[3] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nM[4] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nM[0] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nM[1] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nM[2] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nM[3] +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nM[4] +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (nM[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (nM[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (nM[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (nM[3] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (nM[4] +: nTRST)) = 0;
if (~TCK & scan) (negedge TCK *> (nM[0] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nM[1] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nM[2] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nM[3] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nM[4] +: TCK)) = 0;
if (~(scan | leavingscan)) (BREAKPT *> nMREQ) = 0;
if (~(scan | leavingscan)) (CPB *> nMREQ) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nMREQ +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nMREQ +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nMREQ +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nMREQ +: nTRST)) = 0;
if (~TCK & (scan | leavingscan)) (negedge TCK *> (nMREQ +: TCK)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (nOPC +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (nOPC +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (nOPC +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (nOPC +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nOPC +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (nOPC : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (nOPC : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (nOPC +: TCK)) = 0;
if (TCK & (scan | leavingscan | dbg & ~(dclk | leavingdclk))) (posedge TCK *> (nOPC +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nOPC +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nOPC +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (nOPC +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (nOPC +: nTRST)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (nRW +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (nRW +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (nRW +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (nRW +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nRW +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (nRW : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (nRW : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (nRW +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nRW +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nRW +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nRW +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (nRW +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nRW +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nRW +: nTRST)) = 0;
if (~TCK) (negedge TCK *> (nTDOEN +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (nTDOEN +: nTRST)) = 0;
if (~ABE & (~(scan | testBus) | leavingscan)) (negedge ABE *> (nTRANS +: ABE)) = 0;
if (ABE & (~(scan | testBus) | leavingscan)) (posedge ABE *> (nTRANS +: ABE)) = 0;
if (ALE & ~scan) (posedge ALE *> (nTRANS +: ALE)) = 0;
if (MCLK & normal) (posedge MCLK *> (nTRANS +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (nTRANS +: MCLK)) = 0;
if (~TBE & testBus) (negedge TBE => (nTRANS : TBE)) = 0;
if (TBE & testBus) (posedge TBE => (nTRANS : TBE)) = 0;
if (~TCK & hghz) (negedge TCK *> (nTRANS +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (nTRANS +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (nTRANS +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (nTRANS +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (nTRANS +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (nTRANS +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (nTRANS +: nTRST)) = 0;
(TCK *> PCLKBS) = 0;
if (~MCLK & ~(dclk | leavingdclk)) (negedge MCLK *> (RANGEOUT0 +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (RANGEOUT0 +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (RANGEOUT0 +: TCK)) = 0;
if (~TCK & (scan | scan1Dbg | sc2updatedr)) (negedge TCK *> (RANGEOUT0 +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (RANGEOUT0 +: nTRST)) = 0;
(DBGEN *> RANGEOUT0) = 0;
if (~MCLK & ~(dclk | leavingdclk)) (negedge MCLK *> (RANGEOUT1 +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (RANGEOUT1 +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (RANGEOUT1 +: TCK)) = 0;
if (~TCK & (scan | scan1Dbg | sc2updatedr)) (negedge TCK *> (RANGEOUT1 +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (RANGEOUT1 +: nTRST)) = 0;
(DBGEN *> RANGEOUT1) = 0;
(nTRST *> RSTCLKBS) = 0;
if (TCK) (posedge TCK *> (RSTCLKBS +: TCK)) = 0;
if (~TCK) (negedge TCK *> (RSTCLKBS +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SCREG[0] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SCREG[1] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SCREG[2] +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SCREG[3] +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (SCREG[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (SCREG[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (SCREG[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (SCREG[3] +: nTRST)) = 0;
if (TCK) (posedge TCK *> (SDINBS +: TCK)) = 0;
if (~(scan | leavingscan)) (BREAKPT *> SEQ) = 0;
if (~(scan | leavingscan)) (CPB *> SEQ) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (SEQ +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (SEQ +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (SEQ +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (SEQ +: nTRST)) = 0;
if (~TCK & scan) (negedge TCK *> (SEQ +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SHCLKBS +: TCK)) = 0;
if (TCK) (posedge TCK *> (SHCLKBS +: TCK)) = 0;
if (~TCK) (negedge TCK *> (SHCLK2BS +: TCK)) = 0;
if (TCK) (posedge TCK *> (SHCLK2BS +: TCK)) = 0;
if (TCK) (posedge TCK *> (TAPSM[0] +: TCK)) = 0;
if (TCK) (posedge TCK *> (TAPSM[1] +: TCK)) = 0;
if (TCK) (posedge TCK *> (TAPSM[2] +: TCK)) = 0;
if (TCK) (posedge TCK *> (TAPSM[3] +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (TAPSM[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (TAPSM[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (TAPSM[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (TAPSM[3] +: nTRST)) = 0;
if (MCLK & normal) (posedge MCLK *> (TBIT +: MCLK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (TBIT +: TCK)) = 0;
if (TCK & (dclk | leavingdclk)) (posedge TCK *> (TBIT +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (TBIT +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (TBIT +: nTRST)) = 0;
if (TCK) (posedge TCK *> (TCK1 +: TCK)) = 0;
if (~TCK) (negedge TCK *> (TCK1 +: TCK)) = 0;
if (~TCK) (negedge TCK *> (TCK2 +: TCK)) = 0;
if (TCK) (posedge TCK *> (TCK2 +: TCK)) = 0;
if (~TCK) (negedge TCK *> (TDO +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (TDO +: nTRST)) = 0;
(SDOUTBS => TDO) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[0] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[1] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[2] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[3] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[4] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[5] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[6] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[7] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[8] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[9] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[10] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[11] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[12] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[13] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[14] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[15] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[16] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[17] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[18] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[19] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[20] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[21] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[22] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[23] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[24] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[25] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[26] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[27] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[28] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[29] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[30] +: DBE)) = 0;
if (~DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (negedge DBE *> (D[31] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[0] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[1] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[2] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[3] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[4] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[5] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[6] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[7] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[8] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[9] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[10] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[11] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[12] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[13] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[14] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[15] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[16] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[17] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[18] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[19] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[20] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[21] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[22] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[23] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[24] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[25] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[26] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[27] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[28] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[29] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[30] +: DBE)) = 0;
if (DBE & (~(scan | leavingscan | testDBus) | scan1Dbg)) (posedge DBE *> (D[31] +: DBE)) = 0;
(nENIN *> D[0]) = 0;
(nENIN *> D[1]) = 0;
(nENIN *> D[2]) = 0;
(nENIN *> D[3]) = 0;
(nENIN *> D[4]) = 0;
(nENIN *> D[5]) = 0;
(nENIN *> D[6]) = 0;
(nENIN *> D[7]) = 0;
(nENIN *> D[8]) = 0;
(nENIN *> D[9]) = 0;
(nENIN *> D[10]) = 0;
(nENIN *> D[11]) = 0;
(nENIN *> D[12]) = 0;
(nENIN *> D[13]) = 0;
(nENIN *> D[14]) = 0;
(nENIN *> D[15]) = 0;
(nENIN *> D[16]) = 0;
(nENIN *> D[17]) = 0;
(nENIN *> D[18]) = 0;
(nENIN *> D[19]) = 0;
(nENIN *> D[20]) = 0;
(nENIN *> D[21]) = 0;
(nENIN *> D[22]) = 0;
(nENIN *> D[23]) = 0;
(nENIN *> D[24]) = 0;
(nENIN *> D[25]) = 0;
(nENIN *> D[26]) = 0;
(nENIN *> D[27]) = 0;
(nENIN *> D[28]) = 0;
(nENIN *> D[29]) = 0;
(nENIN *> D[30]) = 0;
(nENIN *> D[31]) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[0] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[1] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[2] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[3] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[4] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[5] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[6] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[7] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[8] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[9] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[10] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[11] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[12] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[13] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[14] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[15] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[16] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[17] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[18] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[19] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[20] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[21] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[22] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[23] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[24] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[25] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[26] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[27] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[28] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[29] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[30] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (D[31] +: MCLK)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[0] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[1] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[2] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[3] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[4] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[5] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[6] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[7] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[8] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[9] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[10] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[11] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[12] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[13] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[14] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[15] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[16] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[17] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[18] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[19] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[20] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[21] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[22] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[23] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[24] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[25] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[26] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[27] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[28] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[29] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[30] : TBE)) = 0;
if (~TBE & testDBus) (negedge TBE => (D[31] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[0] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[1] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[2] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[3] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[4] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[5] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[6] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[7] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[8] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[9] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[10] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[11] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[12] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[13] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[14] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[15] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[16] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[17] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[18] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[19] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[20] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[21] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[22] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[23] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[24] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[25] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[26] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[27] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[28] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[29] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[30] : TBE)) = 0;
if (TBE & testDBus) (posedge TBE => (D[31] : TBE)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[0] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[1] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[2] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[3] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[4] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[5] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[6] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[7] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[8] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[9] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[10] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[11] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[12] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[13] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[14] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[15] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[16] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[17] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[18] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[19] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[20] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[21] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[22] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[23] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[24] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[25] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[26] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[27] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[28] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[29] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[30] +: TCK)) = 0;
if (TCK & (scan | leavingscan)) (posedge TCK *> (D[31] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[0] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[1] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[2] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[3] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[4] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[5] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[6] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[7] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[8] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[9] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[10] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[11] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[12] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[13] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[14] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[15] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[16] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[17] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[18] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[19] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[20] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[21] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[22] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[23] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[24] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[25] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[26] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[27] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[28] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[29] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[30] +: TCK)) = 0;
if (~TCK & scan) (negedge TCK *> (D[31] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[0] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[1] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[2] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[3] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[4] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[5] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[6] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[7] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[8] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[9] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[10] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[11] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[12] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[13] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[14] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[15] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[16] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[17] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[18] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[19] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[20] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[21] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[22] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[23] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[24] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[25] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[26] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[27] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[28] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[29] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[30] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (D[31] +: TCK)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[0] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[1] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[2] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[3] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[4] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[5] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[6] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[7] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[8] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[9] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[10] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[11] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[12] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[13] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[14] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[15] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[16] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[17] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[18] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[19] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[20] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[21] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[22] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[23] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[24] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[25] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[26] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[27] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[28] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[29] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[30] +: nRESET)) = 0;
if (~nRESET & ~(scan | leavingscan)) (negedge nRESET *> (D[31] +: nRESET)) = 0;
if (~nTRST) (negedge nTRST *> (D[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[3] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[4] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[5] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[6] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[7] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[8] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[9] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[10] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[11] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[12] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[13] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[14] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[15] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[16] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[17] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[18] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[19] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[20] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[21] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[22] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[23] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[24] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[25] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[26] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[27] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[28] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[29] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[30] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (D[31] +: nTRST)) = 0;
(BUSEN *> D[0]) = 0;
(BUSEN *> D[1]) = 0;
(BUSEN *> D[2]) = 0;
(BUSEN *> D[3]) = 0;
(BUSEN *> D[4]) = 0;
(BUSEN *> D[5]) = 0;
(BUSEN *> D[6]) = 0;
(BUSEN *> D[7]) = 0;
(BUSEN *> D[8]) = 0;
(BUSEN *> D[9]) = 0;
(BUSEN *> D[10]) = 0;
(BUSEN *> D[11]) = 0;
(BUSEN *> D[12]) = 0;
(BUSEN *> D[13]) = 0;
(BUSEN *> D[14]) = 0;
(BUSEN *> D[15]) = 0;
(BUSEN *> D[16]) = 0;
(BUSEN *> D[17]) = 0;
(BUSEN *> D[18]) = 0;
(BUSEN *> D[19]) = 0;
(BUSEN *> D[20]) = 0;
(BUSEN *> D[21]) = 0;
(BUSEN *> D[22]) = 0;
(BUSEN *> D[23]) = 0;
(BUSEN *> D[24]) = 0;
(BUSEN *> D[25]) = 0;
(BUSEN *> D[26]) = 0;
(BUSEN *> D[27]) = 0;
(BUSEN *> D[28]) = 0;
(BUSEN *> D[29]) = 0;
(BUSEN *> D[30]) = 0;
(BUSEN *> D[31]) = 0;
(DIN *> D[0]) = 0;
(DIN *> D[1]) = 0;
(DIN *> D[2]) = 0;
(DIN *> D[3]) = 0;
(DIN *> D[4]) = 0;
(DIN *> D[5]) = 0;
(DIN *> D[6]) = 0;
(DIN *> D[7]) = 0;
(DIN *> D[8]) = 0;
(DIN *> D[9]) = 0;
(DIN *> D[10]) = 0;
(DIN *> D[11]) = 0;
(DIN *> D[12]) = 0;
(DIN *> D[13]) = 0;
(DIN *> D[14]) = 0;
(DIN *> D[15]) = 0;
(DIN *> D[16]) = 0;
(DIN *> D[17]) = 0;
(DIN *> D[18]) = 0;
(DIN *> D[19]) = 0;
(DIN *> D[20]) = 0;
(DIN *> D[21]) = 0;
(DIN *> D[22]) = 0;
(DIN *> D[23]) = 0;
(DIN *> D[24]) = 0;
(DIN *> D[25]) = 0;
(DIN *> D[26]) = 0;
(DIN *> D[27]) = 0;
(DIN *> D[28]) = 0;
(DIN *> D[29]) = 0;
(DIN *> D[30]) = 0;
(DIN *> D[31]) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[0] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[1] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[2] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[3] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[4] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[5] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[6] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[7] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[8] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[9] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[10] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[11] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[12] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[13] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[14] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[15] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[16] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[17] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[18] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[19] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[20] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[21] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[22] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[23] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[24] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[25] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[26] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[27] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[28] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[29] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[30] +: MCLK)) = 0;
if (~MCLK & (normal | enterDbg)) (negedge MCLK *> (DOUT[31] +: MCLK)) = 0;
(BUSEN *> DOUT[0]) = 0;
(BUSEN *> DOUT[1]) = 0;
(BUSEN *> DOUT[2]) = 0;
(BUSEN *> DOUT[3]) = 0;
(BUSEN *> DOUT[4]) = 0;
(BUSEN *> DOUT[5]) = 0;
(BUSEN *> DOUT[6]) = 0;
(BUSEN *> DOUT[7]) = 0;
(BUSEN *> DOUT[8]) = 0;
(BUSEN *> DOUT[9]) = 0;
(BUSEN *> DOUT[10]) = 0;
(BUSEN *> DOUT[11]) = 0;
(BUSEN *> DOUT[12]) = 0;
(BUSEN *> DOUT[13]) = 0;
(BUSEN *> DOUT[14]) = 0;
(BUSEN *> DOUT[15]) = 0;
(BUSEN *> DOUT[16]) = 0;
(BUSEN *> DOUT[17]) = 0;
(BUSEN *> DOUT[18]) = 0;
(BUSEN *> DOUT[19]) = 0;
(BUSEN *> DOUT[20]) = 0;
(BUSEN *> DOUT[21]) = 0;
(BUSEN *> DOUT[22]) = 0;
(BUSEN *> DOUT[23]) = 0;
(BUSEN *> DOUT[24]) = 0;
(BUSEN *> DOUT[25]) = 0;
(BUSEN *> DOUT[26]) = 0;
(BUSEN *> DOUT[27]) = 0;
(BUSEN *> DOUT[28]) = 0;
(BUSEN *> DOUT[29]) = 0;
(BUSEN *> DOUT[30]) = 0;
(BUSEN *> DOUT[31]) = 0;
if (DBE) (posedge DBE *> (DOUT[0] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[1] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[2] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[3] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[4] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[5] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[6] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[7] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[8] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[9] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[10] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[11] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[12] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[13] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[14] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[15] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[16] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[17] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[18] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[19] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[20] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[21] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[22] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[23] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[24] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[25] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[26] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[27] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[28] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[29] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[30] +: DBE)) = 0;
if (DBE) (posedge DBE *> (DOUT[31] +: DBE)) = 0;
if (scan) (TCK *> DOUT[0]) = 0;
if (scan) (TCK *> DOUT[1]) = 0;
if (scan) (TCK *> DOUT[2]) = 0;
if (scan) (TCK *> DOUT[3]) = 0;
if (scan) (TCK *> DOUT[4]) = 0;
if (scan) (TCK *> DOUT[5]) = 0;
if (scan) (TCK *> DOUT[6]) = 0;
if (scan) (TCK *> DOUT[7]) = 0;
if (scan) (TCK *> DOUT[8]) = 0;
if (scan) (TCK *> DOUT[9]) = 0;
if (scan) (TCK *> DOUT[10]) = 0;
if (scan) (TCK *> DOUT[11]) = 0;
if (scan) (TCK *> DOUT[12]) = 0;
if (scan) (TCK *> DOUT[13]) = 0;
if (scan) (TCK *> DOUT[14]) = 0;
if (scan) (TCK *> DOUT[15]) = 0;
if (scan) (TCK *> DOUT[16]) = 0;
if (scan) (TCK *> DOUT[17]) = 0;
if (scan) (TCK *> DOUT[18]) = 0;
if (scan) (TCK *> DOUT[19]) = 0;
if (scan) (TCK *> DOUT[20]) = 0;
if (scan) (TCK *> DOUT[21]) = 0;
if (scan) (TCK *> DOUT[22]) = 0;
if (scan) (TCK *> DOUT[23]) = 0;
if (scan) (TCK *> DOUT[24]) = 0;
if (scan) (TCK *> DOUT[25]) = 0;
if (scan) (TCK *> DOUT[26]) = 0;
if (scan) (TCK *> DOUT[27]) = 0;
if (scan) (TCK *> DOUT[28]) = 0;
if (scan) (TCK *> DOUT[29]) = 0;
if (scan) (TCK *> DOUT[30]) = 0;
if (scan) (TCK *> DOUT[31]) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[0] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[1] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[2] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[3] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[4] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[5] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[6] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[7] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[8] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[9] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[10] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[11] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[12] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[13] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[14] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[15] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[16] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[17] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[18] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[19] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[20] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[21] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[22] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[23] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[24] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[25] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[26] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[27] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[28] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[29] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[30] +: TCK)) = 0;
if (~TCK & (dclk | leavingdclk)) (negedge TCK *> (DOUT[31] +: TCK)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[0] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[1] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[2] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[3] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[4] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[5] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[6] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[7] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[8] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[9] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[10] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[11] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[12] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[13] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[14] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[15] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[16] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[17] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[18] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[19] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[20] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[21] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[22] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[23] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[24] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[25] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[26] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[27] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[28] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[29] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[30] +: nTRST)) = 0;
if (~nTRST) (negedge nTRST *> (DOUT[31] +: nTRST)) = 0;
(D *> DOUT[0]) = 0;
(D *> DOUT[1]) = 0;
(D *> DOUT[2]) = 0;
(D *> DOUT[3]) = 0;
(D *> DOUT[4]) = 0;
(D *> DOUT[5]) = 0;
(D *> DOUT[6]) = 0;
(D *> DOUT[7]) = 0;
(D *> DOUT[8]) = 0;
(D *> DOUT[9]) = 0;
(D *> DOUT[10]) = 0;
(D *> DOUT[11]) = 0;
(D *> DOUT[12]) = 0;
(D *> DOUT[13]) = 0;
(D *> DOUT[14]) = 0;
(D *> DOUT[15]) = 0;
(D *> DOUT[16]) = 0;
(D *> DOUT[17]) = 0;
(D *> DOUT[18]) = 0;
(D *> DOUT[19]) = 0;
(D *> DOUT[20]) = 0;
(D *> DOUT[21]) = 0;
(D *> DOUT[22]) = 0;
(D *> DOUT[23]) = 0;
(D *> DOUT[24]) = 0;
(D *> DOUT[25]) = 0;
(D *> DOUT[26]) = 0;
(D *> DOUT[27]) = 0;
(D *> DOUT[28]) = 0;
(D *> DOUT[29]) = 0;
(D *> DOUT[30]) = 0;
(D *> DOUT[31]) = 0;
(nENIN *> DOUT[0]) = 0;
(nENIN *> DOUT[1]) = 0;
(nENIN *> DOUT[2]) = 0;
(nENIN *> DOUT[3]) = 0;
(nENIN *> DOUT[4]) = 0;
(nENIN *> DOUT[5]) = 0;
(nENIN *> DOUT[6]) = 0;
(nENIN *> DOUT[7]) = 0;
(nENIN *> DOUT[8]) = 0;
(nENIN *> DOUT[9]) = 0;
(nENIN *> DOUT[10]) = 0;
(nENIN *> DOUT[11]) = 0;
(nENIN *> DOUT[12]) = 0;
(nENIN *> DOUT[13]) = 0;
(nENIN *> DOUT[14]) = 0;
(nENIN *> DOUT[15]) = 0;
(nENIN *> DOUT[16]) = 0;
(nENIN *> DOUT[17]) = 0;
(nENIN *> DOUT[18]) = 0;
(nENIN *> DOUT[19]) = 0;
(nENIN *> DOUT[20]) = 0;
(nENIN *> DOUT[21]) = 0;
(nENIN *> DOUT[22]) = 0;
(nENIN *> DOUT[23]) = 0;
(nENIN *> DOUT[24]) = 0;
(nENIN *> DOUT[25]) = 0;
(nENIN *> DOUT[26]) = 0;
(nENIN *> DOUT[27]) = 0;
(nENIN *> DOUT[28]) = 0;
(nENIN *> DOUT[29]) = 0;
(nENIN *> DOUT[30]) = 0;
(nENIN *> DOUT[31]) = 0;
endspecify

// The next layer down...

ARM7TDMI_inout theinout (.A(A_XMGXi),
  .ABE(ABE_XMGXnegd),
  .ABORT(ABORT_XMGXnegd),
  .ALE(ALE_XMGXnegd),
  .APE(APE_XMGXnegd),
  .BIGEND(BIGEND_XMGXnegd),
  .BL(BL_XMGXnegd),
  .BREAKPT(BREAKPT_XMGXnegd),
  .BUSDIS(BUSDIS_XMGXi),
  .BUSEN(BUSEN_XMGXnegd),
  .COMMRX(COMMRX_XMGXi),
  .COMMTX(COMMTX_XMGXi),
  .CPA(CPA_XMGXnegd),
  .CPB(CPB_XMGXnegd),
  .D_xmgxread(D_XMGXread), .D(D_XMGXi),
  .DBE(DBE_XMGXnegd),
  .DBGACK(DBGACK_XMGXi),
  .DBGEN(DBGEN_XMGXnegd),
  .DBGRQ(DBGRQ_XMGXnegd),
  .DBGRQI(DBGRQI_XMGXi),
  .DIN(DIN_XMGXnegd),
  .DOUT(DOUT_XMGXi),
  .DRIVEBS(DRIVEBS_XMGXi),
  .ECAPCLK(ECAPCLK_XMGXi),
  .ECAPCLKBS(ECAPCLKBS_XMGXi),
  .ECLK(ECLK_XMGXi),
  .EXTERN0(EXTERN0_XMGXnegd),
  .EXTERN1(EXTERN1_XMGXnegd),
  .HIGHZ(HIGHZ_XMGXi),
  .ICAPCLKBS(ICAPCLKBS_XMGXi),
  .IR(IR_XMGXi),
  .ISYNC(ISYNC_XMGXnegd),
  .LOCK(LOCK_XMGXi),
  .MAS(MAS_XMGXi),
  .MCLK(MCLK_XMGXnegd),
  .nCPI(nCPI_XMGXi),
  .nENIN(nENIN_XMGXnegd),
  .nENOUT(nENOUT_XMGXi),
  .nENOUTI(nENOUTI_XMGXi),
  .nEXEC(nEXEC_XMGXi),
  .nFIQ(nFIQ_XMGXnegd),
  .nHIGHZ(nHIGHZ_XMGXi),
  .nIRQ(nIRQ_XMGXnegd),
  .nM(nM_XMGXi),
  .nMREQ(nMREQ_XMGXi),
  .nOPC(nOPC_XMGXi),
  .nRESET(nRESET_XMGXnegd),
  .nRW(nRW_XMGXi),
  .nTDOEN(nTDOEN_XMGXi),
  .nTRANS(nTRANS_XMGXi),
  .nTRST(nTRST_XMGXnegd),
  .nWAIT(nWAIT_XMGXnegd),
  .PCLKBS(PCLKBS_XMGXi),
  .RANGEOUT0(RANGEOUT0_XMGXi),
  .RANGEOUT1(RANGEOUT1_XMGXi),
  .RSTCLKBS(RSTCLKBS_XMGXi),
  .SCREG(SCREG_XMGXi),
  .SDINBS(SDINBS_XMGXi),
  .SDOUTBS(SDOUTBS_XMGXi),
  .SEQ(SEQ_XMGXi),
  .SHCLK2BS(SHCLK2BS_XMGXi),
  .SHCLKBS(SHCLKBS_XMGXi),
  .TAPSM(TAPSM_XMGXi),
  .TBE(TBE_XMGXi),
  .TBIT(TBIT_XMGXi),
  .TCK(TCK_XMGXnegd),
  .TCK1(TCK1_XMGXi),
  .TCK2(TCK2_XMGXi),
  .TDI(TDI_XMGXnegd),
  .TDO(TDO_XMGXi),
  .TMS(TMS_XMGXnegd),
  .r0(r0),
  .r1(r1),
  .r2(r2),
  .r3(r3),
  .r4(r4),
  .r5(r5),
  .r6(r6),
  .r7(r7),
  .r8(r8),
  .r9(r9),
  .r10(r10),
  .r11(r11),
  .r12(r12),
  .r13(r13),
  .r14(r14),
  .r15(r15),
  .r8fiq(r8fiq),
  .r9fiq(r9fiq),
  .r10fiq(r10fiq),
  .r11fiq(r11fiq),
  .r12fiq(r12fiq),
  .r13fiq(r13fiq),
  .r14fiq(r14fiq),
  .r13irq(r13irq),
  .r14irq(r14irq),
  .r13svc(r13svc),
  .r14svc(r14svc),
  .r13abt(r13abt),
  .r14abt(r14abt),
  .r13und(r13und),
  .r14und(r14und),
  .cpsr(cpsr),
  .spsrfiq(spsrfiq),
  .spsrirq(spsrirq),
  .spsrsvc(spsrsvc),
  .spsrabt(spsrabt),
  .spsrund(spsrund),
  .icewp0addr(icewp0addr),
  .icewp0amask(icewp0amask),
  .icewp0data(icewp0data),
  .icewp0dmask(icewp0dmask),
  .icewp0ctl(icewp0ctl),
  .icewp0cmask(icewp0cmask),
  .icewp1addr(icewp1addr),
  .icewp1amask(icewp1amask),
  .icewp1data(icewp1data),
  .icewp1dmask(icewp1dmask),
  .icewp1ctl(icewp1ctl),
  .icewp1cmask(icewp1cmask),
  .icedbgctl(icedbgctl),
  .icedbgstatus(icedbgstatus),
  .normal(normal),
  .scan(scan),
  .dclk(dclk),
  .dbg(dbg),
  .hghz(hghz),
  .testBus(testBus),
  .testDBus(testDBus),
  .enterDbg(enterDbg),
  .leavingscan(leavingscan),
  .leavingdclk(leavingdclk),
  .scan1Dbg(scan1Dbg),
  .scan0Dbg(scan0Dbg),
  .sc2updatedr(sc2updatedr),
  .reads(reads),
  .mem(mem),
  .busen1(busen1),
  .isync1(isync1),
  .bl3(bl3),
  .bl2(bl2),
  .bl1(bl1),
  .bl0(bl0),
  .capture048(capture048),
  .capture0148(capture0148));

endmodule

`endcelldefine

// Debug shell

module ARM7TDMI (A,
  ABE,
  ABORT,
  ALE,
  APE,
  BIGEND,
  BL,
  BREAKPT,
  BUSDIS,
  BUSEN,
  COMMRX,
  COMMTX,
  CPA,
  CPB,
  D,
  DBE,
  DBGACK,
  DBGEN,
  DBGRQ,
  DBGRQI,
  DIN,
  DOUT,
  DRIVEBS,
  ECAPCLK,
  ECAPCLKBS,
  ECLK,
  EXTERN0,
  EXTERN1,
  HIGHZ,
  ICAPCLKBS,
  IR,
  ISYNC,
  LOCK,
  MAS,
  MCLK,
  nCPI,
  nENIN,
  nENOUT,
  nENOUTI,
  nEXEC,
  nFIQ,
  nHIGHZ,
  nIRQ,
  nM,
  nMREQ,
  nOPC,
  nRESET,
  nRW,
  nTDOEN,
  nTRANS,
  nTRST,
  nWAIT,
  PCLKBS,
  RANGEOUT0,
  RANGEOUT1,
  RSTCLKBS,
  SCREG,
  SDINBS,
  SDOUTBS,
  SEQ,
  SHCLK2BS,
  SHCLKBS,
  TAPSM,
  TBE,
  TBIT,
  TCK,
  TCK1,
  TCK2,
  TDI,
  TDO,
  TMS);

output [31:0] A;
input ABE;
input ABORT;
input ALE;
input APE;
input BIGEND;
input [3:0] BL;
input BREAKPT;
output BUSDIS;
input BUSEN;
output COMMRX;
output COMMTX;
input CPA;
input CPB;
inout [31:0] D;
input DBE;
output DBGACK;
input DBGEN;
input DBGRQ;
output DBGRQI;
input [31:0] DIN;
output [31:0] DOUT;
output DRIVEBS;
output ECAPCLK;
output ECAPCLKBS;
output ECLK;
input EXTERN0;
input EXTERN1;
output HIGHZ;
output ICAPCLKBS;
output [3:0] IR;
input ISYNC;
output LOCK;
output [1:0] MAS;
input MCLK;
output nCPI;
input nENIN;
output nENOUT;
output nENOUTI;
output nEXEC;
input nFIQ;
output nHIGHZ;
input nIRQ;
output [4:0] nM;
output nMREQ;
output nOPC;
input nRESET;
output nRW;
output nTDOEN;
output nTRANS;
input nTRST;
input nWAIT;
output PCLKBS;
output RANGEOUT0;
output RANGEOUT1;
output RSTCLKBS;
output [3:0] SCREG;
output SDINBS;
input SDOUTBS;
output SEQ;
output SHCLK2BS;
output SHCLKBS;
output [3:0] TAPSM;
input TBE;
output TBIT;
input TCK;
output TCK1;
output TCK2;
input TDI;
output TDO;
input TMS;

// Unused ports:

wire [31:0] r0;
wire [31:0] r1;
wire [31:0] r2;
wire [31:0] r3;
wire [31:0] r4;
wire [31:0] r5;
wire [31:0] r6;
wire [31:0] r7;
wire [31:0] r8;
wire [31:0] r9;
wire [31:0] r10;
wire [31:0] r11;
wire [31:0] r12;
wire [31:0] r13;
wire [31:0] r14;
wire [31:0] r15;
wire [31:0] r8fiq;
wire [31:0] r9fiq;
wire [31:0] r10fiq;
wire [31:0] r11fiq;
wire [31:0] r12fiq;
wire [31:0] r13fiq;
wire [31:0] r14fiq;
wire [31:0] r13irq;
wire [31:0] r14irq;
wire [31:0] r13svc;
wire [31:0] r14svc;
wire [31:0] r13abt;
wire [31:0] r14abt;
wire [31:0] r13und;
wire [31:0] r14und;
wire [31:0] cpsr;
wire [31:0] spsrfiq;
wire [31:0] spsrirq;
wire [31:0] spsrsvc;
wire [31:0] spsrabt;
wire [31:0] spsrund;
wire [31:0] icewp0addr;
wire [31:0] icewp0amask;
wire [31:0] icewp0data;
wire [31:0] icewp0dmask;
wire [8:0] icewp0ctl;
wire [7:0] icewp0cmask;
wire [31:0] icewp1addr;
wire [31:0] icewp1amask;
wire [31:0] icewp1data;
wire [31:0] icewp1dmask;
wire [8:0] icewp1ctl;
wire [7:0] icewp1cmask;
wire [2:0] icedbgctl;
wire [4:0] icedbgstatus;

parameter
  MG_LOGFILE_NAME = "",
  JTAG_ID = 1057951503,
  whichlog = 0;

ARM7TDMI_timing thetiming (A,
    ABE,
    ABORT,
    ALE,
    APE,
    BIGEND,
    BL,
    BREAKPT,
    BUSDIS,
    BUSEN,
    COMMRX,
    COMMTX,
    CPA,
    CPB,
    D,
    DBE,
    DBGACK,
    DBGEN,
    DBGRQ,
    DBGRQI,
    DIN,
    DOUT,
    DRIVEBS,
    ECAPCLK,
    ECAPCLKBS,
    ECLK,
    EXTERN0,
    EXTERN1,
    HIGHZ,
    ICAPCLKBS,
    IR,
    ISYNC,
    LOCK,
    MAS,
    MCLK,
    nCPI,
    nENIN,
    nENOUT,
    nENOUTI,
    nEXEC,
    nFIQ,
    nHIGHZ,
    nIRQ,
    nM,
    nMREQ,
    nOPC,
    nRESET,
    nRW,
    nTDOEN,
    nTRANS,
    nTRST,
    nWAIT,
    PCLKBS,
    RANGEOUT0,
    RANGEOUT1,
    RSTCLKBS,
    SCREG,
    SDINBS,
    SDOUTBS,
    SEQ,
    SHCLK2BS,
    SHCLKBS,
    TAPSM,
    TBE,
    TBIT,
    TCK,
    TCK1,
    TCK2,
    TDI,
    TDO,
    TMS,
    r0,
    r1,
    r2,
    r3,
    r4,
    r5,
    r6,
    r7,
    r8,
    r9,
    r10,
    r11,
    r12,
    r13,
    r14,
    r15,
    r8fiq,
    r9fiq,
    r10fiq,
    r11fiq,
    r12fiq,
    r13fiq,
    r14fiq,
    r13irq,
    r14irq,
    r13svc,
    r14svc,
    r13abt,
    r14abt,
    r13und,
    r14und,
    cpsr,
    spsrfiq,
    spsrirq,
    spsrsvc,
    spsrabt,
    spsrund,
    icewp0addr,
    icewp0amask,
    icewp0data,
    icewp0dmask,
    icewp0ctl,
    icewp0cmask,
    icewp1addr,
    icewp1amask,
    icewp1data,
    icewp1dmask,
    icewp1ctl,
    icewp1cmask,
    icedbgctl,
    icedbgstatus);

defparam
  thetiming.theinout.MG_LOGFILE_NAME = MG_LOGFILE_NAME,
  thetiming.theinout.JTAG_ID = JTAG_ID,
  thetiming.theinout.whichlog = whichlog;

endmodule

