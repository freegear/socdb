/* --=========================================================================--
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 2001-2002 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
-- -----------------------------------------------------------------------------
--
--  Version and Release Control Information:
--
--  File Name              : Mpmc.h.rca
--  File Revision          : 1.6
--
--  Release Information    : PrimeCell(TM)-PL172-r2p3-00rel0
--
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- Purpose :
--           This file contains the register offsets and other definitions
--           for the Mpmc.c test code.
--
-- --=========================================================================*/

/******************************************************************************/
/******************************************************************************/
/****************************** GENERAL TEST **********************************/
/******************************************************************************/
/******************************************************************************/


#define ZERO        0x00000000
#define NoMask      0xFFFFFFFF
#define MaskAll     0x00000000
/******************************************************************************/
/********************** GENERAL VARIABLE DECLARATION **************************/
/******************************************************************************/
#define MPMC_BASE        0x50000000
#define GS_BASE          0x40000000


/******************************************************************************/
/******************************************************************************/
/************************** GENERIC SLAVE REGISTERS ***************************/
/******************************************************************************/
/******************************************************************************/
/***     Generic slave is used to give all types of responses to the        ***/
/***     transactions initiated by TIC master.                              ***/

#define GS_ARRAY1        (GS_BASE + 0x100)
#define GS_ARRAY2        (GS_BASE + 0x500)
#define GS_WCS1          (GS_BASE + 0x000)
#define GS_WCS2          (GS_BASE + 0x004)
#define GS_CR            (GS_BASE + 0x008)
#define GS_TMOUT         (GS_BASE + 0x00C)
#define GS_XRDLY         (GS_BASE + 0x010)


/******************************************************************************/
/******************************************************************************/
/********************************** MPMC **************************************/
/******************************************************************************/
/******************************************************************************/



/******************************************************************************/
/******************* MPMC Integration Test Support Registers ******************/
/******************************************************************************/
/* ---------------------------------------------------------------------------*/
/* The Offset values are from the MPMC register base address.                 */
/* ---------------------------------------------------------------------------*/
/******************************************************************************/
/*============================================================================*/
/* Register                 Offset                R/W              Size       */
/*============================================================================*/
/* MPMCITCR                 0xF00                R/W                 0        */
/* MPMCITIP                 0xF20                R/W                 0        */
/* MPMCITOP                 0xF40                R/W                 0        */
/******************************************************************************/
#define MPMCITCR                 (MPMC_BASE + 0xF00)
#define MPMCITIP                 (MPMC_BASE + 0xF20)
#define MPMCITOP                 (MPMC_BASE + 0xF40)
/******************************************************************************/

/******************************************************************************/
/************************** REGISTER MASK VALUES ******************************/
/******************************************************************************/

#define MASK_MPMCITIP            0x000003FF
#define MASK_MPMCITOP            0x00000003

/************************************ End *************************************/
