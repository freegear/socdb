// --=========================================================================--
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from ARM Limited
//   (C) COPYRIGHT 2001-2002 ARM Limited
//       ALL RIGHTS RESERVED
// The entire notice above must be reproduced on all authorised
// copies and copies may only be made to the extent permitted
// by a licensing agreement from ARM Limited.
//
// -----------------------------------------------------------------------------
// Version and Release Control Information:
//
// File Name              : EbiTrComparator.v.rca
// File Revision          : 1.2
//
// Release Information    : PrimeCell(TM)-PL220-r0p0-00ltd0
//
// -----------------------------------------------------------------------------
// Purpose :
//           This block compares the signals generated by EBI and Mirrored EBI
//
// --=========================================================================--

`timescale 1ns/1ps

//Include Parameters File
`include "EbiTrParams.v"

// -----------------------------------------------------------------------------

module EbiTrComparator (
// Inputs
                        EBICLK,
                        HRESETn,
                        EBIGNT1,
                        EBIGNT2,
                        EBIGNT3,
                        EBIBACKOFF1,
                        EBIBACKOFF2,
                        EBIBACKOFF3,
                        nEBIEXTDATAEN,
                        EBIEXTADDROUT,
                        EBIEXTDATAOUT,
                        EBIDATAIN,

                        EbiTrGnt1,
                        EbiTrGnt2,
                        EbiTrGnt3,
                        EbiTrBackoff1,
                        EbiTrBackoff2,
                        EbiTrBackoff3,
                        nEbiTrExtDataEn,
                        EbiTrExtAddrOut,
                        EbiTrExtDataOut,
                        EbiTrDataIn
                       );

// Inputs
input         EBICLK;          // Ebi Clock
input         HRESETn;         // Bus Reset
input         EBIGNT1;         // Gnt signal generated by Ebi to Port1
input         EBIGNT2;         // Gnt signal generated by Ebi to Port2
input         EBIGNT3;         // Gnt signal generated by Ebi to Port3
input         EBIBACKOFF1;     // Backoff signal generated Ebi to
                               // Port1
input         EBIBACKOFF2;     // Backoff signal generated Ebi to
                               // Port2
input         EBIBACKOFF3;     // Backoff signal generated Ebi to
                               // Port3
input   [3:0] nEBIEXTDATAEN;   // Data enable signal from Ebi
input  [31:0] EBIEXTADDROUT;   // Address out from Ebi
input  [31:0] EBIEXTDATAOUT;   // Data out from Ebi
input  [31:0] EBIDATAIN;       // Data in from Ebi

input         EbiTrGnt1;       // Gnt signal generated by trickbox
input         EbiTrGnt2;       // Gnt signal generated by trickbox
input         EbiTrGnt3;       // Gnt signal generated by trickbox
input         EbiTrBackoff1;   // Backoff signal generated by trickbox
input         EbiTrBackoff2;   // Backoff signal generated by trickbox
input         EbiTrBackoff3;   // Backoff signal generated by trickbox
input   [3:0] nEbiTrExtDataEn; // Data enable signal from trickbox
input  [31:0] EbiTrExtAddrOut; // Address out from trickbox
input  [31:0] EbiTrExtDataOut; // Data out from trickbox
input  [31:0] EbiTrDataIn;     // Data in from trickbox

// Inputs
wire        EBICLK;          // Ebi Clock
wire        RESETn;          // Bus Reset
wire        EBIGNT1;         // Gnt signal generated by Ebi to Port1
wire        EBIGNT2;         // Gnt signal generated by Ebi to Port2
wire        EBIGNT3;         // Gnt signal generated by Ebi to Port3
wire        EBIBACKOFF1;     // Backoff signal generated Ebi to
                             // Port1
wire        EBIBACKOFF2;     // Backoff signal generated Ebi to
                             // Port2
wire        EBIBACKOFF3;     // Backoff signal generated Ebi to
                             // Port3
wire  [3:0] nEBIEXTDATAEN;   // Data enable signal from Ebi
wire [31:0] EBIEXTADDROUT;   // Address out from Ebi
wire [31:0] EBIEXTDATAOUT;   // Data out from Ebi
wire [31:0] EBIDATAIN;       // Data in from Ebi


wire        EbiTrGnt1;       // Gnt signal generated by trickbox
wire        EbiTrGnt2;       // Gnt signal generated by trickbox
wire        EbiTrGnt3;       // Gnt signal generated by trickbox
wire        EbiTrBackoff1;   // Backoff signal generated by trickbox
wire        EbiTrBackoff2;   // Backoff signal generated by trickbox
wire        EbiTrBackoff3;   // Backoff signal generated by trickbox
wire  [3:0] nEbiTrExtDataEn; // Data enable signal from trickbox
wire [31:0] EbiTrExtAddrOut; // Address out from trickbox
wire [31:0] EbiTrExtDataOut; // Data out from trickbox
wire [31:0] EbiTrDataIn;     // Data in from trickbox

// ----------------------------------------------------------------------------
//
//                               EbiTrComparator
//                               ===============
//
// -----------------------------------------------------------------------------
//
// Overview
// ========
//
// -----------------------------------------------------------------------------

// ---------------------------------------------------------------------
// Constant declarations
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// Wire declarations
// ---------------------------------------------------------------------

// ---------------------------------------------------------------------
// Register declarations
// ---------------------------------------------------------------------
reg         ResetAssrtd;
// Indicates the start of checks

reg         ResetOver;
// Indicates the start of checks

// ---------------------------------------------------------------------
// Function declarations
// -----------------------------------------------------------------------------

// synopsys translate_off

// -----------------------------------------------------------------------------
// Type declarations
// -----------------------------------------------------------------------------

// synopsys translate_on

// -----------------------------------------------------------------------------
//
// Main body of code
// =================
//
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// StartCheck signal is set once the Reset is applied
// -----------------------------------------------------------------------------
always @(HRESETn or ResetAssrtd)
begin : p_ResetOverComb
  if ((ResetAssrtd) && HRESETn == 1'b1)
     ResetOver <= `TRUE;
end // p_ResetOverComb

always @(posedge EBICLK)
begin : p_ResetStrComb
  if (HRESETn == 1'b0)
    ResetAssrtd <= `TRUE;
end // p_ResetStrComb

// -----------------------------------------------------------------------------
// Compare the EBIGNT1 and EbiTrGnt1 signals and flag the error message if the
// the signals are not the same
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompGnt1Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIGNT1 != EbiTrGnt1)
        $display("Error : Time %t : EBIGNT1 and EbiTrGnt1 signals are different!!", $time);
    end
end // p_CompGnt1Seq

// -----------------------------------------------------------------------------
// Compare the EBIGNT2 and EbiTrGnt2 signals and flag the error message if the
// the signals are not the same
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompGnt2Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIGNT2 != EbiTrGnt2)
        $display("Error : Time %t : EBIGNT2 and EbiTrGnt2 signals are different!!", $time);
    end
end // p_CompGnt2Seq

// -----------------------------------------------------------------------------
// Compare the EBIGNT3 and EbiTrGnt3 signals and flag the error message if the
// the signals are not the same
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompGnt3Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIGNT3 != EbiTrGnt3)
        $display("Error : Time %t : EBIGNT3 and EbiTrGnt3 signals are different!!", $time);
    end
end // p_CompGnt3Seq

// -----------------------------------------------------------------------------
// Compare the EBIBACKOFF1 and EbiTrBackoff1 signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompBkoff1Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIBACKOFF1 != EbiTrBackoff1)
        $display("Error : Time %t : EBIBACKOFF1 and EbiTrBackoff1 signals are different!!", $time);
   end
end // p_CompBkoff1Seq

// -----------------------------------------------------------------------------
// Compare the EBIBACKOFF2 and EbiTrBackoff2 signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompBkoff2Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIBACKOFF2 != EbiTrBackoff2)
        $display("Error : Time %t : EBIBACKOFF2 and EbiTrBackoff2 signals are different!!", $time);
    end
end // p_CompBkoff2Seq

// -----------------------------------------------------------------------------
// Compare the EBIBACKOFF3 and EbiTrBackoff3 signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompBkoff3Seq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIBACKOFF3 != EbiTrBackoff3)
        $display("Error : Time %t : EBIBACKOFF3 and EbiTrBackoff3 signals are different!!", $time);
      end
end // p_CompBkoff3Seq

// -----------------------------------------------------------------------------
// Compare the nEBIEXTDATAEN and nEbiTrExtDataEn signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompDataEnSeq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (nEBIEXTDATAEN != nEbiTrExtDataEn)
        $display("Error : Time %t : nEBIEXTDATAEN and nEbiTrExtDataEn signals are different!!", $time);
    end
end // p_CompDataEnSeq

// -----------------------------------------------------------------------------
// Compare the EBIEXTADDROUT and EbiTrExtAddrOut signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompAddrOutSeq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIEXTADDROUT != EbiTrExtAddrOut)
        $display("Error : Time %t : EBIEXTADDROUT and EbiTrExtAddrOut signals are different!!", $time);
    end
end // p_CompAddrOutSeq

// -----------------------------------------------------------------------------
// Compare the EBIEXTDATAOUT and EbiTrExtDataOut signals and flag the error
// message if the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompDataOutSeq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIEXTDATAOUT != EbiTrExtDataOut)
        $display("Error : Time %t : EBIEXTDATAOUT and EbiTrExtDataOut signals are different!!", $time);
    end
end // p_CompDataOutSeq

// -----------------------------------------------------------------------------
// Compare the EBIDATAIN and EbiTrDataIn signals and flag the error message
// if the the signals are not the same.
// -----------------------------------------------------------------------------
always @(posedge EBICLK)
begin : p_CompDataInSeq
  if ((EBICLK == 1'b1) & (ResetOver == `TRUE))
    begin
      if (EBIDATAIN != EbiTrDataIn)
        $display("Error : Time %t : EBIDATAIN and EbiTrDataIn signals are different!!", $time);
    end
end // p_CompDataInSeq

// synopsys translate_off
// -----------------------------------------------------------------------------
// START OF PROTOCOL CHECKERS
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// END OF PROTOCOL CHECKERS
// -----------------------------------------------------------------------------
// synopsys translate_on

endmodule
// --================================== End ==================================--
