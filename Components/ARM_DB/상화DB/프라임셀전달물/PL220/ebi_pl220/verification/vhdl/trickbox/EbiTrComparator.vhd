-- --=========================================================================--
-- This confidential and proprietary software may be used only as
-- authorised by a licensing agreement from ARM Limited
--   (C) COPYRIGHT 2001-2002 ARM Limited
--       ALL RIGHTS RESERVED
-- The entire notice above must be reproduced on all authorised
-- copies and copies may only be made to the extent permitted
-- by a licensing agreement from ARM Limited.
--
-- -----------------------------------------------------------------------------
-- Version and Release Control Information:
--
-- File Name              : EbiTrComparator.vhd.rca
-- File Revision          : 1.2
--
-- Release Information    : PrimeCell(TM)-PL220-r0p0-00ltd0
--
-- -----------------------------------------------------------------------------
-- Purpose :
--           This block compares the signals generated by EBI and Mirrored EBI
--
-- --=========================================================================--

library IEEE;
use IEEE.std_logic_1164.all;
use IEEE.std_logic_arith.all;

-- -----------------------------------------------------------------------------

entity EbiTrComparator is
  port (
-- Inputs
        EBICLK           : in    std_logic; -- Ebi Clock
        HRESETn          : in    std_logic; -- Bus Reset
        EBIGNT1          : in    std_logic; -- Gnt signal generated by Ebi to
                                            -- Port1
        EBIGNT2          : in    std_logic; -- Gnt signal generated by Ebi to
                                            -- Port2
        EBIGNT3          : in    std_logic; -- Gnt signal generated by Ebi to
                                            -- Port3
        EBIBACKOFF1      : in    std_logic; -- Backoff signal generated Ebi to
                                            -- Port1
        EBIBACKOFF2      : in    std_logic; -- Backoff signal generated Ebi to
                                            -- Port2
        EBIBACKOFF3      : in    std_logic; -- Backoff signal generated Ebi to
                                            -- Port3
        nEBIEXTDATAEN    : in    std_logic_vector(3 downto 0);
                                            -- Data enable signal from Ebi
        EBIEXTADDROUT    : in    std_logic_vector(31 downto 0);
                                            -- Address out from Ebi
        EBIEXTDATAOUT    : in    std_logic_vector(31 downto 0);
                                            -- Data out from Ebi
        EBIDATAIN        : in    std_logic_vector(31 downto 0);
                                            -- Data in from Ebi

        EbiTrGnt1        : in    std_logic; -- Gnt signal generated by trickbox
        EbiTrGnt2        : in    std_logic; -- Gnt signal generated by trickbox
        EbiTrGnt3        : in    std_logic; -- Gnt signal generated by trickbox
        EbiTrBackoff1    : in    std_logic; -- Backoff signal generated by
                                            -- trickbox
        EbiTrBackoff2    : in    std_logic; -- Backoff signal generated by
                                            -- trickbox
        EbiTrBackoff3    : in    std_logic; -- Backoff signal generated by
                                            -- trickbox
        nEbiTrExtDataEn  : in    std_logic_vector(3 downto 0);
                                            -- Data enable signal from trickbox
        EbiTrExtAddrOut  : in    std_logic_vector(31 downto 0);
                                            -- Address out from trickbox
        EbiTrExtDataOut  : in    std_logic_vector(31 downto 0);
                                            -- Data out from trickbox
        EbiTrDataIn      : in    std_logic_vector(31 downto 0)
                                            -- Data in from trickbox

       );
end EbiTrComparator;

-- ----------------------------------------------------------------------------
--
--                               EbiTrComparator
--                               ===============
--
-- -----------------------------------------------------------------------------
--
-- Overview
-- ========
--
-- -----------------------------------------------------------------------------

-- --============================ ARCHITECTURE ===============================--

architecture behavioural of EbiTrComparator is

-- -----------------------------------------------------------------------------
-- Component declarations
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- Constant declarations
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- Signal declarations
-- -----------------------------------------------------------------------------
signal ResetAssrtd      : boolean := FALSE;
-- Indicates the start of checks

signal ResetOver        : boolean := FALSE;
-- Indicates the start of checks


-- -----------------------------------------------------------------------------
-- Function declarations
-- -----------------------------------------------------------------------------

-- synopsys translate_off
-- -----------------------------------------------------------------------------
-- Type declarations
-- -----------------------------------------------------------------------------

-- synopsys translate_on

-- -----------------------------------------------------------------------------
--
-- Main body of code
-- =================
--
-- -----------------------------------------------------------------------------

begin

-- -----------------------------------------------------------------------------
-- StartCheck signal is set once the Reset is applied
-- -----------------------------------------------------------------------------
p_ResetOverComb : process (EBICLK, HRESETn, ResetAssrtd)
begin
  if ((ResetAssrtd) and HRESETn = '1') then
    ResetOver <= TRUE;
  end if;
  if (EBICLK'event and EBICLK = '1') then
    if (HRESETn = '0') then
      ResetAssrtd <= TRUE;
    end if;
  end if;
end process p_ResetOverComb;

-- -----------------------------------------------------------------------------
-- Compare the EBIGNT1 and EbiTrGnt1 signals and flag the error message if the
-- the signals are not the same
-- -----------------------------------------------------------------------------
p_CompGnt1Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE))  then
      if (EBIGNT1 /= EbiTrGnt1) then
         assert FALSE
         report "EBIGNT1 and EbiTrGnt1 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompGnt1Seq;

-- -----------------------------------------------------------------------------
-- Compare the EBIGNT2 and EbiTrGnt2 signals and flag the error message if the
-- the signals are not the same
-- -----------------------------------------------------------------------------
p_CompGnt2Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIGNT2 /= EbiTrGnt2) then
         assert FALSE
         report "EBIGNT2 and EbiTrGnt2 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompGnt2Seq;

-- -----------------------------------------------------------------------------
-- Compare the EBIGNT3 and EbiTrGnt3 signals and flag the error message if the
-- the signals are not the same
-- -----------------------------------------------------------------------------
p_CompGnt3Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIGNT3 /= EbiTrGnt3) then
         assert FALSE
         report "EBIGNT3 and EbiTrGnt3 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompGnt3Seq;

-- -----------------------------------------------------------------------------
-- Compare the EBIBACKOFF1 and EbiTrBackoff1 signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompBkoff1Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIBACKOFF1 /= EbiTrBackoff1) then
         assert FALSE
         report "EBIBACKOFF1 and EbiTrBackoff1 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompBkoff1Seq;

-- -----------------------------------------------------------------------------
-- Compare the EBIBACKOFF2 and EbiTrBackoff2 signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompBkoff2Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIBACKOFF2 /= EbiTrBackoff2) then
         assert FALSE
         report "EBIBACKOFF2 and EbiTrBackoff2 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompBkoff2Seq;

-- -----------------------------------------------------------------------------
-- Compare the EBIBACKOFF3 and EbiTrBackoff3 signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompBkoff3Seq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIBACKOFF3 /= EbiTrBackoff3) then
         assert FALSE
         report "EBIBACKOFF3 and EbiTrBackoff3 signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompBkoff3Seq;

-- -----------------------------------------------------------------------------
-- Compare the nEBIEXTDATAEN and nEbiTrExtDataEn signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompDataEnSeq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (nEBIEXTDATAEN /= nEbiTrExtDataEn) then
         assert FALSE
         report "nEBIEXTDATAEN and nEbiTrExtDataEn signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompDataEnSeq;

-- -----------------------------------------------------------------------------
-- Compare the EBIEXTADDROUT and EbiTrExtAddrOut signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompAddrOutSeq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIEXTADDROUT /= EbiTrExtAddrOut) then
         assert FALSE
         report "EBIEXTADDROUT and EbiTrExtAddrOut signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompAddrOutSeq;

-- -----------------------------------------------------------------------------
-- Compare the EBIEXTDATAOUT and EbiTrExtDataOut signals and flag the error
-- message if the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompDataOutSeq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIEXTDATAOUT /= EbiTrExtDataOut) then
         assert FALSE
         report "EBIEXTDATAOUT and EbiTrExtDataOut signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompDataOutSeq;

-- -----------------------------------------------------------------------------
-- Compare the EBIDATAIN and EbiTrDataIn signals and flag the error message
-- if the the signals are not the same.
-- -----------------------------------------------------------------------------
p_CompDataInSeq : process (EBICLK)
begin
   if ((EBICLK'event and EBICLK = '1') and (ResetOver = TRUE)) then
      if (EBIDATAIN /= EbiTrDataIn) then
         assert FALSE
         report "EBIDATAIN and EbiTrDataIn signals are different!!"
         severity error;
      end if;
   end if;
end process p_CompDataInSeq;

-- synopsys translate_off
-- -----------------------------------------------------------------------------
-- START OF PROTOCOL CHECKERS
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- END OF PROTOCOL CHECKERS
-- -----------------------------------------------------------------------------
-- synopsys translate_on

end behavioural;

-- --================================== End ==================================--
