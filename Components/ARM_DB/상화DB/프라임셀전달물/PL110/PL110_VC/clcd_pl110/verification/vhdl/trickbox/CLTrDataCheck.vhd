-- --=========================================================================--
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 1999 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
--  ----------------------------------------------------------------------------
--
--  Version and Release Control Information:
--
--  File Name              : CLTrDataCheck.vhd.rca
--  File Revision          : 1.2
--
--  Release Information    : PrimeCell(TM)-PL110-r1p2-00ltd0
--
--  ----------------------------------------------------------------------------

--  ----------------------------------------------------------------------------
--  Purpose : CLCD Trickbox Data Checker
--
-- --=========================================================================--

library ieee;
use     ieee.std_logic_1164.all;
--use     ieee.std_logic_arith.all;
use     ieee.std_logic_unsigned.all;

library std;
use     std.textio.all;

library common;
use     common.funcs.all;
use     common.funcsmaster.all;
use     common.configmaster.all;
use     common.defs.all;
     
-- use     ieee.std_logic_unsigned.all;
-- use     std.textio.all;
-- library Std_DevelopersKit;
-- use     std_DevelopersKit.Std_Regpak.all;
-- use     std_developerskit.std_IOpak.all;
-- -----------------------------------------------------------------------------
-- Incuding the file for grey scaling with grey scaler function
-- -----------------------------------------------------------------------------


-- -----------------------------------------------------------------------------

entity CLTrDataCheck is
  port (
        HCLK           : in std_logic; 
        -- Clock
        VSYNCState     : in std_logic_vector(2 downto 0);
        -- Vertical Sync input from protocol check
        CLCLK          : in std_logic;     
        -- CLCD Clock
        HRESETn        : in std_logic;     
        -- Asynchronous Reset (active low)
        CLTrEn         : in std_logic;     
        -- CLCD Trickbox Enable
        CLTrIntrTest   : in std_logic;
        -- CLCD Trickbox interupt test  bit
        CLTrFUFIntrTst : in std_logic;
        -- CLCD Trickbox FIFO underflow interupt test  bit
        CLPOWER        : in std_logic;
        -- Panel Power
        DataAvail      : in std_logic;     
        -- FIFO Write Signal = HREADY && HTRANS(1)   : from CLCDIf Module
        Check          : in std_logic;     
        -- FIFO Read Clock = CLCP in Active Region   : from CLCDProtCheck Module
        DataIn         : in std_logic_vector(31 downto 0); 
        -- Data Input from Data Generator
        PPL            : in std_logic_vector(5 downto 0);  
        -- Pixel Per Line
        LPP            : in std_logic_vector(9 downto 0);  
        -- Line Per Panel
        CLD            : in std_logic_vector(23 downto 0); 
        -- Data Input from CLCD Panel Port
        BPP            : in std_logic_vector(2 downto 0);  
        -- Bits per pixel
        -- --------------
        -- Value   BPP
        -- ---------------
        --  000 |  1 bpp
        --  001 |  2 bpp
        --  010 |  4 bpp
        --  011 |  8 bpp
        --  100 | 16 bpp
        --  101 | Reserved
        --  110 | Reserved
        --  111 | Reserved

        BW             : in std_logic; 
        -- Black-White mode in STN
        TFT            : in std_logic; 
        -- Indicates TFT or STN Mode
        Mono8          : in std_logic; 
        -- Indicates MONO 8 bit or 4 bit mode
        Dual           : in std_logic; 
        -- Indicates Single or Dual Panel STN mode
        BGR            : in std_logic; 
        -- Indicates BGR or RGB format
        BEBO           : in std_logic; 
        -- Indicates Big Endian or Little Endian Byte order
        BEPO           : in std_logic; 
        -- Indicates Big Endian or Little Endian Pixel ordering within a byte
        -- Valid for 1, 2 and 4 BPP Mode. In Code 8 BPP mode is included in it 
        -- for Code reduction.
        CLTrPanel      : in std_logic; 
        -- Indicates Lower/Upper Panel Data transaction in STN Dual Panel mode
        -- Value  :  Indicates
        -- ------------------------------
        --   0    : Upper / Default Panel
        --   1    : lower           Panel
        ResetWritePtrs : in std_logic;         
        -- Indicates initilisation of the write pointers
        PalSelect      : in std_logic; 
        -- Palette Select Signal i.e. generated by decoding iHADDR with enable
        -- as iHSEL && iHREADYin && iHTRANS(1)
        PalWrite       : in std_logic; 
        -- Write Signal i.e. iHWRITE && iHSELCom from CLTrAHBIf
        PalData        : in std_logic_vector(31 downto 0); 
        -- Palette Data to write i.e. HWDATA from CLTrAHBIf
        PalAddr        : in std_logic_vector(6 downto 0) 
        -- Palette Address i.e. iHADDR(8:2) from CLTrAHBIf
       );
end CLTrDataCheck;

-- -----------------------------------------------------------------------------
--
--                             CLTrDataCheck
--                             =============
--
-- -----------------------------------------------------------------------------
--
-- Overview
-- ========
-- This module is intended for CLCD Panel Data Check for all the TFT and STN 
-- modes. This module includes:
-- - Palette RAM Write Block
-- - FIFO Write Block for Upper and Lower Panel
-- - Fill Level  Write Block for Upper and Lower Panel
-- - Data Read and Check Block
-- - Data Check Task and data dump
--
-- Note: Two variable `define s are there:
-- ----  o EXIT  : Indicates what to do on ERROR : Exit or Continue
--       o IMAGE : Indicates Image or random testing
-- -----------------------------------------------------------------------------

--============================== ARCHITECTURE ================================--
--
--------------------------------------------------------------------------------
-- Architecture Packages
--------------------------------------------------------------------------------
 
architecture behavioural of CLTrDataCheck is
 
--------------------------------------------------------------------------------
-- Component declaration
--------------------------------------------------------------------------------
 
--------------------------------------------------------------------------------
-- Internal Constants
--------------------------------------------------------------------------------

 
-- -----------------------------------------------------------------------------
-- Constant declarations
-- -----------------------------------------------------------------------------
-- BPP Value
-- ---------
constant BPP1             : std_logic_vector(2 downto 0) := "000";
constant BPP16            : std_logic_vector(2 downto 0) := "100";
constant BPP24            : std_logic_vector(2 downto 0) := "101";

constant ERR_EXIT         : std_logic                    := '0';
-- If cleared, Error will be displayed.
-- Else if set, It will halt the simulation.

constant IMAGE            : std_logic                    := '0';
-- If this bit is defined 1 data will be dumped to the image file 
 
-- -----------------------------------------------------------------------------
-- Register declarations
-- -----------------------------------------------------------------------------
type PaletteMem is array (127 downto 0) of std_logic_vector(31 downto 0);

signal Palette         : PaletteMem; 
-- Palette Memory

-- type FIFOMEM is array (393215 downto 0) of std_logic_vector(31 downto 0);
type FIFOMEM is array (255 downto 0) of std_logic_vector(31 downto 0);

signal FIFO            : FIFOMEM; 
-- FIFO Memory

signal FIFO1           : FIFOMEM; 
-- Another FIFO Memory for Dual mode 

signal RdPtr           : std_logic_vector(7 downto 0) := (others => '0');
-- Read Pointer for FIFO

signal WrPtr           : std_logic_vector(7 downto 0);
-- Write Pointer for FIFO
 
signal Filllevel       : std_logic_vector(8 downto 0);
-- FIFO Fill Level

signal RdPtr1          : std_logic_vector(7 downto 0) := (others => '0');
-- Read Pointer for FIFO1
 
signal WrPtr1          : std_logic_vector(7 downto 0);
-- Write PPointer for FIFO1

--  Fill levels indicates that there should not be difference of
--  of more than 256  words in Read and Write pointers
signal Filllevel1      : std_logic_vector(8 downto 0);
-- FIFO1 Fill Level

signal Wrap            : std_logic;
-- Wraping signal for FIFO read write 

signal Wrap1           : std_logic;
-- Wraping signal for FIFO1 read write 

signal   IntIndex      : std_logic_vector(7 downto 0); 
-- Index to Palette RAM from FIFO

signal IntTemp32       : std_logic_vector(31 downto 0);
-- Temporary Register of 32 bit width to hold the data from FIFO

signal IntTemp321      : std_logic_vector(31 downto 0);
-- Temporary Register of 32 bit width to hold the data from FIFO1

signal IntPhy16        : std_logic_vector(15 downto 0);
-- Physical Image Data (BGR Value with Bright bit) from Palette 
--     or FIFO (16 bpp)

signal IntPhy161       : std_logic_vector(15 downto 0);
-- Physical Image Data (BGR Value with Bright bit) from Palette or FIFO1(16 bpp)

signal IntPhy18        : std_logic_vector(17 downto 0) := (others => '0');
-- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN mode

signal IntPhy181       : std_logic_vector(17 downto 0);
-- Input to Grey Scalar for STN Dual mode 

signal IntPhyGS18      : std_logic_vector(17 downto 0) := (others => '0');
-- Expected CLD(17:0) for STN mode

signal IntGS6          : std_logic_vector(5 downto 0);
-- Output of Grey Scalar


signal StartDis        : std_logic;
-- To be used in Grey Scaler : 
-- Whenever HRESETn comes, this bit becomes high
-- In Data_Check task will be set to low

signal ClearDis        : std_logic;
signal  GreySU         : std_logic_vector(13 downto 1);
-- To read the data twice in 16 bpp STN mode

signal PixelCount : integer; 
signal LineCount  : integer; 

TYPE bitmap IS FILE OF std_logic_vector;

FILE ImageFile : TEXT is OUT "Output.dat"; 
signal SigSelectCount  : std_logic_vector(5 downto 0);
-- -----------------------------------------------------------------------------
-- Function declarations
-- -----------------------------------------------------------------------------
-- function to_integer (val : std_logic_vector; x : integer := 0)
-- return integer is
-- variable return_int, x_tmp : integer;
-- begin
--   return_int := 0;
--   x_tmp := 0;
--   if x /= 0 then
--     x_tmp := 1;
--   end if;
--   for i in val'range loop
--     return_int := return_int + return_int;
--     case val(i) is
--       when '0' =>     null;
--       when '1' =>     return_int := return_int + 1;
--       when others =>  return_int := return_int + x_tmp;
--     end case;
--   end loop;
--   return return_int;
-- end to_integer;
-- -----------------------------------------------------------------------------
function IncFrame5 (
                    constant fp5 : in std_logic_vector(2 downto 0)
                   ) return std_logic_vector is
 
variable Result : std_logic_vector(2 downto 0);
variable printstr  : string(1 to 255);
begin
  --  five frame duty cycle frame phase accumulator
  case fp5(2 downto 0) is
    when "000" => 
      Result := "010";
    when "010" =>
      Result := "001";
    when "001" =>
      Result := "100";
    when "100" =>
      Result := "011";
    when "011" =>
      Result := "000";
    when others  =>
      fprint(printstr, "Illegal value in fp5 phase accumulator at time" &
             " %s ns \n", to_string(now));
        assert false
        report printstr
        severity note;
      Result := "XXX";
  end case;
 
  return Result;
end IncFrame5;
 
function IncFrame9 (
                    constant fp9 : in std_logic_vector(3 downto 0)
                   ) return std_logic_vector is 
variable Result : std_logic_vector (3 downto 0);
variable printstr  : string(1 to 255);
begin
  --  nine frame duty cycle frame phase accumulator
  case fp9 is
    when "0000" =>
      Result := "1001";
    when "1001" =>  
      Result := "0001";
    when "0001" =>  
      Result := "1000";
    when "1000" =>  
      Result := "0010";
    when "0010" =>  
      Result := "1011";
    when "1011" =>  
      Result := "0100";
    when "0100" =>  
      Result := "1010";
    when "1010" =>  
      Result := "0101";
    when "0101" =>  
      Result := "0000";
    when others =>
        fprint(printstr, "Illegal value in fp9 phase accumulator at time" &
             " %s ns \n", to_string(now));
        assert false
        report printstr
        severity note;
      Result := "XXXX"; 
  end case;
 
return Result;
end IncFrame9;

 
function IncFrame15 (
                     constant fp15 : in std_logic_vector(3 downto 0)
                   ) return std_logic_vector is
variable Result : std_logic_vector (3 downto 0);
variable printstr  : string(1 to 255);
begin
  --  fifteen frame duty cycle frame phase accumulator
  case fp15 is
    when "1111"  =>
      Result := "0111";
    when "0111"  =>
      Result := "1110";
    when "1110"  =>
      Result := "0110";
    when "0110"  =>
      Result := "1101";
    when "1101"  =>
      Result := "0101";
    when "0101"  =>
      Result := "1100";
    when "1100"  =>
      Result := "0100";
    when "0100"  =>
      Result := "1011";
    when "1011"  =>
      Result := "0011";
    when "0011"  =>
      Result := "1010";
    when "1010"  =>
      Result := "0010";
    when "0010"  =>
      Result := "1001";
    when "1001"  =>
      Result := "0001";
    when "0001"  =>
      Result := "1000";
    when "1000"  =>
      Result := "1111"; 
    when others  =>
--        fprint(printstr, "Illegal value in fp15 phase accumulator at time" &
--              " %s \n", to_string(now,"%6.1t ns"));
        fprint(printstr, "Illegal value in fp15 phase accumulator at time" &
              " %s ns \n", to_string(now));
        assert false
        report printstr
        severity note;
      Result := "XXXX";
  end case;
 
return Result;
end IncFrame15;

function IncRow5 (
                  constant rp5   : in std_logic_vector(2 downto 0)
                 ) return std_logic_vector is
 
variable Result : std_logic_vector(2 downto 0);
begin
  --  five frame duty cycle row phase accumulator
  case rp5 is
    when "000"  =>
      Result := "001";
    when "001"  =>
      Result := "011";
    when "011"  =>
      Result := "010";
    when "010"  =>
      Result := "100";
    when "100"  =>
      Result := "000";
    when others =>
      Result := "XXX";
  end case;
 
return Result;
end IncRow5;

function ROTRIGHT (arg: std_logic_vector; count: integer) 
                   return std_logic_vector is
    constant arg_l: integer := arg'LENGTH - 1;
    alias xarg: std_logic_vector(arg_l downto 0) is arg;
    variable result32: std_logic_vector(arg_l downto 0) := xarg;
    variable result: std_logic_vector(15 downto 0) := xarg(15 downto 0);
    variable countm: integer;
  begin
    countm := count mod (arg_l + 1);
    if countm /= 0 then
      result32(arg_l-countm downto 0) := xarg(arg_l downto countm);
      result32(arg_l downto arg_l-countm+1) := xarg(countm-1 downto 0);
    end if;
    result := result32(15 downto 0);
    return result;
end ROTRIGHT; 

function IncRow9 (
                  constant rp9   : in std_logic_vector(3 downto 0)
                 ) return std_logic_vector is
variable Result : std_logic_vector(3 downto 0);
 
begin
  --  nine frame duty cycle row phase accumulator
  case rp9 is
    when "0000" =>
      Result := "0010";
    when "0010" =>
      Result := "0101";
    when "0101" =>
      Result := "1000";
    when "1000" =>
      Result := "1010";
    when "1010" =>
      Result := "0001";
    when "0001" =>
      Result := "0100";
    when "0100" =>
      Result := "1001";
    when "1001" =>
      Result := "1011";
    when "1011" =>
      Result := "0000";
    when others =>  
      Result := "XXXX";
  end case;
return Result;
end IncRow9;
 
function IncRow15 (
                   constant rp15   : in std_logic_vector(3 downto 0)
                  ) return std_logic_vector is
variable Result : std_logic_vector(3 downto 0);

begin
  --  fifteen frame duty cycle row phase accumulator
  case rp15 is
    when "1111"  =>
      Result := "1100";
    when "1100"  =>
      Result := "1001";
    when "1001"  =>
      Result := "0110";
    when "0110"  =>
      Result := "0011";
    when "0011"  =>
      Result := "1111";
    when "1110"  =>
      Result := "1011";
    when "1011"  =>
      Result := "1000";
    when "1000"  =>
      Result := "0101";
    when "0101"  =>
      Result := "0010";
    when "0010"  =>
      Result := "1110";
    when "1101"  =>
      Result := "1010";
    when "1010"  =>
      Result := "0111";
    when "0111"  =>
      Result := "0100";
    when "0100"  =>
      Result := "0001";
    when "0001"  =>
      Result := "1101";
    when others   =>
      Result := "XXXX";
  end case;
 
return Result;
end IncRow15;
 
function IncCol5 (
                  constant cp5 : in std_logic_vector (2 downto 0)
                 ) return std_logic_vector is
 
variable Result : std_logic_vector(2 downto 0);
begin
  --  five frame duty cycle column phase accumulator
  case cp5 is
    when "000" =>
      Result := "001";
    when "001" =>
      Result := "011";
    when "011" =>
      Result := "010";
    when "010" =>
      Result := "100";
    when "100" =>
      Result := "000";
    when others => 
      Result := "XXX";
  end case;
return Result;
end IncCol5;
 
 
function IncCol9 (
                  cp9 : in std_logic_vector(3 downto 0)
                 ) return std_logic_vector is
variable Result : std_logic_vector(3 downto 0);
begin
  --  nine frame duty cycle column phase accumulator
  case cp9 is
    when "0000"  => 
      Result := "0001";
    when "0001"  => 
      Result := "0010";
    when "0010"  => 
      Result := "0100";
    when "0100"  => 
      Result := "0101";
    when "0101"  => 
      Result := "1001";
    when "1001"  => 
      Result := "1000";
    when "1000"  => 
      Result := "1011";
    when "1011"  => 
      Result := "1010";
    when "1010"  => 
      Result := "0000";
    when others  => 
      Result := "XXXX";
  end case;
 
return Result;
end IncCol9;
 
function IncCol15 (
                   cp15 : in std_logic_vector(3 downto 0)
                  ) return std_logic_vector is
variable Result : std_logic_vector(3 downto 0);
 
begin
  --  fifteen frame duty cycle column phase accumulator
  --  this is a straight down counter, state machine notation used for
  --  consistency with other descriptions
  case cp15 is
    when "1111" =>
      Result := "1110";
    when "1110" =>
      Result := "1101";
    when "1101" =>
      Result := "1100";
    when "1100" =>
      Result := "1011";
    when "1011" =>
      Result := "1010";
    when "1010" =>
      Result := "1001";
    when "1001" =>
      Result := "1000";
    when "1000" =>
      Result := "0111";
    when "0111" =>
      Result := "0110";
    when "0110" =>
      Result := "0101";
    when "0101" =>
      Result := "0100";
    when "0100" =>
      Result := "0011";
    when "0011" =>
      Result := "0010";
    when "0010" =>
      Result := "0001";
    when "0001" =>
      Result := "1111";
    when others =>
      Result := "XXXX";
  end case;
 
return Result;
end IncCol15;
 
function Greyscale (
                    cp2  : in std_logic;
                    cp5  : in std_logic_vector(2 downto 0);
                    cp9  : in std_logic_vector(3 downto 0);
                    cp15 : in std_logic_vector(3 downto 0)
                   ) return std_logic_vector is
 
  --  Define the 16 grey-scales, as a function of the outputs of the column
  --  phase accumulators
variable Result : std_logic_vector(13 downto 1);
begin
  Result(1)  := cp9(1) and cp9(0);
  Result(2)  := cp5(2);
  Result(3)  := cp15(3) and cp15(0);
  Result(4)  := not (cp9(1) or cp9(0));
  Result(5)  := cp5(0);
  Result(6)  := cp9(3);
  Result(7)  := cp2;
  Result(8)  := not(Result(6));
  Result(9)  := not(Result(5));
  Result(10) := not(Result(4));
  Result(11) := not(Result(3));
  Result(12) := not(Result(2));
  Result(13) := not(Result(1));
return Result;
end Greyscale;
 
function  vidgsmux (
                    Colour    : in std_logic_vector(3 downto 0);
                    Greyscale : in std_logic_vector(13 downto 1)
                   ) return std_logic is
 
  --  16 input mux to select the greyscale
variable Result : std_logic;
begin
  case Colour is
    when "0000" =>
      Result := '0';
    when "0001" =>
      Result := Greyscale(1);
    when "0010" =>
      Result := Greyscale(2);
    when "0011" =>
      Result := Greyscale(3);
    when "0100" =>
      Result := Greyscale(4);
    when "0101" =>
      Result := Greyscale(5);
    when "0110" =>
      Result := Greyscale(6);
    when "0111" =>
      Result := Greyscale(7);
    when "1000" =>
      Result := Greyscale(8);
    when "1001" =>
      Result := Greyscale(9);
    when "1010" =>
      Result := Greyscale(10);
    when "1011" =>
      Result := Greyscale(11);
    when "1100" =>
      Result := Greyscale(12);
    when "1101" =>
      Result := Greyscale(13);
    when "1110" =>
      Result := '1';
    when "1111" =>
      Result := '1';
    when others  =>
      -- $display("Illegal greyscale value in GSMux at time %t", $time);
      Result := 'X';
  end case;
 
return Result;
end vidgsmux;

-- -----------------------------------------------------------------------------
-- Grey Scaler Main Function
-- -----------------------------------------------------------------------------
procedure GreyScaler (
                      --  State registers for grey-scale state machines
                      constant fp2in        : std_logic;
                      constant fp5in        : std_logic_vector(2 downto 0);
                      constant fp9in        : std_logic_vector(3 downto 0);
                      constant fp15in       : std_logic_vector(3 downto 0);
 
                      constant trp2in       : std_logic;
                      constant trp5in       : std_logic_vector(2 downto 0);
                      constant trp9in       : std_logic_vector(3 downto 0);
                      constant trp15in      : std_logic_vector(3 downto 0);
 
                      constant urp2in       : std_logic;
                      constant urp5in       : std_logic_vector(2 downto 0);
                      constant urp9in       : std_logic_vector(3 downto 0);
                      constant urp15in      : std_logic_vector(3 downto 0);
 
                      constant ucp2in       : std_logic;
                      constant ucp5in       : std_logic_vector(2 downto 0);
                      constant ucp9in       : std_logic_vector(3 downto 0);
                      constant ucp15in      : std_logic_vector(3 downto 0);
                       
                      constant lrp2in       : std_logic;
                      constant lrp5in       : std_logic_vector(2 downto 0);
                      constant lrp9in       : std_logic_vector(3 downto 0);
                      constant lrp15in      : std_logic_vector(3 downto 0);
                      
                      constant lcp2in       : std_logic;
                      constant lcp5in       : std_logic_vector(2 downto 0);
                      constant lcp9in       : std_logic_vector(3 downto 0);
                      constant lcp15in      : std_logic_vector(3 downto 0);
                      constant ClearDisin   : std_logic; 
                      -- Counters
                      constant LineCountin  : integer;
                      constant PixelCountin : integer;

                      variable fp2out       : out std_logic;
                      variable fp5out       : out std_logic_vector(2 downto 0);
                      variable fp9out       : out std_logic_vector(3 downto 0);
                      variable fp15out      : out std_logic_vector(3 downto 0);
                      
                      variable trp2out      : out std_logic;
                      variable trp5out      : out std_logic_vector(2 downto 0);
                      variable trp9out      : out std_logic_vector(3 downto 0);
                      variable trp15out     : out std_logic_vector(3 downto 0);
                       
                      variable urp2out      : out std_logic;
                      variable urp5out      : out std_logic_vector(2 downto 0);
                      variable urp9out      : out std_logic_vector(3 downto 0);
                      variable urp15out     : out std_logic_vector(3 downto 0);
                      
                      variable ucp2out      : out std_logic;
                      variable ucp5out      : out std_logic_vector(2 downto 0);
                      variable ucp9out      : out std_logic_vector(3 downto 0);
                      variable ucp15out     : out std_logic_vector(3 downto 0);
                       
                      variable lrp2out      : out std_logic;
                      variable lrp5out      : out std_logic_vector(2 downto 0);
                      variable lrp9out      : out std_logic_vector(3 downto 0);
                      variable lrp15out     : out std_logic_vector(3 downto 0);
                       
                      variable lcp2out      : out std_logic;
                      variable lcp5out      : out std_logic_vector(2 downto 0);
                      variable lcp9out      : out std_logic_vector(3 downto 0);
                      variable lcp15out     : out std_logic_vector(3 downto 0);
                       
                      -- Counters
                      variable LineCountout  : out integer;
                      variable PixelCountout : out integer;


                     UpColor                : std_logic_vector (17 downto 0);
                     variable GreysU        : out std_logic_vector(13 downto 1);
                     variable ClearDis      : out std_logic;
                     variable GreyScaler    : out std_logic_vector(5 downto 0); 
                     PPL                    : std_logic_vector (5 downto 0);
                     LPP                    : std_logic_vector (9 downto 0);
                     LpColor                : std_logic_vector (17 downto 0)
                    ) is
-- -----------------------------------------------------------------------------
--   Variable declarations
-- -----------------------------------------------------------------------------
variable iGreysU       : std_logic_vector(13 downto 1);
variable GreysL        : std_logic_vector(13 downto 1);

variable ifp2out       : std_logic;
variable ifp5out       : std_logic_vector(2 downto 0);
variable ifp9out       : std_logic_vector(3 downto 0);
variable ifp15out      : std_logic_vector(3 downto 0);

variable itrp2out      : std_logic;
variable itrp5out      : std_logic_vector(2 downto 0);
variable itrp9out      : std_logic_vector(3 downto 0);
variable itrp15out     : std_logic_vector(3 downto 0);
 
variable iurp2out      : std_logic;
variable iurp5out      : std_logic_vector(2 downto 0);
variable iurp9out      : std_logic_vector(3 downto 0);
variable iurp15out     : std_logic_vector(3 downto 0);
 
variable iucp2out      : std_logic;
variable iucp5out      : std_logic_vector(2 downto 0);
variable iucp9out      : std_logic_vector(3 downto 0);
variable iucp15out     : std_logic_vector(3 downto 0);
 
variable ilrp2out      : std_logic;
variable ilrp5out      : std_logic_vector(2 downto 0);
variable ilrp9out      : std_logic_vector(3 downto 0);
variable ilrp15out     : std_logic_vector(3 downto 0);
 
variable ilcp2out      : std_logic;
variable ilcp5out      : std_logic_vector(2 downto 0);
variable ilcp9out      : std_logic_vector(3 downto 0);
variable ilcp15out     : std_logic_vector(3 downto 0);
 
-- Counters
variable iLineCountout  : integer;
variable iPixelCountout : integer;

variable UpRGS         : std_logic;
variable UpGGS         : std_logic;
variable UpBGS         : std_logic;
variable LpRGS         : std_logic;
variable LpGGS         : std_logic;
variable LpBGS         : std_logic;

begin

-- -----------------------------------------------------------------------------
-- Load and Increment Control Signal Generation : Line & Pixel Counters
-- -----------------------------------------------------------------------------
  iLineCountout   := LineCountin;
  iPixelCountout  := PixelCountin;
  ifp2out         := fp2in;
  ifp5out         := fp5in;
  ifp9out         := fp9in;
  ifp15out        := fp15in;
  itrp2out        := trp2in;
  itrp5out        := trp5in;
  itrp9out        := trp9in;
  itrp15out       := trp15in;
  iurp2out        := urp2in;
  iurp5out        := urp5in;
  iurp9out        := urp9in;
  iurp15out       := urp15in;
  iucp2out        := ucp2in;
  iucp5out        := ucp5in;
  iucp9out        := ucp9in;
  iucp15out       := ucp15in;
  ilrp2out        := lrp2in;
  ilrp5out        := lrp5in;
  ilrp9out        := lrp9in;
  ilrp15out       := lrp15in;
  ilcp2out        := lcp2in;
  ilcp5out        := lcp5in;
  ilcp9out        := lcp9in;
  ilcp15out       := lcp15in;

  if (StartDis = '1' and ClearDisin = '0') then
    -- At the start of display after reset
    iPixelCountout := (16 * (to_integer(('0' & PPL) + 1))) - 1;
    iLineCountout  := to_integer('0' & LPP);
  else
    -- Decrement Pixel and Line Counter
    if (PixelCountin = 0) then
      if (LineCountin = 0) then
        iLineCountout := to_integer('0' & LPP);
      else
        iLineCountout := LineCountin - 1;
      end if;
      iPixelCountout := 16 * to_integer((('0' & PPL) + 1)) - 1;
    else
      iPixelCountout := PixelCountin - 1;
    end if;
  end if;
-- -----------------------------------------------------------------------------
-- Frame Phase Accumulator Update
-- -----------------------------------------------------------------------------
  if (StartDis = '1' and ClearDisin = '0') then
    ifp2out   := '0';
    ifp5out   := "000";
    ifp9out   := "0000";
    ifp15out  := "1111";
    itrp2out  := '0';
    itrp5out  := "000";
    itrp9out  := "0000";
    itrp15out := "1111";
  elsif (iLineCountout = 0 and iPixelCountout = 0) then 
    --  At End of a Frame increment frame counters
    ifp2out   := not(fp2in);
    ifp5out   := IncFrame5(fp5in);
    ifp9out   := IncFrame9(fp9in);
    ifp15out  := IncFrame15(fp15in);
    itrp2out  := urp2in;
    itrp5out  := urp5in;
    itrp9out  := urp9in;
    itrp15out := urp15in;
  end if;
     
-- -----------------------------------------------------------------------------
-- Row Phase Accumulator Update
-- -----------------------------------------------------------------------------
  if ((StartDis = '1' and ClearDisin = '0') or (iLineCountout = 0 and (iPixelCountout = 0))) then
    --  Load row values at the end of frame
    iurp2out  := ifp2out;
    iurp5out  := ifp5out;
    iurp9out  := ifp9out;
    iurp15out := ifp15out;
    ilrp2out  := itrp2out;
    ilrp5out  := itrp5out;
    ilrp9out  := itrp9out;
    ilrp15out := itrp15out;
  else 
    if (iPixelCountout = 1) then
      -- Increment Row Conters at the end of each row
      iurp2out  := not(urp2in);
      iurp5out  := IncRow5 (urp5in);
      iurp9out  := IncRow9 (urp9in);
      iurp15out := IncRow15 (urp15in);
      ilrp2out  := not(lrp2in);
      ilrp5out  := IncRow5 (lrp5in);
      ilrp9out  := IncRow9 (lrp9in);
      ilrp15out := IncRow15 (lrp15in);
    end if;
  end if;

-- -----------------------------------------------------------------------------
-- Column Phase Accumulator Update
-- -----------------------------------------------------------------------------
    if ((StartDis = '1' and ClearDisin = '0') or 
       (iPixelCountout = (16 * (to_integer(('0' & PPL) + 1)) - 1))) then
      --  Load column values
      iucp2out  := iurp2out;
      iucp5out  := iurp5out;
      iucp9out  := iurp9out;
      iucp15out := iurp15out;
      ilcp2out  := ilrp2out;
      ilcp5out  := ilrp5out;
      ilcp9out  := ilrp9out;
      ilcp15out := ilrp15out;
    else
      --  Increment  column counters
      iucp2out  := not(ucp2in);
      iucp5out  := IncCol5 (ucp5in);
      iucp9out  := IncCol9 (ucp9in);
      iucp15out := IncCol15 (ucp15in);
      ilcp2out  := not(lcp2in);
      ilcp5out  := IncCol5 (lcp5in);
      ilcp9out  := IncCol9 (lcp9in);
      ilcp15out := IncCol15 (lcp15in);
    end if;
-- -----------------------------------------------------------------------------
-- Make StartDis low:
-- -----------------------------------------------------------------------------
  if (StartDis = '1') then
    ClearDis := '1';
  else
    ClearDis := '0';
  end if;
-- -----------------------------------------------------------------------------
-- Greyscaler Output Generation
-- -----------------------------------------------------------------------------
  fp2out        := ifp2out; 
  fp5out        := ifp5out; 
  fp9out        := ifp9out;
  fp15out       := ifp15out;     
  trp2out       := itrp2out ;   
  trp5out       := itrp5out;   
  trp9out       := itrp9out;  
  trp15out      := itrp15out;
  urp2out       := iurp2out  ;
  urp5out       := iurp5out ;
  urp9out       := iurp9out;
  urp15out      := iurp15out ;   
  ucp2out       := iucp2out    ;
  ucp5out       := iucp5out   ;
  ucp9out       := iucp9out ; 
  ucp15out      := iucp15out;
  lrp2out       := ilrp2out;     
  lrp5out       := ilrp5out;    
  lrp9out       := ilrp9out;   
  lrp15out      := ilrp15out; 
  lcp2out       := ilcp2out;   
  lcp5out       := ilcp5out;  
  lcp9out       := ilcp9out; 
  lcp15out      := ilcp15out;
 
  LineCountout  := iLineCountout;  
  PixelCountout := iPixelCountout; 
  
  iGreysU       := Greyscale (iucp2out, iucp5out, iucp9out, iucp15out);
  GreySU        := iGreySU;
  GreysL        := Greyscale (ilcp2out, ilcp5out, ilcp9out, ilcp15out);
  
  UpRGS         := vidgsmux (UpColor(5 downto 2), iGreysU);
  UpGGS         := vidgsmux (UpColor(11 downto 8), iGreysU);
  UpBGS         := vidgsmux (UpColor(17 downto 14), iGreysU);
  LpRGS         := vidgsmux (LpColor(5 downto 2), GreysL);
  LpGGS         := vidgsmux (LpColor(11 downto 8), GreysL);
  LpBGS         := vidgsmux (LpColor(17 downto 14), GreysL);

  GreyScaler    := LpRGS & LpGGS & LpBGS & UpRGS & UpGGS & UpBGS;
end GreyScaler;
-- -----------------------------------------------------------------------------
-- Data Check Block (Task) : Checking will wait for a CLCP to arrive in Active
-- region and then check. Simultaneously, for actual image data this block will
-- write the formatted Panel data to a file.
-- -----------------------------------------------------------------------------
procedure Data_Check (
                      constant CLD       : in std_logic_vector(23 downto 0);
                      constant CLTrData  : in std_logic_vector(23 downto 0)
                     ) is
variable ImageLine  : line;
variable printstr    : string(1 to 255);
begin
  if (CLTrEn = '1') then
    if (VSYNCState = "011") then
      -- Check signal denotes new CLD data is valid, or CLCP had arrived in the
      -- Active Region. In the DtatCheck module the data will be checked on the
      -- negetive edge of Chcek. The generation of Check is shown below:
      --                  __    __    __    __    __    __    __    __
      --  CLCLK     :  __1  |__1  |__1  |__1  |__1  |__1  |__1  |__1  |__
      --                        ___________             ___________
      --  CLCP      :  ________|           |___________|           |_____
      --               _________ _______________________ ________________
      --  CLD       :  ___D(i)__X__________D(i+1)_______X______D(i+2)____
      --                        _____                   _____
      --  Check     :  ________1     Y_________________|     Y___________
      --                      /|\    ^                       ^
      --                       |     ^ = Data will be checked at these NegEdges.
      --                       |------ = Data can be checked here, otherwise it
      --                                 it will compare D(i) with
      --                                 "Expected D(i+1)".
      wait until ((Check'event and Check = '0') or 
                  ( CLTrEn'event and CLTrEn = '0') or
                  (VSYNCState'event and VSYNCState(2) = '1'));
      if (CLD /= CLTrData) then
        if ((CLTrEn = '1') and (VSYNCState = "011")) then
          fprint(printstr, "ERROR:CLCD Panel Data is not matching \n");
          assert false
          report printstr
          severity error;
          if (ERR_EXIT = '0') then
            fprint(printstr, "Error Exit");
            assert false
            report printstr
            severity error;
          else
            assert false
            report printstr
            severity failure;
          end if;
        end if;
      end if;
      wait for 10 ps;
      if (IMAGE = '1') then
        -- Writing the formatted data in a file
        --$fdisplay(ImageFile,"%b",CLD);
        WRITE (ImageLine, to_integer('0' & CLD));
        WRITELINE (ImageFile, ImageLine);
      end if;
    end if;
  end if;
end Data_Check;
 
-------------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- Main body of code
-- =================
-- -----------------------------------------------------------------------------

begin

-- -----------------------------------------------------------------------------
-- The assigning the diference in read and write pointers to the fill levels
-- -----------------------------------------------------------------------------
p_FillComb : process (Wrap, Wrptr, RdPtr, Wrap1, Wrptr1, RdPtr1)
begin
  Filllevel  <= (Wrap & WrPtr) - ('0' & RdPtr);
  Filllevel1 <= (Wrap1 & WrPtr1) - ('0' & RdPtr1);
end process p_FillComb;

-- -----------------------------------------------------------------------------
-- The assigning the diference in read and write pointers to the fill levels
-- -----------------------------------------------------------------------------
p_WrapComb : process (HCLK, HRESETN, CLTrEn, DataAvail, Check, ResetWritePtrs)
begin
  if (HRESETN = '0'  or CLTrEn = '0' or ResetWritePtrs = '1') then
    Wrap  <= '0';
  elsif(WrPtr = "11111111" and DataAvail = '1' and CLTrPanel = '0') then
    Wrap  <= '1';  
  elsif(RdPtr = "11111111" and Check = '1') then
    Wrap  <= '0'; 
  end if;
end process p_WrapComb;
-- -----------------------------------------------------------------------------
-- The assigning the diference in read and write pointers to the fill levels
-- -----------------------------------------------------------------------------
p_Wrap1Comb : process (HCLK, HRESETN, CLTrEn, DataAvail, Check, ResetWritePtrs)
begin
  if (HRESETN = '0'  or CLTrEn = '0' or ResetWritePtrs = '1') then
    Wrap1  <= '0';
  elsif(WrPtr1 = "11111111" and DataAvail = '1' and 
        CLTrPanel = '1' and TFT = '0' and Dual = '1') then
    Wrap1  <= '1';  
  elsif(RdPtr1 = "11111111" and Check = '1') then
    Wrap1  <= '0'; 
  end if;
end process p_Wrap1Comb;

-- -----------------------------------------------------------------------------
-- Palette RAM Write Block
-- -----------------------------------------------------------------------------
p_PaletteWrite : process (HCLK) 
begin
  if (HCLK'event and HCLK = '1' and PalSelect = '1' and PalWrite = '1') then
      -- Each write will update two successive Palette entries
      Palette((to_integer((PalAddr)))) <= PalData;
  end if;
end process p_PaletteWrite;

-- -----------------------------------------------------------------------------
-- FIFO Write Block : Write will happen at each HCLK whenever DataAvail is high
-- -----------------------------------------------------------------------------
p_FIFOWrite : process (HCLK, HRESETn, CLTrEn) 
variable printstr  : string(1 to 255);
begin
  if ((HRESETn'event and HRESETn = '0') or (HCLK'event and HCLK = '0' and
       ResetWritePtrs = '1') or (CLTrEn'event and CLTrEn = '0')) then
    WrPtr  <= (others => '0');
  -- FIFO Write for Upper Panel for which CLTrPanel = 0
  elsif (HCLK'event and HCLK = '0' and DataAvail = '1' and CLTrPanel = '0') then
    -- If FIFO is Full
    if (Filllevel = 255) then
      -- $display($time," : ERROR : CLCD Input without Output\n");
      fprint(printstr, "ERROR : CLCD Input without Output\n");
        assert false
        report printstr
        severity error;
      if (ERR_EXIT = '0') then
        fprint(printstr, "Error Exit");
        assert false
        report printstr
        severity error;
      else
        assert false
        report printstr
        severity failure;
      end if;
    else 
      FIFO(to_integer(WrPtr)) <= DataIn;
      WrPtr       <= (WrPtr) + '1';
    end if;
  end if;
end process p_FIFOWrite;
-- -----------------------------------------------------------------------------
-- FIFO1 Write Block : Write will happen at each HCLK whenever DataAvail is high
-- and in STN Dual Panel Mode
-- -----------------------------------------------------------------------------
p_FIFO1Write : process (HCLK, HRESETn, CLTrEn) 
variable printstr  : string(1 to 255);
begin
  if ((HRESETn'event and HRESETn = '0') or (HCLK'event and HCLK = '0' and 
       ResetWritePtrs = '1') or (CLTrEn'event and CLTrEn = '0')) then
    WrPtr1 <= (others => '0');
  -- FIFO Write to Lower Panel FIFO in Dual panel STN mode
  elsif (((HCLK'event and HCLK = '0') or (CLTrEn'event and CLTrEn = '0')) and 
           DataAvail = '1' and TFT = '0' and Dual = '1' and CLTrPanel = '1')then
    if (Filllevel1 = 255) then
      -- $display($time," : ERROR : CLCD Input without Output\n");
      fprint(printstr, "ERROR : CLCD Input without Output\n");
        assert false
        report printstr
        severity error;
      if (ERR_EXIT = '0') then
        fprint(printstr, "Error Exit");
        assert false
        report printstr
        severity error;
      else
        assert false
        report printstr
        severity failure;
      end if;
    else
      FIFO1(to_integer(WrPtr1)) <= DataIn;
      WrPtr1 <= (WrPtr1) + '1';
    end if;
  end if;
end process p_FIFO1Write;

-- -----------------------------------------------------------------------------
-- Filllevel Check Block for FIFO1 in STN Dual Panel mode
-- -----------------------------------------------------------------------------
p_GenFilllevel1 : process (HCLK, Check, HRESETn, CLTrEn) 
variable printstr  : string(1 to 255);
begin
  -- Check if CLTrPanel are high when Dual is low : ERROR in Test
  if (((HCLK'event and HCLK = '1') or (Check'event and Check = '1') or
       (HRESETn'event and HRESETn = '0') or (CLTrEn'event and CLTrEn = '0') or
       (Check'event and Check = '1')) and TFT = '0' and Dual = '0' and 
       CLTrPanel = '1') then
    fprint(printstr, "ERROR : CLTrPanel is 1 in STN Single panel mode\n");
      assert false
      report printstr
      severity error;
    if (ERR_EXIT = '0') then
      fprint(printstr, "Error Exit");
      assert false
      report printstr
      severity error;
    else
      assert false
      report printstr
      severity failure;
    end if;
  end if;
end process p_GenFilllevel1;

-- -----------------------------------------------------------------------------
-- This block generate startdis signal at the start of the frame
-- -----------------------------------------------------------------------------

p_DispInit : process (CLTrEn, HRESETN, ClearDis)
begin
  if ((HRESETn'event and HRESETN = '1') or (CLTrEn'event and CLTrEn = '1')) then
    StartDis <= '1';
  elsif (ClearDis'event and ClearDis = '1') then
    StartDis <= '0';
  end if;
end process p_DispInit;

-- -----------------------------------------------------------------------------
-- Data Read and Check Block : This block will read the data from FIFO in a
-- continuous manner and process it. Then the data will be checked by invoking
-- Data_Check task which will check the data at each CLCP in Active region.
-- Note: Check is the version of CLCP in Active Region.
--       Data processing and Error checking for Lower Panel FIFO (FIFO1) will
--       be active only in STN Dual Panel mode i.e. at logic (!TFT && Dual).
-- -----------------------------------------------------------------------------
p_DataReadNCheck : process
-- -----------------------------------------------------------------------------
--   Variable declarations
-- -----------------------------------------------------------------------------
variable printstr             : string(1 to 255);

variable Bitno                : integer;
variable PixDataNum           : integer := 0;
variable SelectCount          : std_logic_vector(5 downto 0);

variable Temp32               : std_logic_vector(31 downto 0);
-- Temporary Register of 32 bit width to hold the data from FIFO

variable Temp321              : std_logic_vector(31 downto 0);
-- Temporary Register of 32 bit width to hold the data from FIFO1

variable Phy16                : std_logic_vector(15 downto 0);
-- Physical Image Data (BGR Value with Bright bit) from Palette or FIFO (16 bpp)

variable Phy161               : std_logic_vector(15 downto 0);
-- Physical Image Data (BGR Value with Bright bit) from Palette or FIFO1(16 bpp)

variable Phy18                : std_logic_vector(17 downto 0) := (others => '0');
-- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN mode

variable Phy24                : std_logic_vector(23 downto 0) := (others => '0');
-- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN mode

variable Phy181               : std_logic_vector(17 downto 0);
-- Input to Grey Scalar for STN Dual mode 

variable PhyGS18              : std_logic_vector(17 downto 0) := (others => '0');
-- Expected CLD(17:0) for STN mode

variable GS6                  : std_logic_vector(5 downto 0);
-- Output of Grey Scalar

variable Temp8                : std_logic_vector(7 downto 0);
-- Temporary Register of 8 bit width to hold bytes extracted from Temp32

variable Temp81               : std_logic_vector(7 downto 0);
-- Temporary Register of 8 bit width to hold bytes extracted from Temp321

variable BPPValue             : std_logic_vector(3 downto 0); 
-- Actual BPP Value i.e. 2 E+BPP

variable iClearDis            : std_logic;
variable iGreySU              : std_logic_vector(13 downto 1);

variable n      : integer;
variable m      : integer;
variable k      : integer;

variable Bitpos               : std_logic_vector(2 downto 0) := "111";
variable Previous             : integer;

variable Index                : std_logic_vector(7 downto 0);
-- Index to Palette RAM from FIFO

variable Index1               : std_logic_vector(7 downto 0);
-- Index to Palette RAM from FIFO1
variable CldLoop              : std_logic_vector(2 downto 0);
 
variable ClearDisin           : std_logic := '0';

-- These are the varibles for grey scaler function
-- These act as the column ,row,and frame counters
variable fp2in        : std_logic;
variable fp5in        : std_logic_vector(2 downto 0);
variable fp9in        : std_logic_vector(3 downto 0);
variable fp15in       : std_logic_vector(3 downto 0);
variable trp2in       : std_logic;
variable trp5in       : std_logic_vector(2 downto 0);
variable trp9in       : std_logic_vector(3 downto 0);
variable trp15in      : std_logic_vector(3 downto 0);
 
variable urp2in       : std_logic;
variable urp5in       : std_logic_vector(2 downto 0);
variable urp9in       : std_logic_vector(3 downto 0);
variable urp15in      : std_logic_vector(3 downto 0);
 
variable ucp2in       : std_logic;
variable ucp5in       : std_logic_vector(2 downto 0);
variable ucp9in       : std_logic_vector(3 downto 0);
variable ucp15in      : std_logic_vector(3 downto 0);
 
variable lrp2in       : std_logic;
variable lrp5in       : std_logic_vector(2 downto 0);
variable lrp9in       : std_logic_vector(3 downto 0);
variable lrp15in      : std_logic_vector(3 downto 0);
 
variable lcp2in       : std_logic;
variable lcp5in       : std_logic_vector(2 downto 0);
variable lcp9in       : std_logic_vector(3 downto 0);
variable lcp15in      : std_logic_vector(3 downto 0);
variable LineCountin  : integer;
variable PixelCountin : integer;
 
variable fp2out       : std_logic;
variable fp5out       : std_logic_vector(2 downto 0);
variable fp9out       : std_logic_vector(3 downto 0);
variable fp15out      : std_logic_vector(3 downto 0);
 
variable trp2out      : std_logic;
variable trp5out      : std_logic_vector(2 downto 0);
variable trp9out      : std_logic_vector(3 downto 0);
variable trp15out     : std_logic_vector(3 downto 0);
 
variable urp2out      : std_logic;
variable urp5out      : std_logic_vector(2 downto 0);
variable urp9out      : std_logic_vector(3 downto 0);
variable urp15out     : std_logic_vector(3 downto 0);
 
variable ucp2out      : std_logic;
variable ucp5out      : std_logic_vector(2 downto 0);
variable ucp9out      : std_logic_vector(3 downto 0);
variable ucp15out     : std_logic_vector(3 downto 0);
 
variable lrp2out      : std_logic;
variable lrp5out      : std_logic_vector(2 downto 0);
variable lrp9out      : std_logic_vector(3 downto 0);
variable lrp15out     : std_logic_vector(3 downto 0);
 
variable lcp2out      : std_logic;
variable lcp5out      : std_logic_vector(2 downto 0);
variable lcp9out      : std_logic_vector(3 downto 0);
variable lcp15out     : std_logic_vector(3 downto 0);
 
-- Counters
variable LineCountout  : integer;
variable PixelCountout : integer;
variable iRdPtr        : std_logic_vector(7 downto 0) := (others => '0');
variable iRdPtr1       : std_logic_vector(7 downto 0) := (others => '0');
begin
  if (HRESETn = '0' or CLTrEn = '0' or (VSYNCState = "001")) then
    iRdPtr    := (others => '0');
    RdPtr     <= iRdPtr;
    iRdPtr1   := (others => '0');
    RdPtr1    <= iRdPtr1;
    Bitpos    := "111";
    Phy18     := (others => '0'); 
    IntPhy18  <= Phy18;
    PhyGS18   := (others => '0');
  end if;
  PixDataNum  := 0;
  SelectCount := "000000";
  SigSelectCount <= SelectCount;

  -- Wait for a Check i.e. CLCP to come in Active region
  wait until ((Check'event and Check = '1') or
              (VSYNCState'event and VSYNCState(2) = '1') or
              (VSYNCState'event and VSYNCState = "001"));
  if (VSYNCState(2) = '1' or VSYNCState = "001") then
    iRdPtr   := (others => '0');
    RdPtr    <= iRdPtr;
    RdPtr1   <= (others => '0');
    RdPtr1   <= iRdPtr1;
    Bitpos   := "111";
    Phy18    := (others => '0'); 
    IntPhy18 <= Phy18;
    PhyGS18  := (others => '0');
  elsif (Check = '1') then
    Previous := 2;
    if (TFT = '1') then
      CldLoop := "001";
    else 
      case BPP is
        when BPP16  => CldLoop := "010";
        when others => CldLoop := "001";
      end case;
    end if;
 
    -- Check is no data  in Upper/Lower Panel FIFO to Read
    if (Filllevel = "000000000" or (TFT = '0' and Dual = '1' 
        and Filllevel1 = "000000000")) then
      fprint(printstr, "ERROR : CLCD GIVING OUTPUT without INPUT\n");
      assert (CLTrFUFIntrTst /= '0')
      report printstr
      severity error;
      if (ERR_EXIT = '0') then
        fprint(printstr, "Error Exit");
        assert (CLTrFUFIntrTst /= '0')
        report printstr
        severity error;
      else
        assert (CLTrFUFIntrTst /= '0')
        report printstr
        severity failure;
      end if;
    else 
      for i in 1 to to_integer(CldLoop) loop
        -- Read a 32 bit data from Upper Panel FIFO
        Temp32     := FIFO(to_integer(iRdPtr)); 
        IntTemp32  <= Temp32;
        -- Temporary Register of 32 bit width to hold the data from FIFO
        iRdPtr := (iRdPtr) + '1';
        RdPtr  <= iRdPtr;
        if (TFT = '0' and Dual = '1') then
          -- Read a 32 bit data from Lower Panel FIFO (FIFO1)
          Temp321 := FIFO1(to_integer(iRdPtr1)); 
          iRdPtr1 := (iRdPtr1) + '1';
          RdPtr1  <= iRdPtr1;
        end if;
  
        -- Data Processing and Checking
        -- ============================
        if (BPP = BPP24 and TFT = '1') then 
          if (BGR = '1') then
             Phy24 := (Temp32(7 downto 0) & Temp32(15 downto 8) & 
                       Temp32(23 downto 16));
             Data_Check(CLD, Phy24);
          else 
            Phy24 := Temp32(23 downto 0);
            Data_Check(CLD, Phy24);
          end if;
        elsif (BPP = BPP24 and TFT = '0') then
          fprint(printstr, "ERROR : INVALID BPP SETTING FOR STN MODE\n ");
          assert false
          report printstr
          severity error;

        elsif (BPP = BPP16) then
          -- 16 BPP Mode :  BEPO Value is Insignificant
          -- ------------------------------------------
          -- For 1st 16 bit half of 32 bit data
          -- ----------------------------------
          if (BEBO = '1') then
          -- In Big Endian Byte Ordering : 1st data will be the upper half
            Phy16 := Temp32(31 downto 16); 
             -- In case of STN Dual Panel mode
            if (TFT = '0' and Dual = '1') then
                Phy161 := Temp321(31 downto 16);
            end if;
          else
          -- In Little Endian Ordering : 1st data will be the Upper half
            Phy16  := Temp32(15 downto 0);
            -- In case of STN Dual Panel mode
            if (TFT = '0' and Dual = '1') then
              Phy161  := Temp321(15 downto 0);
            end if;
          end if;
            -- Formatter : Converts 16 bit Data to actual 18 bit CLD
            -- ---------
            -- Interchange the R and B for BGR mode and also place the 
            -- bright bit as the LSB of each R, G, B field.
            if (BGR = '1') then
              -- R and B interchange is needed.
              Phy18 := Phy16(4 downto 0) & Phy16(15) & 
                       Phy16(9 downto 5) & Phy16(15) &
                       Phy16(14 downto 10) & Phy16(15);
              IntPhy18 <=  Phy18;
              -- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN
              Phy181   := "000000000000000000"; 
              if (TFT = '0' and Dual = '1') then
                Phy181 := Phy161(4 downto 0) & Phy161(15) & 
                          Phy161(9 downto 5) & Phy161(15) &
                          Phy161(14 downto 10) & Phy161(15);
              end if;
            else
              -- R and B interchange is not needed.
              Phy18 := Phy16(14 downto 10) & Phy16(15) & 
                       Phy16(9 downto 5) & Phy16(15) &
                       Phy16(4 downto 0) & Phy16(15);
              IntPhy18       <=  Phy18;
              -- Expected CLD(17:0) for TFT mode : Input to Grey Scalar STN

              Phy181 := "000000000000000000";
              if (TFT = '0' and Dual = '1') then
                Phy181 := Phy161(14 downto 10) & Phy161(15) & 
                          Phy161(9 downto 5) & Phy161(15) & 
                          Phy161(4 downto 0) & Phy161(15);
              end if;
            end if;
            if (TFT = '1') then
              -- For TFT 16 Bpp mode Palette is not required.
                IntPhy18 <=  Phy18;
                Data_Check(CLD,"000000" &  Phy18);
            else
              -- STN mode
              IntPhy18 <=  Phy18;
              GreyScaler(
                         fp2in, fp5in, fp9in, fp15in,
                         trp2in, trp5in, trp9in, trp15in,
                         urp2in, urp5in, urp9in, urp15in,
                         ucp2in, ucp5in, ucp9in, ucp15in,
                         lrp2in, lrp5in, lrp9in, lrp15in,
                         lcp2in, lcp5in, lcp9in, lcp15in, ClearDisin,
                         LineCountin, PixelCountin, 
                         fp2out, fp5out, fp9out, fp15out,
                         trp2out, trp5out, trp9out, trp15out,
                         urp2out, urp5out, urp9out, urp15out,
                         ucp2out, ucp5out, ucp9out, ucp15out,
                         lrp2out, lrp5out, lrp9out, lrp15out,
                         lcp2out, lcp5out, lcp9out, lcp15out,
                         LineCountout, PixelCountout,
                         Phy18, iGreySU, iClearDis, GS6, PPL, LPP, Phy181);

              fp2in        := fp2out;
              fp5in        := fp5out;
              fp9in        := fp9out;
              fp15in       := fp15out;
              trp2in       := trp2out;
              trp5in       := trp5out;
              trp9in       := trp9out;
              trp15in      := trp15out;
              urp2in       := urp2out;
              urp5in       := urp5out;
              urp9in       := urp9out;
              urp15in      := urp15out;
              ucp2in       := ucp2out;
              ucp5in       := ucp5out;
              ucp9in       := ucp9out;
              ucp15in      := ucp15out;
              lrp2in       := lrp2out;
              lrp5in       := lrp5out;
              lrp9in       := lrp9out;
              lrp15in      := lrp15out;
              lcp2in       := lcp2out;
              lcp5in       := lcp5out;
              lcp9in       := lcp9out;
              lcp15in      := lcp15out;
              PixelCountin := PixelCountout;
              LineCountin  := LineCountout;
              PixelCount   <= PixelCountin;
              LineCount    <= LineCountin;
              GreySU       <= iGreySU;
              ClearDisin   := iClearDis;
              ClearDis     <= iClearDis;
              IntGS6       <= GS6;
              -- GS6(2 downto 0) = (RGS,GGS,BGS) for Upper Panel
              -- GS6(5 downto 3) = (RGS,GGS,BGS) for Lower Panel
              if (BW = '1') then
                -- For MONO mode of STN
                if (Mono8 = '1') then
                  m := 8;
                else
                  m := 4;
                end if;
                Bitno := (to_integer(Bitpos) mod m);
                PhyGS18(Bitno) := GS6(2);
                if (Dual = '1') then
                  PhyGS18(8 + Bitno) := GS6(5);
                else
                  PhyGS18(8 + Bitno) := '0';
                end if;
                -- 1st Pixel will correspond to MSB
                -- When one data is ready Check it
                if (Bitno = 0) then
                  Data_Check(CLD,"000000" &  PhyGS18);
                  IntPhyGS18 <=  PhyGS18; 
                end if;
                Bitpos := Bitpos - '1';
              else
              -- For COLOR mode of STN
                n := Previous;
                while (n >= 0) loop
                  PhyGS18(to_integer(Bitpos)) := GS6(n);
                  if (Dual = '1') then
                    PhyGS18(8 + to_integer(Bitpos)) := GS6(3 + n);
                  end if;
                  if (n /= 0) then
                    Previous := n -1;
                  else 
                    Previous := 2;
                  end if;
                  n := n - 1;
                  if (Bitpos = 0) then
                    Data_Check(CLD,"000000" &  PhyGS18);
                    IntPhyGS18 <=  PhyGS18;
                  end if;
                  Bitpos := Bitpos - '1';
                end loop;
              end if;
            end if;

          -- For 2nd 16 bit half of 32 bit data
          -- ----------------------------------
          if (BEBO = '1') then
            -- In Big Endian Byte Ordering : 1st data will be the upper half
            Phy16  := Temp32(15 downto 0);
            if (TFT = '0' and Dual = '1') then
              Phy161  := Temp321(15 downto 0);
            end if;
          else
            -- In Little Endian Ordering : 1st data will be the Upper half
            Phy16 := Temp32(31 downto 16);
            if (TFT = '0' and Dual = '1') then
              Phy161 := Temp321(31 downto 16);
            end if;
          end if;
          -- BGR and Bright bit consideration to form the 18 bit CLD
          if (BGR = '1') then
            Phy18 := Phy16(4 downto 0) & Phy16(15) & 
                     Phy16(9 downto 5) & Phy16(15) &
                     Phy16(14 downto 10) & Phy16(15);
            IntPhy18       <=  Phy18;
            -- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN
            Phy181 := "000000000000000000";
            if (TFT = '0' and Dual = '1') then
              Phy181 := Phy161(4 downto 0) & Phy161(15) & 
                        Phy161(9 downto 5) & Phy161(15) & 
                        Phy161(14 downto 10) & Phy161(15);
            end if;
          else
            Phy18 := Phy16(14 downto 10) & Phy16(15) & 
                     Phy16(9 downto 5) & Phy16(15) &
                     Phy16(4 downto 0) & Phy16(15);
            IntPhy18       <=  Phy18;
            Phy181 := "000000000000000000";
            if (TFT = '0' and Dual = '1') then
              Phy181 := Phy161(14 downto 10) & Phy161(15) & 
                        Phy161(9 downto 5) & Phy161(15) & 
                        Phy161(4 downto 0) & Phy161(15);
            end if;
          end if; 
          if (TFT ='1') then
            -- For TFT mode
            IntPhy18       <=  Phy18;
            Data_Check(CLD,"000000" &  Phy18);
          else
            -- For STN mode
              GreyScaler(
                         fp2in, fp5in, fp9in, fp15in,
                         trp2in, trp5in, trp9in, trp15in,
                         urp2in, urp5in, urp9in, urp15in,
                         ucp2in, ucp5in, ucp9in, ucp15in,
                         lrp2in, lrp5in, lrp9in, lrp15in,
                         lcp2in, lcp5in, lcp9in, lcp15in, ClearDisin,
                         LineCountin, PixelCountin, 
                         fp2out, fp5out, fp9out, fp15out,
                         trp2out, trp5out, trp9out, trp15out,
                         urp2out, urp5out, urp9out, urp15out,
                         ucp2out, ucp5out, ucp9out, ucp15out,
                         lrp2out, lrp5out, lrp9out, lrp15out,
                         lcp2out, lcp5out, lcp9out, lcp15out,
                         LineCountout, PixelCountout,
                         Phy18, iGreySU, iClearDis, GS6, PPL, LPP, Phy181);

              fp2in        := fp2out;
              fp5in        := fp5out;
              fp9in        := fp9out;
              fp15in       := fp15out;
              trp2in       := trp2out;
              trp5in       := trp5out;
              trp9in       := trp9out;
              trp15in      := trp15out;
              urp2in       := urp2out;
              urp5in       := urp5out;
              urp9in       := urp9out;
              urp15in      := urp15out;
              ucp2in       := ucp2out;
              ucp5in       := ucp5out;
              ucp9in       := ucp9out;
              ucp15in      := ucp15out;
              lrp2in       := lrp2out;
              lrp5in       := lrp5out;
              lrp9in       := lrp9out;
              lrp15in      := lrp15out;
              lcp2in       := lcp2out;
              lcp5in       := lcp5out;
              lcp9in       := lcp9out;
              lcp15in      := lcp15out;
              PixelCountin := PixelCountout;
              LineCountin  := LineCountout;
              PixelCount   <= PixelCountin;
              LineCount    <= LineCountin;
              GreySU       <= iGreySU;
              ClearDisin   := iClearDis;
              ClearDis     <= iClearDis;
              IntGS6       <= GS6;
            -- GS6(2 downto 0) = (RGS,GGS,BGS) for Upper Panel
            -- GS6(5 downto 3) = (RGS,GGS,BGS) for Lower Panel
            if (BW = '1') then
              -- MONO STN mode
              if (Mono8 = '1') then
                m := 8;
              else
                m := 4;
              end if;
              Bitno := (to_integer(Bitpos) mod m);
              PhyGS18(Bitno) := GS6(2);
              if (Dual = '1') then
                PhyGS18(8 + Bitno) := GS6(5);
              else
                PhyGS18(8 + Bitno) := '0';
              end if;
              if (Bitno = 0) then
                IntPhyGS18 <=  PhyGS18;
                Data_Check(CLD,"000000" &  PhyGS18);
              end if;
              Bitpos := Bitpos - '1';
            else
              -- COLOR STN mode
              n := Previous;
              while ( n >= 0) loop
                PhyGS18(to_integer(Bitpos)) := GS6(n);
                if (Dual = '1') then
                  PhyGS18(8 + to_integer(Bitpos)) := GS6(3 + n);
                end if;
                if (n /= 0) then
                  Previous := n - 1;
                else 
                  Previous := 2;
                end if;
                n := n - 1;  
                if (Bitpos = 0) then
                  IntPhyGS18 <=  PhyGS18; 
                  Data_Check(CLD,"000000" &  PhyGS18);
                end if;
                Bitpos := Bitpos - '1';
              end loop;
            end if;
          end if;
        else
 
-- -----------------------------------------------------------------------------
-- 1, 2, 4 and 8 BPP Modes : BEPO Value is Significant (except 8 BPP mode)
-- Idea is to extract each byte from 32 bit data depending on BEBO and 
-- then extract each pixel from the byte depending on BEPO.
-- -----------------------------------------------------------------------------
          SelectCount := "000000";
          SigSelectCount <= SelectCount;
          while (to_integer(SelectCount) < 31) loop
            SigSelectCount <= SelectCount;
            -- Extraction of Bytes from 32 bit data
            if (BEBO = '1') then
              -- Temp8(7 downto 0) = Temp32(32 - i:24 - i)
              for k in 0 to 7 loop
                Temp8(k) := Temp32(24 - to_integer(SelectCount) + k);
                if (TFT = '0' and Dual = '1') then
                  Temp81(k) := Temp321(24 - to_integer(SelectCount) + k);
                end if;
              end loop;
            else
              -- Temp8(7:0) = Temp32(i + 7 downto i)
              for k in 0 to 7 loop
                Temp8(k) := Temp32(to_integer(SelectCount) + k);
                if (TFT = '0' and Dual = '1') then
                  Temp81(k) := Temp321(to_integer(SelectCount) + k);
                end if;
              end loop;
            end if;
            -- BPPValue = 2 E +BPP;
            case BPP(1 downto 0) is
              when "00" =>
                BPPValue := "0001";
              when "01" =>
                BPPValue := "0010";
              when "10" =>
                BPPValue := "0100";
              when "11" =>
                BPPValue := "1000";
              when others =>
                BPPValue := "0000";
            end case;
            PixDataNum := 0;
            -- Extraction of Pixels from each byte
            while (PixDataNum < 8) loop         --j= 0; j < 8; j = j + BPPValue)
              -- Initialize Index values
              Index  := (others => '0');
              Index1 := (others => '0');
              if (BEPO = '1') then
                -- Big Endian Pixel Ordering within a Byte
                if (BPP = BPP1) then
                  -- For 1 Bpp mode
                  Index(0) := Temp8(7 - PixDataNum);
                  if (TFT = '0' and Dual = '1') then
                    Index1(0) := Temp81(7 - PixDataNum);
                  end if;
                else
                  -- For 2, 4, 8 Bpp mode
                  Index := (others => '0');
                  -- Index = Temp8(15 - BPPValue - j:8 - BPPValue - j)
                  for k in 0 to (to_integer(BPPValue) - 1) loop 
                    Index(k) := Temp8(8 - to_integer(BPPValue) + k -
                                      PixDataNum);
                    if (TFT = '0' and Dual = '1') then
                      Index1(k) := Temp81(8 - to_integer(BPPValue) -
                                          PixDataNum +k);
                    end if;
                  end loop;
                  IntIndex <= Index;
                end if;
              -- Little Endian Pixel Ordering within a Byte
              else
                if (BPP = BPP1) then
                  -- For 1 Bpp mode
                  Index(0) := Temp8(PixDataNum);
                  IntIndex <= Index;
                  if (TFT = '0' and Dual = '1') then
                    Index1(0) := Temp81(PixDataNum);
                  end if;
                else
                  -- For 2, 4, 8 Bpp mode
                  for k in 0 to (to_integer(BPPValue) - 1) loop
                    Index(k) := Temp8(PixDataNum + k);
                    if (TFT = '0' and Dual = '1') then
                      Index1(k) := Temp81(PixDataNum + k);
                    end if;
                  end loop;
                  IntIndex <= Index;
                end if;
              end if;
              -- Form the Palette Output
              if (BEBO = '1') then
                if (Index(0) = '0') then 
                  Phy16  := Palette(to_integer(Index(7 downto 1)))(31 downto 16);
                  IntPhy16     <=    Phy16;
                else
                  Phy16  := Palette(to_integer(Index(7 downto 1)))
                                    (15 downto 0);
                  IntPhy16     <=    Phy16;
                end if;
                if (Index1(0) = '0') then 
                  Phy161 := ROTRIGHT(Palette(to_integer(Index1(7 downto 1)))
                                    , 16);
                else
                  Phy161 := Palette(to_integer(Index1(7 downto 1))) 
                                   (15 downto 0);
                end if;
              else
                if (Index(0) = '1') then 
                  Phy16  := Palette(to_integer(Index(7 downto 1)))(31 downto 16);
                  IntPhy16     <=    Phy16;
                else
                  Phy16  := Palette(to_integer(Index(7 downto 1)))
                                    (15 downto 0);
                  IntPhy16     <=    Phy16;
                end if;
                if (Index1(0) = '1') then
                  Phy161 := Palette(to_integer(Index1(7 downto 1)))(31 downto 16);
                else
                  Phy161 := Palette(to_integer(Index1(7 downto 1)))
                                               (15 downto 0);
                end if;
              end if;
              if (BGR = '1') then
                Phy18 := Phy16(4 downto 0) & Phy16(15) & 
                         Phy16(9 downto 5) & Phy16(15) &
                         Phy16(14 downto 10) & Phy16(15);
                IntPhy18       <=  Phy18;
              -- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN
                Phy181 := (others => '0');
                if (TFT = '0' and Dual = '1') then
                  Phy181 := Phy161(4 downto 0) & Phy161(15) &
                            Phy161(9 downto 5) & Phy161(15) &
                            Phy161(14 downto 10) & Phy161(15);
                end if;
              else
                Phy18 := Phy16(14 downto 10) & Phy16(15) & 
                         Phy16(9 downto 5) & Phy16(15) &
                         Phy16(4 downto 0) & Phy16(15);
                IntPhy18       <=  Phy18;
              -- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN

                Phy181 := "000000000000000000";
                if (TFT = '0' and Dual = '1') then
                  Phy181 := Phy161(14 downto 10) & Phy161(15) & 
                            Phy161(9 downto 5) &  Phy161(15) &  
                            Phy161(4 downto 0) & Phy161(15);
                end if;
              end if;
              if (TFT = '1') then
                -- For TFT mode
                IntPhy18 <=  Phy18;
                Data_Check(CLD,"000000" &  Phy18);
              else
                -- For STN mode
                GreyScaler(
                           fp2in, fp5in, fp9in, fp15in,
                           trp2in, trp5in, trp9in, trp15in,
                           urp2in, urp5in, urp9in, urp15in,
                           ucp2in, ucp5in, ucp9in, ucp15in,
                           lrp2in, lrp5in, lrp9in, lrp15in,
                           lcp2in, lcp5in, lcp9in, lcp15in, ClearDisin,
                           LineCountin, PixelCountin, 
                           fp2out, fp5out, fp9out, fp15out,
                           trp2out, trp5out, trp9out, trp15out,
                           urp2out, urp5out, urp9out, urp15out,
                           ucp2out, ucp5out, ucp9out, ucp15out,
                           lrp2out, lrp5out, lrp9out, lrp15out,
                           lcp2out, lcp5out, lcp9out, lcp15out,
                           LineCountout, PixelCountout,
                           Phy18, iGreySU, iClearDis, GS6, PPL, LPP, Phy181);

                fp2in        := fp2out;
                fp5in        := fp5out;
                fp9in        := fp9out;
                fp15in       := fp15out;
                trp2in       := trp2out;
                trp5in       := trp5out;
                trp9in       := trp9out;
                trp15in      := trp15out;
                urp2in       := urp2out;
                urp5in       := urp5out;
                urp9in       := urp9out;
                urp15in      := urp15out;
                ucp2in       := ucp2out;
                ucp5in       := ucp5out;
                ucp9in       := ucp9out;
                ucp15in      := ucp15out;
                lrp2in       := lrp2out;
                lrp5in       := lrp5out;
                lrp9in       := lrp9out;
                lrp15in      := lrp15out;
                lcp2in       := lcp2out;
                lcp5in       := lcp5out;
                lcp9in       := lcp9out;
                lcp15in      := lcp15out;
                PixelCountin := PixelCountout;
                LineCountin  := LineCountout;
                PixelCount   <= PixelCountin;
                LineCount    <= LineCountin;
                GreySU       <= iGreySU;
                ClearDis     <= iClearDis;
                ClearDisin   := iClearDis;
                IntGS6       <= GS6;
                -- GS6(2 downto 0) = (RGS,GGS,BGS) for Upper Panel
                -- GS6(5 downto 3) = (RGS,GGS,BGS) for Lower Panel
                if (BW = '1') then
                  -- MONO STN mode
                  if (Mono8 = '1') then
                    m := 8;
                  else
                    m := 4;
                  end if;
                  Bitno := (to_integer(Bitpos) mod m);
                  PhyGS18(Bitno) := GS6(2);
                  if (Dual = '1') then
                    PhyGS18(8 + Bitno) := GS6(5);
                  else
                    PhyGS18(8 + Bitno) := '0';
                  end if;
                  if (Bitno = 0) then
                    -- Check when data becomes avaiable
                    Data_Check(CLD, "000000" & PhyGS18);
                  end if;
                  Bitpos := Bitpos - '1';
                else
                  -- COLOR STN mode
                  n := Previous;
                  while( n >= 0) loop
                    PhyGS18(to_integer(Bitpos)) := GS6(n);
                      if (Dual = '1') then
                      PhyGS18(8 + to_integer(Bitpos)) := GS6(3 + n);
                    end if;
                    if (n /= 0) then
                      Previous := n -1;
                    else
                      Previous := 2;
                    end if;
                    n := n - 1;
                    if (Bitpos = 0) then
                      IntPhyGS18 <=  PhyGS18;
                      Data_Check(CLD,"000000" &  PhyGS18);
                    end if;
                    Bitpos := Bitpos - '1';
                  end loop;
                end if;
              end if;
              PixDataNum := PixDataNum + to_integer('0' & BPPValue); 
            end loop;
            SelectCount := SelectCount + "001000";
            SigSelectCount <= SelectCount;
          end loop;
        end if;
      end loop;
    end if; 
  end if;

IntTemp321  <=     Temp321;
-- Temporary Register of 32 bit width to hold the data from FIFO1

IntPhy161     <=   Phy161;
-- Physical Image Data (BGR Value with Bright bit) from Palette or FIFO1(16

IntPhy18       <=  Phy18;
-- Expected CLD(17:0) for TFT mode : Input to Grey Scalar for STN mode

IntPhy181       <= Phy181;
-- Input to Grey Scalar for STN Dual mode

IntPhyGS18       <= PhyGS18;
-- Expected CLD(17:0) for STN mode

IntGS6         <=  GS6;
-- Output of Grey Scalar

end process p_DataReadNCheck; 
      
-- -----------------------------------------------------------------------------
-- Check that the Data CLD is not changing while CLPOWER bit is LOW
-- -----------------------------------------------------------------------------
p_CheckDataProt : process (HCLK)
begin
  if (HCLK'event and HCLK = '1') then
    if ((CLPOWER = '0') and (CLD /= "000000000000000000000000")) then
      assert false
        report "CLTrDataCheck1 : Panel Data is NOT zero when CLPOWER is LOW"
        severity error;
    end if;
  end if;
end process p_CheckDataProt;

end behavioural;
 
-- --================================== End ==================================--

