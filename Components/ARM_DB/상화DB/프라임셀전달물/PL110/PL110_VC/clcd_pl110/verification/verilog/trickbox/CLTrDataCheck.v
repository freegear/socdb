// --=========================================================================--
//  This confidential and proprietary software may be used only as
//  authorised by a licensing agreement from ARM Limited
//    (C) COPYRIGHT 1999 ARM Limited
//        ALL RIGHTS RESERVED
//  The entire notice above must be reproduced on all authorised
//  copies and copies may only be made to the extent permitted
//  by a licensing agreement from ARM Limited.
//  ----------------------------------------------------------------------------
//
//  Version and Release Control Information:
//
//  File Name              : CLTrDataCheck.v.rca
//  File Revision          : 1.2
//
//  Release Information    : PrimeCell(TM)-PL110-r1p2-00ltd0
//
//  ----------------------------------------------------------------------------

//  ----------------------------------------------------------------------------
//  Purpose : CLCD Trickbox Data Checker
//
// --=========================================================================--

 `timescale 1ns/1ps
// -----------------------------------------------------------------------------
// Incuding the file for grey scaling with grey scaler function
// -----------------------------------------------------------------------------


// -----------------------------------------------------------------------------

module CLTrDataCheck(
                     HCLK,
                     VSYNCState,
                     CLCLK,
                     HRESETN,
                     CLTrEn,
                     CLTrIntrTest,
                     CLTrFUFIntrTst,
                     CLPOWER,
                     DataAvail,
                     Check,
                     DataIn,
                     PPL,
                     LPP,
                     CLD,
                     BPP,
                     BW,
                     TFT,
                     Mono8,
                     Dual,
                     BGR,
                     BEBO,
                     BEPO,
                     CLTrPanel,
                     ResetWritePtrs,

                     // Palette RAM Signals
                     PalSelect,
                     PalWrite,
                     PalData,
                     PalAddr
                     );

input         HCLK; 
// Clock


input [2:0]   VSYNCState;
// Vertical Sync input from protocol check
input         CLCLK; 
// CLCD Clock

input         HRESETN;
// Asynchronous Reset (active low)

input         CLTrEn;
// CLCD Trickbox Enable

input         CLTrIntrTest;
// CLCD Trickbox interupt test  bit

input         CLTrFUFIntrTst;
// CLCD Trickbox FIFO underflow interupt test  bit

input         CLPOWER;
// Panel Power

input         DataAvail;
// FIFO Write Signal = HREADY && HTRANS[1]   : from CLCDIf Module

input         Check;
// FIFO Read Clock = CLCP in Active Region   : from CLCDProtCheck Module

input [31:0]  DataIn;
// Data Input from Data Generator

input [5:0]      PPL;
// Pixel Per Line

input [9:0]      LPP;
// Line Per Panel

input [23:0]  CLD;
// Data Input from CLCD Panel Port

input [2:0]   BPP;
// Bits per pixel
// --------------
// Value   BPP
// ---------------
//  000 :  1 bpp
//  001 :  2 bpp
//  010 :  4 bpp
//  011 :  8 bpp
//  100 : 16 bpp
//  101 : Reserved
//  110 : Reserved
//  111 : Reserved

input         BW;
// Black-White mode in STN

input         TFT;
// Indicates TFT or STN Mode

input         Mono8;
// Indicates MONO 8 bit or 4 bit mode

input         Dual;
// Indicates Single or Dual Panel STN mode

input         BGR;
// Indicates BGR or RGB format

input         BEBO;
// Indicates Big Endian or Little Endian Byte order

input         BEPO;
// Indicates Big Endian or Little Endian Pixel ordering within a byte
// Valid for 1, 2 and 4 BPP Mode. In Code 8 BPP mode is included in it for
// Code reduction.

input         CLTrPanel;
// Indicates Lower or Upper Panel Data transaction in STN Dual Panel mode
// Value  :  Indicates
// ------------------------------
//   0    : Upper / Default Panel
//   1    : lower           Panel

input         ResetWritePtrs;
// Indicates initilisation of the write pointers

// Palette Signals
// ---------------

input         PalSelect;
// Palette Select Signal : generated by decoding iHADDR with enable as
// iHSEL && iHREADYin && iHTRANS[1]

input         PalWrite;
// Write Signal : iHWRITE && iHSELCom from CLTrAHBIf

input [31:0]  PalData;
// Palette Data to write : HWDATA from CLTrAHBIf

input [6:0]   PalAddr;
// Palette Address : iHADDR[8:2] from CLTrAHBIf

// -----------------------------------------------------------------------------
//
//                             CLTrDataCheck
//                             =============
//
// -----------------------------------------------------------------------------
//
// Overview
// ========
// This module is intended for CLCD Panel Data Check for all the TFT and STN 
// modes. This module includes:
// - Palette RAM Write Block
// - FIFO Write Block for Upper and Lower Panel
// - Fill Level  Write Block for Upper and Lower Panel
// - Data Read and Check Block
// - Data Check Task and data dump
//
// Note: Two variable `define s are there:
// ----  o EXIT  : Indicates what to do on ERROR : Exit or Continue
//       o IMAGE : Indicates Image or random testing
// -----------------------------------------------------------------------------
 
// -----------------------------------------------------------------------------
// Constant declarations
// -----------------------------------------------------------------------------
// BPP Value
// ---------
`define BPP1             3'b000
`define BPP16            3'b100
`define BPP24            3'b101

// What to do on ERROR : Exit or Continue
// --------------------------------------
`ifdef EXIT
  `define ERR_EXIT   $finish
`else
  `define ERR_EXIT   $display("Error Exit\n")
`endif
 
// -----------------------------------------------------------------------------
// Wire declarations
// -----------------------------------------------------------------------------
wire          HCLK;              // (module input)
wire          CLCLK;             // (module input)
wire          HRESETN;           // (module input)
wire          CLTrEn;            // (module input)
wire          CLTrIntrTest;      // (module input)
wire          CLTrFUFIntrTst;    // (module input)
wire          CLPOWER;           // (module input)
wire          DataAvail;         // (module input)
wire          Check;             // (module input)
wire  [31:0]  DataIn;            // (module input)
wire  [5:0]   PPL;               // (module input)
wire  [9:0]   LPP;               // (module input)
wire  [23:0]  CLD;               // (module input)
wire  [2:0]   BPP;               // (module input)
wire          BW;                // (module input)
wire          TFT;               // (module input)
wire          Mono8;             // (module input)
wire          Dual;              // (module input)
wire          BGR;               // (module input)
wire          BEBO;              // (module input)  
wire          BEPO;              // (module input)
wire          CLTrPanel;         // (module input)
wire          PalWrite;          // (module input)
wire  [31:0]  PalData;           // (module input)
wire  [6:0]   PalAddr;           // (module input)
wire          ResetWritePtrs;    // (module input)

// -----------------------------------------------------------------------------
// Register declarations
// -----------------------------------------------------------------------------
reg [31:0]                Palette[127:0];
// Palette Memory

reg [31:0]                FIFO[393215:0];
// FIFO Memory

reg [31:0]                FIFO1[393215:0];
// Another FIFO Memory for Dual mode 

reg [18:0]                 RdPtr;
// Read Pointer for FIFO

reg [18:0]                 WrPtr;
// Write Pointer for FIFO
 
reg [18:0]                 Filllevel;
// FIFO Fill Level

reg [18:0]                 RdPtr1;
// Read Pointer for FIFO1
 
reg [18:0]                 WrPtr1;
// Write PPointer for FIFO1


//  Fill levels indicates that there should not be difference of
//  of more than 256  words in Read and Write pointers
reg [18:0]                 Filllevel1;
// FIFO1 Fill Level

reg [7:0]                 Index;
// Index to Palette RAM from FIFO

reg [7:0]                 Index1;
// Index to Palette RAM from FIFO1

reg [31:0]                Temp32;
// Temporary Register of 32 bit width to hold the data from FIFO

reg [31:0]                Temp321;
// Temporary Register of 32 bit width to hold the data from FIFO1

reg [15:0]                Phy16;
// Physical Image Data (BGR Value with Bright bit) from Palette or FIFO (16 bpp)

reg [23:0]                Phy24;
// Physical Image Data in 24 bpp TFT mode

reg [15:0]                Phy161;
// Physical Image Data (BGR Value with Bright bit) from Palette or FIFO1(16 bpp)

reg [17:0]                Phy18;
// Expected CLD[23:0] for TFT mode : Input to Grey Scalar for STN mode

reg [17:0]                Phy181;
// Input to Grey Scalar for STN Dual mode 

reg [17:0]                PhyGS18;
// Expected CLD[23:0] for STN mode

reg [5:0]                 GS6;
// Output of Grey Scalar

reg [7:0]                 Temp8;
// Temporary Register of 8 bit width to hold bytes extracted from Temp32

reg [7:0]                 Temp81;
// Temporary Register of 8 bit width to hold bytes extracted from Temp321

reg [3:0]                 BPPValue;
// Actual BPP Value i.e. 2 E+BPP

reg [2:0]                 Bitpos;
// Bit position variable in Output Formater in STN mode

reg                       StartDis;
// To be used in Grey Scaler : 
// Whenever HRESETN comes, this bit becomes high
// In Data_Check task will be set to low

reg [2:0]                Cld_loop;
// To read the data twice in 16 bpp STN mode

integer                   i;
// Count Variable i

integer                   j;
// Count Variable j

integer                   k;
// Count Variable k

integer                   n;
// Count Variable n

integer                   m;
// Count Variable m


integer                   Previous;
// Count Variable Previous value of n

integer                   ImageFile;
// Image File Handler : For data dump


// -----------------------------------------------------------------------------
// Main body of code
// =================
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// File Initiation for Data Dumping
// -----------------------------------------------------------------------------
`ifdef IMAGE
initial
begin : File_Ini
  ImageFile = $fopen("Output.dat");
end
`endif

// -----------------------------------------------------------------------------
// Palette RAM Write Block
// -----------------------------------------------------------------------------
always @(posedge HCLK)
begin : p_PaletteWrite
  if (PalSelect && PalWrite)
    begin
      // Each write will update two successive Palette entries
      Palette[PalAddr] <= PalData[31:0];
    end
end

// -----------------------------------------------------------------------------
//  Initialising the write pointers at each edge of Vsync pulse 
// -----------------------------------------------------------------------------
always @( negedge HCLK)
begin : p_Reset_Ptrs
  if(ResetWritePtrs)
    begin
      WrPtr  = 19'b0;
      WrPtr1  = 19'b0;
      Filllevel = 19'b0;
      Filllevel1 = 19'b0;
    end
end
// -----------------------------------------------------------------------------
// FIFO Write Block : Write will happen at each HCLK whenever DataAvail is high
// -----------------------------------------------------------------------------
always @(negedge HCLK or negedge HRESETN or negedge CLTrEn )
begin : p_FIFOWrite
  if (!HRESETN || !CLTrEn )
    WrPtr  = 19'b0;
  // FIFO Write for Upper Panel for which CLTrPanel = 0
  else if (DataAvail && !CLTrPanel)
    begin
      // If FIFO is Full
      if (Filllevel == 393215)
        begin
          $display($time," : ERROR : CLCD Input without Output\n");
          `ERR_EXIT;
        end
      else
        begin
          FIFO[WrPtr] = DataIn;
          WrPtr = WrPtr + 1'b1;
        end
    end
end

// -----------------------------------------------------------------------------
// Filllevel Generation Block : Fill-level value denotes the number of elements
// in the FIFO.
// -----------------------------------------------------------------------------
always @(posedge HCLK or posedge Check or negedge HRESETN or negedge CLTrEn)
begin : p_GenFilllevel
  if (!HRESETN || !CLTrEn)
    Filllevel = 19'b0;
  // Increment Fill-level value in Write cycle
  else if (DataAvail && Filllevel != 393215 && !CLTrPanel)
    Filllevel = Filllevel + 1'b1;
end
 
// -----------------------------------------------------------------------------
// FIFO1 Write Block : Write will happen at each HCLK whenever DataAvail is high
// and in STN Dual Panel Mode
// -----------------------------------------------------------------------------
always @(negedge HCLK or negedge HRESETN or negedge CLTrEn)
begin : p_FIFO1Write
  if (!HRESETN || !CLTrEn)
    WrPtr1 = 19'b0;
  // FIFO Write to Lower Panel FIFO in Dual panel STN mode
  else if (DataAvail && !TFT && Dual && CLTrPanel)
    begin
      if (Filllevel1 == 393215)
        begin
          $display($time," : ERROR : CLCD Input without Output\n");
          `ERR_EXIT;
        end
      else
        begin
          FIFO1[WrPtr1] = DataIn;
          WrPtr1 = WrPtr1 + 1'b1;
        end
    end
end

// -----------------------------------------------------------------------------
// Filllevel Generation Block for FIFO1 in STN Dual Panel mode
// -----------------------------------------------------------------------------
always @(posedge HCLK or posedge Check or negedge HRESETN or negedge CLTrEn)
begin : p_GenFilllevel1
  if (!HRESETN || !CLTrEn)
    Filllevel1 = 19'b0;
  else if (DataAvail && Filllevel1 != 393215  && !TFT && Dual && CLTrPanel)
    Filllevel1 = Filllevel1 + 1'b1;
  // Check if CLTrPanel are high when Dual is low : ERROR in Test
  if (!TFT && !Dual && CLTrPanel)
    begin
      $display($time," : ERROR : CLTrPanel is 1 in STN Single panel mode\n");
     `ERR_EXIT;
    end
end

// -----------------------------------------------------------------------------
// This block initialises the read pointers at the start of the frame
// -----------------------------------------------------------------------------
always @(HRESETN or CLTrEn or VSYNCState)
begin :p_Initialize   
  // Initialize all the variables used in this block
  if (!HRESETN || !CLTrEn || (VSYNCState == 3'b001))
     begin
       RdPtr    = 19'b0;
       RdPtr1    = 19'b0;
       Bitpos   = 3'b111;
       Phy18    = 18'b0;
       PhyGS18  = 18'b0;
     end
end
// -----------------------------------------------------------------------------
// This block generate startdis signal at the start of the frame
// -----------------------------------------------------------------------------
always @(posedge CLTrEn or posedge HRESETN)
begin : p_StartDisplay
    StartDis = 1'b1;
end
// -----------------------------------------------------------------------------
// Data Read and Check Block : This block will read the data from FIFO in a
// continuous manner and process it. Then the data will be checked by invoking
// Data_Check task which will check the data at each CLCP in Active region.
// Note: Check is the version of CLCP in Active Region.
//       Data processing and Error checking for Lower Panel FIFO (FIFO1) will
//       be active only in STN Dual Panel mode i.e. at logic (!TFT && Dual).
// -----------------------------------------------------------------------------
always @ (posedge Check)
begin : p_DataReadNCheck
  Previous = 2;
  if (TFT) Cld_loop = 1;
  else 
    begin
      case (BPP)
        `BPP16 : Cld_loop = 2;
        default: Cld_loop = 1;
      endcase
    end
  // Check is no data  in Upper/Lower Panel FIFO to Read
  if (Filllevel == 19'b0 || !TFT && Dual && Filllevel1 == 19'b0)
    begin
      if(!CLTrFUFIntrTst)
        begin
          $display($time," : ERROR : CLCD GIVING OUTPUT without INPUT\n");
          `ERR_EXIT;
        end
    end
  else 
    begin
      repeat (Cld_loop) 
        begin
          // Read a 32 bit data from Upper Panel FIFO
          Temp32 = FIFO[RdPtr];
          RdPtr = RdPtr + 1'b1;
          Filllevel = Filllevel - 1'b1;
          if (!TFT && Dual)
            begin
              // Read a 32 bit data from Lower Panel FIFO (FIFO1)
              Temp321 = FIFO1[RdPtr1];
              RdPtr1 = RdPtr1 + 1'b1;
              Filllevel1 = Filllevel1 - 1'b1;
            end
          // Data Processing and Checking
          // ============================
          if ((BPP == `BPP24) && TFT)
            begin
             if (BGR == 1)
               begin
                 Phy24 = {Temp32[7:0],Temp32[15:8],Temp32[23:16]};
                 Data_Check(Phy24);
               end
             else
               begin
                 Phy24 = Temp32[23:0];
                 Data_Check(Phy24);
               end
            end
          else if ((BPP == `BPP24) && !TFT)
            $display($time," : ERROR : INVALID BPP SETTING FOR STN MODE\n");
 
          else if (BPP == `BPP16)
            // 16 BPP Mode :  BEPO Value is Insignificant
            // ------------------------------------------
            begin
              // For 1st 16 bit half of 32 bit data
              // ----------------------------------
              if (BEBO)
                // In Big Endian Byte Ordering : 1st data will be the upper half
                begin
                  Phy16 = Temp32[31:16];
                  // In case of STN Dual Panel mode
                  if (!TFT && Dual)
                    Phy161 = Temp321[31:16];
                end
              else
              // In Little Endian Byte Ordering :1st data will be the Upper half
                begin
                  Phy16  = Temp32[15:0];
                  // In case of STN Dual Panel mode
                  if (!TFT && Dual)
                    Phy161  = Temp321[15:0];
                end
              // Formatter : Converts 16 bit Data to actual 18 bit CLD
              // ---------
              // Interchange the R and B for BGR mode and also place the bright 
              // bit as the LSB of each R, G, B field.
              if (BGR)
                // R and B interchange is needed.
                begin
                  Phy18 = {Phy16[4:0],Phy16[15],Phy16[9:5],Phy16[15],
                                     Phy16[14:10],Phy16[15]};
                  Phy181 = 0; 
                  if (!TFT && Dual)
                    Phy181 = {Phy161[4:0],Phy161[15],Phy161[9:5],Phy161[15],
                                       Phy161[14:10],Phy161[15]};
                end
              else
                // R and B interchange is not needed.
                begin
                  Phy18 = {Phy16[14:10],Phy16[15],Phy16[9:5],Phy16[15],
                                       Phy16[4:0],Phy16[15]};
                  Phy181 = 0;
                  if (!TFT && Dual)
                    Phy181 = {Phy161[14:10],Phy161[15],Phy161[9:5],Phy161[15],
                                       Phy161[4:0],Phy161[15]};
                end
              if (TFT)
                // For TFT 16 Bpp mode Palette is not required.
                Data_Check({6'b0,Phy18});
              else
                // STN mode
                begin
                  GS6 = GreyScaler(Phy18,Phy181);
                  // GS6[2:0] = [RGS,GGS,BGS] for Upper Panel
                  // GS6[5:3] = [RGS,GGS,BGS] for Lower Panel
                  if (BW)
                    // For MONO mode of STN
                    begin
                      if (Mono8)
                        m = 8;
                      else
                        m = 4;
                      PhyGS18[Bitpos % m] = GS6[2];
                      if (Dual)
                        PhyGS18[8 + Bitpos % m] = GS6[5];
                      else
                        PhyGS18[8 + Bitpos % m] = 1'b0;
                      // 1st Pixel will correspond to MSB
                      // When one data is ready Check it
                      if (Bitpos % m == 0)
                        Data_Check({6'b0,PhyGS18});
                      Bitpos = Bitpos - 1'b1;
                    end
                  else
                    // For COLOR mode of STN
                    begin
                      n = Previous;
                      while( n >= 0)
                        begin
                          PhyGS18[Bitpos] = GS6[n];
                          if (Dual)
                            PhyGS18[8 + Bitpos] = GS6[3 + n];
                          if(n != 0)
                            Previous = n -1;
                          else 
                            Previous = 2;
                          n = n - 1;
                          if (Bitpos == 0)
                              Data_Check({6'b0,PhyGS18});
                          Bitpos = Bitpos - 1'b1;
                        end
                    end
                end
  
              // For 2nd 16 bit half of 32 bit data
              // ----------------------------------
              if (BEBO)
                // In Big Endian Byte Ordering : 1st data will be the upper half
                begin
                  Phy16  = Temp32[15:0];
                  if (!TFT && Dual)
                    Phy161  = Temp321[15:0];
                end
              else
              // In Little Endian Byte Ordering :1st data will be the Upper half
                begin
                  Phy16 = Temp32[31:16];
                  if (!TFT && Dual)
                    Phy161 = Temp321[31:16];
                end
              // BGR and Bright bit consideration to form the 18 bit CLD
              if (BGR)
                begin
                  Phy18 = {Phy16[4:0],Phy16[15],Phy16[9:5],Phy16[15],
                                     Phy16[14:10],Phy16[15]};
                  Phy181 = 0;
                  if (!TFT && Dual)
                    Phy181 = {Phy161[4:0],Phy161[15],Phy161[9:5],Phy161[15],
                                   Phy161[14:10],Phy161[15]};
                end
              else
                begin
                  Phy18 = {Phy16[14:10],Phy16[15],Phy16[9:5],Phy16[15],
                                       Phy16[4:0],Phy16[15]};
                  Phy181 = 0;
                  if (!TFT && Dual)
                    Phy181 = {Phy161[14:10],Phy161[15],Phy161[9:5],Phy161[15],
                                         Phy161[4:0],Phy161[15]};
                end
    
              if (TFT)
                // For TFT mode
                Data_Check({6'b0,Phy18});
              else
                // For STN mode
                begin
                  GS6 = GreyScaler(Phy18,Phy181);
                  // GS6[2:0] = [RGS,GGS,BGS] for Upper Panel
                  // GS6[5:3] = [RGS,GGS,BGS] for Lower Panel
                  if (BW)
                    // MONO STN mode
                    begin
                      if (Mono8)
                        m = 8;
                      else
                        m = 4;
                      PhyGS18[Bitpos % m] = GS6[2];
                      if (Dual)
                        PhyGS18[8 + Bitpos % m] = GS6[5];
                      else
                        PhyGS18[8 + Bitpos % m] = 1'b0;
                      if(Bitpos % m == 0)
                        Data_Check({6'b0,PhyGS18});
                      Bitpos = Bitpos - 1'b1;
                    end
                  else
                    // COLOR STN mode
                    begin
                      n = Previous;
                      while( n >= 0)
                        begin
                          PhyGS18[Bitpos] = GS6[n];
                          if (Dual)
                             PhyGS18[8 + Bitpos] = GS6[3 + n];
                          if(n != 0)
                             Previous = n - 1;
                          else 
                             Previous = 2;
                          n = n - 1;  
                          if (Bitpos == 0)
                            begin
                             Data_Check({6'b0,PhyGS18});
                            end
                          Bitpos = Bitpos - 1'b1;
                        end
                    end
                end
            end
          else
     
            // 1,2,4 and 8 BPP Modes : BEPO Value is Significant (except 8 BPP)
            // ---------------------------------------------------
            // Extract each byte from 32 bit data depending on BEBO and then
            // extract each pixel from the byte depending on BEPO.
            begin
              for (i = 0; i < 32; i = i + 8)
                begin
                  // Extraction of Bytes from 32 bit data
                  if (BEBO)
                    // Temp8[7:0] = Temp32[32 - i:24 - i]
                    for (k = 0; k < 8; k = k + 1)
                      begin
                        Temp8[k] = Temp32[24 - i + k];
                        if (!TFT && Dual)
                          Temp81[k] = Temp321[24 - i + k];
                      end
                  else
                    // Temp8[7:0] = Temp32[i + 7:i]
                    for (k = 0; k < 8; k = k + 1)
                      begin
                        Temp8[k] = Temp32[i + k];
                        if (!TFT && Dual)
                          Temp81[k] = Temp321[i + k];
                      end
                  // BPPValue = 2 E +BPP;
                  BPPValue = 1 << BPP;
                  // Extraction of Pixels from each byte
                  for (j = 0; j < 8; j = j + BPPValue)
                    begin
                      // Initialize Index values
                      Index  = 8'b0;
                      Index1 = 8'b0;
                      if (BEPO)
                      // Big Endian Pixel Ordering within a Byte
                        if (BPP == `BPP1)
                          // For 1 Bpp mode
                          begin
                            Index[0] = Temp8[7-j];
                            if (!TFT && Dual)
                              Index1[0] = Temp81[7-j];
                          end
                        else
                          // For 2, 4, 8 Bpp mode
                          begin
                            Index = 0;
                            // Index = Temp8[15 - BPPValue - j:8 - BPPValue - j]
                            for (k = 0; k < BPPValue; k = k + 1)
                              begin
                                Index[k] = Temp8[8-BPPValue-j+k];
                                if (!TFT && Dual)
                                  Index1[k] = Temp81[8-BPPValue-j+k];
                              end
                          end
                      // Little Endian Pixel Ordering within a Byte
                      else
                        if (BPP == `BPP1)
                          // For 1 Bpp mode
                          begin
                            Index = Temp8[j];
                            if (!TFT && Dual)
                              Index1 = Temp81[j];
                          end
                        else
                          // For 2, 4, 8 Bpp mode
                          begin
                            for (k = 0; k < BPPValue; k = k + 1)
                              begin
                                Index[k] = Temp8[j+k];
                                if (!TFT && Dual)
                                  Index1[k] = Temp81[j+k];
                              end
                          end
                      // Form the Palette Output
                      if (BEBO) begin
                        Phy16  = Palette[Index [7:1]] >> (16 * (1 - Index[0]));
                        Phy161 = Palette[Index1[7:1]] >> (16 * (1 - Index1[0]));
                      end
                      else begin
                          Phy16  = Palette[Index [7:1]] >> (16 * Index[0]);
                          Phy161 = Palette[Index1[7:1]] >> (16 * Index1[0]);
                      end
                      if (BGR)
                        begin
                          Phy18 = {Phy16[4:0],Phy16[15],Phy16[9:5],Phy16[15],
                                               Phy16[14:10],Phy16[15]};
                          Phy181 = 0;
                          if (!TFT && Dual)
                            Phy181 = {Phy161[4:0],Phy161[15],Phy161[9:5],
                                      Phy161[15],Phy161[14:10],Phy161[15]};
                        end
                      else
                        begin
                          Phy18 = {Phy16[14:10],Phy16[15],Phy16[9:5],Phy16[15],
                                               Phy16[4:0],Phy16[15]};
                          Phy181 = 0;
                          if (!TFT && Dual)
                            Phy181 = {Phy161[14:10],Phy161[15],Phy161[9:5],
                                      Phy161[15], Phy161[4:0],Phy161[15]};
                        end
                      if (TFT)
                        // For TFT mode
                        Data_Check({6'b0,Phy18});
                      else
                        // For STN mode
                        begin
                          GS6 = GreyScaler(Phy18,Phy181);
                          // GS6[2:0] = [RGS,GGS,BGS] for Upper Panel
                          // GS6[5:3] = [RGS,GGS,BGS] for Lower Panel
                          if (BW)
                            // MONO STN mode
                            begin
                              if (Mono8)
                                m = 8;
                              else
                                m = 4;
                              PhyGS18[Bitpos % m] = GS6[2];
                              if (Dual)
                                PhyGS18[8 + Bitpos % m] = GS6[5];
                              else
                                PhyGS18[8 + Bitpos % m] = 1'b0;
                              if (Bitpos % m == 0)
                                 // Check when data becomes avaiable
                                 Data_Check({6'b0,PhyGS18});
                              Bitpos = Bitpos - 1'b1;
                            end
                          else
                            // COLOR STN mode
                            begin
                            n = Previous;
                            while( n >= 0)
                              begin
                                PhyGS18[Bitpos] = GS6[n];
                                if (Dual)
                                  PhyGS18[8 + Bitpos] = GS6[3 + n];
                                if(n != 0)
                                  Previous = n -1;
                                else
                                  Previous = 2;
                                n = n - 1;
                                if (Bitpos == 0)
                                  begin
                                    Data_Check({6'b0,PhyGS18});
                                  end
                                Bitpos = Bitpos - 1'b1;
                              end
                            end
                        end
                    end   
                end
            end
        end 
    end
end
      
// -----------------------------------------------------------------------------
// Data Check Block (Task) : Checking will wait for a CLCP to arrive in Active
// region and then check. Simultaneously, for actual image data this block will 
// write the formatted Panel data to a file.
// -----------------------------------------------------------------------------
task Data_Check;
input [23:0]  CLTrData;
begin
  if (CLTrEn)
    if(VSYNCState == 3'b011)
      begin
        // Check signal denotes new CLD data  valid, or CLCP had arrived in the
        // Active Region. In the DtatCheck module  data will be checked on the
        // negetive edge of Chcek. The generation of Check is shown below:
        //                  __    __    __    __    __    __    __    __
        //  CLCLK     :  __1  |__1  |__1  |__1  |__1  |__1  |__1  |__1  |__
        //                        ___________             ___________
        //  CLCP      :  ________|           |___________|           |_____
        //               _________ _______________________ ________________
        //  CLD       :  ___D(i)__X__________D(i+1)_______X______D(i+2)____
        //                        _____                   _____
        //  Check     :  ________1     Y_________________|     Y___________
        //                      /|\    ^                       ^
        //                     |     ^ = Data will be checked at these NegEdges.
        //                       |---- = Data can be checked here, otherwise it
        //                                 it will compare D(i) with 
        //                                 "Expected D(i+1)".
            @ (negedge Check or negedge CLTrEn or posedge VSYNCState[2]);
            if (CLD !== CLTrData)
              begin
                if(CLTrEn && VSYNCState == 3'b011 )
                  begin
                    $display($time," ERROR:CLCD Panel Data is not matching \n");
                    `ERR_EXIT;
                  end    
              end
            `ifdef IMAGE
              // Writing the formatted data in a file
              $fdisplay(ImageFile,"%b",CLD);
            `endif
      end
end
endtask

//  ----------------------------------------------------------------------------
//  Purpose : CLCD Trickbox Grey Scaler Function
//
// --=========================================================================--

// -----------------------------------------------------------------------------
//
//                             CLTrGS
//                             ======
//
// -----------------------------------------------------------------------------
//
// Overview:
// ========
// This portion of the code includes the Main GreyScaler function and the 
// supporting function declaration
// ----------------------------------------------------------------------------
 
function [2:0]  IncFrame5;
 
  input [2:0] fp5;
  reg [2:0] Result;
begin
  //  five frame duty cycle frame phase accumulator
  case (fp5[2:0])
    3'b000 :
      Result = 3'b010;
    3'b010 :
      Result = 3'b001;
    3'b001 :
      Result = 3'b100;
    3'b100 :
      Result = 3'b011;
    3'b011 :
      Result = 3'b000;
    default  :
    begin
      $display("Illegal value in fp5 phase accumulator at time %t", $time);
      Result = 3'bx;
    end
  endcase
 
  IncFrame5 =  Result;
end
endfunction // IncFrame5  
 
function [3:0]  IncFrame9;
 
  input [3:0] fp9;
  reg [3:0] Result;
begin
  //  nine frame duty cycle frame phase accumulator
  case (fp9)
    4'b0000 :
      Result = 4'b1001;
    4'b1001 :  
      Result = 4'b0001;
    4'b0001 :  
      Result = 4'b1000;
    4'b1000 :  
      Result = 4'b0010;
    4'b0010 :  
      Result = 4'b1011;
    4'b1011 :  
      Result = 4'b0100;
    4'b0100 :  
      Result = 4'b1010;
    4'b1010 :  
      Result = 4'b0101;
    4'b0101 :  
      Result = 4'b0000;
    default  :
    begin
      $display("Illegal value in fp9 phase accumulator at time %t", $time);
      Result = 4'bxxxx;
    end
  endcase
 
  IncFrame9 =  Result;
end
endfunction // IncFrame9

 
function [3:0]  IncFrame15;
 
  input [3:0] fp15;
  reg [3:0] Result;
begin
  //  fifteen frame duty cycle frame phase accumulator
  case (fp15)
    4'b1111 :
      Result = 4'b0111;
    4'b0111 :
      Result = 4'b1110;
    4'b1110 :
      Result = 4'b0110;
    4'b0110 :
      Result = 4'b1101;
    4'b1101 :
      Result = 4'b0101;
    4'b0101 :
      Result = 4'b1100;
    4'b1100 :
      Result = 4'b0100;
    4'b0100 :
      Result = 4'b1011;
    4'b1011 :
      Result = 4'b0011;
    4'b0011 :
      Result = 4'b1010;
    4'b1010 :
      Result = 4'b0010;
    4'b0010 :
      Result = 4'b1001;
    4'b1001 :
      Result = 4'b0001;
    4'b0001 :
      Result = 4'b1000;
    4'b1000 :
      Result = 4'b1111; 
    default  :
    begin
      $display("Illegal value in fp15 phase accumulator at time %t", $time);
      Result = 4'bxxxx;
    end
  endcase
 
  IncFrame15 =  Result;
end
endfunction // IncFrame15

function [2:0]  IncRow5;
 
  input [2:0] rp5;
  reg [2:0] Result;
begin
  //  five frame duty cycle row phase accumulator
  case (rp5)
    3'b000 :
      Result = 3'b001;
    3'b001 :
      Result = 3'b011;
    3'b011 :
      Result = 3'b010;
    3'b010 :
      Result = 3'b100;
    3'b100 :
      Result = 3'b000;
    default  :
    begin
      Result = 3'bxxx;
    end
  endcase
 
  IncRow5 =  Result;
end
endfunction
 
function [3:0]  IncRow9;
 
  input [3:0] rp9;
  reg [3:0] Result;
begin
  //  nine frame duty cycle row phase accumulator
  case (rp9)
    4'b0000 :
      Result = 4'b0010;
    4'b0010 :
      Result = 4'b0101;
    4'b0101 :
      Result = 4'b1000;
    4'b1000 :
      Result = 4'b1010;
    4'b1010 :
      Result = 4'b0001;
    4'b0001 :
      Result = 4'b0100;
    4'b0100 :
      Result = 4'b1001;
    4'b1001 :
      Result = 4'b1011;
    4'b1011 :
      Result = 4'b0000;
    default  :
    begin
      Result = 4'bxxxx;
    end
  endcase
 
  IncRow9 =  Result;
end
endfunction
 
function [3:0]  IncRow15;
 
  input [3:0] rp15;
  reg [3:0] Result;
begin
  //  fifteen frame duty cycle row phase accumulator
  case (rp15)
    4'b1111 :
      Result = 4'b1100;
    4'b1100 :
      Result = 4'b1001;
    4'b1001 :
      Result = 4'b0110;
    4'b0110 :
      Result = 4'b0011;
    4'b0011 :
      Result = 4'b1111;
    4'b1110 :
      Result = 4'b1011;
    4'b1011 :
      Result = 4'b1000;
    4'b1000 :
      Result = 4'b0101;
    4'b0101 :
      Result = 4'b0010;
    4'b0010 :
      Result = 4'b1110;
    4'b1101 :
      Result = 4'b1010;
    4'b1010 :
      Result = 4'b0111;
    4'b0111 :
      Result = 4'b0100;
    4'b0100 :
      Result = 4'b0001;
    4'b0001 :
      Result = 4'b1101;
    default  :
    begin
      Result = 4'bxxxx;
    end
  endcase
 
  IncRow15 =  Result;
end
endfunction
 
function [2:0]  IncCol5;
 
  input [2:0] cp5;
  reg [2:0] Result;
begin
  //  five frame duty cycle column phase accumulator
  case (cp5)
    3'b000 :
      Result = 3'b001;
    3'b001 :
      Result = 3'b011;
    3'b011 :
      Result = 3'b010;
    3'b010 :
      Result = 3'b100;
    3'b100 :
      Result = 3'b000;
    default  :
    begin
      Result = 3'bxxx;
    end
  endcase
 
  IncCol5 =  Result;
end
endfunction
 
function [3:0]  IncCol9;
 
  input [3:0] cp9;
  reg [3:0] Result;
begin
  //  nine frame duty cycle column phase accumulator
  case (cp9)
    4'b0000 :
      Result = 4'b0001;
    4'b0001 :
      Result = 4'b0010;
    4'b0010 :
      Result = 4'b0100;
    4'b0100 :
      Result = 4'b0101;
    4'b0101 :
      Result = 4'b1001;
    4'b1001 :
      Result = 4'b1000;
    4'b1000 :
      Result = 4'b1011;
    4'b1011 :
      Result = 4'b1010;
    4'b1010 :
      Result = 4'b0000;
    default  :
    begin
      Result = 4'bxxxx;
    end
  endcase
 
  IncCol9 =  Result;
end
endfunction
 
function [3:0]  IncCol15;
 
  input [3:0] cp15;
  reg [3:0] Result;
begin
  //  fifteen frame duty cycle column phase accumulator
  //  this is a straight down counter, state machine notation used for
  //  consistency with other descriptions
  case (cp15)
    4'b1111 :
      Result = 4'b1110;
    4'b1110 :
      Result = 4'b1101;
    4'b1101 :
      Result = 4'b1100;
    4'b1100 :
      Result = 4'b1011;
    4'b1011 :
      Result = 4'b1010;
    4'b1010 :
      Result = 4'b1001;
    4'b1001 :
      Result = 4'b1000;
    4'b1000 :
      Result = 4'b0111;
    4'b0111 :
      Result = 4'b0110;
    4'b0110 :
      Result = 4'b0101;
    4'b0101 :
      Result = 4'b0100;
    4'b0100 :
      Result = 4'b0011;
    4'b0011 :
      Result = 4'b0010;
    4'b0010 :
      Result = 4'b0001;
    4'b0001 :
      Result = 4'b1111;
    default  :
    begin
      Result = 4'bxxxx;
    end
  endcase
 
  IncCol15 =  Result;
end
endfunction
 
function [13:1]  Greyscale;
 
  input cp2;
  input [2:0] cp5;
  input [3:0] cp9;
  input [3:0] cp15;
   
  //  Define the 16 grey-scales, as a function of the outputs of the column
  //  phase accumulators
  reg [13:1] Result;
begin
  Result[1] = cp9[1] & cp9[0];
  Result[2] = cp5[2];
  Result[3] = cp15[3] & cp15[0];
  Result[4] = ~ (cp9[1] | cp9[0]);
  Result[5] = cp5[0];
  Result[6] = cp9[3];
  Result[7] = cp2;
  Result[8] = ~ Result[6];
  Result[9] = ~ Result[5];
  Result[10] = ~ Result[4];
  Result[11] = ~ Result[3];
  Result[12] = ~ Result[2];
  Result[13] = ~ Result[1];
  Greyscale =  Result;
end
endfunction
 
function  vidgsmux;
 
  input [3:0] Colour;
  input [13:1] Greyscale;
  //  16 input mux to select the greyscale
  reg Result;
begin
  case (Colour)
    4'b0000 :
      Result = 1'b0;
    4'b0001 :
      Result = Greyscale[1];
    4'b0010 :
      Result = Greyscale[2];
    4'b0011 :
      Result = Greyscale[3];
    4'b0100 :
      Result = Greyscale[4];
    4'b0101 :
      Result = Greyscale[5];
    4'b0110 :
      Result = Greyscale[6];
    4'b0111 :
      Result = Greyscale[7];
    4'b1000 :
      Result = Greyscale[8];
    4'b1001 :
      Result = Greyscale[9];
    4'b1010 :
      Result = Greyscale[10];
    4'b1011 :
      Result = Greyscale[11];
    4'b1100 :
      Result = Greyscale[12];
    4'b1101 :
      Result = Greyscale[13];
    4'b1110 :
      Result = 1'b1;
    4'b1111 :
      Result = 1'b1;
    default  :
      Result = 1'bx;
  endcase
 
  vidgsmux =  Result;
end
endfunction

// -----------------------------------------------------------------------------
//   Signal declarations
// -----------------------------------------------------------------------------

//  The 16 GreyScales output from the state machines
reg  [13:1] GreysU;
reg  [13:1] GreysL;

//  State registers for grey-scale state machines
reg          fp2;
reg   [2:0]  fp5;
reg   [3:0]  fp9;
reg   [3:0]  fp15;

reg          trp2;
reg   [2:0]  trp5;
reg   [3:0]  trp9;
reg   [3:0]  trp15;

reg          urp2;
reg   [2:0]  urp5;
reg   [3:0]  urp9;
reg   [3:0]  urp15;

reg          ucp2;
reg   [2:0]  ucp5;
reg   [3:0]  ucp9;
reg   [3:0]  ucp15;

reg          lrp2;
reg   [2:0]  lrp5;
reg   [3:0]  lrp9;
reg   [3:0]  lrp15;
 
reg          lcp2;
reg   [2:0]  lcp5;
reg   [3:0]  lcp9;
reg   [3:0]  lcp15;

reg         UpRGS;
reg         UpGGS;
reg         UpBGS;
reg         LpRGS;
reg         LpGGS;
reg         LpBGS;

// Counters
integer     LineCount;
integer     PixelCount;

// -----------------------------------------------------------------------------
// Grey Scaler Main Function
// -----------------------------------------------------------------------------
function [5:0] GreyScaler;

input [17:0] UpColor;
input [17:0] LpColor;

begin

// -----------------------------------------------------------------------------
// Load and Increment Control Signal Generation : Line & Pixel Counters
// -----------------------------------------------------------------------------
  if (StartDis)
    begin
      // At the start of display after reset
      PixelCount = 16 * (PPL + 1) - 1;
      LineCount  = LPP;
    end
  else
    begin
      // Decrement Pixel and Line Counter
      if (!PixelCount)
        begin
          if (!LineCount)
            LineCount = LPP;
          else
            LineCount = LineCount - 1'b1;
          PixelCount = 16 * (PPL + 1) - 1;
        end
      else
        PixelCount = PixelCount - 1'b1;
    end

// -----------------------------------------------------------------------------
// Frame Phase Accumulator Update
// -----------------------------------------------------------------------------
  if (StartDis)
    begin
      // At the beginning of display
      fp2 =  1'b0;
      fp5 =  3'b000;
      fp9 =  4'b0000;
      fp15 = 4'b1111;
      trp2 =  1'b0;
      trp5 =  3'b000;
      trp9 =  4'b0000;
      trp15 = 4'b1111;
    end
  else if (!LineCount && !PixelCount) 
    begin
      //  At End of a Frame increment frame counters
      fp2  = ~ fp2;
      fp5  = IncFrame5(fp5);
      fp9  = IncFrame9(fp9);
      fp15 = IncFrame15(fp15);
      trp2 = urp2;
      trp5 = urp5;
      trp9 = urp9;
      trp15 = urp15;
    end
  
// -----------------------------------------------------------------------------
// Row Phase Accumulator Update
// -----------------------------------------------------------------------------
  if (StartDis || !LineCount && !PixelCount)
    begin
      //  Load row values at the end of frame
      urp2  = fp2;
      urp5  = fp5;
      urp9  = fp9;
      urp15 = fp15;
      lrp2 = trp2;
      lrp5 = trp5;
      lrp9 = trp9;
      lrp15 = trp15;
    end
  else if (PixelCount == 1)
    begin
      // Increment Row Conters at the end of each row
      urp2  = ~ urp2;
      urp5  = IncRow5 (urp5);
      urp9  = IncRow9 (urp9);
      urp15 = IncRow15 (urp15);
      lrp2  = ~ lrp2;
      lrp5  = IncRow5 (lrp5);
      lrp9  = IncRow9 (lrp9);
      lrp15 = IncRow15 (lrp15);
    end

// -----------------------------------------------------------------------------
// Column Phase Accumulator Update
// -----------------------------------------------------------------------------
    if (StartDis || (PixelCount== (16 * (PPL + 1) - 1)))
    begin
      //  Load column values
      ucp2  = urp2;
      ucp5  = urp5;
      ucp9  = urp9;
      ucp15 = urp15;
      lcp2  = lrp2;
      lcp5  = lrp5;
      lcp9  = lrp9;
      lcp15 = lrp15;
    end
  else
    begin
      //  Increment  column counters
      ucp2  = ~ ucp2;
      ucp5  = IncCol5 (ucp5);
      ucp9  = IncCol9 (ucp9);
      ucp15 = IncCol15 (ucp15);
      lcp2  = ~ lcp2;
      lcp5  = IncCol5 (lcp5);
      lcp9  = IncCol9 (lcp9);
      lcp15 = IncCol15 (lcp15);
    end

// -----------------------------------------------------------------------------
// Make StartDis low:
// -----------------------------------------------------------------------------
  StartDis = 1'b0;

// -----------------------------------------------------------------------------
// Greyscaler Output Generation
// -----------------------------------------------------------------------------

  GreysU = Greyscale (ucp2, ucp5, ucp9, ucp15);
  GreysL = Greyscale (lcp2, lcp5, lcp9, lcp15);

  UpRGS = vidgsmux (UpColor[5:2], GreysU);
  UpGGS = vidgsmux (UpColor[11:8], GreysU);
  UpBGS = vidgsmux (UpColor[17:14], GreysU);
  LpRGS = vidgsmux (LpColor[5:2], GreysL);
  LpGGS = vidgsmux (LpColor[11:8], GreysL);
  LpBGS = vidgsmux (LpColor[17:14], GreysL);

  GreyScaler = {LpRGS, LpGGS, LpBGS, UpRGS, UpGGS, UpBGS};

end
endfunction

// -----------------------------------------------------------------------------
// Check that the Data CLD is not changing while CLPOWER bit is LOW
// -----------------------------------------------------------------------------
always @(posedge HCLK)
begin : p_CheckDataProt
  if (HCLK == 1'b1)
    begin
      if ((CLPOWER == 1'b0) && (CLD != 24'b0))
        begin
          $display($time," : ERROR : Panel Data is NOT zero when CLPOWER is LOW\n");
        end
    end
end // p_CheckDataProt;

// -----------------------------------------------------------------------------
endmodule
 
// --================================== End ==================================--

