/* --=================================================================--
-- This confidential and proprietary software may be used only as
-- authorised by a licensing agreement from ARM Limited
--   (C) COPYRIGHT 2000 ARM Limited
--       ALL RIGHTS RESERVED
-- The entire notice above must be reproduced on all authorised
-- copies and copies may only be made to the extent permitted
-- by a licensing agreement from ARM Limited.
--
-- ---------------------------------------------------------------------
-- Version and Release Control Information:
--
-- File Name              : AddrRangeTest.c.rca
-- File Revision          : 1.4
--
-- Release Information    : PrimeCell(TM)-PL041-REL1v0
--
-- ---------------------------------------------------------------------
-- Purpose : 
--           This test verifies the accessibility of the FIFOs
--           through each address in the FIFOs' addressable range.
--
-- --=================================================================*/

/**********************************************************************/
/**************** Internal function declarations  *********************/
/**********************************************************************/
 void AddrWrRdTest(int32 Offset, int Channel_No, int RxOrTxFIFO);

/**********************************************************************/
/*** This test verifies the accessibility of the FIFOs through each ***/
/*** address in the FIFOs' addressable range.                       ***/
/**********************************************************************/
void AddrRangeTest(void)
{
 /*
   Summary : AddrRangeTest
   =======================
   Each FIFO in the AACI is accessible from 8 different addresses in
   a contiguous address range. A write to any address in this range
   is expected to be accounted as the next data entry in the Transmit
   FIFO. A read from any of these addresses is expected to return the
   current most recent entry in the Receive FIFO.

   The addresses to be used are generated by associating a base
   address to each of the Channel FIFOs and by adding offsets
   ranging from 0x0 to 0x1C to these FIFO base addresses.
   
   To test the Transmit FIFOs, data are written to the Channel FIFOs
   in the normal mode to addresses that fall within the address
   range for that FIFO. In order to verify that data has been
   internally stored in the correct order within the relevant FIFO, 
   data is read from the read port of the Transmit FIFO by programming
   the FIFOTEST[1:0] bits in the AACITCR register to '01'.
 
   The Receive FIFOs are tested in a similar manner.
   For the Receive FIFOs, data is written to the write port of the
   FIFOs by programming the FIFOTEST[1:0] bits in the AACITCR register 
   to '01'. Reads from the Receive FIFOs are done in the normal
   mode.
 */

 int   One_BitClk_Period = AACIBITCLK_PERIOD / PCLK_PERIOD;
 int   Channel_No;
 int32 i, Offset;

 if (AACIBITCLK_PERIOD < PCLK_PERIOD)
   One_BitClk_Period = 1;

 /* Disable the AACI to Flush the FIFOs of any data left over from
    earlier tests */
 PSW(0x0, AACIMAINCR);
 PI(One_BitClk_Period * 4);

 /* Enable the AACI */
 PSW(AACI_AACIIFE, AACIMAINCR);
 PI(One_BitClk_Period * 4);

 C("ADDRESS RANGE TEST FOR CHANNEL 1");

 Channel_No = 1;

 for (i = 0x0; i < 0x8; i = i + 0x1)
   {
    Offset = i * 0x4;
    AddrWrRdTest(Offset, Channel_No, 0);
    AddrWrRdTest(Offset, Channel_No, 1);
   }

 C("END OF THE ADDRESS RANGE TEST FOR CHANNEL 1");

 C("THE ADDRESS RANGE TEST FOR CHANNEL 2");

 Channel_No = 2;

 for (i = 0x0; i < 0x8; i = i + 0x1)
   {
    Offset = i * 0x4;
    AddrWrRdTest(Offset, Channel_No, 0);
    AddrWrRdTest(Offset, Channel_No, 1);
   }

 C("END OF THE ADDRESS RANGE TEST FOR CHANNEL 2");

 C("THE ADDRESS RANGE TEST FOR CHANNEL 3");

 Channel_No = 3;

 for (i = 0x0; i < 0x8; i = i + 0x1)
   {
    Offset = i * 4;
    AddrWrRdTest(Offset, Channel_No, 0);
    AddrWrRdTest(Offset, Channel_No, 1);
   }

 C("END OF THE ADDRESS RANGE TEST FOR CHANNEL 3");

 C("THE ADDRESS RANGE TEST FOR CHANNEL 4");

 Channel_No = 4;

 for (i = 0x0; i < 0x8; i = i + 0x1)
   {
    Offset = i * 0x4;
    AddrWrRdTest(Offset, Channel_No, 0);
    AddrWrRdTest(Offset, Channel_No, 1);
   }

 C("END OF THE ADDRESS RANGE TEST FOR CHANNEL 4");

}

/**********************************************************************/
/*** The test checks the address range for all the Channel FIFOs    ***/
/**********************************************************************/
void AddrWrRdTest(int32 Offset, int Channel_No, int RxOrTxFIFO)
{
 /*
   Summary : AddrWrRdTest
   ======================
     This function is called by the AddrRangeTest(void) function.
   Eight words of data are written to the FIFO at the fixed
   address derived from Channel_No and Offset arguments. Data is then
   removed through the read port of the FIFO by reading from each 
   address in the address range of the relevant FIFO.

   For the Transmit FIFO, the writing is done in the normal mode but 
   the reading is done in test mode (FIFOTEST[1:0] = 01). 
   For the Receive FIFO, the writing is done in the test mode 
   (FIFOTEST[1:0] = 01) but the reading is done in normal mode.
 */

 int j;
 int32 Data, Address, ReadOffset;
 int   One_BitClk_Period = AACIBITCLK_PERIOD / PCLK_PERIOD;

 if (AACIBITCLK_PERIOD < PCLK_PERIOD)
   One_BitClk_Period = 1;

 printf(";- WRITING 8 WORDS TO THE DATA REGISTER AT OFFSET %lu\n",Offset);

 /* FIFO mode enabled for all the channel FIFO's. FIFO width set to
    20 bits */
 PSW(AACI_RSIZE20 | AACI_FEN, AACIRXCR1);
 PSW(AACI_RSIZE20 | AACI_FEN, AACIRXCR2);
 PSW(AACI_RSIZE20 | AACI_FEN, AACIRXCR3);
 PSW(AACI_RSIZE20 | AACI_FEN, AACIRXCR4);

 PSW(AACI_RSIZE20 | AACI_FEN, AACITXCR1);
 PSW(AACI_RSIZE20 | AACI_FEN, AACITXCR2);
 PSW(AACI_RSIZE20 | AACI_FEN, AACITXCR3);
 PSW(AACI_RSIZE20 | AACI_FEN, AACITXCR4);
 PI(One_BitClk_Period * 4);

 /* Enable AACI to allow read and write to the FIFOs */

 PSW(AACI_AACIIFE, AACIMAINCR);

 /* Select the mode (Normal mode / Test mode) for writing to the
    FIFOs
 */
 switch (RxOrTxFIFO)
   {
    /* RxOrTxFIFO = 0 indicates Tx FIFO */
    /* Program the AACI for normal mode operation */
    case 0  :
      PSW(NORMALMODE, AACITCR,Test_Control_Write);
      break;

    /* RxOrTxFIFO = 1 indicates Rx FIFO */
    /* Program the AACI for test mode operation */
    case 1  :
      PSW(TESTMODE01, AACITCR,Test_Control_Write);
      break;

    default :
      C("Invalid FIFO type");
   }

 for (j = 0x0; j < 0x8; j = j + 0x1)
   {
    /* The data written is unique for every Offset and Channel */
    Data = 0x12345678 * j + 0x01234567 * Channel_No + 56789 * Offset;

    /* Mask out all but the 20 LSBits */
    Data = Data & 0xFFFFF;

    switch (Channel_No)
      {
       case 1  :
         Address = AACIDR1 + Offset;
         PSW(Data, Address,Channel_1_Write);
         break;
       case 2  :
         Address = AACIDR2 + Offset;
         PSW(Data, Address,Channel_2_Write);
         break;
       case 3  :
         Address = AACIDR3 + Offset;
         PSW(Data, Address,Channel_3_Write);
         break;
       case 4  :
         Address = AACIDR4 + Offset;
         PSW(Data, Address,Channel_4_Write);
         break;
       default :
         C("Invalid Channel Number");
      }
   }

 C(" READING BACK FROM EACH ADDRESS IN THE FIFO'S ADDRESS RANGE");

 /* Select the mode (Normal mode / Test mode) for reading from the
    FIFOs 
 */
 switch (RxOrTxFIFO)
   {
    /* RxOrTxFIFO = 0 indicates Tx FIFO */
    /* Program the AACI for test mode operation */
    case 0  :
      PSW(TESTMODE01, AACITCR,Test_Control_Write);
      break;

    /* RxOrTxFIFO = 1 indicates Rx FIFO */
    /* Program the AACI for normal mode operation */
    case 1  :
      PSW(NORMALMODE, AACITCR,Test_Control_Write);
      break;

    default :
      C("Invalid FIFO type");
   }

 ReadOffset = 0x0;

 for (j = 0x0; j < 0x8; j = j + 0x1)
   {
    /* The data to be read is unique for every Offset and Channel.
       Read data (expected data) is derived using the same formula as 
       was used to generate write data
    */
    Data = 0x12345678 * j + 0x01234567 * Channel_No + 56789 * Offset;

    /* Mask out all but the 20 LSBits */
    Data = Data & 0xFFFFF;

    switch (Channel_No)
      {
       case 1  :
         Address = AACIDR1 + ReadOffset;
         PSR(Data, MASK_ALL, Address,Channel_1_Read);
         break;
       case 2  :
         Address = AACIDR2 + ReadOffset;
         PSR(Data, MASK_ALL, Address,Channel_2_Read);
         break;
       case 3  :
         Address = AACIDR3 + ReadOffset;
         PSR(Data, MASK_ALL, Address,Channel_3_Read);
         break;
       case 4  :
         Address = AACIDR4 + ReadOffset;
         PSR(Data, MASK_ALL, Address,Channel_4_Read);
         break;
       default :
         C("Invalid Channel Number");
      }

    ReadOffset = ReadOffset + 0x4;
   }

}

/*********************** End of AddrRangeTest.c ***********************/
