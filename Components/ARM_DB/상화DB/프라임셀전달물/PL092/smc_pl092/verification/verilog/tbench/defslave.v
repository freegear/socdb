// --=================================================================--
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from ARM Limited
//   (C) COPYRIGHT 2000-2001 ARM Limited
//       ALL RIGHTS RESERVED
// The entire notice above must be reproduced on all authorised
// copies and copies may only be made to the extent permitted
// by a licensing agreement from ARM Limited.
//
// ---------------------------------------------------------------------
// Version and Release Control Information:
//
// File Name              : defslave.v.rca
// File Revision          : 1.8
//
// Release Information    : PrimeCell(TM)-PL092-REL1v1
//
// ---------------------------------------------------------------------
// Purpose :
//           Drives all the AHB Slave output signals when no other slave
//           is selected.
//
// --=================================================================--

`timescale 1ns/1ps

// ---------------------------------------------------------------------
module defslave (
                 HCLK,   
                 HRESETn,
                 HSEL,  
                 HTRANS,
                 HRESP,
                 HREADYIn,
                 HREADYOut,
                 HRDATAOut
                );

input         HCLK;
input         HRESETn;
input         HSEL;
input         HTRANS;
input         HREADYIn;
output        HREADYOut;
output [1:0]  HRESP;
output [63:0] HRDATAOut;

// ---------------------------------------------------------------------
//
//                             defslave 
//                             =========
//
// ---------------------------------------------------------------------
//
// Overview
// ========
//   This modules drives the response, when an access is to a unmapped
// region. Default slave has to drive its HREADY output high, when
// other slaves are not selected. It has to drive a zero wait state OK
// response for IDLE and BUSY transfers and a two cycle ERROR response
// for an NSEQ or SEQ transfer access to an unmapped address.
//
// ---------------------------------------------------------------------
// Constant declarations
// ---------------------------------------------------------------------

// ---------------------------------------------------------------------
// Signal declarations
// ---------------------------------------------------------------------
wire [1:0]  HRESP;   
// HRESP generated by Default slave

wire        HREADYOut;
// HREADY generated by Default slave   

reg         iHREADYOut;
// Internal signal for HREADT Output

reg [63:0]  HRDATAOut;
// Read data Output signal

reg         HTRANSInt;
// Internal latched version of HTRANS

reg         NxtHTRANSInt;
// Combinational input for HTRANS

reg         Count;
// Counter for two cycle ERROR response generation 

reg         NxtCount;
// Combinational signal for the counter

reg         Resetstrd;
// Latching HRESETn status

// ---------------------------------------------------------------------
//
// Main body of code
// =================
//
// ---------------------------------------------------------------------
// Assigning local copy to output
// ---------------------------------------------------------------------
assign HREADYOut = iHREADYOut;

// ---------------------------------------------------------------------
// Latching Control signal HTRANS
// ---------------------------------------------------------------------
always @(posedge HCLK or negedge HRESETn)
begin : p_HTRANSSeq
  if (HRESETn == 1'b0)
    HTRANSInt = 1'b0;
  else
    HTRANSInt = NxtHTRANSInt;
end // p_HTRANSSeq;
 
// ---------------------------------------------------------------------
// Loading HTRANS signal only when HREADY is set
// ---------------------------------------------------------------------
always @(HTRANS or HREADYIn or HTRANSInt)
begin : p_HTRANSComb
  if (HREADYIn == 1'b1)
      NxtHTRANSInt = HTRANS;
  else
    NxtHTRANSInt = HTRANSInt;
end // p_HTRANSComb;

// ---------------------------------------------------------------------
// Storing reset status 
// ---------------------------------------------------------------------
always @( posedge HCLK or HRESETn)
begin : p_HRESETn
   Resetstrd = HRESETn;
end // p_HRESETn;

// ---------------------------------------------------------------------
// Generating HREADY and HRESP internally
// ---------------------------------------------------------------------
always @(HTRANSInt or HRESETn or Count or HSEL or Resetstrd)
begin
  # 2 iHREADYOut = (((HTRANSInt == 1'b0) || (HRESETn == 1'b0) ||
                     ((HTRANSInt == 1'b1) && (Count == 1'b1) &&
                     (HSEL == 1'b1))) || Resetstrd == 1'b0) ?
                    1'b1  : 1'b0;
end

assign #2 HRESP = ((HSEL == 1'b1) && (HTRANSInt == 1'b1)) ? 1'b1 : 1'b0;

// ---------------------------------------------------------------------
// Initialising HREADY and HRDATA
// ---------------------------------------------------------------------
initial
begin
  iHREADYOut = 1'b0;
  HRDATAOut  = 64'h0000000000000000;
end
// ---------------------------------------------------------------------
// Counter
// ---------------------------------------------------------------------
always @(posedge HCLK or negedge HRESETn)
begin : p_CntSeq
  if (HRESETn == 1'b0)
    Count =  1'b0;
  else
    Count = NxtCount;
end // p_CntSeq;
 
// ---------------------------------------------------------------------
// Timeout Counter loaded when a Master takes over the slave
// ---------------------------------------------------------------------
always @(Count or HTRANSInt)
begin : p_CntComb
  if ((HTRANSInt == 1'b1) && (Count == 1'b0)) 
    NxtCount = 1'b1;
  else
    NxtCount = 1'b0;
  
end // p_CntComb;

endmodule

// --============================= End ===============================--
