#if !defined(BANNER_H)
#define BANNER_H
static char *Unknown_Bold_Normal_14[][62] = {
{
"         ",
"   @@@   ",
" @@   @@ ",
"@@     @@",
"@@     @@",
"@@     @@",
"@@     @@",
"@@     @@",
"@@     @@",
"@@     @@",
" @@   @@ ",
"   @@@   ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2331 */
{
"      ",
"   @  ",
"  @@  ",
"@@@@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"@@@@@@",
"      ",
"      ",
"      "},
/* lines 15 */
/* 2332 */
{
"        ",
"  @@@@  ",
" @   @@ ",
"@@    @@",
"@@@   @@",
" @   @@ ",
"     @  ",
"    @   ",
"   @    ",
"  @    @",
" @@@@@@ ",
"@@@@@@@ ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2333 */
{
"        ",
"  @@@@  ",
" @   @@ ",
"@@    @@",
"@@    @@",
"     @@ ",
"   @@@  ",
"      @ ",
"@@    @@",
"@@    @@",
" @   @@ ",
"  @@@@  ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2334 */
{
"         ",
"     @@  ",
"    @@@  ",
"   @ @@  ",
"   @ @@  ",
"  @  @@  ",
" @   @@  ",
"@@   @@  ",
"@@@@@@@@@",
"     @@  ",
"     @@  ",
"    @@@@ ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2335 */
{
"        ",
" @@@@@@@",
" @@@@@@ ",
" @      ",
" @      ",
" @@@@@  ",
"     @@ ",
"      @@",
"      @@",
"@@    @@",
"@@   @@ ",
" @@@@   ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2336 */
{
"         ",
"   @@@@  ",
"  @   @@ ",
" @@   @@ ",
" @       ",
"@@ @@@@  ",
"@@@   @@ ",
"@@     @@",
"@@     @@",
"@@     @@",
" @@   @@ ",
"   @@@   ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2337 */
{
"         ",
" @@@@@@@@",
" @@@@@@@ ",
"@     @  ",
"     @   ",
"     @   ",
"    @    ",
"    @    ",
"   @@    ",
"   @@    ",
"   @@    ",
"   @@    ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2338 */
{
"        ",
"  @@@@  ",
" @    @ ",
"@@    @@",
"@@@   @@",
" @@@ @@ ",
"  @@@@  ",
" @@ @@@ ",
"@@   @@@",
"@@    @@",
" @    @ ",
"  @@@@  ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2339 */
{
"        ",
"   @@   ",
" @@  @@ ",
"@@    @@",
"@@    @@",
"@@    @@",
" @@  @@@",
"  @@@ @@",
"      @@",
"@@    @ ",
"@@   @  ",
" @@@@   ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2341 */
{
"            ",
"      @     ",
"      @     ",
"     @@@    ",
"     @@@    ",
"    @  @@   ",
"    @  @@   ",
"   @    @@  ",
"   @@@@@@@  ",
"  @      @@ ",
"  @      @@ ",
"@@@@    @@@@",
"            ",
"            ",
"            "},
/* lines 15 */
/* 2342 */
{
"           ",
"@@@@@@@    ",
"  @@   @@  ",
"  @@    @@ ",
"  @@    @@ ",
"  @@   @@  ",
"  @@@@@@   ",
"  @@    @@ ",
"  @@     @@",
"  @@     @@",
"  @@    @@ ",
"@@@@@@@@   ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2343 */
{
"          ",
"    @@@@ @",
"  @@    @@",
" @@      @",
"@@       @",
"@@        ",
"@@        ",
"@@        ",
"@@        ",
" @@      @",
"  @@    @@",
"    @@@@  ",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2344 */
{
"           ",
"@@@@@@@    ",
"  @@   @@  ",
"  @@    @@ ",
"  @@     @@",
"  @@     @@",
"  @@     @@",
"  @@     @@",
"  @@     @@",
"  @@    @@ ",
"  @@   @@  ",
"@@@@@@@    ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2345 */
{
"           ",
"@@@@@@@@@  ",
"  @@    @  ",
"  @@     @ ",
"  @@       ",
"  @@   @   ",
"  @@@@@@   ",
"  @@   @   ",
"  @@       ",
"  @@      @",
"  @@     @ ",
"@@@@@@@@@@ ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2346 */
{
"          ",
"@@@@@@@@@ ",
"  @@    @ ",
"  @@     @",
"  @@      ",
"  @@   @  ",
"  @@@@@@  ",
"  @@   @  ",
"  @@      ",
"  @@      ",
"  @@      ",
"@@@@@@    ",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2347 */
{
"            ",
"    @@@@ @  ",
"  @@    @@  ",
" @@      @  ",
"@@          ",
"@@          ",
"@@     @@@@@",
"@@     @ @@ ",
"@@    @  @@ ",
" @@      @@ ",
"  @@    @@  ",
"    @@@@    ",
"            ",
"            ",
"            "},
/* lines 15 */
/* 2348 */
{
"           ",
"@@@@   @@@@",
" @@     @@ ",
" @@     @@ ",
" @@     @@ ",
" @@     @@ ",
" @@@@@@@@@ ",
" @@     @@ ",
" @@     @@ ",
" @@     @@ ",
" @@     @@ ",
"@@@@   @@@@",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2349 */
{
"      ",
"@@@@@@",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"@@@@@@",
"      ",
"      ",
"      "},
/* lines 15 */
/* 234a */
{
"           ",
"     @@@@@@",
"       @@  ",
"       @@  ",
"       @@  ",
"       @@  ",
"       @@  ",
" @     @@  ",
"@@@    @@  ",
"@@     @@  ",
" @@   @@   ",
"   @@@     ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 234b */
{
"           ",
"@@@@   @@@@",
" @@     @  ",
" @@    @   ",
" @@   @    ",
" @@  @@    ",
" @@ @ @@   ",
" @@@  @@   ",
" @@    @@  ",
" @@    @@  ",
" @@     @@ ",
"@@@@   @@@@",
"           ",
"           ",
"           "},
/* lines 15 */
/* 234c */
{
"           ",
"@@@@@@     ",
"  @@       ",
"  @@       ",
"  @@       ",
"  @@       ",
"  @@       ",
"  @@       ",
"  @@       ",
"  @@      @",
"  @@     @ ",
"@@@@@@@@@@ ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 234d */
{
"           ",
"@@@     @@@",
" @@     @@ ",
" @@@   @@@ ",
" @@@   @@@ ",
" @ @@ @ @@ ",
" @ @@ @ @@ ",
" @ @@@  @@ ",
" @  @@  @@ ",
" @  @   @@ ",
" @      @@ ",
"@@@    @@@@",
"           ",
"           ",
"           "},
/* lines 15 */
/* 234e */
{
"          ",
"@@@    @@@",
" @@     @ ",
" @@@    @ ",
" @ @@   @ ",
" @ @@   @ ",
" @  @@  @ ",
" @   @@ @ ",
" @   @@ @ ",
" @    @@@ ",
" @     @@ ",
"@@@    @@ ",
"          ",
"          ",
"          "},
/* lines 15 */
/* 234f */
{
"           ",
"    @@@    ",
"  @@   @@  ",
" @@     @@ ",
"@@       @@",
"@@       @@",
"@@       @@",
"@@       @@",
"@@       @@",
" @@     @@ ",
"  @@   @@  ",
"    @@@    ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2350 */
{
"          ",
"@@@@@@@   ",
"  @@   @@ ",
"  @@    @@",
"  @@    @@",
"  @@   @@ ",
"  @@@@@   ",
"  @@      ",
"  @@      ",
"  @@      ",
"  @@      ",
"@@@@@@    ",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2351 */
{
"           ",
"    @@@    ",
"  @@   @@  ",
" @@     @@ ",
"@@       @@",
"@@       @@",
"@@       @@",
"@@       @@",
"@@  @@   @@",
" @@@  @ @@ ",
"  @@   @@  ",
"    @@@@@  ",
"         @@",
"           ",
"           "},
/* lines 15 */
/* 2352 */
{
"           ",
"@@@@@@@    ",
"  @@   @@  ",
"  @@    @@ ",
"  @@    @@ ",
"  @@   @@  ",
"  @@@@@    ",
"  @@  @@   ",
"  @@   @@  ",
"  @@   @@  ",
"  @@    @@ ",
"@@@@@   @@@",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2353 */
{
"         ",
"  @@@@ @ ",
" @    @@ ",
"@@     @ ",
"@@@      ",
" @@@@    ",
"   @@@@  ",
"     @@@ ",
"@      @@",
"@@     @@",
"@@@    @ ",
"@  @@@@  ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2354 */
{
"            ",
" @@@@@@@@@@ ",
" @   @@   @ ",
"@    @@    @",
"     @@     ",
"     @@     ",
"     @@     ",
"     @@     ",
"     @@     ",
"     @@     ",
"     @@     ",
"   @@@@@@   ",
"            ",
"            ",
"            "},
/* lines 15 */
/* 2355 */
{
"           ",
"@@@@    @@@",
" @@      @ ",
" @@      @ ",
" @@      @ ",
" @@      @ ",
" @@      @ ",
" @@      @ ",
" @@      @ ",
" @@      @ ",
"  @@    @  ",
"    @@@@   ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2356 */
{
"           ",
"@@@@    @@@",
" @@      @ ",
" @@      @ ",
"  @@    @  ",
"  @@    @  ",
"   @@  @   ",
"   @@  @   ",
"    @@@    ",
"    @@@    ",
"     @     ",
"     @     ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2357 */
{
"           ",
"@@@ @@@ @@@",
" @@  @@  @ ",
" @@  @@  @ ",
" @@  @@  @ ",
"  @@ @@@ @ ",
"  @@@ @@@  ",
"  @@@ @@@  ",
"   @@  @@  ",
"   @@  @@  ",
"   @@  @@  ",
"   @@  @@  ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2358 */
{
"           ",
"@@@@   @@@@",
" @@     @  ",
"  @@   @   ",
"   @@ @    ",
"    @@     ",
"    @@     ",
"    @@@    ",
"   @  @@   ",
"  @    @@  ",
" @      @@ ",
"@@@    @@@@",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2359 */
{
"           ",
"@@@@   @@@@",
" @@     @  ",
"  @@   @   ",
"   @@ @    ",
"    @@     ",
"    @@     ",
"    @@     ",
"    @@     ",
"    @@     ",
"    @@     ",
"  @@@@@@   ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 235a */
{
"           ",
" @@@@@@@@@ ",
" @     @@  ",
"@     @@   ",
"     @@    ",
"     @@    ",
"    @@     ",
"   @@      ",
"   @@      ",
"  @@      @",
" @@      @ ",
"@@@@@@@@@@ ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2361 */
{
"         ",
"         ",
"         ",
"         ",
"  @@@@   ",
" @@   @  ",
" @@   @@ ",
"   @@@@@ ",
" @@   @@ ",
"@@    @@ ",
"@@   @@@ ",
" @@@@  @@",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2362 */
{
"         ",
"@@@      ",
" @@      ",
" @@      ",
" @@ @@   ",
" @@@  @@ ",
" @@    @@",
" @@    @@",
" @@    @@",
" @@    @@",
" @@@  @@ ",
"@@@ @@   ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2363 */
{
"        ",
"        ",
"        ",
"        ",
"   @@@  ",
" @@   @@",
"@@     @",
"@@      ",
"@@      ",
"@@     @",
" @@   @@",
"   @@@  ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2364 */
{
"         ",
"     @@@ ",
"      @@ ",
"      @@ ",
"   @@ @@ ",
" @@  @@@ ",
"@@    @@ ",
"@@    @@ ",
"@@    @@ ",
"@@    @@ ",
" @@  @@@ ",
"   @@ @@@",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2365 */
{
"         ",
"         ",
"         ",
"         ",
"  @@@@@  ",
" @     @ ",
"@@     @@",
"@@@@@@@@@",
"@@       ",
"@@      @",
" @@    @@",
"   @@@@  ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2366 */
{
"        ",
"    @@@ ",
"   @  @@",
"  @@  @@",
"  @@    ",
"@@@@@@@@",
"  @@    ",
"  @@    ",
"  @@    ",
"  @@    ",
"  @@    ",
"@@@@@@  ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2367 */
{
"        ",
"        ",
"        ",
"        ",
"  @@@@@@",
" @@  @@ ",
" @   @@ ",
" @   @  ",
"  @@@   ",
" @@     ",
" @@@@@@ ",
"@@   @@@",
" @     @",
"  @@@@@ ",
"        "},
/* lines 15 */
/* 2368 */
{
"          ",
"@@@       ",
" @@       ",
" @@       ",
" @@ @@@   ",
" @@@  @@  ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
"@@@@  @@@@",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2369 */
{
"      ",
"   @  ",
"  @@@ ",
"   @  ",
"      ",
"@@@@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"@@@@@@",
"      ",
"      ",
"      "},
/* lines 15 */
/* 236a */
{
"      ",
"    @ ",
"   @@@",
"    @ ",
"      ",
" @@@@@",
"    @@",
"    @@",
"    @@",
"    @@",
"    @@",
"@@  @@",
"@@  @ ",
" @@@  ",
"      "},
/* lines 15 */
/* 236b */
{
"          ",
"@@@       ",
" @@       ",
" @@   @@@ ",
" @@   @   ",
" @@  @    ",
" @@ @@@   ",
" @@@ @@   ",
" @@   @@  ",
" @@   @@  ",
" @@    @@ ",
"@@@@   @@@",
"          ",
"          ",
"          "},
/* lines 15 */
/* 236c */
{
"      ",
"@@@@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"  @@  ",
"@@@@@@",
"      ",
"      ",
"      "},
/* lines 15 */
/* 236d */
{
"            ",
"            ",
"            ",
"            ",
"@@@ @@ @@@  ",
" @@@ @@  @@ ",
" @@  @@  @@ ",
" @@  @@  @@ ",
" @@  @@  @@ ",
" @@  @@  @@ ",
" @@  @@  @@ ",
"@@@@ @@@ @@@",
"            ",
"            ",
"            "},
/* lines 15 */
/* 236e */
{
"          ",
"          ",
"          ",
"          ",
"@@@ @@@   ",
" @@@   @  ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
"@@@@  @@@@",
"          ",
"          ",
"          "},
/* lines 15 */
/* 236f */
{
"         ",
"         ",
"         ",
"         ",
"   @@@   ",
" @@   @@ ",
"@@     @@",
"@@     @@",
"@@     @@",
"@@     @@",
" @@   @@ ",
"   @@@   ",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2370 */
{
"         ",
"         ",
"         ",
"         ",
"@@@ @@@  ",
" @@@  @@ ",
" @@    @@",
" @@    @@",
" @@    @@",
" @@    @@",
" @@@  @@ ",
" @@ @@@  ",
" @@      ",
"@@@@     ",
"         "},
/* lines 15 */
/* 2371 */
{
"         ",
"         ",
"         ",
"         ",
"  @@@ @@@",
" @@  @@@ ",
"@@    @@ ",
"@@    @@ ",
"@@    @@ ",
"@@    @@ ",
" @@  @@@ ",
"  @@@ @@ ",
"      @@ ",
"     @@@@",
"         "},
/* lines 15 */
/* 2372 */
{
"        ",
"        ",
"        ",
"        ",
"@@@ @@@ ",
" @@@  @@",
" @@   @@",
" @@     ",
" @@     ",
" @@     ",
" @@     ",
"@@@@    ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2373 */
{
"        ",
"        ",
"        ",
"        ",
" @@@@@@ ",
"@@    @ ",
"@@@     ",
" @@@@   ",
"   @@@@ ",
"@    @@@",
"@@    @@",
"@ @@@@@ ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2374 */
{
"        ",
"        ",
"   @    ",
"  @@    ",
"  @@    ",
"@@@@@@@@",
"  @@    ",
"  @@    ",
"  @@    ",
"  @@    ",
"  @@   @",
"   @@@@ ",
"        ",
"        ",
"        "},
/* lines 15 */
/* 2375 */
{
"          ",
"          ",
"          ",
"          ",
"@@@  @@@@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@    @@ ",
" @@   @@@ ",
"  @@@@  @@",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2376 */
{
"          ",
"          ",
"          ",
"          ",
"@@@@@  @@@",
" @@     @ ",
"  @@   @  ",
"  @@   @  ",
"   @@ @   ",
"   @@ @   ",
"    @@    ",
"    @@    ",
"          ",
"          ",
"          "},
/* lines 15 */
/* 2377 */
{
"           ",
"           ",
"           ",
"           ",
"@@@@ @@ @@@",
" @@  @@  @ ",
" @@  @@  @ ",
"  @@@ @@ @ ",
"  @@@ @@@  ",
"   @@  @@  ",
"   @@  @@  ",
"   @@  @@  ",
"           ",
"           ",
"           "},
/* lines 15 */
/* 2378 */
{
"         ",
"         ",
"         ",
"         ",
"@@@@  @@@",
" @@    @ ",
"  @@  @  ",
"   @@@   ",
"   @@@   ",
"  @  @@  ",
" @    @@ ",
"@@@  @@@@",
"         ",
"         ",
"         "},
/* lines 15 */
/* 2379 */
{
"         ",
"         ",
"         ",
"         ",
"@@@@@ @@@",
" @@    @ ",
"  @@   @ ",
"  @@  @  ",
"   @@ @  ",
"   @@@   ",
"    @@   ",
"@@  @    ",
"@@  @    ",
" @@@     ",
"         "},
/* lines 15 */
/* 237a */
{
"        ",
"        ",
"        ",
"        ",
"@@@@@@@@",
"@    @@ ",
"    @@  ",
"   @@   ",
"  @@    ",
" @@     ",
"@@     @",
"@@@@@@@@",
"        ",
"        ",
"        "}
};
#endif
