//#define DDRRAM_STARTADDR (0x60800000)
#define DDRRAM_STARTADDR (0x62000000)

#define DDRRAM_USER		(DDRRAM_STARTADDR+2*1024*1024)	// lower 2MB used as code/data
#define DDR_TESTREGION 	(DDRRAM_USER+4*1024*1024)		// 4MB as Frame buffer
#define AUDIO_TESTADDR 	(DDRRAM_USER+12*1024*1024)		// 8MB as Frame buffer

#define USB_FIFOBUF_STARTADDR	(FRAME_BASEADDR-1024*1024)	//
#define USB_FIFOBUF_ENDADDR		(FRAME_BASEADDR)	// 1MB
// start : DDRRAM_USER+16M ~ 1MBw

#define FRAME_BASEADDR		(0x63000000)
#define CURSOR_BASEADDR		(FRAME_BASEADDR)					// 2MB for Cursor plane 
#define GRAPHIC_BASEADDR	(CURSOR_BASEADDR     +2*1024*1024)	// 2MB for Graphic plane	
#define VIDEO_BASEADDR		(GRAPHIC_BASEADDR	 +2*1024*1024)	// 4MB for Video plane	
#define VIDEO_SRC0_BASEADDR (VIDEO_BASEADDR		 +4*1024*1024)	// 4MB for Video panorama0	
#define VIDEO_SRC1_BASEADDR (VIDEO_SRC0_BASEADDR +4*1024*1024)	// 4MB for Video panorama1	

