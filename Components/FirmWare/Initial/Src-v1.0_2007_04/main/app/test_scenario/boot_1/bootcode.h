#ifndef _BOOTCODE_H_
#define	_BOOTCODE_H_

#include "sysinc.h"
const smtUint32 bootCode[] = 
{   
		#ifdef __CT500_EVB__
		0xe59f00d4,    //....    DCD    3852402900
        0xe59f10d4,    //....    DCD    3852406996
        0xe59f20d4,    //. ..    DCD    3852411092
        0xe59f30d4,    //.0..    DCD    3852415188
        0xe59f40d4,    //.@..    DCD    3852419284
        0xe59f50d4,    //.P..    DCD    3852423380
        0xe5825000,    //.P..    DCD    3850522624
        0xe59f50d0,    //.P..    DCD    3852423376
        0xe5835000,    //.P..    DCD    3850588160
        0xe59f50cc,    //.P..    DCD    3852423372
        0xe5845000,    //.P..    DCD    3850653696
        0xe59f00c8,    //....    DCD    3852402888
        0xe59f10c8,    //....    DCD    3852406984
        0xe59f20c8,    //. ..    DCD    3852411080
        0xe59f30c8,    //.0..    DCD    3852415176
        0xe59f40c8,    //.@..    DCD    3852419272
        0xe59f50c8,    //.P..    DCD    3852423368
        0xe5805000,    //.P..    DCD    3850391552
        0xe3a05024,    //$P..    DCD    3818934308
        0xe5845000,    //.P..    DCD    3850653696
        0xe3a05e41,    //A^..    DCD    3818937921
        0xe5835000,    //.P..    DCD    3850588160
        0xe3a050a1,    //.P..    DCD    3818934433
        0xe5815000,    //.P..    DCD    3850457088
        0xe3a0577c,    //|W..    DCD    3818936188
        0xe5936000,    //.`..    DCD    3851640832
        0xe0066005,    //.`..    DCD    3758514181
        0xe3560000,    //..V.    DCD    3814064128
        0x1afffffb,    //....    DCD    452984827
        0xee110f10,    //....    DCD    3994095376
        0xe3c00d40,    //@...    DCD    3821014336
        0xee010f10,    //....    DCD    3993046800
        0xee110f10,    //....    DCD    3994095376
        0xe3c00004,    //....    DCD    3821010948
        0xee010f10,    //....    DCD    3993046800
        0xe3a00000,    //....    DCD    3818913792
        0xee070f17,    //....    DCD    3993440023
        0xee110f10,    //....    DCD    3994095376
        0xe3c00001,    //....    DCD    3821010945
        0xee010f10,    //....    DCD    3993046800
        0xe3a00000,    //....    DCD    3818913792
        0xee080f17,    //....    DCD    3993505559
        0xeaffffff,    //....    DCD    3942645759
        0xe3c000df,    //....    DCD    3821011167
        0xe3801013,    //....    DCD    3816820755
        0xe12ff001,    //../.    DCD    3778015233
        0xe3a0d462,    //b...    DCD    3818968162
        0xe10f0000,    //....    DCD    3775856640
        0xe3800080,    //....    DCD    3816816768
        0xe12ff000,    //../.    DCD    3778015232
        0xe10f0000,    //....    DCD    3775856640
        0xe3800040,    //@...    DCD    3816816704
        0xe12ff000,    //../.    DCD    3778015232
        0xeb00000e,    //....    DCD    3942645774
        0xe1a0f000,    //....    DCD    3785420800
        0x50003000,    //.0.P    DCD    1342189568
        0x50003004,    //.0.P    DCD    1342189572
        0x50003008,    //.0.P    DCD    1342189576
        0x5000300c,    //.0.P    DCD    1342189580
        0x50003010,    //.0.P    DCD    1342189584
        0x80000380,    //....    DCD    2147484544
        0x0000252a,    //*%..    DCD    9514
        0x000fddfc,    //....    DCD    1039868
        0x40004000,    //.@.@    DCD    1073758208
        0x40004004,    //.@.@    DCD    1073758212
        0x40004008,    //.@.@    DCD    1073758216
        0x4000400c,    //.@.@    DCD    1073758220
        0x40004010,    //.@.@    DCD    1073758224
        0x00037535,    //5u..    DCD    226613
        0xe92d4ffe,    //.O-.    DCD    3912060926
        0xe59f0154,    //T...    DCD    3852403028
        0xe3a08b80,    //....    DCD    3818949504
        0xe59f2150,    //P!..    DCD    3852411216
        0xe59f1150,    //P...    DCD    3852407120
        0xe58d0008,    //....    DCD    3851223048
        0xe58d8004,    //....    DCD    3851255812
        0xe5812008,    //. ..    DCD    3850444808
        0xe3a00000,    //....    DCD    3818913792
        0xe59f2140,    //@!..    DCD    3852411200
        0xe581200c,    //. ..    DCD    3850444812
        0xe59f213c,    //<!..    DCD    3852411196
        0xe5812000,    //. ..    DCD    3850444800
        0xe59f2138,    //8!..    DCD    3852411192
        0xe5812000,    //. ..    DCD    3850444800
        0xe5912010,    //. ..    DCD    3851493392
        0xe3120740,    //@...    DCD    3809609536
        0x0afffffc,    //....    DCD    184549372
        0xe59f2128,    //(!..    DCD    3852411176
        0xe1a03001,    //.0..    DCD    3785371649
        0xe5812010,    //. ..    DCD    3850444816
        0xe1a01a00,    //....    DCD    3785366016
        0xe1a0ee21,    //!...    DCD    3785420321
        0xe3a04000,    //.@..    DCD    3818930176
        0xe200c0ff,    //....    DCD    3791700223
        0xe59f1110,    //....    DCD    3852407056
        0xe2849001,    //....    DCD    3800338433
        0xe1a05809,    //.X..    DCD    3785381897
        0xe5910004,    //....    DCD    3851485188
        0xe1a05825,    //%X..    DCD    3785381925
        0xe1800404,    //....    DCD    3783263236
        0xe5810008,    //....    DCD    3850436616
        0xe1a02b05,    //.+..    DCD    3785370373
        0xe1a00525,    //%...    DCD    3785360677
        0xe2056003,    //.`..    DCD    3792003075
        0xe59d5008,    //.P..    DCD    3852292104
        0xe59d8004,    //....    DCD    3852304388
        0xe1a02c22,    //",..    DCD    3785370658
        0xe1820400,    //....    DCD    3783394304
        0xe59f20e0,    //. ..    DCD    3852411104
        0xe59fa0d8,    //....    DCD    3852443864
        0xe0275498,    //.T'.    DCD    3760673944
        0xe38089c0,    //....    DCD    3816851904
        0xe3a01000,    //....    DCD    3818917888
        0xe3a0b044,    //D...    DCD    3818958916
        0xe201003f,    //?...    DCD    3791716415
        0xe1805306,    //.S..    DCD    3783283462
        0xe3a0000f,    //....    DCD    3818913807
        0xe59f40c0,    //.@..    DCD    3852419264
        0xe5820010,    //....    DCD    3850502160
        0xe3a00040,    //@...    DCD    3818913856
        0xe5830010,    //....    DCD    3850567696
        0xe3a00d71,    //q...    DCD    3818917233
        0xe583000c,    //....    DCD    3850567692
        0xe59f00ac,    //....    DCD    3852402860
        0xe5830000,    //....    DCD    3850567680
        0xe1a00c05,    //....    DCD    3785362437
        0xe180080e,    //....    DCD    3783264270
        0xe180040c,    //....    DCD    3783263244
        0xe5830000,    //....    DCD    3850567680
        0xe5838000,    //....    DCD    3850600448
        0xe582a000,    //....    DCD    3850543104
        0xe0870581,    //....    DCD    3766945153
        0xe5820004,    //....    DCD    3850502148
        0xe5824008,    //.@..    DCD    3850518536
        0xe3a00001,    //....    DCD    3818913793
        0xe582000c,    //....    DCD    3850502156
        0xe3a00298,    //....    DCD    3818914456
        0xe5820010,    //....    DCD    3850502160
        0xe5920010,    //....    DCD    3851550736
        0xe3100009,    //....    DCD    3809476617
        0x0afffffc,    //....    DCD    184549372
        0xe5930010,    //....    DCD    3851616272
        0xe3100040,    //@...    DCD    3809476672
        0x0afffffc,    //....    DCD    184549372
        0xe583b010,    //....    DCD    3850612752
        0xe2811001,    //....    DCD    3800109057
        0xe3510040,    //@.Q.    DCD    3813736512
        0xbaffffdd,    //....    DCD    3137339357
        0xe1a04009,    //.@..    DCD    3785375753
        0xe3590030,    //0.Y.    DCD    3814260784
        0xbaffffc6,    //....    DCD    3137339334
        0xe59f102c,    //,...    DCD    3852406828
        0xe3a0000f,    //....    DCD    3818913807
        0xe5810008,    //....    DCD    3850436616
        0xe59f0004,    //....    DCD    3852402692
        0xe8bd4ffe,    //.O..    DCD    3904720894
        0xeaffff98,    //....    DCD    3942645656
        0x60100000,    //...`    DCD    1611661312
        0x00001e92,    //....    DCD    7826
        0x40008000,    //...@    DCD    1073774592
        0x00001c35,    //5...    DCD    7221
        0x4001c203,    //...@    DCD    1073857027
        0x000070ff,    //.p..    DCD    28927
        0x01000004,    //....    DCD    16777220
        0x50002000,    //. .P    DCD    1342185472
        0x40008004,    //...@    DCD    1073774596
        0x4000c000,    //...@    DCD    1073790976
        0x0b500800,    //..P.    DCD    189794304
        0x10002741,    //A'..    DCD    268445505
		#else
		#if 1 //shkim-20070404 : load 6MB image
		0xe59f00a8,    //0x00000000:   ....    DCD    3852402856
		0xe59f10a8,    //0x00000004:   ....    DCD    3852406952
		0xe59f20a8,    //0x00000008:   . ..    DCD    3852411048
		0xe59f30a8,    //0x0000000c:   .0..    DCD    3852415144
		0xe59f40a8,    //0x00000010:   .@..    DCD    3852419240
		0xe59f50a8,    //0x00000014:   .P..    DCD    3852423336
		0xe5805000,    //0x00000018:   .P..    DCD    3850391552
		0xe3a05024,    //0x0000001c:   $P..    DCD    3818934308
		0xe5845000,    //0x00000020:   .P..    DCD    3850653696
		0xe3a05e41,    //0x00000024:   A^..    DCD    3818937921
		0xe5835000,    //0x00000028:   .P..    DCD    3850588160
		0xe3a050a1,    //0x0000002c:   .P..    DCD    3818934433
		0xe5815000,    //0x00000030:   .P..    DCD    3850457088
		0xe3a0577c,    //0x00000034:   |W..    DCD    3818936188
		0xe5936000,    //0x00000038:   .`..    DCD    3851640832
		0xe0066005,    //0x0000003c:   .`..    DCD    3758514181
		0xe3560000,    //0x00000040:   ..V.    DCD    3814064128
		0x1afffffb,    //0x00000044:   ....    DCD    452984827
		0xee110f10,    //0x00000048:   ....    DCD    3994095376
		0xe3c00d40,    //0x0000004c:   @...    DCD    3821014336
		0xee010f10,    //0x00000050:   ....    DCD    3993046800
		0xee110f10,    //0x00000054:   ....    DCD    3994095376
		0xe3c00004,    //0x00000058:   ....    DCD    3821010948
		0xee010f10,    //0x0000005c:   ....    DCD    3993046800
		0xe3a00000,    //0x00000060:   ....    DCD    3818913792
		0xee070f17,    //0x00000064:   ....    DCD    3993440023
		0xee110f10,    //0x00000068:   ....    DCD    3994095376
		0xe3c00001,    //0x0000006c:   ....    DCD    3821010945
		0xee010f10,    //0x00000070:   ....    DCD    3993046800
		0xe3a00000,    //0x00000074:   ....    DCD    3818913792
		0xee080f17,    //0x00000078:   ....    DCD    3993505559
		0xeaffffff,    //0x0000007c:   ....    DCD    3942645759
		0xe3c000df,    //0x00000080:   ....    DCD    3821011167
		0xe3801013,    //0x00000084:   ....    DCD    3816820755
		0xe12ff001,    //0x00000088:   ../.    DCD    3778015233
		0xe3a0d462,    //0x0000008c:   b...    DCD    3818968162
		0xe10f0000,    //0x00000090:   ....    DCD    3775856640
		0xe3800080,    //0x00000094:   ....    DCD    3816816768
		0xe12ff000,    //0x00000098:   ../.    DCD    3778015232
		0xe10f0000,    //0x0000009c:   ....    DCD    3775856640
		0xe3800040,    //0x000000a0:   @...    DCD    3816816704
		0xe12ff000,    //0x000000a4:   ../.    DCD    3778015232
		0xeb000006,    //0x000000a8:   ....    DCD    3942645766
		0xe1a0f000,    //0x000000ac:   ....    DCD    3785420800
		0x40004000,    //0x000000b0:   .@.@    DCD    1073758208
		0x40004004,    //0x000000b4:   .@.@    DCD    1073758212
		0x40004008,    //0x000000b8:   .@.@    DCD    1073758216
		0x4000400c,    //0x000000bc:   .@.@    DCD    1073758220
		0x40004010,    //0x000000c0:   .@.@    DCD    1073758224
		0x00037535,    //0x000000c4:   5u..    DCD    226613
		0xe92d4ffe,    //0x000000c8:   .O-.    DCD    3912060926
		0xe59f0154,    //0x000000cc:   T...    DCD    3852403028
		0xe3a08b80,    //0x000000d0:   ....    DCD    3818949504
		0xe59f2150,    //0x000000d4:   P!..    DCD    3852411216
		0xe59f1150,    //0x000000d8:   P...    DCD    3852407120
		0xe58d0008,    //0x000000dc:   ....    DCD    3851223048
		0xe58d8004,    //0x000000e0:   ....    DCD    3851255812
		0xe5812008,    //0x000000e4:   . ..    DCD    3850444808
		0xe3a00000,    //0x000000e8:   ....    DCD    3818913792
		0xe59f2140,    //0x000000ec:   @!..    DCD    3852411200
		0xe581200c,    //0x000000f0:   . ..    DCD    3850444812
		0xe59f213c,    //0x000000f4:   <!..    DCD    3852411196
		0xe5812000,    //0x000000f8:   . ..    DCD    3850444800
		0xe59f2138,    //0x000000fc:   8!..    DCD    3852411192
		0xe5812000,    //0x00000100:   . ..    DCD    3850444800
		0xe5912010,    //0x00000104:   . ..    DCD    3851493392
		0xe3120740,    //0x00000108:   @...    DCD    3809609536
		0x0afffffc,    //0x0000010c:   ....    DCD    184549372
		0xe59f2128,    //0x00000110:   (!..    DCD    3852411176
		0xe1a03001,    //0x00000114:   .0..    DCD    3785371649
		0xe5812010,    //0x00000118:   . ..    DCD    3850444816
		0xe1a01a00,    //0x0000011c:   ....    DCD    3785366016
		0xe1a0ee21,    //0x00000120:   !...    DCD    3785420321
		0xe3a04000,    //0x00000124:   .@..    DCD    3818930176
		0xe200c0ff,    //0x00000128:   ....    DCD    3791700223
		0xe59f1110,    //0x0000012c:   ....    DCD    3852407056
		0xe2849001,    //0x00000130:   ....    DCD    3800338433
		0xe1a05809,    //0x00000134:   .X..    DCD    3785381897
		0xe5910004,    //0x00000138:   ....    DCD    3851485188
		0xe1a05825,    //0x0000013c:   %X..    DCD    3785381925
		0xe1800404,    //0x00000140:   ....    DCD    3783263236
		0xe5810008,    //0x00000144:   ....    DCD    3850436616
		0xe1a02b05,    //0x00000148:   .+..    DCD    3785370373
		0xe1a00525,    //0x0000014c:   %...    DCD    3785360677
		0xe2056003,    //0x00000150:   .`..    DCD    3792003075
		0xe59d5008,    //0x00000154:   .P..    DCD    3852292104
		0xe59d8004,    //0x00000158:   ....    DCD    3852304388
		0xe1a02c22,    //0x0000015c:   ",..    DCD    3785370658
		0xe1820400,    //0x00000160:   ....    DCD    3783394304
		0xe59f20e0,    //0x00000164:   . ..    DCD    3852411104
		0xe59fa0d8,    //0x00000168:   ....    DCD    3852443864
		0xe0275498,    //0x0000016c:   .T'.    DCD    3760673944
		0xe38089c0,    //0x00000170:   ....    DCD    3816851904
		0xe3a01000,    //0x00000174:   ....    DCD    3818917888
		0xe3a0b044,    //0x00000178:   D...    DCD    3818958916
		0xe201003f,    //0x0000017c:   ?...    DCD    3791716415
		0xe1805306,    //0x00000180:   .S..    DCD    3783283462
		0xe3a0000f,    //0x00000184:   ....    DCD    3818913807
		0xe59f40c0,    //0x00000188:   .@..    DCD    3852419264
		0xe5820010,    //0x0000018c:   ....    DCD    3850502160
		0xe3a00040,    //0x00000190:   @...    DCD    3818913856
		0xe5830010,    //0x00000194:   ....    DCD    3850567696
		0xe3a00d71,    //0x00000198:   q...    DCD    3818917233
		0xe583000c,    //0x0000019c:   ....    DCD    3850567692
		0xe59f00ac,    //0x000001a0:   ....    DCD    3852402860
		0xe5830000,    //0x000001a4:   ....    DCD    3850567680
		0xe1a00c05,    //0x000001a8:   ....    DCD    3785362437
		0xe180080e,    //0x000001ac:   ....    DCD    3783264270
		0xe180040c,    //0x000001b0:   ....    DCD    3783263244
		0xe5830000,    //0x000001b4:   ....    DCD    3850567680
		0xe5838000,    //0x000001b8:   ....    DCD    3850600448
		0xe582a000,    //0x000001bc:   ....    DCD    3850543104
		0xe0870581,    //0x000001c0:   ....    DCD    3766945153
		0xe5820004,    //0x000001c4:   ....    DCD    3850502148
		0xe5824008,    //0x000001c8:   .@..    DCD    3850518536
		0xe3a00001,    //0x000001cc:   ....    DCD    3818913793
		0xe582000c,    //0x000001d0:   ....    DCD    3850502156
		0xe3a00298,    //0x000001d4:   ....    DCD    3818914456
		0xe5820010,    //0x000001d8:   ....    DCD    3850502160
		0xe5920010,    //0x000001dc:   ....    DCD    3851550736
		0xe3100009,    //0x000001e0:   ....    DCD    3809476617
		0x0afffffc,    //0x000001e4:   ....    DCD    184549372
		0xe5930010,    //0x000001e8:   ....    DCD    3851616272
		0xe3100040,    //0x000001ec:   @...    DCD    3809476672
		0x0afffffc,    //0x000001f0:   ....    DCD    184549372
		0xe583b010,    //0x000001f4:   ....    DCD    3850612752
		0xe2811001,    //0x000001f8:   ....    DCD    3800109057
		0xe3510040,    //0x000001fc:   @.Q.    DCD    3813736512
		0xbaffffdd,    //0x00000200:   ....    DCD    3137339357
		0xe1a04009,    //0x00000204:   .@..    DCD    3785375753
		0xe3590030,    //0x00000208:   0.Y.    DCD    3814260784
		0xbaffffc6,    //0x0000020c:   ....    DCD    3137339334
		0xe59f102c,    //0x00000210:   ,...    DCD    3852406828
		0xe3a0000f,    //0x00000214:   ....    DCD    3818913807
		0xe5810008,    //0x00000218:   ....    DCD    3850436616
		0xe59f0004,    //0x0000021c:   ....    DCD    3852402692
		0xe8bd4ffe,    //0x00000220:   .O..    DCD    3904720894
		0xeaffffa0,    //0x00000224:   ....    DCD    3942645664
		0x60100000,    //0x00000228:   ...`    DCD    1611661312
		0x00001e92,    //0x0000022c:   ....    DCD    7826
		0x40008000,    //0x00000230:   ...@    DCD    1073774592
		0x00001c35,    //0x00000234:   5...    DCD    7221
		0x4001c203,    //0x00000238:   ...@    DCD    1073857027
		0x000070ff,    //0x0000023c:   .p..    DCD    28927
		0x01000004,    //0x00000240:   ....    DCD    16777220
		0x50002000,    //0x00000244:   . .P    DCD    1342185472
		0x40008004,    //0x00000248:   ...@    DCD    1073774596
		0x4000c000,    //0x0000024c:   ...@    DCD    1073790976
		0x0b500800,    //0x00000250:   ..P.    DCD    189794304
		0x10002741,    //0x00000254:   A'..    DCD    268445505
		#endif
		#endif
};

#endif             
                                                                                                                                                       
                                                                                                                                                       
