/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */
#define  __GCC_ARM__  1
#include "sysinc.h"
#include "Commonmacro.h"
//#include "gpio.h"
//#include "uart.h"
//#include "dmac.h"
#include "rec.h"	//[mhshin] for test
#define CHECK_READY while( ( SMT_READ(SEIP_RST) & 0x80 )==0 ){;}
#define SEIP_WRITE(addr, data)   (*(unsigned short *)( SEIP_BASEADDR + (addr)) = ((unsigned short)(data)));
#define SEIP_READ(addr)          (*(unsigned short *)( SEIP_BASEADDR + (addr)))

#if 1
#define REC_BUFF_SIZE (32000*2)  // 3 sec 
#else
#define REC_BUFF_SIZE (32000 / 3)  //0.5sec 
#endif
int RecCount = 0;
unsigned int RecBuffer[ REC_BUFF_SIZE ];

/*/////////////////////////////////////////////////////////
        FUNCTION
///////////////////////////////////////////////////////// */
//------------------------------------------------------
// Delay
//-------------------------------------------------------
volatile int cnt;
void delay(int _cnt)
{
    cnt = _cnt;
    while(cnt) cnt--;
}
const unsigned short InitSEIP_Parameter[315][2]=
{
{0x0300,0x007e},
{0x0302,0x5e7f},
{0x0304,0x5f7f},
{0x0306,0x004d},
{0x0308,0x005b},
{0x030a,0x006d},
{0x030c,0x007f},
{0x030e,0x0010},
{0x0310,0x002e},
{0x0312,0x006a},
{0x0314,0x007f},
{0x0316,0x6170},
{0x0318,0x756e},
{0x031a,0x6251},
{0x031c,0x0000},
{0x031e,0x7900},
{0x0320,0x0004},
{0x0322,0x0000},
{0x0324,0x001a},
{0x0326,0x7225},
{0x0328,0x0000},
{0x032a,0x0000},
{0x032c,0x6300},
{0x032e,0x021d},
{0x0330,0x0000},
{0x0332,0x4000},
{0x0334,0x0050},
{0x0336,0x7b74},
{0x0338,0x777f},
{0x033a,0x5000},
{0x033c,0x6874},
{0x033e,0x0069},
{0x0340,0x0000},
{0x0342,0x7c00},
{0x0344,0x72c4},
{0x0346,0x0041},
{0x0348,0x7fc4},
{0x034a,0x7c40},
{0x034c,0x0040},
{0x034e,0x200f},
{0x0350,0x1120},
{0x0352,0x2101},
{0x0354,0x0120},
{0x0356,0x007a},
{0x0358,0x2020},
{0x035a,0x200e},
{0x035c,0x0d20},
{0x035e,0x2200},
{0x0360,0x007e},
{0x0362,0x0000},
{0x0364,0x7f00},
{0x0366,0x7fc9},
{0x0368,0x0040},
{0x036a,0x77c5},
{0x036c,0x7a41},
{0x036e,0x0046},
{0x0370,0x1e2a},
{0x0372,0x2a06},
{0x0374,0x2010},
{0x0376,0x3320},
{0x0378,0x0153},
{0x037a,0x1320},
{0x037c,0x2020},
{0x037e,0x0424},
{0x0380,0x0928},
{0x0382,0x005f},
{0x0384,0x007f},
{0x0386,0x002e},
{0x0388,0x005c},
{0x038a,0x006e},
{0x038c,0x007f},
{0x038e,0x7f00},
{0x0200,0x0802},////////////
{0x0202,0x0800},
{0x0204,0x0898},
{0x0206,0x0804},
{0x0208,0x093f},
{0x020a,0x089b},
{0x020c,0x09ad},
{0x020e,0x0941},
{0x0210,0x0bc5},
{0x0212,0x09af},
{0x0214,0x1585},
{0x0216,0x0bc7},
{0x0218,0x1869},
{0x021a,0x1585},
{0x021c,0x2311},
{0x021e,0x186b},
{0x0220,0x2622},
{0x0222,0x2312},
{0x0224,0x31b4},
{0x0226,0x2624},
{0x0228,0x347e},
{0x022a,0x31b6},
{0x022c,0x3fff},
{0x022e,0x3480},
{0x0230,0x0c08},
{0x0232,0x2080},
{0x0234,0x2f80},
{0x0236,0x3680},
{0x0238,0x1380},
{0x023a,0x1980},
{0x023c,0x2800},
{0x023e,0x3d80},
{0x0280,0x4802},
{0x0282,0x4800},
{0x0284,0x4898},
{0x0286,0x4804},
{0x0288,0x493f},
{0x028a,0x489a},
{0x028c,0x49ad},
{0x028e,0x4940},
{0x0290,0x4bc7},
{0x0292,0x49af},
{0x0294,0x5585},
{0x0296,0x4bc7},
{0x0298,0x5868},
{0x029a,0x5585},
{0x029c,0x6311},
{0x029e,0x586b},
{0x02a0,0x6622},
{0x02a2,0x6312},
{0x02a4,0x71b4},
{0x02a6,0x6624},
{0x02a8,0x747e},
{0x02aa,0x71b6},
{0x02ac,0x7ff2},
{0x02ae,0x747f},
{0x02b0,0x4c03},
{0x02b2,0x6080},
{0x02b4,0x6f62},
{0x02b6,0x761e},
{0x02b8,0x5380},
{0x02ba,0x59a5},
{0x02bc,0x681d},
{0x02be,0x7e7f},
{0x03c8,0x0001},
{0x03d4,0xa66f},
{0x03d6,0x8001},
{0x03d8,0xdfe1},
{0x03da,0xfaa6},
{0x03d2,0x4000},
{0x0300,0x007e},/////////////////
{0x0302,0x5e7f},
{0x0304,0x5f7f},
{0x0306,0x004d},
{0x0308,0x005b},
{0x030a,0x006d},
{0x030c,0x007f},
{0x030e,0x0010},
{0x0310,0x002e},
{0x0312,0x006a},
{0x0314,0x007f},
{0x0316,0x6170},
{0x0318,0x756e},
{0x031a,0x6251},
{0x031c,0x0000},
{0x031e,0x7900},
{0x0320,0x0004},
{0x0322,0x0000},
{0x0324,0x001a},
{0x0326,0x7225},
{0x0328,0x0000},
{0x032a,0x0000},
{0x032c,0x6300},
{0x032e,0x021d},
{0x0330,0x0000},
{0x0332,0x4000},
{0x0334,0x0050},
{0x0336,0x7b74},
{0x0338,0x777f},
{0x033a,0x5000},
{0x033c,0x6874},
{0x033e,0x0069},
{0x0340,0x0000},
{0x0342,0x7c00},
{0x0344,0x72c4},
{0x0346,0x0041},
{0x0348,0x7fc4},
{0x034a,0x7c40},
{0x034c,0x0040},
{0x034e,0x200f},
{0x0350,0x1120},
{0x0352,0x2101},
{0x0354,0x0120},
{0x0356,0x007a},
{0x0358,0x2020},
{0x035a,0x200e},
{0x035c,0x0d20},
{0x035e,0x2200},
{0x0360,0x007e},
{0x0362,0x0000},
{0x0364,0x7f00},
{0x0366,0x7fc9},
{0x0368,0x0040},
{0x036a,0x77c5},
{0x036c,0x7a41},
{0x036e,0x0046},
{0x0370,0x1e2a},
{0x0372,0x2a06},
{0x0374,0x2010},
{0x0376,0x3320},
{0x0378,0x0153},
{0x037a,0x1320},
{0x037c,0x2020},
{0x037e,0x0424},
{0x0380,0x0928},
{0x0382,0x005f},
{0x0384,0x007f},
{0x0386,0x002e},
{0x0388,0x005c},
{0x038a,0x006e},
{0x038c,0x007f},
{0x038e,0x7f00},
{0x0200,0x0802},
{0x0202,0x0800},
{0x0204,0x0898},
{0x0206,0x0804},
{0x0208,0x093f},
{0x020a,0x089b},
{0x020c,0x09ad},
{0x020e,0x0941},
{0x0210,0x0bc5},
{0x0212,0x09af},
{0x0214,0x1585},
{0x0216,0x0bc7},
{0x0218,0x1869},
{0x021a,0x1585},
{0x021c,0x2311},
{0x021e,0x186b},
{0x0220,0x2622},
{0x0222,0x2312},
{0x0224,0x31b4},
{0x0226,0x2624},
{0x0228,0x347e},
{0x022a,0x31b6},
{0x022c,0x3fff},
{0x022e,0x3480},
{0x0230,0x0c08},
{0x0232,0x2080},
{0x0234,0x2f80},
{0x0236,0x3680},
{0x0238,0x1380},
{0x023a,0x1980},
{0x023c,0x2800},
{0x023e,0x3d80},
{0x0280,0x4802},
{0x0282,0x4800},
{0x0284,0x4898},
{0x0286,0x4804},
{0x0288,0x493f},
{0x028a,0x489a},
{0x028c,0x49ad},
{0x028e,0x4940},
{0x0290,0x4bc7},
{0x0292,0x49af},
{0x0294,0x5585},
{0x0296,0x4bc7},
{0x0298,0x5868},
{0x029a,0x5585},
{0x029c,0x6311},
{0x029e,0x586b},
{0x02a0,0x6622},
{0x02a2,0x6312},
{0x02a4,0x71b4},
{0x02a6,0x6624},
{0x02a8,0x747e},
{0x02aa,0x71b6},
{0x02ac,0x7ff2},
{0x02ae,0x747f},
{0x02b0,0x4c03},
{0x02b2,0x6080},
{0x02b4,0x6f62},
{0x02b6,0x761e},
{0x02b8,0x5380},
{0x02ba,0x59a5},
{0x02bc,0x681d},
{0x02be,0x7e7f},
{0x03c8,0x0001},
{0x03d4,0xa66f},
{0x03d6,0x8001},
{0x03d8,0xdfe1},
{0x03da,0xfaa6},
{0x03d2,0x4000},
{0x0400,0x0000},
{0x0402,0x0006},
{0x0404,0x0001},
{0x0406,0x0a3c},
{0x0408,0x9d95},
{0x040a,0x787f},
{0x040c,0x650d},
{0x040e,0x0000},
{0x0800,0x0000}, ///////
{0x0802,0x0000},
{0x0804,0x0000},
{0x0806,0x07e3},
{0x0808,0x035a},
{0x080a,0x07ff},
{0x080c,0x0076},
{0x080e,0x0000},
{0x0c00,0x0000},
{0x0c02,0x0000},
{0x0c04,0x0000},
{0x0c06,0x0481},
{0x0c08,0x06fd},
{0x0c0a,0x0000},
{0x0c0c,0x0710},
{0x0c0e,0x06e0},
//{0x0c0e,0x0000},
{0x0000,0x001d},///////////
{0x0002,0x009f},
{0x0004,0x000f},
{0x0020,0x0000},/////////////
{0x0022,0x0000},
{0x0024,0x0000},
{0x0026,0x0000},
};

void InitSEIP()
{
    int i;
    SMT_WRITE(RS_SEIPMUX, 0x03);        // Wave ROM/Internal SRAM Owner : SEIP
    SMT_WRITE( SEIP_ADMCK, 0x80 + 12 ); //ADC MCLK Set *256

    SMT_WRITE(SEIP_RST,0x00000000 ); //SEIP Reset
    delay(10000);
    SMT_WRITE(SEIP_RST,0x00000001 );

    for( i=0; i<315; i++ ){
        CHECK_READY;
        SEIP_WRITE( InitSEIP_Parameter[i][0],InitSEIP_Parameter[i][1] );
    }
}

void NoteOn()
{
	SEIP_WRITE( 0x0020,0x0001 );
}
void NoteOff()
{
	SEIP_WRITE( 0x0020,0x0000 );
}
extern  const unsigned sounddata[];
void PlaySoundData_NotUseDMA()
{
    int i;
    char uart_input;

    for( i=0; i<262120; i++ ){

        while( (SMT_READ(SEIP_RXSTS) & 0x00000200) ){;}
        SMT_WRITE(SEIP_RXDAT, sounddata[i] );
		smt2UARTDataValid(CFG_UART_CH, &uart_input);
		if(uart_input)
        {
            smt2UARTGetCh(CFG_UART_CH, &uart_input, 0);
            if(uart_input == '0')
                break;
        }
    }
}
void Rec_NotUseDMA()
{
	int i;
    char uart_input;
    unsigned int data;
    
    RecCount = 0;
    for( i=0; i<REC_BUFF_SIZE; i++ ){

        while( (SMT_READ(SEIP_TXSTS) & 0x00000100) ){;}
        //DPRINTF("RecData\n");
        
        data = SMT_READ(SEIP_TXDAT);
        RecBuffer[i] = data;
        RecCount = i;
         
		smt2UARTDataValid(CFG_UART_CH, &uart_input);
		if(uart_input)
        {
            smt2UARTGetCh(CFG_UART_CH, &uart_input, 0);
            if(uart_input == '0')
                break;
        }
    }
}
void Play_RecData_NotUseDMA()
{
    int i;
    char uart_input;
	
    for( i=0; i<RecCount; i++ ){

        while( (SMT_READ(SEIP_RXSTS) & 0x00000200) ){;}
        SMT_WRITE(SEIP_RXDAT, RecBuffer[i] );
		smt2UARTDataValid(CFG_UART_CH, &uart_input);
		if(uart_input)
        {
            smt2UARTGetCh(CFG_UART_CH, &uart_input, 0);
            if(uart_input == '0')
                break;
        }
    }
}


