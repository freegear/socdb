/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File name	: gps.h
	Description	: gps header file of SDI v5
	Created by	: SHMT SOC Team
-----------------------------------------------------------*/
#ifndef	__GPS_H__
#define	__GPS_H__

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */

// Edit your code

#endif /* __GPS_H__ */
