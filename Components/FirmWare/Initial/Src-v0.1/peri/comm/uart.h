/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File name		: uart.h
	Description	: 
----------------------------------------------------------*/
#ifndef __UART_H__
#define __UART_H__
/*/////////////////////////////////////////////////////////
	INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"
#include "structdef.h"
#include "commonmacro.h"

/*/////////////////////////////////////////////////////////
	DEFINITION
///////////////////////////////////////////////////////// */

/*/////////////////////////////////////////////////////////
	FUNCTION DECLARATION
///////////////////////////////////////////////////////// */
smtUint32 UARTTest(void);
#endif/* __UART_H__ */

