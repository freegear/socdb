/*----------------------------------------------------------
	 SkyWalker for Navigation
	 Developed by S/W Team, SHMT.Co
	 Copyright @ 2006 SHMT. Co
	 All Rights Reserved.
----------------------------------------------------------*/
/*----------------------------------------------------------
	File Name	: pll.h
	Description	: pll header file of SDI v5
	Created by	: SHMT SOC Team
-----------------------------------------------------------*/
#ifndef	__PLL_H__
#define	__PLL_H__

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */
#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */

// Edit your code

#endif /* __PLL_H__ */
