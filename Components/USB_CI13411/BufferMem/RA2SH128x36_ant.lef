MACRO RA2SH128x36
  PIN AA[0]
    AntennaGateArea  0.039 ;
  END AA[0]
  PIN AA[1]
    AntennaGateArea  0.039 ;
  END AA[1]
  PIN AA[2]
    AntennaGateArea  0.039 ;
  END AA[2]
  PIN AA[3]
    AntennaGateArea  0.039 ;
  END AA[3]
  PIN AA[4]
    AntennaGateArea  0.039 ;
  END AA[4]
  PIN AA[5]
    AntennaGateArea  0.039 ;
  END AA[5]
  PIN AA[6]
    AntennaGateArea  0.039 ;
  END AA[6]
  PIN AB[0]
    AntennaGateArea  0.039 ;
  END AB[0]
  PIN AB[1]
    AntennaGateArea  0.039 ;
  END AB[1]
  PIN AB[2]
    AntennaGateArea  0.039 ;
  END AB[2]
  PIN AB[3]
    AntennaGateArea  0.039 ;
  END AB[3]
  PIN AB[4]
    AntennaGateArea  0.039 ;
  END AB[4]
  PIN AB[5]
    AntennaGateArea  0.039 ;
  END AB[5]
  PIN AB[6]
    AntennaGateArea  0.039 ;
  END AB[6]
  PIN CENA
    AntennaGateArea  0.039 ;
  END CENA
  PIN CENB
    AntennaGateArea  0.039 ;
  END CENB
  PIN CLKA
    AntennaGateArea  0.039 ;
  END CLKA
  PIN CLKB
    AntennaGateArea  0.039 ;
  END CLKB
  PIN DA[0]
    AntennaGateArea  0.039 ;
  END DA[0]
  PIN DA[10]
    AntennaGateArea  0.039 ;
  END DA[10]
  PIN DA[11]
    AntennaGateArea  0.039 ;
  END DA[11]
  PIN DA[12]
    AntennaGateArea  0.039 ;
  END DA[12]
  PIN DA[13]
    AntennaGateArea  0.039 ;
  END DA[13]
  PIN DA[14]
    AntennaGateArea  0.039 ;
  END DA[14]
  PIN DA[15]
    AntennaGateArea  0.039 ;
  END DA[15]
  PIN DA[16]
    AntennaGateArea  0.039 ;
  END DA[16]
  PIN DA[17]
    AntennaGateArea  0.039 ;
  END DA[17]
  PIN DA[18]
    AntennaGateArea  0.039 ;
  END DA[18]
  PIN DA[19]
    AntennaGateArea  0.039 ;
  END DA[19]
  PIN DA[1]
    AntennaGateArea  0.039 ;
  END DA[1]
  PIN DA[20]
    AntennaGateArea  0.039 ;
  END DA[20]
  PIN DA[21]
    AntennaGateArea  0.039 ;
  END DA[21]
  PIN DA[22]
    AntennaGateArea  0.039 ;
  END DA[22]
  PIN DA[23]
    AntennaGateArea  0.039 ;
  END DA[23]
  PIN DA[24]
    AntennaGateArea  0.039 ;
  END DA[24]
  PIN DA[25]
    AntennaGateArea  0.039 ;
  END DA[25]
  PIN DA[26]
    AntennaGateArea  0.039 ;
  END DA[26]
  PIN DA[27]
    AntennaGateArea  0.039 ;
  END DA[27]
  PIN DA[28]
    AntennaGateArea  0.039 ;
  END DA[28]
  PIN DA[29]
    AntennaGateArea  0.039 ;
  END DA[29]
  PIN DA[2]
    AntennaGateArea  0.039 ;
  END DA[2]
  PIN DA[30]
    AntennaGateArea  0.039 ;
  END DA[30]
  PIN DA[31]
    AntennaGateArea  0.039 ;
  END DA[31]
  PIN DA[32]
    AntennaGateArea  0.039 ;
  END DA[32]
  PIN DA[33]
    AntennaGateArea  0.039 ;
  END DA[33]
  PIN DA[34]
    AntennaGateArea  0.039 ;
  END DA[34]
  PIN DA[35]
    AntennaGateArea  0.039 ;
  END DA[35]
  PIN DA[3]
    AntennaGateArea  0.039 ;
  END DA[3]
  PIN DA[4]
    AntennaGateArea  0.039 ;
  END DA[4]
  PIN DA[5]
    AntennaGateArea  0.039 ;
  END DA[5]
  PIN DA[6]
    AntennaGateArea  0.039 ;
  END DA[6]
  PIN DA[7]
    AntennaGateArea  0.039 ;
  END DA[7]
  PIN DA[8]
    AntennaGateArea  0.039 ;
  END DA[8]
  PIN DA[9]
    AntennaGateArea  0.039 ;
  END DA[9]
  PIN DB[0]
    AntennaGateArea  0.039 ;
  END DB[0]
  PIN DB[10]
    AntennaGateArea  0.039 ;
  END DB[10]
  PIN DB[11]
    AntennaGateArea  0.039 ;
  END DB[11]
  PIN DB[12]
    AntennaGateArea  0.039 ;
  END DB[12]
  PIN DB[13]
    AntennaGateArea  0.039 ;
  END DB[13]
  PIN DB[14]
    AntennaGateArea  0.039 ;
  END DB[14]
  PIN DB[15]
    AntennaGateArea  0.039 ;
  END DB[15]
  PIN DB[16]
    AntennaGateArea  0.039 ;
  END DB[16]
  PIN DB[17]
    AntennaGateArea  0.039 ;
  END DB[17]
  PIN DB[18]
    AntennaGateArea  0.039 ;
  END DB[18]
  PIN DB[19]
    AntennaGateArea  0.039 ;
  END DB[19]
  PIN DB[1]
    AntennaGateArea  0.039 ;
  END DB[1]
  PIN DB[20]
    AntennaGateArea  0.039 ;
  END DB[20]
  PIN DB[21]
    AntennaGateArea  0.039 ;
  END DB[21]
  PIN DB[22]
    AntennaGateArea  0.039 ;
  END DB[22]
  PIN DB[23]
    AntennaGateArea  0.039 ;
  END DB[23]
  PIN DB[24]
    AntennaGateArea  0.039 ;
  END DB[24]
  PIN DB[25]
    AntennaGateArea  0.039 ;
  END DB[25]
  PIN DB[26]
    AntennaGateArea  0.039 ;
  END DB[26]
  PIN DB[27]
    AntennaGateArea  0.039 ;
  END DB[27]
  PIN DB[28]
    AntennaGateArea  0.039 ;
  END DB[28]
  PIN DB[29]
    AntennaGateArea  0.039 ;
  END DB[29]
  PIN DB[2]
    AntennaGateArea  0.039 ;
  END DB[2]
  PIN DB[30]
    AntennaGateArea  0.039 ;
  END DB[30]
  PIN DB[31]
    AntennaGateArea  0.039 ;
  END DB[31]
  PIN DB[32]
    AntennaGateArea  0.039 ;
  END DB[32]
  PIN DB[33]
    AntennaGateArea  0.039 ;
  END DB[33]
  PIN DB[34]
    AntennaGateArea  0.039 ;
  END DB[34]
  PIN DB[35]
    AntennaGateArea  0.039 ;
  END DB[35]
  PIN DB[3]
    AntennaGateArea  0.039 ;
  END DB[3]
  PIN DB[4]
    AntennaGateArea  0.039 ;
  END DB[4]
  PIN DB[5]
    AntennaGateArea  0.039 ;
  END DB[5]
  PIN DB[6]
    AntennaGateArea  0.039 ;
  END DB[6]
  PIN DB[7]
    AntennaGateArea  0.039 ;
  END DB[7]
  PIN DB[8]
    AntennaGateArea  0.039 ;
  END DB[8]
  PIN DB[9]
    AntennaGateArea  0.039 ;
  END DB[9]
  PIN WENA
    AntennaGateArea  0.039 ;
  END WENA
  PIN WENB
    AntennaGateArea  0.039 ;
  END WENB
END RA2SH128x36
