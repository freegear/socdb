* 
* Copyright 2007 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.3f
* Version: 2005Q2V1
* Name: SRAM-DP-HS SRAM Generator|TSMC CL013G Process
* Comment: 
* Configuration:  -instname RA2SH128x36 -words 128 -bits 36 -freque\
* Configuration: ncy 100 -ring_width 4 -mux 4 -drive 6 -write_mask \
* Configuration: off -wp_size 8 -top_layer met6 -power_type rings -\
* Configuration: horiz met3 -vert met2 -cust_comment "" -left_bus_d\
* Configuration: elim "[" -right_bus_delim "]" -pwr_gnd_rename "VDD\
* Configuration: :VDD,GND:VSS" -prefix "" -pin_space 0.0 -name_case\
* Configuration:  upper -check_instname on -diodes on -inside_ring_\
* Configuration: type GND
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA2SH128x36FCBWM4 BWEN BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWM4: 2 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS D DN 0.2116P 1.84U
.ENDS RA2SH128x36FCBWM4
****
.SUBCKT RA2SH128x36FCBWM4A BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWM4A: 2 flat devices **
XI0_0 BWENA BWENA BWENB D Q VSS VDD RA2SH128x36FCBWM4
.ENDS RA2SH128x36FCBWM4A
****
.SUBCKT RA2SH128x36FCBWM4B BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWM4B: 2 flat devices **
XI0_0 BWENB BWENA BWENB D Q VSS VDD RA2SH128x36FCBWM4
.ENDS RA2SH128x36FCBWM4B
****
.SUBCKT RA2SH128x36IO4 BWE BWEN D DPN DPU DW DW_ GTP2 GTPA GTPB OEA_ OEB_ OE_
+  Q SP STUBWEA STUBWEB STUBWEIA STUBWEIB WE WEA WEB VSS VDD
** RA2SH128x36IO4: 58 flat devices **
m1 QI DPU VSS VSS N L=0.13U W=1.25U
m10 QPD OEI_ VSS VSS N L=0.13U W=0.26U
m11 QIL QI VDD VDD P L=0.13U W=0.33U
m12 QIL QI VSS VSS N L=0.13U W=0.26U
m13 SPN SP VDD VDD P L=0.13U W=0.17U
m14 SPN SP VSS VSS N L=0.13U W=0.15U
m15 DWPD GTPND DWI VSS N L=0.13U W=0.38U
m16 DWPD DW VDD VDD P L=0.2U W=0.15U
m17 DWPD DW VSS VSS N L=0.45U W=0.15U
m18 DWPD GTP2 DWI VDD P L=0.13U W=0.48U
m19 DW_PU GTPND DNWI VSS N L=0.13U W=0.38U
m2 QI DPN VDD VDD P L=0.13U W=2.4U
m20 DW_PU GTP2 DNWI VDD P L=0.13U W=0.48U
m21 GTPND GTP2 VDD VDD P L=0.13U W=0.2U
m22 GTPND GTP2 VSS VSS N L=0.13U W=0.19U
m23 DI N56 VDD VDD P L=0.13U W=0.64U
m24 DI N56 VSS VSS N L=0.13U W=0.43U
m25 DNN DI VDD VDD P L=0.13U W=0.47U
m26 DNN DI VSS VSS N L=0.13U W=0.31U
m27 WEI N61 VDD VDD P L=0.13U W=0.55U
m28 WEI N61 VSS VSS N L=0.13U W=0.44U
m29 OEI OEI_ VDD VDD P L=0.13U W=0.3U
m3 Q QPU VDD VDD P L=0.13U W=3.94U
m30 OEI OEI_ VSS VSS N L=0.13U W=0.21U
m31 QI SP N87 VDD P L=0.13U W=0.72U
m32 N87 QIL VDD VDD P L=0.13U W=0.72U
m33 QI SPN N86 VSS N L=0.13U W=0.72U
m34 N86 QIL VSS VSS N L=0.13U W=0.72U
m35 N43 OE_ VDD VDD P L=0.13U W=0.22U
m36 N43 OE_ VSS VSS N L=0.13U W=0.15U
m37 N61 WE VDD VDD P L=0.13U W=0.23U
m38 N61 WE VSS VSS N L=0.13U W=0.15U
m39 DWI WEI VDD VDD P L=0.13U W=0.76U
m4 Q QPD VSS VSS N L=0.13U W=2.52U
m40 N88 WEI VSS VSS N L=0.13U W=0.93U
m41 DWI DI VDD VDD P L=0.13U W=0.76U
m42 DWI DI N88 VSS N L=0.13U W=0.93U
m43 DNWI WEI VDD VDD P L=0.13U W=0.76U
m44 N89 WEI VSS VSS N L=0.13U W=0.93U
m45 DNWI DNN VDD VDD P L=0.13U W=0.76U
m46 DNWI DNN N89 VSS N L=0.13U W=0.93U
m47 N56 D VDD VDD P L=0.13U W=0.23U
m48 N56 D VSS VSS N L=0.13U W=0.15U
m49 QPU OEI_ QI VDD P L=0.13U W=0.15U
m5 OEI_ N43 VDD VDD P L=0.13U W=0.7U
m50 QPD OEI QI VSS N L=0.13U W=0.17U
m51 DW DWPD VDD VDD P L=0.13U W=3.14U
m52 DW DWPD VSS VSS N L=0.13U W=2.12U
m53 DW_PU DW_ VDD VDD P L=0.2U W=0.15U
m54 DW_PU DW_ VSS VSS N L=0.45U W=0.15U
m55 DW_ DW_PU VDD VDD P L=0.13U W=3.14U
m56 DW_ DW_PU VSS VSS N L=0.13U W=2.12U
m57 BWE BWEN VDD VDD P L=0.13U W=0.7U
m58 BWE BWEN VSS VSS N L=0.13U W=0.48U
m6 OEI_ N43 VSS VSS N L=0.13U W=0.48U
m7 QPD OEI_ QI VDD P L=0.13U W=1.78U
m8 QPU OEI QI VSS N L=0.13U W=1.18U
m9 QPU OEI VDD VDD P L=0.13U W=0.47U
.ENDS RA2SH128x36IO4
****
.SUBCKT RA2SH128x36IOXX_A D DPN DPU DW DW_ GTPA GTPB OEA_ OEB_ Q SP STUBWEIA
+  STUBWEIB VSS VDD
** RA2SH128x36IOXX_A: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTPA GTPA GTPB OEA_ OEB_ OEA_ Q SP STUBWEIA
+  STUBWEIB STUBWEIA STUBWEIB STUBWEIA STUBWEIA STUBWEIB VSS VDD
+  RA2SH128x36IO4
.ENDS RA2SH128x36IOXX_A
****
.SUBCKT RA2SH128x36IOXX_B D DPN DPU DW DW_ GTPA GTPB OEA_ OEB_ Q SP STUBWEIA
+  STUBWEIB VSS VDD
** RA2SH128x36IOXX_B: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTPB GTPA GTPB OEA_ OEB_ OEB_ Q SP STUBWEIA
+  STUBWEIB STUBWEIA STUBWEIB STUBWEIB STUBWEIA STUBWEIB VSS VDD
+  RA2SH128x36IO4
.ENDS RA2SH128x36IOXX_B
****
.SUBCKT RA2SH128x36SA4 DPN DPU DR DR_ DW DW_ GTP GTPA GTPB SP VSS VDD
** RA2SH128x36SA4: 41 flat devices **
m1 N23 SRCD VSS VSS N L=0.13U W=1.07U
m10 DPN SDN VDD VDD P L=0.13U W=0.81U
m11 DPN SDN VSS VSS N L=0.13U W=2.06U
m12 SP SPN VDD VDD P L=0.13U W=0.95U
m13 SP SPN VSS VSS N L=0.13U W=0.78U
m14 GTPN GTP VDD VDD P L=0.13U W=0.3U
m15 GTPN GTP VSS VSS N L=0.13U W=0.17U
m16 ND1 GTPN VDD VDD P L=0.13U W=0.2U
m17 ND1 GTPN VSS VSS N L=0.13U W=0.16U
m18 ND2 ND1 VDD VDD P L=0.13U W=0.68U
m19 ND2 ND1 VSS VSS N L=0.13U W=0.4U
m2 SD SP DR VDD P L=0.13U W=1.65U
m20 N41 DRP VSS VSS N L=0.13U W=0.6U
m21 SPN GTPN N41 VSS N L=0.13U W=0.41U
m22 SPN DRP VDD VDD P L=0.13U W=0.4U
m23 SPN GTPN VDD VDD P L=0.13U W=0.24U
m24 DRP ND2 VDD VDD P L=0.13U W=1.47U
m25 DRP ND2 VSS VSS N L=0.13U W=1.35U
m26 DR_ DRP VDD VDD P L=0.13U W=2.58U
m27 DR DRP VDD VDD P L=0.13U W=2.58U
m28 DR DRP DR_ VDD P L=0.13U W=3.3U
m29 SD_ SD SRC VSS N L=0.19U W=1.8U
m3 SD_ SP DR_ VDD P L=0.13U W=1.65U
m30 SD SD_ SRC VSS N L=0.19U W=1.8U
m31 SD_ SD SRC VSS N L=0.19U W=1.8U
m32 SD SD_ SRC VSS N L=0.19U W=1.8U
m33 SRC GTPN N23 VSS N L=0.13U W=1.17U
m34 SRCD SRCPU VDD VDD P L=0.13U W=0.31U
m35 SRCD SRCPU VSS VSS N L=0.13U W=0.16U
m36 SRCPU DRP VDD VDD P L=0.13U W=0.43U
m37 SRCPU DRP VSS VSS N L=0.13U W=0.24U
m38 VDD SRCPU SRC VSS N L=0.13U W=1.18U
m39 SD SRCD SD_ VDD P L=0.13U W=0.5U
m4 SD_ SD VDD VDD P L=0.13U W=0.5U
m40 SRC GTPN N53 VSS N L=0.13U W=1.17U
m41 N53 SRCD VSS VSS N L=0.13U W=1.07U
m5 SD SD_ VDD VDD P L=0.13U W=0.5U
m6 SDN SD VDD VDD P L=0.13U W=0.86U
m7 SDN SD VSS VSS N L=0.13U W=0.42U
m8 DPU SD_ VDD VDD P L=0.13U W=0.86U
m9 DPU SD_ VSS VSS N L=0.13U W=0.42U
.ENDS RA2SH128x36SA4
****
.SUBCKT RA2SH128x36SAX_A DPN DPU DR DR_ DW DW_ GTPA GTPB SP VSS VDD
** RA2SH128x36SAX_A: 41 flat devices **
XI0_0 DPN DPU DR DR_ DW DW_ GTPA GTPA GTPB SP VSS VDD RA2SH128x36SA4
.ENDS RA2SH128x36SAX_A
****
.SUBCKT RA2SH128x36SAX_B DPN DPU DR DR_ DW DW_ GTPA GTPB SP VSS VDD
** RA2SH128x36SAX_B: 41 flat devices **
XI0_0 DPN DPU DR DR_ DW DW_ GTPB GTPA GTPB SP VSS VDD RA2SH128x36SA4
.ENDS RA2SH128x36SAX_B
****
.SUBCKT RA2SH128x36CD A0 A0A A0A_ A0B A0B_ A0_ BL0 BL0_ BL1 BL1_ DR DRA DRA_
+  DRB DRB_ DRSA DR_ DW DWA DWA_ DWB DWB_ DWSA DW_ G0 G1 GTP GTPA GTPB STUBDRA
+  STUBDRA_ STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.13U W=2.28U
m10 BL1_ BL1PD VSS VSS N L=0.13U W=4.8U
m11 BL1_PD CS1 DW_ VDD P L=0.13U W=1.84U
m12 BL1_PD CS1 VSS VSS N L=0.13U W=0.64U
m13 BL1_ CS1 DR_ VDD P L=0.13U W=2.28U
m14 BL1PD CS1 DW VDD P L=0.13U W=1.84U
m15 BL1PD CS1 VSS VSS N L=0.13U W=0.64U
m16 BL1 BL1_PD VSS VSS N L=0.13U W=4.8U
m17 BL0_ YI VDD VDD P L=0.13U W=4.14U
m18 BL0 YI VDD VDD P L=0.13U W=4.14U
m19 BL0 YI BL0_ VDD P L=0.13U W=4.14U
m2 BL0 BL0PD VSS VSS N L=0.13U W=4.8U
m20 BL1 YI VDD VDD P L=0.13U W=4.14U
m21 BL1_ YI VDD VDD P L=0.13U W=4.14U
m22 BL1_ YI BL1 VDD P L=0.13U W=4.14U
m23 CS0 A0_ VDD VDD P L=0.13U W=1.04U
m24 N91 A0_ VSS VSS N L=0.13U W=1.45U
m25 CS0 YI VDD VDD P L=0.13U W=1.04U
m26 CS0 YI N91 VSS N L=0.13U W=1.45U
m27 CS1 A0 VDD VDD P L=0.13U W=1.04U
m28 N92 A0 VSS VSS N L=0.13U W=1.45U
m29 CS1 YI VDD VDD P L=0.13U W=1.04U
m3 BL0_PD CS0 DW VDD P L=0.13U W=1.84U
m30 CS1 YI N92 VSS N L=0.13U W=1.45U
m31 YCDSEL_ G0 VDD VDD P L=0.13U W=0.3U
m32 N93 G0 VSS VSS N L=0.13U W=0.38U
m33 YCDSEL_ G1 VDD VDD P L=0.13U W=0.3U
m34 YCDSEL_ G1 N93 VSS N L=0.13U W=0.38U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.13U W=0.24U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.13U W=0.15U
m37 N63 YCDSEL_ GTP VDD P L=0.13U W=0.3U
m38 N63 YCDSEL_ VSS VSS N L=0.13U W=0.3U
m39 YI WL1_EN_ VDD VDD P L=0.13U W=3.62U
m4 BL0_PD CS0 VSS VSS N L=0.13U W=0.64U
m40 YI WL1_EN_ VSS VSS N L=0.13U W=2.9U
m41 WL1_EN_ N63 VDD VDD P L=0.13U W=1.46U
m42 WL1_EN_ N63 VSS VSS N L=0.13U W=0.93U
m43 N63 YCDSEL GTP VSS N L=0.13U W=0.3U
m5 BL0 CS0 DR VDD P L=0.13U W=2.28U
m6 BL0PD CS0 DW_ VDD P L=0.13U W=1.84U
m7 BL0PD CS0 VSS VSS N L=0.13U W=0.64U
m8 BL0_ BL0_PD VSS VSS N L=0.13U W=4.8U
m9 BL1 CS1 DR VDD P L=0.13U W=2.28U
.ENDS RA2SH128x36CD
****
.SUBCKT RA2SH128x36CDASX A0A A0A_ A0B A0B_ BL0 BL0_ BL1 BL1_ DRA DRA_ DRB DRB_
+  DRSA DWA DWA_ DWB DWB_ DWSA G0 G1 GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CDASX: 43 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BL0 BL0_ BL1 BL1_ DRA DRA DRA_ DRB DRB_ DRSA
+  DRA_ DWA DWA DWA_ DWB DWB_ DWSA DWA_ G0 G1 GTPA GTPA GTPB DRA DRA_ DRB DRB_
+  DWA DWA_ DWB DWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36CD
.ENDS RA2SH128x36CDASX
****
.SUBCKT RA2SH128x36CDBSX A0A A0A_ A0B A0B_ BL0 BL0_ BL1 BL1_ DRA DRA_ DRB DRB_
+  DRSA DWA DWA_ DWB DWB_ DWSA G0 G1 GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CDBSX: 43 flat devices **
XI0_0 A0B A0A A0A_ A0B A0B_ A0B_ BL0 BL0_ BL1 BL1_ DRB DRA DRA_ DRB DRB_ DRSA
+  DRB_ DWB DWA DWA_ DWB DWB_ DWSA DWB_ G0 G1 GTPB GTPA GTPB DRA DRA_ DRB DRB_
+  DWA DWA_ DWB DWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36CD
.ENDS RA2SH128x36CDBSX
****
.SUBCKT RA2SH128x36CDAX A0A A0A_ A0B A0B_ BL0 BL0_ BL1 BL1_ DRA DRA_ DRB DRB_
+  DRSA DWA DWA_ DWB DWB_ DWSA G0 G1 GTPA GTPB STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CDAX: 43 flat devices **
XI0_0 A0A A0A A0A_ A0B A0B_ A0A_ BL0 BL0_ BL1 BL1_ DRA DRA DRA_ DRB DRB_ DRSA
+  DRA_ DWA DWA DWA_ DWB DWB_ DWSA DWA_ G0 G1 GTPA GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CD
.ENDS RA2SH128x36CDAX
****
.SUBCKT RA2SH128x36MXCD_EVEN_RIGHT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_
+  BLA2 BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ DRSA
+  DRSA_0 DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MXCD_EVEN_RIGHT: 172 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA YPA0_0 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDASX
XI1_0 A0A A0A_ A0B A0B_ BLB0 BLB0_ BLB1 BLB1_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_0
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_0 YPB0_0 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI2_0 A0A A0A_ A0B A0B_ BLB2 BLB2_ BLB3 BLB3_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_1
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_1 YPB0_1 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI3_0 A0A A0A_ A0B A0B_ BLA2 BLA2_ BLA3 BLA3_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_2
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_2 YPA0_1 VDD GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDAX
.ENDS RA2SH128x36MXCD_EVEN_RIGHT
****
.SUBCKT RA2SH128x36CCG BLA BLA_ BLB BLB_ WLA WLB VSS VDD
** RA2SH128x36CCG: 8 flat devices **
m1 BLB WLB CORED VSS NCH_SRAM L=0.13U W=0.15U
m2 BLB_ WLB CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m3 BLA WLA CORED VSS NCH_SRAM L=0.13U W=0.15U
m4 BLA_ WLA CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m5 CORED_ CORED VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 CORED CORED_ VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.86U
.ENDS RA2SH128x36CCG
****
.SUBCKT RA2SH128x36CCP BLA BLA_ BLB BLB_ WLA WLB VSS VDD
** RA2SH128x36CCP: 8 flat devices **
m1 BLB WLB CORED VSS NCH_SRAM L=0.13U W=0.15U
m2 BLB_ WLB CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m3 BLA WLA CORED VSS NCH_SRAM L=0.13U W=0.15U
m4 BLA_ WLA CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m5 CORED_ CORED VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 CORED CORED_ VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.86U
.ENDS RA2SH128x36CCP
****
.SUBCKT RA2SH128x36BIT_MUX_0 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2
+  BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 WLA WLB VSS VDD
** RA2SH128x36BIT_MUX_0: 32 flat devices **
XI0_0 BLA BLA_ BLB BLB_ WLA WLB VSS VDD RA2SH128x36CCG
XI1_0 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VSS VDD RA2SH128x36CCP
XI2_0 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VSS VDD RA2SH128x36CCP
XI3_0 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VSS VDD RA2SH128x36CCG
.ENDS RA2SH128x36BIT_MUX_0
****
.SUBCKT RA2SH128x36BIT_MUX_1 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2
+  BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 WLA WLB VSS VDD
** RA2SH128x36BIT_MUX_1: 32 flat devices **
XI0_0 BLA BLA_ BLB BLB_ WLA WLB VSS VDD RA2SH128x36CCG
XI1_0 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VSS VDD RA2SH128x36CCP
XI2_0 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VSS VDD RA2SH128x36CCP
XI3_0 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VSS VDD RA2SH128x36CCG
.ENDS RA2SH128x36BIT_MUX_1
****
.SUBCKT RA2SH128x36BIT_COL BLA[0] BLA[1] BLA[2] BLA[3] BLA_[0] BLA_[1] BLA_[2]
+  BLA_[3] BLB[0] BLB[1] BLB[2] BLB[3] BLB_[0] BLB_[1] BLB_[2] BLB_[3] WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 VSS VDD
** RA2SH128x36BIT_COL: 1024 flat devices **
XI0_0 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA WLB VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_1 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_0 WLB_0 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_10 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_9 WLB_9 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_11 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_10 WLB_10 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_12 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_11 WLB_11 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_13 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_12 WLB_12 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_14 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_13 WLB_13 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_15 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_14 WLB_14 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_17 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_15 WLB_15 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_18 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_16 WLB_16 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_19 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_17 WLB_17 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_2 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_1 WLB_1 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_20 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_18 WLB_18 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_21 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_19 WLB_19 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_22 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_20 WLB_20 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_23 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_21 WLB_21 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_24 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_22 WLB_22 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_25 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_23 WLB_23 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_26 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_24 WLB_24 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_27 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_25 WLB_25 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_28 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_26 WLB_26 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_29 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_27 WLB_27 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_3 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_2 WLB_2 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_30 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_28 WLB_28 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_31 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_29 WLB_29 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_32 BLA[3] BLA_[3] BLA[2] BLA[1] BLA[0] BLA_[2] BLA_[1] BLA_[0] BLB[3]
+  BLB_[3] BLB[2] BLB[1] BLB[0] BLB_[2] BLB_[1] BLB_[0] WLA_30 WLB_30 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_4 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_3 WLB_3 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_5 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_4 WLB_4 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_6 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_5 WLB_5 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_7 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_6 WLB_6 VSS VDD
+  RA2SH128x36BIT_MUX_1
XI0_8 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_7 WLB_7 VSS VDD
+  RA2SH128x36BIT_MUX_0
XI0_9 BLA_[3] BLA[3] BLA_[2] BLA_[1] BLA_[0] BLA[2] BLA[1] BLA[0] BLB_[3]
+  BLB[3] BLB_[2] BLB_[1] BLB_[0] BLB[2] BLB[1] BLB[0] WLA_8 WLB_8 VSS VDD
+  RA2SH128x36BIT_MUX_1
.ENDS RA2SH128x36BIT_COL
****
.SUBCKT RA2SH128x36MCOL_MER4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_MER4: 1398 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWM4A
XI0_1 D DPN DPU STUBDWA_0 STUBDWA__0 GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB
+  VSS VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 SP VSS
+  VDD RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA_ BLA BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLB_
+  BLB BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 STUBDRA_0 STUBDRA__0 STUBDRB__0
+  STUBDRB_0 STUBDWA_0 STUBDWA__0 STUBDWB__0 STUBDWB_0 GTPA_1 GTPB_1 STUBDRA
+  STUBDRA_ STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_EVEN_RIGHT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA GTPB OEA_ OEB_ Q_0 SP_3
+  STUBWEA STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 SP_3
+  VSS VDD RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_MER4
****
.SUBCKT RA2SH128x36MXCD_ODD_RIGHT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ GTPA GTPB
+  STUBDRA STUBDRA_ STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0
+  STUBDWA STUBDWA_ STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MXCD_ODD_RIGHT: 172 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA2 BLA2_ BLA3 BLA3_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRA STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWA YPA0_1 VDD GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36CDAX
XI1_0 A0A A0A_ A0B A0B_ BLB2 BLB2_ BLB3 BLB3_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRA_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWA_ YPB0_1 VDD
+  GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI2_0 A0A A0A_ A0B A0B_ BLB0 BLB0_ BLB1 BLB1_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWB_ YPB0_0 VDD
+  GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI3_0 A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRB STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWB YPA0_0 VDD GTPA
+  GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDASX
.ENDS RA2SH128x36MXCD_ODD_RIGHT
****
.SUBCKT RA2SH128x36MCOL_MOR4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_MOR4: 1398 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWM4A
XI0_1 D DPN DPU STUBDWA STUBDWA_ GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB VSS
+  VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA STUBDRA_ STUBDWA STUBDWA_ GTPA_0 GTPB_0 SP VSS VDD
+  RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0 BLA_ BLA BLB__2
+  BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 BLB_ BLB GTPA_1 GTPB_1 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_ODD_RIGHT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB STUBDWB_ GTPA GTPB OEA_ OEB_ Q_0 SP_3 STUBWEA
+  STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB STUBDRB_ STUBDWB STUBDWB_ GTPA_0 GTPB_0 SP_3 VSS VDD
+  RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_MOR4
****
.SUBCKT RA2SH128x36FCBWRO4 BWEN BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWRO4: 3 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS D DN 0.2116P 1.84U
d3 VSS BWENB DN 0.2116P 1.84U
.ENDS RA2SH128x36FCBWRO4
****
.SUBCKT RA2SH128x36FCBWRO4A BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWRO4A: 3 flat devices **
XI0_0 BWENA BWENA BWENB D Q VSS VDD RA2SH128x36FCBWRO4
.ENDS RA2SH128x36FCBWRO4A
****
.SUBCKT RA2SH128x36MCOL_ROR4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_ROR4: 1399 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWRO4A
XI0_1 D DPN DPU STUBDWA STUBDWA_ GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB VSS
+  VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA STUBDRA_ STUBDWA STUBDWA_ GTPA_0 GTPB_0 SP VSS VDD
+  RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0 BLA_ BLA BLB__2
+  BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 BLB_ BLB GTPA_1 GTPB_1 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_ODD_RIGHT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB STUBDWB_ GTPA GTPB OEA_ OEB_ Q_0 SP_3 STUBWEA
+  STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB STUBDRB_ STUBDWB STUBDWB_ GTPA_0 GTPB_0 SP_3 VSS VDD
+  RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_ROR4
****
.SUBCKT RA2SH128x36WING_18_RIGHT A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13
+  BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23
+  BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33
+  BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43
+  BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53
+  BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63
+  BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA__0 BLA__1 BLA__2
+  BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12
+  BLA__13 BLA__14 BLA__15 BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21
+  BLA__22 BLA__23 BLA__24 BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30
+  BLA__31 BLA__32 BLA__33 BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39
+  BLA__40 BLA__41 BLA__42 BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48
+  BLA__49 BLA__50 BLA__51 BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57
+  BLA__58 BLA__59 BLA__60 BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66
+  BLA__67 BLA__68 BLA__69 BLA__70 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB_3 BLB_4
+  BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15
+  BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25
+  BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35
+  BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45
+  BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55
+  BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65
+  BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23
+  BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32
+  BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41
+  BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50
+  BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59
+  BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68
+  BLB__69 BLB__70 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12
+  D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23 D_24 D_25 D_26 D_27
+  D_28 D_29 D_30 D_31 D_32 D_33 D_34 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1
+  OEA_ OEB_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13
+  Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20 Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28
+  Q_29 Q_30 Q_31 Q_32 Q_33 Q_34 STUBDRA STUBDRA_ STUBDRA_0 STUBDRA__0 STUBDRB
+  STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_ STUBDWA_0 STUBDWA__0 STUBDWB
+  STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36WING_18_RIGHT: 25165 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB
+  BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0 GTPA GTPA_0 GTPA_1 GTPB
+  GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA_131 STUBDRA__129 STUBDRA_0 STUBDRA__0
+  STUBDRB_135 STUBDRB__133 STUBDRB_0 STUBDRB__0 STUBDWA_137 STUBDWA__139
+  STUBDWA_0 STUBDWA__0 STUBDWB_141 STUBDWB__143 STUBDWB_0 STUBDWB__0 STUBWEA
+  STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MER4
XI10_0 A0A A0A_ A0B A0B_ BLA_39 BLA__39 BLA_40 BLA_41 BLA_42 BLA__40 BLA__41
+  BLA__42 BLB_39 BLB__39 BLB_40 BLB_41 BLB_42 BLB__40 BLB__41 BLB__42 D_19
+  D_20 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_19 Q_20 STUBDRA_3
+  STUBDRA__1 STUBDRA_0_19 STUBDRA__0_17 STUBDRB_7 STUBDRB__5 STUBDRB_0_23
+  STUBDRB__0_21 STUBDWA_9 STUBDWA__11 STUBDWA_0_25 STUBDWA__0_27 STUBDWB_13
+  STUBDWB__15 STUBDWB_0_29 STUBDWB__0_31 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MER4
XI11_0 A0A A0A_ A0B A0B_ BLA_46 BLA__46 BLA_45 BLA_44 BLA_43 BLA__45 BLA__44
+  BLA__43 BLB_46 BLB__46 BLB_45 BLB_44 BLB_43 BLB__45 BLB__44 BLB__43 D_22
+  D_21 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_22 Q_21 STUBDRA_3
+  STUBDRA__1 STUBDRA_0_35 STUBDRA__0_33 STUBDRB_7 STUBDRB__5 STUBDRB_0_39
+  STUBDRB__0_37 STUBDWA_9 STUBDWA__11 STUBDWA_0_41 STUBDWA__0_43 STUBDWB_13
+  STUBDWB__15 STUBDWB_0_45 STUBDWB__0_47 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOR4
XI12_0 A0A A0A_ A0B A0B_ BLA_47 BLA__47 BLA_48 BLA_49 BLA_50 BLA__48 BLA__49
+  BLA__50 BLB_47 BLB__47 BLB_48 BLB_49 BLB_50 BLB__48 BLB__49 BLB__50 D_23
+  D_24 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_23 Q_24 STUBDRA_51
+  STUBDRA__49 STUBDRA_0_35 STUBDRA__0_33 STUBDRB_55 STUBDRB__53 STUBDRB_0_39
+  STUBDRB__0_37 STUBDWA_57 STUBDWA__59 STUBDWA_0_41 STUBDWA__0_43 STUBDWB_61
+  STUBDWB__63 STUBDWB_0_45 STUBDWB__0_47 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MER4
XI13_0 A0A A0A_ A0B A0B_ BLA_54 BLA__54 BLA_53 BLA_52 BLA_51 BLA__53 BLA__52
+  BLA__51 BLB_54 BLB__54 BLB_53 BLB_52 BLB_51 BLB__53 BLB__52 BLB__51 D_26
+  D_25 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_26 Q_25 STUBDRA_51
+  STUBDRA__49 STUBDRA_0_67 STUBDRA__0_65 STUBDRB_55 STUBDRB__53 STUBDRB_0_71
+  STUBDRB__0_69 STUBDWA_57 STUBDWA__59 STUBDWA_0_73 STUBDWA__0_75 STUBDWB_61
+  STUBDWB__63 STUBDWB_0_77 STUBDWB__0_79 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOR4
XI14_0 A0A A0A_ A0B A0B_ BLA_55 BLA__55 BLA_56 BLA_57 BLA_58 BLA__56 BLA__57
+  BLA__58 BLB_55 BLB__55 BLB_56 BLB_57 BLB_58 BLB__56 BLB__57 BLB__58 D_27
+  D_28 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_27 Q_28 STUBDRA_83
+  STUBDRA__81 STUBDRA_0_67 STUBDRA__0_65 STUBDRB_87 STUBDRB__85 STUBDRB_0_71
+  STUBDRB__0_69 STUBDWA_89 STUBDWA__91 STUBDWA_0_73 STUBDWA__0_75 STUBDWB_93
+  STUBDWB__95 STUBDWB_0_77 STUBDWB__0_79 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MER4
XI15_0 A0A A0A_ A0B A0B_ BLA_62 BLA__62 BLA_61 BLA_60 BLA_59 BLA__61 BLA__60
+  BLA__59 BLB_62 BLB__62 BLB_61 BLB_60 BLB_59 BLB__61 BLB__60 BLB__59 D_30
+  D_29 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_30 Q_29 STUBDRA_83
+  STUBDRA__81 STUBDRA_0_99 STUBDRA__0_97 STUBDRB_87 STUBDRB__85 STUBDRB_0_103
+  STUBDRB__0_101 STUBDWA_89 STUBDWA__91 STUBDWA_0_105 STUBDWA__0_107
+  STUBDWB_93 STUBDWB__95 STUBDWB_0_109 STUBDWB__0_111 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOR4
XI16_0 A0A A0A_ A0B A0B_ BLA_63 BLA__63 BLA_64 BLA_65 BLA_66 BLA__64 BLA__65
+  BLA__66 BLB_63 BLB__63 BLB_64 BLB_65 BLB_66 BLB__64 BLB__65 BLB__66 D_31
+  D_32 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_31 Q_32 STUBDRA_115
+  STUBDRA__113 STUBDRA_0_99 STUBDRA__0_97 STUBDRB_119 STUBDRB__117
+  STUBDRB_0_103 STUBDRB__0_101 STUBDWA_121 STUBDWA__123 STUBDWA_0_105
+  STUBDWA__0_107 STUBDWB_125 STUBDWB__127 STUBDWB_0_109 STUBDWB__0_111
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MER4
XI17_0 A0A A0A_ A0B A0B_ BLA_70 BLA__70 BLA_69 BLA_68 BLA_67 BLA__69 BLA__68
+  BLA__67 BLB_70 BLB__70 BLB_69 BLB_68 BLB_67 BLB__69 BLB__68 BLB__67 D_34
+  D_33 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_34 Q_33 STUBDRA_115
+  STUBDRA__113 STUBDRA STUBDRA_ STUBDRB_119 STUBDRB__117 STUBDRB STUBDRB_
+  STUBDWA_121 STUBDWA__123 STUBDWA STUBDWA_ STUBDWB_125 STUBDWB__127 STUBDWB
+  STUBDWB_ STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_ROR4
XI1_0 A0A A0A_ A0B A0B_ BLA_6 BLA__6 BLA_5 BLA_4 BLA_3 BLA__5 BLA__4 BLA__3
+  BLB_6 BLB__6 BLB_5 BLB_4 BLB_3 BLB__5 BLB__4 BLB__3 D_2 D_1 GTPA GTPA_0
+  GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_2 Q_1 STUBDRA_131 STUBDRA__129
+  STUBDRA_0_147 STUBDRA__0_145 STUBDRB_135 STUBDRB__133 STUBDRB_0_151
+  STUBDRB__0_149 STUBDWA_137 STUBDWA__139 STUBDWA_0_153 STUBDWA__0_155
+  STUBDWB_141 STUBDWB__143 STUBDWB_0_157 STUBDWB__0_159 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOR4
XI2_0 A0A A0A_ A0B A0B_ BLA_7 BLA__7 BLA_8 BLA_9 BLA_10 BLA__8 BLA__9 BLA__10
+  BLB_7 BLB__7 BLB_8 BLB_9 BLB_10 BLB__8 BLB__9 BLB__10 D_3 D_4 GTPA GTPA_0
+  GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_3 Q_4 STUBDRA_163 STUBDRA__161
+  STUBDRA_0_147 STUBDRA__0_145 STUBDRB_167 STUBDRB__165 STUBDRB_0_151
+  STUBDRB__0_149 STUBDWA_169 STUBDWA__171 STUBDWA_0_153 STUBDWA__0_155
+  STUBDWB_173 STUBDWB__175 STUBDWB_0_157 STUBDWB__0_159 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MER4
XI3_0 A0A A0A_ A0B A0B_ BLA_14 BLA__14 BLA_13 BLA_12 BLA_11 BLA__13 BLA__12
+  BLA__11 BLB_14 BLB__14 BLB_13 BLB_12 BLB_11 BLB__13 BLB__12 BLB__11 D_6 D_5
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_6 Q_5 STUBDRA_163
+  STUBDRA__161 STUBDRA_0_179 STUBDRA__0_177 STUBDRB_167 STUBDRB__165
+  STUBDRB_0_183 STUBDRB__0_181 STUBDWA_169 STUBDWA__171 STUBDWA_0_185
+  STUBDWA__0_187 STUBDWB_173 STUBDWB__175 STUBDWB_0_189 STUBDWB__0_191
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOR4
XI4_0 A0A A0A_ A0B A0B_ BLA_15 BLA__15 BLA_16 BLA_17 BLA_18 BLA__16 BLA__17
+  BLA__18 BLB_15 BLB__15 BLB_16 BLB_17 BLB_18 BLB__16 BLB__17 BLB__18 D_7 D_8
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_7 Q_8 STUBDRA_195
+  STUBDRA__193 STUBDRA_0_179 STUBDRA__0_177 STUBDRB_199 STUBDRB__197
+  STUBDRB_0_183 STUBDRB__0_181 STUBDWA_201 STUBDWA__203 STUBDWA_0_185
+  STUBDWA__0_187 STUBDWB_205 STUBDWB__207 STUBDWB_0_189 STUBDWB__0_191
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MER4
XI5_0 A0A A0A_ A0B A0B_ BLA_22 BLA__22 BLA_21 BLA_20 BLA_19 BLA__21 BLA__20
+  BLA__19 BLB_22 BLB__22 BLB_21 BLB_20 BLB_19 BLB__21 BLB__20 BLB__19 D_10
+  D_9 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_10 Q_9 STUBDRA_195
+  STUBDRA__193 STUBDRA_0_211 STUBDRA__0_209 STUBDRB_199 STUBDRB__197
+  STUBDRB_0_215 STUBDRB__0_213 STUBDWA_201 STUBDWA__203 STUBDWA_0_217
+  STUBDWA__0_219 STUBDWB_205 STUBDWB__207 STUBDWB_0_221 STUBDWB__0_223
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOR4
XI6_0 A0A A0A_ A0B A0B_ BLA_23 BLA__23 BLA_24 BLA_25 BLA_26 BLA__24 BLA__25
+  BLA__26 BLB_23 BLB__23 BLB_24 BLB_25 BLB_26 BLB__24 BLB__25 BLB__26 D_11
+  D_12 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_11 Q_12 STUBDRA_227
+  STUBDRA__225 STUBDRA_0_211 STUBDRA__0_209 STUBDRB_231 STUBDRB__229
+  STUBDRB_0_215 STUBDRB__0_213 STUBDWA_233 STUBDWA__235 STUBDWA_0_217
+  STUBDWA__0_219 STUBDWB_237 STUBDWB__239 STUBDWB_0_221 STUBDWB__0_223
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MER4
XI7_0 A0A A0A_ A0B A0B_ BLA_30 BLA__30 BLA_29 BLA_28 BLA_27 BLA__29 BLA__28
+  BLA__27 BLB_30 BLB__30 BLB_29 BLB_28 BLB_27 BLB__29 BLB__28 BLB__27 D_14
+  D_13 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_14 Q_13 STUBDRA_227
+  STUBDRA__225 STUBDRA_0_243 STUBDRA__0_241 STUBDRB_231 STUBDRB__229
+  STUBDRB_0_247 STUBDRB__0_245 STUBDWA_233 STUBDWA__235 STUBDWA_0_249
+  STUBDWA__0_251 STUBDWB_237 STUBDWB__239 STUBDWB_0_253 STUBDWB__0_255
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOR4
XI8_0 A0A A0A_ A0B A0B_ BLA_31 BLA__31 BLA_32 BLA_33 BLA_34 BLA__32 BLA__33
+  BLA__34 BLB_31 BLB__31 BLB_32 BLB_33 BLB_34 BLB__32 BLB__33 BLB__34 D_15
+  D_16 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_15 Q_16 STUBDRA_259
+  STUBDRA__257 STUBDRA_0_243 STUBDRA__0_241 STUBDRB_263 STUBDRB__261
+  STUBDRB_0_247 STUBDRB__0_245 STUBDWA_265 STUBDWA__267 STUBDWA_0_249
+  STUBDWA__0_251 STUBDWB_269 STUBDWB__271 STUBDWB_0_253 STUBDWB__0_255
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MER4
XI9_0 A0A A0A_ A0B A0B_ BLA_38 BLA__38 BLA_37 BLA_36 BLA_35 BLA__37 BLA__36
+  BLA__35 BLB_38 BLB__38 BLB_37 BLB_36 BLB_35 BLB__37 BLB__36 BLB__35 D_18
+  D_17 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_18 Q_17 STUBDRA_259
+  STUBDRA__257 STUBDRA_0_19 STUBDRA__0_17 STUBDRB_263 STUBDRB__261
+  STUBDRB_0_23 STUBDRB__0_21 STUBDWA_265 STUBDWA__267 STUBDWA_0_25
+  STUBDWA__0_27 STUBDWB_269 STUBDWB__271 STUBDWB_0_29 STUBDWB__0_31 STUBWEA
+  STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOR4
.ENDS RA2SH128x36WING_18_RIGHT
****
.SUBCKT RA2SH128x36FLCIO A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBLA
+  MBLA_ MBLB MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36FLCIO: 22 flat devices **
d1 VSS A0B_ DN 0.2116P 1.84U
d10 VSS YPB0_0 DN 0.2116P 1.84U
d11 VSS YPA0_0 DN 0.2116P 1.84U
d12 VSS YPB1_3 DN 0.2116P 1.84U
d13 VSS YPA1_3 DN 0.2116P 1.84U
d14 VSS YPB1_2 DN 0.2116P 1.84U
d15 VSS YPA1_2 DN 0.2116P 1.84U
d16 VSS YPB1_1 DN 0.2116P 1.84U
d17 VSS YPA1_1 DN 0.2116P 1.84U
d18 VSS YPB1_0 DN 0.2116P 1.84U
d19 VSS YPA1_0 DN 0.2116P 1.84U
d2 VSS A0A DN 0.2116P 1.84U
d20 VSS GTPB DN 0.2116P 1.84U
d21 VSS GTPA DN 0.2116P 1.84U
d22 VSS A0B DN 0.2116P 1.84U
d3 VSS A0A_ DN 0.2116P 1.84U
d4 VSS YPB0_3 DN 0.2116P 1.84U
d5 VSS YPA0_3 DN 0.2116P 1.84U
d6 VSS YPB0_2 DN 0.2116P 1.84U
d7 VSS YPA0_2 DN 0.2116P 1.84U
d8 VSS YPB0_1 DN 0.2116P 1.84U
d9 VSS YPA0_1 DN 0.2116P 1.84U
.ENDS RA2SH128x36FLCIO
****
.SUBCKT RA2SH128x36FLCIOX_A A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL
+  MBLA_ MBLB MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36FLCIOX_A: 22 flat devices **
XI0_0 A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBL MBLA_ MBLB MBLB_
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36FLCIO
.ENDS RA2SH128x36FLCIOX_A
****
.SUBCKT RA2SH128x36CCMWG BLA BLAD BLA_ BLB BLBD BLB_ WLA WLB VSS VDD
** RA2SH128x36CCMWG: 8 flat devices **
m1 BLBD WLB CORED VSS NCH_SRAM L=0.13U W=0.15U
m2 N11 WLB CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m3 BLAD WLA CORED VSS NCH_SRAM L=0.13U W=0.15U
m4 N12 WLA CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m5 CORED_ CORED VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 CORED CORED_ VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.86U
.ENDS RA2SH128x36CCMWG
****
.SUBCKT RA2SH128x36FCIO4 GTPA GTPB OEA_ OEB_ WEA WEB VSS VDD
** RA2SH128x36FCIO4: 6 flat devices **
d1 VSS WEA DN 0.2116P 1.84U
d2 VSS GTPB DN 0.2116P 1.84U
d3 VSS GTPA DN 0.2116P 1.84U
d4 VSS OEB_ DN 0.2116P 1.84U
d5 VSS OEA_ DN 0.2116P 1.84U
d6 VSS WEB DN 0.2116P 1.84U
.ENDS RA2SH128x36FCIO4
****
.SUBCKT RA2SH128x36FCSA4 GTPA GTPB VSS VDD
** RA2SH128x36FCSA4: 2 flat devices **
d1 VSS GTPB DN 0.2116P 1.84U
d2 VSS GTPA DN 0.2116P 1.84U
.ENDS RA2SH128x36FCSA4
****
.SUBCKT RA2SH128x36CAP A0A A0A_ A0B A0B_ GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1
+  OEA_ OEB_ WEA WEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CAP: 288 flat devices **
XI0_0 GTPA GTPB OEA_ OEB_ WEA WEB VSS VDD RA2SH128x36FCIO4
XI0_1 GTPA_0 GTPB_0 VSS VDD RA2SH128x36FCSA4
XI0_10 VDD VDD VDD VDD WLA_6 WLB_6 VSS VDD RA2SH128x36CCG
XI0_11 VDD VDD VDD VDD WLA_7 WLB_7 VSS VDD RA2SH128x36CCG
XI0_12 VDD VDD VDD VDD WLA_8 WLB_8 VSS VDD RA2SH128x36CCG
XI0_13 VDD VDD VDD VDD WLA_9 WLB_9 VSS VDD RA2SH128x36CCG
XI0_14 VDD VDD VDD VDD WLA_10 WLB_10 VSS VDD RA2SH128x36CCG
XI0_15 VDD VDD VDD VDD WLA_11 WLB_11 VSS VDD RA2SH128x36CCG
XI0_16 VDD VDD VDD VDD WLA_12 WLB_12 VSS VDD RA2SH128x36CCG
XI0_17 VDD VDD VDD VDD WLA_13 WLB_13 VSS VDD RA2SH128x36CCG
XI0_18 VDD VDD VDD VDD WLA_14 WLB_14 VSS VDD RA2SH128x36CCG
XI0_20 VDD VDD VDD VDD WLA_15 WLB_15 VSS VDD RA2SH128x36CCG
XI0_21 VDD VDD VDD VDD WLA_16 WLB_16 VSS VDD RA2SH128x36CCG
XI0_22 VDD VDD VDD VDD WLA_17 WLB_17 VSS VDD RA2SH128x36CCG
XI0_23 VDD VDD VDD VDD WLA_18 WLB_18 VSS VDD RA2SH128x36CCG
XI0_24 VDD VDD VDD VDD WLA_19 WLB_19 VSS VDD RA2SH128x36CCG
XI0_25 VDD VDD VDD VDD WLA_20 WLB_20 VSS VDD RA2SH128x36CCG
XI0_26 VDD VDD VDD VDD WLA_21 WLB_21 VSS VDD RA2SH128x36CCG
XI0_27 VDD VDD VDD VDD WLA_22 WLB_22 VSS VDD RA2SH128x36CCG
XI0_28 VDD VDD VDD VDD WLA_23 WLB_23 VSS VDD RA2SH128x36CCG
XI0_29 VDD VDD VDD VDD WLA_24 WLB_24 VSS VDD RA2SH128x36CCG
XI0_3 VDD VDD VDD VDD WLA WLB VSS VDD RA2SH128x36CCG
XI0_30 VDD VDD VDD VDD WLA_25 WLB_25 VSS VDD RA2SH128x36CCG
XI0_31 VDD VDD VDD VDD WLA_26 WLB_26 VSS VDD RA2SH128x36CCG
XI0_32 VDD VDD VDD VDD WLA_27 WLB_27 VSS VDD RA2SH128x36CCG
XI0_33 VDD VDD VDD VDD WLA_28 WLB_28 VSS VDD RA2SH128x36CCG
XI0_34 VDD VDD VDD VDD WLA_29 WLB_29 VSS VDD RA2SH128x36CCG
XI0_35 VDD VDD VDD VDD WLA_30 WLB_30 VSS VDD RA2SH128x36CCG
XI0_36 VDD BLAD VDD VDD BLBD VDD VSS VSS VSS VDD RA2SH128x36CCMWG
XI0_37 VDD BLAD VDD VDD BLBD VDD VSS VSS VSS VDD RA2SH128x36CCMWG
XI0_38 VDD VDD VDD VDD VSS VSS VSS VDD RA2SH128x36CCG
XI0_4 VDD VDD VDD VDD WLA_0 WLB_0 VSS VDD RA2SH128x36CCG
XI0_5 VDD VDD VDD VDD WLA_1 WLB_1 VSS VDD RA2SH128x36CCG
XI0_6 VDD VDD VDD VDD WLA_2 WLB_2 VSS VDD RA2SH128x36CCG
XI0_7 VDD VDD VDD VDD WLA_3 WLB_3 VSS VDD RA2SH128x36CCG
XI0_8 VDD VDD VDD VDD WLA_4 WLB_4 VSS VDD RA2SH128x36CCG
XI0_9 VDD VDD VDD VDD WLA_5 WLB_5 VSS VDD RA2SH128x36CCG
.ENDS RA2SH128x36CAP
****
.SUBCKT RA2SH128x36CCMB BLA BLA_ BLB BLB_ WLA WLB VSS VDD
** RA2SH128x36CCMB: 8 flat devices **
m1 BLB VSS CORED VSS NCH_SRAM L=0.13U W=0.15U
m2 BLB_ VSS CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m3 BLA VSS CORED VSS NCH_SRAM L=0.13U W=0.15U
m4 BLA_ VSS CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m5 CORED_ CORED VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 CORED CORED_ VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.86U
.ENDS RA2SH128x36CCMB
****
.SUBCKT RA2SH128x36MODEL_COL_A BLA BLA_ MWLAS MWLBD MWLBS MWLD WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 VSS VDD
** RA2SH128x36MODEL_COL_A: 256 flat devices **
XI0_0 BLA BLA_ VDD VDD WLA WLB VSS VDD RA2SH128x36CCMB
XI0_1 BLA BLA_ VDD VDD WLA_0 WLB_0 VSS VDD RA2SH128x36CCMB
XI0_10 BLA BLA_ VDD VDD WLA_9 WLB_9 VSS VDD RA2SH128x36CCMB
XI0_11 BLA BLA_ VDD VDD WLA_10 WLB_10 VSS VDD RA2SH128x36CCMB
XI0_12 BLA BLA_ VDD VDD WLA_11 WLB_11 VSS VDD RA2SH128x36CCMB
XI0_13 BLA BLA_ VDD VDD WLA_12 WLB_12 VSS VDD RA2SH128x36CCMB
XI0_14 BLA BLA_ VDD VDD WLA_13 WLB_13 VSS VDD RA2SH128x36CCMB
XI0_15 BLA BLA_ VDD VDD WLA_14 WLB_14 VSS VDD RA2SH128x36CCMB
XI0_17 BLA_ BLA VDD VDD WLA_15 WLB_15 VSS VDD RA2SH128x36CCMB
XI0_18 BLA_ BLA VDD VDD WLA_16 WLB_16 VSS VDD RA2SH128x36CCMB
XI0_19 BLA_ BLA VDD VDD WLA_17 WLB_17 VSS VDD RA2SH128x36CCMB
XI0_2 BLA BLA_ VDD VDD WLA_1 WLB_1 VSS VDD RA2SH128x36CCMB
XI0_20 BLA_ BLA VDD VDD WLA_18 WLB_18 VSS VDD RA2SH128x36CCMB
XI0_21 BLA_ BLA VDD VDD WLA_19 WLB_19 VSS VDD RA2SH128x36CCMB
XI0_22 BLA_ BLA VDD VDD WLA_20 WLB_20 VSS VDD RA2SH128x36CCMB
XI0_23 BLA_ BLA VDD VDD WLA_21 WLB_21 VSS VDD RA2SH128x36CCMB
XI0_24 BLA_ BLA VDD VDD WLA_22 WLB_22 VSS VDD RA2SH128x36CCMB
XI0_25 BLA_ BLA VDD VDD WLA_23 WLB_23 VSS VDD RA2SH128x36CCMB
XI0_26 BLA_ BLA VDD VDD WLA_24 WLB_24 VSS VDD RA2SH128x36CCMB
XI0_27 BLA_ BLA VDD VDD WLA_25 WLB_25 VSS VDD RA2SH128x36CCMB
XI0_28 BLA_ BLA VDD VDD WLA_26 WLB_26 VSS VDD RA2SH128x36CCMB
XI0_29 BLA_ BLA VDD VDD WLA_27 WLB_27 VSS VDD RA2SH128x36CCMB
XI0_3 BLA BLA_ VDD VDD WLA_2 WLB_2 VSS VDD RA2SH128x36CCMB
XI0_30 BLA_ BLA VDD VDD WLA_28 WLB_28 VSS VDD RA2SH128x36CCMB
XI0_31 BLA_ BLA VDD VDD WLA_29 WLB_29 VSS VDD RA2SH128x36CCMB
XI0_32 BLA_ BLA VDD VDD WLA_30 WLB_30 VSS VDD RA2SH128x36CCMB
XI0_4 BLA BLA_ VDD VDD WLA_3 WLB_3 VSS VDD RA2SH128x36CCMB
XI0_5 BLA BLA_ VDD VDD WLA_4 WLB_4 VSS VDD RA2SH128x36CCMB
XI0_6 BLA BLA_ VDD VDD WLA_5 WLB_5 VSS VDD RA2SH128x36CCMB
XI0_7 BLA BLA_ VDD VDD WLA_6 WLB_6 VSS VDD RA2SH128x36CCMB
XI0_8 BLA BLA_ VDD VDD WLA_7 WLB_7 VSS VDD RA2SH128x36CCMB
XI0_9 BLA BLA_ VDD VDD WLA_8 WLB_8 VSS VDD RA2SH128x36CCMB
.ENDS RA2SH128x36MODEL_COL_A
****
.SUBCKT RA2SH128x36CCMWP BLA BLAD BLA_ BLB BLBD BLB_ WLA WLB VSS VDD
** RA2SH128x36CCMWP: 8 flat devices **
m1 BLBD WLB CORED VSS NCH_SRAM L=0.13U W=0.15U
m2 N11 WLB CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m3 BLAD WLA CORED VSS NCH_SRAM L=0.13U W=0.15U
m4 N12 WLA CORED_ VSS NCH_SRAM L=0.13U W=0.15U
m5 CORED_ CORED VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 CORED CORED_ VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.86U
.ENDS RA2SH128x36CCMWP
****
.SUBCKT RA2SH128x36FLMWG BLA BLA_ BLB BLB_ MWLA MWLB VSS VDD
** RA2SH128x36FLMWG: 16 flat devices **
m1 VSS VSS N12 VSS NCH_SRAM L=0.13U W=0.15U
m10 VSS VSS N15 VSS NCH_SRAM L=0.13U W=0.15U
m11 VSS VSS N14 VSS NCH_SRAM L=0.13U W=0.15U
m12 VSS VSS N15 VSS NCH_SRAM L=0.13U W=0.15U
m13 N15 N14 VDD VDD PCH_SRAM L=0.13U W=0.15U
m14 N15 N14 VSS VSS NCH_SRAM L=0.13U W=0.86U
m15 N14 N15 VDD VDD PCH_SRAM L=0.13U W=0.15U
m16 N14 N15 VSS VSS NCH_SRAM L=0.13U W=0.86U
m2 VSS VSS N13 VSS NCH_SRAM L=0.13U W=0.15U
m3 VSS VSS N12 VSS NCH_SRAM L=0.13U W=0.15U
m4 VSS VSS N13 VSS NCH_SRAM L=0.13U W=0.15U
m5 N13 N12 VDD VDD PCH_SRAM L=0.13U W=0.15U
m6 N13 N12 VSS VSS NCH_SRAM L=0.13U W=0.86U
m7 N12 N13 VDD VDD PCH_SRAM L=0.13U W=0.15U
m8 N12 N13 VSS VSS NCH_SRAM L=0.13U W=0.86U
m9 VSS VSS N14 VSS NCH_SRAM L=0.13U W=0.15U
.ENDS RA2SH128x36FLMWG
****
.SUBCKT RA2SH128x36MODEL_ROW_RIGHT BLA BLA_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4
+  BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15
+  BLA_16 BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25
+  BLA_26 BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35
+  BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45
+  BLA_46 BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55
+  BLA_56 BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65
+  BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4
+  BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14
+  BLA__15 BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23
+  BLA__24 BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32
+  BLA__33 BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41
+  BLA__42 BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50
+  BLA__51 BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59
+  BLA__60 BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68
+  BLA__69 BLA__70 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7
+  BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18
+  BLB_19 BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28
+  BLB_29 BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38
+  BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48
+  BLB_49 BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58
+  BLB_59 BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68
+  BLB_69 BLB_70 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7
+  BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16
+  BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25
+  BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34
+  BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43
+  BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52
+  BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61
+  BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 WLA
+  WLA_0 WLB WLB_0 VSS VDD
** RA2SH128x36MODEL_ROW_RIGHT: 1728 flat devices **
XI0_0 BLA BLAD_118 BLA_ BLB BLBD_120 BLB_ WLA_0 WLB_0 VSS VDD RA2SH128x36CCMWG
XI0_1 BLA BLAD_118 BLA_ BLB BLBD_120 BLB_ WLA_0 WLB_0 VSS VDD RA2SH128x36CCMWG
XI0_2 BLA BLA_ BLB BLB_ WLA WLB VSS VDD RA2SH128x36CCG
XI10_0 BLA_9 BLAD_18 BLA__9 BLB_9 BLBD_20 BLB__9 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI10_1 BLA_9 BLAD_18 BLA__9 BLB_9 BLBD_20 BLB__9 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI10_2 BLA_9 BLA__9 BLB_9 BLB__9 WLA WLB VSS VDD RA2SH128x36CCP
XI11_0 BLA_10 BLAD_90 BLA__10 BLB_10 BLBD_92 BLB__10 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI11_1 BLA_10 BLAD_90 BLA__10 BLB_10 BLBD_92 BLB__10 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI11_2 BLA_10 BLA__10 BLB_10 BLB__10 WLA WLB VSS VDD RA2SH128x36CCG
XI12_0 BLA_11 BLAD_162 BLA__11 BLB_11 BLBD_164 BLB__11 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI12_1 BLA_11 BLAD_162 BLA__11 BLB_11 BLBD_164 BLB__11 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI12_2 BLA_11 BLA__11 BLB_11 BLB__11 WLA WLB VSS VDD RA2SH128x36CCG
XI13_0 BLA_12 BLAD_238 BLA__12 BLB_12 BLBD_240 BLB__12 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI13_1 BLA_12 BLAD_238 BLA__12 BLB_12 BLBD_240 BLB__12 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI13_2 BLA_12 BLA__12 BLB_12 BLB__12 WLA WLB VSS VDD RA2SH128x36CCP
XI14_0 BLA_13 BLAD_26 BLA__13 BLB_13 BLBD_28 BLB__13 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI14_1 BLA_13 BLAD_26 BLA__13 BLB_13 BLBD_28 BLB__13 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI14_2 BLA_13 BLA__13 BLB_13 BLB__13 WLA WLB VSS VDD RA2SH128x36CCP
XI15_0 BLA_14 BLAD_98 BLA__14 BLB_14 BLBD_100 BLB__14 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI15_1 BLA_14 BLAD_98 BLA__14 BLB_14 BLBD_100 BLB__14 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI15_2 BLA_14 BLA__14 BLB_14 BLB__14 WLA WLB VSS VDD RA2SH128x36CCG
XI16_0 BLA_15 BLAD_174 BLA__15 BLB_15 BLBD_176 BLB__15 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI16_1 BLA_15 BLAD_174 BLA__15 BLB_15 BLBD_176 BLB__15 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI16_2 BLA_15 BLA__15 BLB_15 BLB__15 WLA WLB VSS VDD RA2SH128x36CCG
XI17_0 BLA_16 BLAD_250 BLA__16 BLB_16 BLBD_252 BLB__16 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI17_1 BLA_16 BLAD_250 BLA__16 BLB_16 BLBD_252 BLB__16 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI17_2 BLA_16 BLA__16 BLB_16 BLB__16 WLA WLB VSS VDD RA2SH128x36CCP
XI18_0 BLA_17 BLAD_38 BLA__17 BLB_17 BLBD_40 BLB__17 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI18_1 BLA_17 BLAD_38 BLA__17 BLB_17 BLBD_40 BLB__17 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI18_2 BLA_17 BLA__17 BLB_17 BLB__17 WLA WLB VSS VDD RA2SH128x36CCP
XI19_0 BLA_18 BLAD_110 BLA__18 BLB_18 BLBD_112 BLB__18 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI19_1 BLA_18 BLAD_110 BLA__18 BLB_18 BLBD_112 BLB__18 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI19_2 BLA_18 BLA__18 BLB_18 BLB__18 WLA WLB VSS VDD RA2SH128x36CCG
XI1_0 BLA_0 BLAD_194 BLA__0 BLB_0 BLBD_196 BLB__0 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI1_1 BLA_0 BLAD_194 BLA__0 BLB_0 BLBD_196 BLB__0 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI1_2 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VSS VDD RA2SH128x36CCP
XI20_0 BLA_19 BLAD_130 BLA__19 BLB_19 BLBD_132 BLB__19 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI20_1 BLA_19 BLAD_130 BLA__19 BLB_19 BLBD_132 BLB__19 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI20_2 BLA_19 BLA__19 BLB_19 BLB__19 WLA WLB VSS VDD RA2SH128x36CCG
XI21_0 BLA_20 BLAD_206 BLA__20 BLB_20 BLBD_208 BLB__20 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI21_1 BLA_20 BLAD_206 BLA__20 BLB_20 BLBD_208 BLB__20 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI21_2 BLA_20 BLA__20 BLB_20 BLB__20 WLA WLB VSS VDD RA2SH128x36CCP
XI22_0 BLA_21 BLAD_274 BLA__21 BLB_21 BLBD_276 BLB__21 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI22_1 BLA_21 BLAD_274 BLA__21 BLB_21 BLBD_276 BLB__21 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI22_2 BLA_21 BLA__21 BLB_21 BLB__21 WLA WLB VSS VDD RA2SH128x36CCP
XI23_0 BLA_22 BLAD_62 BLA__22 BLB_22 BLBD_64 BLB__22 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI23_1 BLA_22 BLAD_62 BLA__22 BLB_22 BLBD_64 BLB__22 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI23_2 BLA_22 BLA__22 BLB_22 BLB__22 WLA WLB VSS VDD RA2SH128x36CCG
XI24_0 BLA_23 BLAD_138 BLA__23 BLB_23 BLBD_140 BLB__23 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI24_1 BLA_23 BLAD_138 BLA__23 BLB_23 BLBD_140 BLB__23 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI24_2 BLA_23 BLA__23 BLB_23 BLB__23 WLA WLB VSS VDD RA2SH128x36CCG
XI25_0 BLA_24 BLAD_214 BLA__24 BLB_24 BLBD_216 BLB__24 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI25_1 BLA_24 BLAD_214 BLA__24 BLB_24 BLBD_216 BLB__24 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI25_2 BLA_24 BLA__24 BLB_24 BLB__24 WLA WLB VSS VDD RA2SH128x36CCP
XI26_0 BLA_25 BLAD BLA__25 BLB_25 BLBD BLB__25 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI26_1 BLA_25 BLAD BLA__25 BLB_25 BLBD BLB__25 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI26_2 BLA_25 BLA__25 BLB_25 BLB__25 WLA WLB VSS VDD RA2SH128x36CCP
XI27_0 BLA_26 BLAD_74 BLA__26 BLB_26 BLBD_76 BLB__26 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI27_1 BLA_26 BLAD_74 BLA__26 BLB_26 BLBD_76 BLB__26 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI27_2 BLA_26 BLA__26 BLB_26 BLB__26 WLA WLB VSS VDD RA2SH128x36CCG
XI28_0 BLA_27 BLAD_150 BLA__27 BLB_27 BLBD_152 BLB__27 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI28_1 BLA_27 BLAD_150 BLA__27 BLB_27 BLBD_152 BLB__27 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI28_2 BLA_27 BLA__27 BLB_27 BLB__27 WLA WLB VSS VDD RA2SH128x36CCG
XI29_0 BLA_28 BLAD_226 BLA__28 BLB_28 BLBD_228 BLB__28 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI29_1 BLA_28 BLAD_226 BLA__28 BLB_28 BLBD_228 BLB__28 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI29_2 BLA_28 BLA__28 BLB_28 BLB__28 WLA WLB VSS VDD RA2SH128x36CCP
XI2_0 BLA_1 BLAD_266 BLA__1 BLB_1 BLBD_268 BLB__1 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI2_1 BLA_1 BLAD_266 BLA__1 BLB_1 BLBD_268 BLB__1 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI2_2 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VSS VDD RA2SH128x36CCP
XI30_0 BLA_29 BLAD_234 BLA__29 BLB_29 BLBD_236 BLB__29 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI30_1 BLA_29 BLAD_234 BLA__29 BLB_29 BLBD_236 BLB__29 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI30_2 BLA_29 BLA__29 BLB_29 BLB__29 WLA WLB VSS VDD RA2SH128x36CCP
XI31_0 BLA_30 BLAD_22 BLA__30 BLB_30 BLBD_24 BLB__30 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI31_1 BLA_30 BLAD_22 BLA__30 BLB_30 BLBD_24 BLB__30 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI31_2 BLA_30 BLA__30 BLB_30 BLB__30 WLA WLB VSS VDD RA2SH128x36CCG
XI32_0 BLA_31 BLAD_94 BLA__31 BLB_31 BLBD_96 BLB__31 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI32_1 BLA_31 BLAD_94 BLA__31 BLB_31 BLBD_96 BLB__31 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI32_2 BLA_31 BLA__31 BLB_31 BLB__31 WLA WLB VSS VDD RA2SH128x36CCG
XI33_0 BLA_32 BLAD_170 BLA__32 BLB_32 BLBD_172 BLB__32 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI33_1 BLA_32 BLAD_170 BLA__32 BLB_32 BLBD_172 BLB__32 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI33_2 BLA_32 BLA__32 BLB_32 BLB__32 WLA WLB VSS VDD RA2SH128x36CCP
XI34_0 BLA_33 BLAD_246 BLA__33 BLB_33 BLBD_248 BLB__33 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI34_1 BLA_33 BLAD_246 BLA__33 BLB_33 BLBD_248 BLB__33 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI34_2 BLA_33 BLA__33 BLB_33 BLB__33 WLA WLB VSS VDD RA2SH128x36CCP
XI35_0 BLA_34 BLAD_34 BLA__34 BLB_34 BLBD_36 BLB__34 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI35_1 BLA_34 BLAD_34 BLA__34 BLB_34 BLBD_36 BLB__34 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI35_2 BLA_34 BLA__34 BLB_34 BLB__34 WLA WLB VSS VDD RA2SH128x36CCG
XI36_0 BLA_35 BLA__35 BLB_35 BLB__35 WLA_0 WLB_0 VSS VDD RA2SH128x36FLMWG
XI36_2 BLA_35 BLA__35 BLB_35 BLB__35 WLA WLB VSS VDD RA2SH128x36CCG
XI37_0 BLA_36 BLAD_186 BLA__36 BLB_36 BLBD_188 BLB__36 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI37_1 BLA_36 BLAD_186 BLA__36 BLB_36 BLBD_188 BLB__36 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI37_2 BLA_36 BLA__36 BLB_36 BLB__36 WLA WLB VSS VDD RA2SH128x36CCP
XI38_0 BLA_37 BLAD_258 BLA__37 BLB_37 BLBD_260 BLB__37 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI38_1 BLA_37 BLAD_258 BLA__37 BLB_37 BLBD_260 BLB__37 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI38_2 BLA_37 BLA__37 BLB_37 BLB__37 WLA WLB VSS VDD RA2SH128x36CCP
XI39_0 BLA_38 BLAD_46 BLA__38 BLB_38 BLBD_48 BLB__38 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI39_1 BLA_38 BLAD_46 BLA__38 BLB_38 BLBD_48 BLB__38 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI39_2 BLA_38 BLA__38 BLB_38 BLB__38 WLA WLB VSS VDD RA2SH128x36CCG
XI3_0 BLA_2 BLAD_50 BLA__2 BLB_2 BLBD_52 BLB__2 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI3_1 BLA_2 BLAD_50 BLA__2 BLB_2 BLBD_52 BLB__2 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI3_2 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VSS VDD RA2SH128x36CCG
XI40_0 BLA_39 BLAD_58 BLA__39 BLB_39 BLBD_60 BLB__39 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI40_1 BLA_39 BLAD_58 BLA__39 BLB_39 BLBD_60 BLB__39 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI40_2 BLA_39 BLA__39 BLB_39 BLB__39 WLA WLB VSS VDD RA2SH128x36CCG
XI41_0 BLA_40 BLAD_134 BLA__40 BLB_40 BLBD_136 BLB__40 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI41_1 BLA_40 BLAD_134 BLA__40 BLB_40 BLBD_136 BLB__40 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI41_2 BLA_40 BLA__40 BLB_40 BLB__40 WLA WLB VSS VDD RA2SH128x36CCP
XI42_0 BLA_41 BLAD_210 BLA__41 BLB_41 BLBD_212 BLB__41 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI42_1 BLA_41 BLAD_210 BLA__41 BLB_41 BLBD_212 BLB__41 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI42_2 BLA_41 BLA__41 BLB_41 BLB__41 WLA WLB VSS VDD RA2SH128x36CCP
XI43_0 BLA_42 BLAD_2 BLA__42 BLB_42 BLBD_4 BLB__42 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI43_1 BLA_42 BLAD_2 BLA__42 BLB_42 BLBD_4 BLB__42 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI43_2 BLA_42 BLA__42 BLB_42 BLB__42 WLA WLB VSS VDD RA2SH128x36CCG
XI44_0 BLA_43 BLAD_70 BLA__43 BLB_43 BLBD_72 BLB__43 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI44_1 BLA_43 BLAD_70 BLA__43 BLB_43 BLBD_72 BLB__43 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI44_2 BLA_43 BLA__43 BLB_43 BLB__43 WLA WLB VSS VDD RA2SH128x36CCG
XI45_0 BLA_44 BLAD_146 BLA__44 BLB_44 BLBD_148 BLB__44 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI45_1 BLA_44 BLAD_146 BLA__44 BLB_44 BLBD_148 BLB__44 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI45_2 BLA_44 BLA__44 BLB_44 BLB__44 WLA WLB VSS VDD RA2SH128x36CCP
XI46_0 BLA_45 BLAD_222 BLA__45 BLB_45 BLBD_224 BLB__45 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI46_1 BLA_45 BLAD_222 BLA__45 BLB_45 BLBD_224 BLB__45 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI46_2 BLA_45 BLA__45 BLB_45 BLB__45 WLA WLB VSS VDD RA2SH128x36CCP
XI47_0 BLA_46 BLAD_10 BLA__46 BLB_46 BLBD_12 BLB__46 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI47_1 BLA_46 BLAD_10 BLA__46 BLB_46 BLBD_12 BLB__46 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI47_2 BLA_46 BLA__46 BLB_46 BLB__46 WLA WLB VSS VDD RA2SH128x36CCG
XI48_0 BLA_47 BLAD_82 BLA__47 BLB_47 BLBD_84 BLB__47 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI48_1 BLA_47 BLAD_82 BLA__47 BLB_47 BLBD_84 BLB__47 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI48_2 BLA_47 BLA__47 BLB_47 BLB__47 WLA WLB VSS VDD RA2SH128x36CCG
XI49_0 BLA_48 BLAD_158 BLA__48 BLB_48 BLBD_160 BLB__48 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI49_1 BLA_48 BLAD_158 BLA__48 BLB_48 BLBD_160 BLB__48 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI49_2 BLA_48 BLA__48 BLB_48 BLB__48 WLA WLB VSS VDD RA2SH128x36CCP
XI4_0 BLA_3 BLAD_122 BLA__3 BLB_3 BLBD_124 BLB__3 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI4_1 BLA_3 BLAD_122 BLA__3 BLB_3 BLBD_124 BLB__3 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI4_2 BLA_3 BLA__3 BLB_3 BLB__3 WLA WLB VSS VDD RA2SH128x36CCG
XI50_0 BLA_49 BLAD_166 BLA__49 BLB_49 BLBD_168 BLB__49 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI50_1 BLA_49 BLAD_166 BLA__49 BLB_49 BLBD_168 BLB__49 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI50_2 BLA_49 BLA__49 BLB_49 BLB__49 WLA WLB VSS VDD RA2SH128x36CCP
XI51_0 BLA_50 BLAD_242 BLA__50 BLB_50 BLBD_244 BLB__50 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI51_1 BLA_50 BLAD_242 BLA__50 BLB_50 BLBD_244 BLB__50 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI51_2 BLA_50 BLA__50 BLB_50 BLB__50 WLA WLB VSS VDD RA2SH128x36CCG
XI52_0 BLA_51 BLAD_30 BLA__51 BLB_51 BLBD_32 BLB__51 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI52_1 BLA_51 BLAD_30 BLA__51 BLB_51 BLBD_32 BLB__51 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI52_2 BLA_51 BLA__51 BLB_51 BLB__51 WLA WLB VSS VDD RA2SH128x36CCG
XI53_0 BLA_52 BLAD_106 BLA__52 BLB_52 BLBD_108 BLB__52 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI53_1 BLA_52 BLAD_106 BLA__52 BLB_52 BLBD_108 BLB__52 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI53_2 BLA_52 BLA__52 BLB_52 BLB__52 WLA WLB VSS VDD RA2SH128x36CCP
XI54_0 BLA_53 BLAD_182 BLA__53 BLB_53 BLBD_184 BLB__53 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI54_1 BLA_53 BLAD_182 BLA__53 BLB_53 BLBD_184 BLB__53 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI54_2 BLA_53 BLA__53 BLB_53 BLB__53 WLA WLB VSS VDD RA2SH128x36CCP
XI55_0 BLA_54 BLAD_254 BLA__54 BLB_54 BLBD_256 BLB__54 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI55_1 BLA_54 BLAD_254 BLA__54 BLB_54 BLBD_256 BLB__54 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI55_2 BLA_54 BLA__54 BLB_54 BLB__54 WLA WLB VSS VDD RA2SH128x36CCG
XI56_0 BLA_55 BLAD_42 BLA__55 BLB_55 BLBD_44 BLB__55 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI56_1 BLA_55 BLAD_42 BLA__55 BLB_55 BLBD_44 BLB__55 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI56_2 BLA_55 BLA__55 BLB_55 BLB__55 WLA WLB VSS VDD RA2SH128x36CCG
XI57_0 BLA_56 BLAD_114 BLA__56 BLB_56 BLBD_116 BLB__56 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI57_1 BLA_56 BLAD_114 BLA__56 BLB_56 BLBD_116 BLB__56 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI57_2 BLA_56 BLA__56 BLB_56 BLB__56 WLA WLB VSS VDD RA2SH128x36CCP
XI58_0 BLA_57 BLAD_190 BLA__57 BLB_57 BLBD_192 BLB__57 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI58_1 BLA_57 BLAD_190 BLA__57 BLB_57 BLBD_192 BLB__57 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI58_2 BLA_57 BLA__57 BLB_57 BLB__57 WLA WLB VSS VDD RA2SH128x36CCP
XI59_0 BLA_58 BLAD_262 BLA__58 BLB_58 BLBD_264 BLB__58 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI59_1 BLA_58 BLAD_262 BLA__58 BLB_58 BLBD_264 BLB__58 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI59_2 BLA_58 BLA__58 BLB_58 BLB__58 WLA WLB VSS VDD RA2SH128x36CCG
XI5_0 BLA_4 BLAD_198 BLA__4 BLB_4 BLBD_200 BLB__4 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI5_1 BLA_4 BLAD_198 BLA__4 BLB_4 BLBD_200 BLB__4 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI5_2 BLA_4 BLA__4 BLB_4 BLB__4 WLA WLB VSS VDD RA2SH128x36CCP
XI60_0 BLA_59 BLAD_278 BLA__59 BLB_59 BLBD_280 BLB__59 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI60_1 BLA_59 BLAD_278 BLA__59 BLB_59 BLBD_280 BLB__59 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI60_2 BLA_59 BLA__59 BLB_59 BLB__59 WLA WLB VSS VDD RA2SH128x36CCG
XI61_0 BLA_60 BLAD_66 BLA__60 BLB_60 BLBD_68 BLB__60 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI61_1 BLA_60 BLAD_66 BLA__60 BLB_60 BLBD_68 BLB__60 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI61_2 BLA_60 BLA__60 BLB_60 BLB__60 WLA WLB VSS VDD RA2SH128x36CCP
XI62_0 BLA_61 BLAD_142 BLA__61 BLB_61 BLBD_144 BLB__61 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI62_1 BLA_61 BLAD_142 BLA__61 BLB_61 BLBD_144 BLB__61 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI62_2 BLA_61 BLA__61 BLB_61 BLB__61 WLA WLB VSS VDD RA2SH128x36CCP
XI63_0 BLA_62 BLAD_218 BLA__62 BLB_62 BLBD_220 BLB__62 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI63_1 BLA_62 BLAD_218 BLA__62 BLB_62 BLBD_220 BLB__62 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI63_2 BLA_62 BLA__62 BLB_62 BLB__62 WLA WLB VSS VDD RA2SH128x36CCG
XI64_0 BLA_63 BLAD_6 BLA__63 BLB_63 BLBD_8 BLB__63 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI64_1 BLA_63 BLAD_6 BLA__63 BLB_63 BLBD_8 BLB__63 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI64_2 BLA_63 BLA__63 BLB_63 BLB__63 WLA WLB VSS VDD RA2SH128x36CCG
XI65_0 BLA_64 BLAD_78 BLA__64 BLB_64 BLBD_80 BLB__64 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI65_1 BLA_64 BLAD_78 BLA__64 BLB_64 BLBD_80 BLB__64 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI65_2 BLA_64 BLA__64 BLB_64 BLB__64 WLA WLB VSS VDD RA2SH128x36CCP
XI66_0 BLA_65 BLAD_154 BLA__65 BLB_65 BLBD_156 BLB__65 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI66_1 BLA_65 BLAD_154 BLA__65 BLB_65 BLBD_156 BLB__65 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI66_2 BLA_65 BLA__65 BLB_65 BLB__65 WLA WLB VSS VDD RA2SH128x36CCP
XI67_0 BLA_66 BLAD_230 BLA__66 BLB_66 BLBD_232 BLB__66 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI67_1 BLA_66 BLAD_230 BLA__66 BLB_66 BLBD_232 BLB__66 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI67_2 BLA_66 BLA__66 BLB_66 BLB__66 WLA WLB VSS VDD RA2SH128x36CCG
XI68_0 BLA_67 BLAD_14 BLA__67 BLB_67 BLBD_16 BLB__67 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI68_1 BLA_67 BLAD_14 BLA__67 BLB_67 BLBD_16 BLB__67 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI68_2 BLA_67 BLA__67 BLB_67 BLB__67 WLA WLB VSS VDD RA2SH128x36CCG
XI69_0 BLA_68 BLAD_86 BLA__68 BLB_68 BLBD_88 BLB__68 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI69_1 BLA_68 BLAD_86 BLA__68 BLB_68 BLBD_88 BLB__68 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI69_2 BLA_68 BLA__68 BLB_68 BLB__68 WLA WLB VSS VDD RA2SH128x36CCP
XI6_0 BLA_5 BLAD_270 BLA__5 BLB_5 BLBD_272 BLB__5 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI6_1 BLA_5 BLAD_270 BLA__5 BLB_5 BLBD_272 BLB__5 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI6_2 BLA_5 BLA__5 BLB_5 BLB__5 WLA WLB VSS VDD RA2SH128x36CCP
XI70_0 BLA_69 BLAD_102 BLA__69 BLB_69 BLBD_104 BLB__69 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI70_1 BLA_69 BLAD_102 BLA__69 BLB_69 BLBD_104 BLB__69 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI70_2 BLA_69 BLA__69 BLB_69 BLB__69 WLA WLB VSS VDD RA2SH128x36CCP
XI71_0 BLA_70 BLAD_178 BLA__70 BLB_70 BLBD_180 BLB__70 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI71_1 BLA_70 BLAD_178 BLA__70 BLB_70 BLBD_180 BLB__70 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI71_2 BLA_70 BLA__70 BLB_70 BLB__70 WLA WLB VSS VDD RA2SH128x36CCG
XI7_0 BLA_6 BLAD_54 BLA__6 BLB_6 BLBD_56 BLB__6 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI7_1 BLA_6 BLAD_54 BLA__6 BLB_6 BLBD_56 BLB__6 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI7_2 BLA_6 BLA__6 BLB_6 BLB__6 WLA WLB VSS VDD RA2SH128x36CCG
XI8_0 BLA_7 BLAD_126 BLA__7 BLB_7 BLBD_128 BLB__7 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI8_1 BLA_7 BLAD_126 BLA__7 BLB_7 BLBD_128 BLB__7 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI8_2 BLA_7 BLA__7 BLB_7 BLB__7 WLA WLB VSS VDD RA2SH128x36CCG
XI9_0 BLA_8 BLAD_202 BLA__8 BLB_8 BLBD_204 BLB__8 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI9_1 BLA_8 BLAD_202 BLA__8 BLB_8 BLBD_204 BLB__8 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI9_2 BLA_8 BLA__8 BLB_8 BLB__8 WLA WLB VSS VDD RA2SH128x36CCP
.ENDS RA2SH128x36MODEL_ROW_RIGHT
****
.SUBCKT RA2SH128x36MXCD_ODD_LEFT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTPA GTPB STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MXCD_ODD_LEFT: 172 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA2 BLA2_ BLA3 BLA3_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA YPA0_1 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDASX
XI1_0 A0A A0A_ A0B A0B_ BLB2 BLB2_ BLB3 BLB3_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_0
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_0 YPB0_1 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI2_0 A0A A0A_ A0B A0B_ BLB0 BLB0_ BLB1 BLB1_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_1
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_1 YPB0_0 VDD GTPA GTPB YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI3_0 A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ DRSA DRSA_0 DRSA_2 DRSA_1 DRSA_2
+  DWSA DWSA_0 DWSA_2 DWSA_1 DWSA_2 YPA0_0 VDD GTPA GTPB STUBDRA STUBDRA_
+  STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDAX
.ENDS RA2SH128x36MXCD_ODD_LEFT
****
.SUBCKT RA2SH128x36MCOL_MOL4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_MOL4: 1398 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWM4A
XI0_1 D DPN DPU STUBDWA_0 STUBDWA__0 GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB
+  VSS VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA_0 STUBDRA__0 STUBDWA_0 STUBDWA__0 GTPA_0 GTPB_0 SP VSS
+  VDD RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA__2 BLA_2 BLA__1 BLA_1 BLA__0 BLA_0 BLA_ BLA BLB__2
+  BLB_2 BLB__1 BLB_1 BLB__0 BLB_0 BLB_ BLB STUBDRA_0 STUBDRA__0 STUBDRB__0
+  STUBDRB_0 STUBDWA_0 STUBDWA__0 STUBDWB__0 STUBDWB_0 GTPA_1 GTPB_1 STUBDRA
+  STUBDRA_ STUBDRB STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_ODD_LEFT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB_0 STUBDWB__0 GTPA GTPB OEA_ OEB_ Q_0 SP_3
+  STUBWEA STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB_0 STUBDRB__0 STUBDWB_0 STUBDWB__0 GTPA_0 GTPB_0 SP_3
+  VSS VDD RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_MOL4
****
.SUBCKT RA2SH128x36MXCD_EVEN_LEFT A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ BLA2
+  BLA2_ BLA3 BLA3_ BLB0 BLB0_ BLB1 BLB1_ BLB2 BLB2_ BLB3 BLB3_ GTPA GTPB
+  STUBDRA STUBDRA_ STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0
+  STUBDWA STUBDWA_ STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MXCD_EVEN_LEFT: 172 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA0 BLA0_ BLA1 BLA1_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRA STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWA YPA0_0 VDD GTPA
+  GTPB STUBDRA_0 STUBDRA__0 STUBDRB_0 STUBDRB__0 STUBDWA_0 STUBDWA__0
+  STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36CDAX
XI1_0 A0A A0A_ A0B A0B_ BLB0 BLB0_ BLB1 BLB1_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRA_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWA_ YPB0_0 VDD
+  GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI2_0 A0A A0A_ A0B A0B_ BLB2 BLB2_ BLB3 BLB3_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRB_ STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWB_ YPB0_1 VDD
+  GTPA GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDBSX
XI3_0 A0A A0A_ A0B A0B_ BLA2 BLA2_ BLA3 BLA3_ STUBDRA STUBDRA_ STUBDRB
+  STUBDRB_ STUBDRB STUBDWA STUBDWA_ STUBDWB STUBDWB_ STUBDWB YPA0_1 VDD GTPA
+  GTPB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36CDASX
.ENDS RA2SH128x36MXCD_EVEN_LEFT
****
.SUBCKT RA2SH128x36MCOL_MEL4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_MEL4: 1398 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWM4A
XI0_1 D DPN DPU STUBDWA STUBDWA_ GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB VSS
+  VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA STUBDRA_ STUBDWA STUBDWA_ GTPA_0 GTPB_0 SP VSS VDD
+  RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA_ BLA BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLB_
+  BLB BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 GTPA_1 GTPB_1 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_EVEN_LEFT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB STUBDWB_ GTPA GTPB OEA_ OEB_ Q_0 SP_3 STUBWEA
+  STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB STUBDRB_ STUBDWB STUBDWB_ GTPA_0 GTPB_0 SP_3 VSS VDD
+  RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_MEL4
****
.SUBCKT RA2SH128x36FCBWLE4 BWEN BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWLE4: 3 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS BWENA DN 0.2116P 1.84U
d3 VSS D DN 0.2116P 1.84U
.ENDS RA2SH128x36FCBWLE4
****
.SUBCKT RA2SH128x36FCBWLE4A BWENA BWENB D Q VSS VDD
** RA2SH128x36FCBWLE4A: 3 flat devices **
XI0_0 BWENA BWENA BWENB D Q VSS VDD RA2SH128x36FCBWLE4
.ENDS RA2SH128x36FCBWLE4A
****
.SUBCKT RA2SH128x36MCOL_LEL4 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA__0 BLA__1 BLA__2 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB
+  WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10
+  WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20
+  WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB
+  WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11
+  WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21
+  WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36MCOL_LEL4: 1399 flat devices **
XI0_0 VSS VSS D Q VSS VDD RA2SH128x36FCBWLE4A
XI0_1 D DPN DPU STUBDWA STUBDWA_ GTPA GTPB OEA_ OEB_ Q SP STUBWEA STUBWEB VSS
+  VDD RA2SH128x36IOXX_A
XI0_2 DPN DPU STUBDRA STUBDRA_ STUBDWA STUBDWA_ GTPA_0 GTPB_0 SP VSS VDD
+  RA2SH128x36SAX_A
XI0_3 A0A A0A_ A0B A0B_ BLA_ BLA BLA__0 BLA_0 BLA__1 BLA_1 BLA__2 BLA_2 BLB_
+  BLB BLB__0 BLB_0 BLB__1 BLB_1 BLB__2 BLB_2 GTPA_1 GTPB_1 STUBDRA STUBDRA_
+  STUBDRA_0 STUBDRA__0 STUBDRB STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_
+  STUBDWA_0 STUBDWA__0 STUBDWB STUBDWB_ STUBDWB_0 STUBDWB__0 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MXCD_EVEN_LEFT
XI0_4 BLA_2 BLA_1 BLA_0 BLA BLA__2 BLA__1 BLA__0 BLA_ BLB_2 BLB_1 BLB_0 BLB
+  BLB__2 BLB__1 BLB__0 BLB_ WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 VSS VDD RA2SH128x36BIT_COL
XI1_0 VSS VSS D_0 Q_0 VSS VDD RA2SH128x36FCBWM4B
XI1_1 D_0 DPN_7 DPU_5 STUBDWB STUBDWB_ GTPA GTPB OEA_ OEB_ Q_0 SP_3 STUBWEA
+  STUBWEB VSS VDD RA2SH128x36IOXX_B
XI1_2 DPN_7 DPU_5 STUBDRB STUBDRB_ STUBDWB STUBDWB_ GTPA_0 GTPB_0 SP_3 VSS VDD
+  RA2SH128x36SAX_B
.ENDS RA2SH128x36MCOL_LEL4
****
.SUBCKT RA2SH128x36WING_18_LEFT A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2
+  BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13
+  BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23
+  BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33
+  BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43
+  BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53
+  BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63
+  BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69 BLA_70 BLA__0 BLA__1 BLA__2
+  BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12
+  BLA__13 BLA__14 BLA__15 BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21
+  BLA__22 BLA__23 BLA__24 BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30
+  BLA__31 BLA__32 BLA__33 BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39
+  BLA__40 BLA__41 BLA__42 BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48
+  BLA__49 BLA__50 BLA__51 BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57
+  BLA__58 BLA__59 BLA__60 BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66
+  BLA__67 BLA__68 BLA__69 BLA__70 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB_3 BLB_4
+  BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15
+  BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25
+  BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35
+  BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45
+  BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55
+  BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65
+  BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4
+  BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14
+  BLB__15 BLB__16 BLB__17 BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23
+  BLB__24 BLB__25 BLB__26 BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32
+  BLB__33 BLB__34 BLB__35 BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41
+  BLB__42 BLB__43 BLB__44 BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50
+  BLB__51 BLB__52 BLB__53 BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59
+  BLB__60 BLB__61 BLB__62 BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68
+  BLB__69 BLB__70 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12
+  D_13 D_14 D_15 D_16 D_17 D_18 D_19 D_20 D_21 D_22 D_23 D_24 D_25 D_26 D_27
+  D_28 D_29 D_30 D_31 D_32 D_33 D_34 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1
+  OEA_ OEB_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13
+  Q_14 Q_15 Q_16 Q_17 Q_18 Q_19 Q_20 Q_21 Q_22 Q_23 Q_24 Q_25 Q_26 Q_27 Q_28
+  Q_29 Q_30 Q_31 Q_32 Q_33 Q_34 STUBDRA STUBDRA_ STUBDRA_0 STUBDRA__0 STUBDRB
+  STUBDRB_ STUBDRB_0 STUBDRB__0 STUBDWA STUBDWA_ STUBDWA_0 STUBDWA__0 STUBDWB
+  STUBDWB_ STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3
+  WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14
+  WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24
+  WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4
+  WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15
+  WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25
+  WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36WING_18_LEFT: 25165 flat devices **
XI0_0 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2 BLA__0 BLA__1 BLA__2 BLB
+  BLB_ BLB_0 BLB_1 BLB_2 BLB__0 BLB__1 BLB__2 D D_0 GTPA GTPA_0 GTPA_1 GTPB
+  GTPB_0 GTPB_1 OEA_ OEB_ Q Q_0 STUBDRA_131 STUBDRA__129 STUBDRA_0 STUBDRA__0
+  STUBDRB_135 STUBDRB__133 STUBDRB_0 STUBDRB__0 STUBDWA_137 STUBDWA__139
+  STUBDWA_0 STUBDWA__0 STUBDWB_141 STUBDWB__143 STUBDWB_0 STUBDWB__0 STUBWEA
+  STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOL4
XI10_0 A0A A0A_ A0B A0B_ BLA_39 BLA__39 BLA_40 BLA_41 BLA_42 BLA__40 BLA__41
+  BLA__42 BLB_39 BLB__39 BLB_40 BLB_41 BLB_42 BLB__40 BLB__41 BLB__42 D_19
+  D_20 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_19 Q_20 STUBDRA_3
+  STUBDRA__1 STUBDRA_0_19 STUBDRA__0_17 STUBDRB_7 STUBDRB__5 STUBDRB_0_23
+  STUBDRB__0_21 STUBDWA_9 STUBDWA__11 STUBDWA_0_25 STUBDWA__0_27 STUBDWB_13
+  STUBDWB__15 STUBDWB_0_29 STUBDWB__0_31 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOL4
XI11_0 A0A A0A_ A0B A0B_ BLA_46 BLA__46 BLA_45 BLA_44 BLA_43 BLA__45 BLA__44
+  BLA__43 BLB_46 BLB__46 BLB_45 BLB_44 BLB_43 BLB__45 BLB__44 BLB__43 D_22
+  D_21 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_22 Q_21 STUBDRA_3
+  STUBDRA__1 STUBDRA_0_35 STUBDRA__0_33 STUBDRB_7 STUBDRB__5 STUBDRB_0_39
+  STUBDRB__0_37 STUBDWA_9 STUBDWA__11 STUBDWA_0_41 STUBDWA__0_43 STUBDWB_13
+  STUBDWB__15 STUBDWB_0_45 STUBDWB__0_47 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MEL4
XI12_0 A0A A0A_ A0B A0B_ BLA_47 BLA__47 BLA_48 BLA_49 BLA_50 BLA__48 BLA__49
+  BLA__50 BLB_47 BLB__47 BLB_48 BLB_49 BLB_50 BLB__48 BLB__49 BLB__50 D_23
+  D_24 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_23 Q_24 STUBDRA_51
+  STUBDRA__49 STUBDRA_0_35 STUBDRA__0_33 STUBDRB_55 STUBDRB__53 STUBDRB_0_39
+  STUBDRB__0_37 STUBDWA_57 STUBDWA__59 STUBDWA_0_41 STUBDWA__0_43 STUBDWB_61
+  STUBDWB__63 STUBDWB_0_45 STUBDWB__0_47 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOL4
XI13_0 A0A A0A_ A0B A0B_ BLA_54 BLA__54 BLA_53 BLA_52 BLA_51 BLA__53 BLA__52
+  BLA__51 BLB_54 BLB__54 BLB_53 BLB_52 BLB_51 BLB__53 BLB__52 BLB__51 D_26
+  D_25 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_26 Q_25 STUBDRA_51
+  STUBDRA__49 STUBDRA_0_67 STUBDRA__0_65 STUBDRB_55 STUBDRB__53 STUBDRB_0_71
+  STUBDRB__0_69 STUBDWA_57 STUBDWA__59 STUBDWA_0_73 STUBDWA__0_75 STUBDWB_61
+  STUBDWB__63 STUBDWB_0_77 STUBDWB__0_79 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MEL4
XI14_0 A0A A0A_ A0B A0B_ BLA_55 BLA__55 BLA_56 BLA_57 BLA_58 BLA__56 BLA__57
+  BLA__58 BLB_55 BLB__55 BLB_56 BLB_57 BLB_58 BLB__56 BLB__57 BLB__58 D_27
+  D_28 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_27 Q_28 STUBDRA_83
+  STUBDRA__81 STUBDRA_0_67 STUBDRA__0_65 STUBDRB_87 STUBDRB__85 STUBDRB_0_71
+  STUBDRB__0_69 STUBDWA_89 STUBDWA__91 STUBDWA_0_73 STUBDWA__0_75 STUBDWB_93
+  STUBDWB__95 STUBDWB_0_77 STUBDWB__0_79 STUBWEA STUBWEB WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2
+  YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0
+  YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOL4
XI15_0 A0A A0A_ A0B A0B_ BLA_62 BLA__62 BLA_61 BLA_60 BLA_59 BLA__61 BLA__60
+  BLA__59 BLB_62 BLB__62 BLB_61 BLB_60 BLB_59 BLB__61 BLB__60 BLB__59 D_30
+  D_29 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_30 Q_29 STUBDRA_83
+  STUBDRA__81 STUBDRA_0_99 STUBDRA__0_97 STUBDRB_87 STUBDRB__85 STUBDRB_0_103
+  STUBDRB__0_101 STUBDWA_89 STUBDWA__91 STUBDWA_0_105 STUBDWA__0_107
+  STUBDWB_93 STUBDWB__95 STUBDWB_0_109 STUBDWB__0_111 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MEL4
XI16_0 A0A A0A_ A0B A0B_ BLA_63 BLA__63 BLA_64 BLA_65 BLA_66 BLA__64 BLA__65
+  BLA__66 BLB_63 BLB__63 BLB_64 BLB_65 BLB_66 BLB__64 BLB__65 BLB__66 D_31
+  D_32 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_31 Q_32 STUBDRA_115
+  STUBDRA__113 STUBDRA_0_99 STUBDRA__0_97 STUBDRB_119 STUBDRB__117
+  STUBDRB_0_103 STUBDRB__0_101 STUBDWA_121 STUBDWA__123 STUBDWA_0_105
+  STUBDWA__0_107 STUBDWB_125 STUBDWB__127 STUBDWB_0_109 STUBDWB__0_111
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOL4
XI17_0 A0A A0A_ A0B A0B_ BLA_70 BLA__70 BLA_69 BLA_68 BLA_67 BLA__69 BLA__68
+  BLA__67 BLB_70 BLB__70 BLB_69 BLB_68 BLB_67 BLB__69 BLB__68 BLB__67 D_34
+  D_33 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_34 Q_33 STUBDRA_115
+  STUBDRA__113 STUBDRA STUBDRA_ STUBDRB_119 STUBDRB__117 STUBDRB STUBDRB_
+  STUBDWA_121 STUBDWA__123 STUBDWA STUBDWA_ STUBDWB_125 STUBDWB__127 STUBDWB
+  STUBDWB_ STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6
+  WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17
+  WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27
+  WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7
+  WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18
+  WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28
+  WLB_29 WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_LEL4
XI1_0 A0A A0A_ A0B A0B_ BLA_6 BLA__6 BLA_5 BLA_4 BLA_3 BLA__5 BLA__4 BLA__3
+  BLB_6 BLB__6 BLB_5 BLB_4 BLB_3 BLB__5 BLB__4 BLB__3 D_2 D_1 GTPA GTPA_0
+  GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_2 Q_1 STUBDRA_131 STUBDRA__129
+  STUBDRA_0_147 STUBDRA__0_145 STUBDRB_135 STUBDRB__133 STUBDRB_0_151
+  STUBDRB__0_149 STUBDWA_137 STUBDWA__139 STUBDWA_0_153 STUBDWA__0_155
+  STUBDWB_141 STUBDWB__143 STUBDWB_0_157 STUBDWB__0_159 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MEL4
XI2_0 A0A A0A_ A0B A0B_ BLA_7 BLA__7 BLA_8 BLA_9 BLA_10 BLA__8 BLA__9 BLA__10
+  BLB_7 BLB__7 BLB_8 BLB_9 BLB_10 BLB__8 BLB__9 BLB__10 D_3 D_4 GTPA GTPA_0
+  GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_3 Q_4 STUBDRA_163 STUBDRA__161
+  STUBDRA_0_147 STUBDRA__0_145 STUBDRB_167 STUBDRB__165 STUBDRB_0_151
+  STUBDRB__0_149 STUBDWA_169 STUBDWA__171 STUBDWA_0_153 STUBDWA__0_155
+  STUBDWB_173 STUBDWB__175 STUBDWB_0_157 STUBDWB__0_159 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36MCOL_MOL4
XI3_0 A0A A0A_ A0B A0B_ BLA_14 BLA__14 BLA_13 BLA_12 BLA_11 BLA__13 BLA__12
+  BLA__11 BLB_14 BLB__14 BLB_13 BLB_12 BLB_11 BLB__13 BLB__12 BLB__11 D_6 D_5
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_6 Q_5 STUBDRA_163
+  STUBDRA__161 STUBDRA_0_179 STUBDRA__0_177 STUBDRB_167 STUBDRB__165
+  STUBDRB_0_183 STUBDRB__0_181 STUBDWA_169 STUBDWA__171 STUBDWA_0_185
+  STUBDWA__0_187 STUBDWB_173 STUBDWB__175 STUBDWB_0_189 STUBDWB__0_191
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MEL4
XI4_0 A0A A0A_ A0B A0B_ BLA_15 BLA__15 BLA_16 BLA_17 BLA_18 BLA__16 BLA__17
+  BLA__18 BLB_15 BLB__15 BLB_16 BLB_17 BLB_18 BLB__16 BLB__17 BLB__18 D_7 D_8
+  GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_7 Q_8 STUBDRA_195
+  STUBDRA__193 STUBDRA_0_179 STUBDRA__0_177 STUBDRB_199 STUBDRB__197
+  STUBDRB_0_183 STUBDRB__0_181 STUBDWA_201 STUBDWA__203 STUBDWA_0_185
+  STUBDWA__0_187 STUBDWB_205 STUBDWB__207 STUBDWB_0_189 STUBDWB__0_191
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOL4
XI5_0 A0A A0A_ A0B A0B_ BLA_22 BLA__22 BLA_21 BLA_20 BLA_19 BLA__21 BLA__20
+  BLA__19 BLB_22 BLB__22 BLB_21 BLB_20 BLB_19 BLB__21 BLB__20 BLB__19 D_10
+  D_9 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_10 Q_9 STUBDRA_195
+  STUBDRA__193 STUBDRA_0_211 STUBDRA__0_209 STUBDRB_199 STUBDRB__197
+  STUBDRB_0_215 STUBDRB__0_213 STUBDWA_201 STUBDWA__203 STUBDWA_0_217
+  STUBDWA__0_219 STUBDWB_205 STUBDWB__207 STUBDWB_0_221 STUBDWB__0_223
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MEL4
XI6_0 A0A A0A_ A0B A0B_ BLA_23 BLA__23 BLA_24 BLA_25 BLA_26 BLA__24 BLA__25
+  BLA__26 BLB_23 BLB__23 BLB_24 BLB_25 BLB_26 BLB__24 BLB__25 BLB__26 D_11
+  D_12 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_11 Q_12 STUBDRA_227
+  STUBDRA__225 STUBDRA_0_211 STUBDRA__0_209 STUBDRB_231 STUBDRB__229
+  STUBDRB_0_215 STUBDRB__0_213 STUBDWA_233 STUBDWA__235 STUBDWA_0_217
+  STUBDWA__0_219 STUBDWB_237 STUBDWB__239 STUBDWB_0_221 STUBDWB__0_223
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOL4
XI7_0 A0A A0A_ A0B A0B_ BLA_30 BLA__30 BLA_29 BLA_28 BLA_27 BLA__29 BLA__28
+  BLA__27 BLB_30 BLB__30 BLB_29 BLB_28 BLB_27 BLB__29 BLB__28 BLB__27 D_14
+  D_13 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_14 Q_13 STUBDRA_227
+  STUBDRA__225 STUBDRA_0_243 STUBDRA__0_241 STUBDRB_231 STUBDRB__229
+  STUBDRB_0_247 STUBDRB__0_245 STUBDWA_233 STUBDWA__235 STUBDWA_0_249
+  STUBDWA__0_251 STUBDWB_237 STUBDWB__239 STUBDWB_0_253 STUBDWB__0_255
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MEL4
XI8_0 A0A A0A_ A0B A0B_ BLA_31 BLA__31 BLA_32 BLA_33 BLA_34 BLA__32 BLA__33
+  BLA__34 BLB_31 BLB__31 BLB_32 BLB_33 BLB_34 BLB__32 BLB__33 BLB__34 D_15
+  D_16 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_15 Q_16 STUBDRA_259
+  STUBDRA__257 STUBDRA_0_243 STUBDRA__0_241 STUBDRB_263 STUBDRB__261
+  STUBDRB_0_247 STUBDRB__0_245 STUBDWA_265 STUBDWA__267 STUBDWA_0_249
+  STUBDWA__0_251 STUBDWB_269 STUBDWB__271 STUBDWB_0_253 STUBDWB__0_255
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MOL4
XI9_0 A0A A0A_ A0B A0B_ BLA_38 BLA__38 BLA_37 BLA_36 BLA_35 BLA__37 BLA__36
+  BLA__35 BLB_38 BLB__38 BLB_37 BLB_36 BLB_35 BLB__37 BLB__36 BLB__35 D_18
+  D_17 GTPA GTPA_0 GTPA_1 GTPB GTPB_0 GTPB_1 OEA_ OEB_ Q_18 Q_17 STUBDRA_259
+  STUBDRA__257 STUBDRA_0_19 STUBDRA__0_17 STUBDRB_263 STUBDRB__261
+  STUBDRB_0_23 STUBDRB__0_21 STUBDWA_265 STUBDWA__267 STUBDWA_0_25
+  STUBDWA__0_27 STUBDWB_269 STUBDWB__271 STUBDWB_0_29 STUBDWB__0_31 STUBWEA
+  STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9
+  WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0
+  YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36MCOL_MEL4
.ENDS RA2SH128x36WING_18_LEFT
****
.SUBCKT RA2SH128x36HBF4 CEN CLK GSRCN GTP GTPA GTPB GTPN MBL RST STOV STUBBWA
+  STUBBWB TMS WEI WEIA WEIB WEN VSS VDD
** RA2SH128x36HBF4: 76 flat devices **
d72 VSS WEN DN 0.2116P 1.84U
d73 VSS CEN DN 0.2116P 1.84U
d74 VSS STOV DN 0.2116P 1.84U
d75 VSS CLK DN 0.2116P 1.84U
d76 VSS TMS DN 0.2116P 1.84U
m1 WEI N35 VDD VDD P L=0.13U W=7.67U
m10 BF-CLKN CLK VSS VSS N L=0.26U W=0.38U
m11 N79 GTP VSS VSS N L=0.13U W=0.91U
m12 BF-RSRCN BF-CKSTOV N79 VSS N L=0.13U W=0.91U
m13 BF-RSRCN GTP VDD VDD P L=0.13U W=1.43U
m14 N78 GTP VSS VSS N L=0.13U W=0.91U
m15 BF-RSRCN BF-CKSTOV VDD VDD P L=0.13U W=1.43U
m16 BF-RSRCN BF-CKSTOV N78 VSS N L=0.13U W=0.91U
m17 BF-RSTSRC BF-RSRCN VDD VDD P L=0.13U W=4.32U
m18 BF-RSTSRC BF-RSRCN VSS VSS N L=0.13U W=2.77U
m19 BF-CKSTOV STOV VDD VDD P L=0.13U W=0.58U
m2 WEI N35 VSS VSS N L=0.13U W=5.39U
m20 N80 STOV VSS VSS N L=0.13U W=0.74U
m21 BF-CKSTOV CLK VDD VDD P L=0.13U W=0.58U
m22 BF-CKSTOV CLK N80 VSS N L=0.13U W=0.74U
m23 GTPN BF-GTPI N50 VSS N L=0.13U W=0.15U
m24 N29 N29 VDD VDD P L=0.13U W=0.15U
m25 GTPN BF-GTPI VDD VDD P L=0.13U W=0.15U
m26 N29 VDD VDD VDD P L=0.13U W=0.15U
m27 BF-GTPI GTPN VDD VDD P L=0.13U W=0.3U
m28 BF-GTPI GTPN VSS VSS N L=0.13U W=0.15U
m29 N50 N29 VSS VSS N L=0.13U W=0.15U
m3 BF-CENMML BF-CLKN N77 VDD P L=0.13U W=0.15U
m30 N82 BF-CLKN VSS VSS N L=0.13U W=1.78U
m31 GSRCN BF-CEL N82 VSS N L=0.13U W=1.78U
m32 GSRCN BF-CLKN VDD VDD P L=0.13U W=2.22U
m33 N81 BF-CLKN VSS VSS N L=0.13U W=1.78U
m34 GSRCN BF-CEL VDD VDD P L=0.13U W=2.22U
m35 GSRCN BF-CEL N81 VSS N L=0.13U W=1.78U
m36 N59 BF-CLKN VSS VSS N L=0.13U W=0.34U
m37 N61 CLK VDD VDD P L=0.13U W=0.63U
m38 BF-CENMML N63 N64 VDD P L=0.13U W=0.63U
m39 BF-CENMML N63 N59 VSS N L=0.13U W=0.34U
m4 N77 BF-CEL VDD VDD P L=0.13U W=0.15U
m40 N64 TMS N61 VDD P L=0.13U W=0.63U
m41 BF-CENMML TMS N59 VSS N L=0.13U W=0.34U
m42 RST BF-MBLN VDD VDD P L=0.13U W=2.25U
m43 RST BF-RSTSRC VDD VDD P L=0.13U W=7.66U
m44 BF-MBLN MBL VDD VDD P L=0.13U W=3.28U
m45 BF-MBLN MBL VSS VSS N L=0.13U W=1.5U
m46 N69 WEN VDD VDD P L=0.13U W=0.79U
m47 N69 WEN VSS VSS N L=0.13U W=0.53U
m48 N63 CEN VDD VDD P L=0.13U W=0.7U
m49 N63 CEN VSS VSS N L=0.13U W=0.47U
m5 BF-CENMML CLK N76 VSS N L=0.13U W=0.15U
m50 RST BF-MBLN N92 VSS N L=0.13U W=1.28U
m51 N92 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m52 RST BF-MBLN N91 VSS N L=0.13U W=1.28U
m53 N91 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m54 RST BF-MBLN N90 VSS N L=0.13U W=1.28U
m55 N90 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m56 RST BF-MBLN N89 VSS N L=0.13U W=1.28U
m57 N89 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m58 RST BF-MBLN N88 VSS N L=0.13U W=1.28U
m59 N88 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m6 N76 BF-CEL VSS VSS N L=0.13U W=0.15U
m60 RST BF-MBLN N87 VSS N L=0.13U W=1.28U
m61 N87 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m62 RST BF-MBLN N86 VSS N L=0.13U W=1.28U
m63 N86 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m64 RST BF-MBLN N85 VSS N L=0.13U W=1.28U
m65 N85 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m66 RST BF-MBLN N84 VSS N L=0.13U W=1.28U
m67 N84 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m68 RST BF-MBLN N83 VSS N L=0.13U W=1.28U
m69 N83 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m7 BF-CEL BF-CENMML VDD VDD P L=0.13U W=0.91U
m70 N35 N69 VDD VDD P L=0.13U W=2.24U
m71 N35 N69 VSS VSS N L=0.13U W=1.44U
m8 BF-CEL BF-CENMML VSS VSS N L=0.13U W=0.65U
m9 BF-CLKN CLK VDD VDD P L=0.13U W=1.05U
.ENDS RA2SH128x36HBF4
****
.SUBCKT RA2SH128x36HBFX_B CEN CLK GSRCN GTPA GTPB GTPN MBL RST STUBBWA STUBBWB
+  WEIA WEIB WEN VSS VDD
** RA2SH128x36HBFX_B: 76 flat devices **
XI0_0 CEN CLK GSRCN GTPB GTPA GTPB GTPN MBL RST VSS STUBBWA STUBBWB VSS WEIB
+  WEIA WEIB WEN VSS VDD RA2SH128x36HBF4
.ENDS RA2SH128x36HBFX_B
****
.SUBCKT RA2SH128x36FLCIOX_B A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL
+  MBLA MBLA_ MBLB_ YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36FLCIOX_B: 22 flat devices **
XI0_0 A0A A0A_ A0B A0B_ CLK GSRCN GTPA GTPB GTPN MBL MBLA MBLA_ MBL MBLB_
+  YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1
+  YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36FLCIO
.ENDS RA2SH128x36FLCIOX_B
****
.SUBCKT RA2SH128x36HCKA A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTPN RST YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK CK-GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 AGTP GTPN VDD VDD P L=0.13U W=27.52U
m5 AGTP GTPN VSS VSS N L=0.13U W=12.44U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.13U W=6.27U
m9 CK-GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA2SH128x36HCKA
****
.SUBCKT RA2SH128x36CK A0A A0A_ A0B A0B_ CLK GSRCN GTP GTPN RST YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 GTP GTPN VDD VDD P L=0.13U W=27.52U
m5 GTP GTPN VSS VSS N L=0.13U W=12.44U
m6 GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 GTPFEED CLK SRCFEED VSS N L=0.13U W=6.27U
m9 GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA2SH128x36CK
****
.SUBCKT RA2SH128x36CK1 A0A A0A_ A0B A0B_ CLK GSRCN GTP GTPN RST YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CK1: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 GTP GTPN VDD VDD P L=0.13U W=27.52U
m5 GTP GTPN VSS VSS N L=0.13U W=12.44U
m6 GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 GTPFEED CLK SRCFEED VSS N L=0.13U W=6.27U
m9 GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA2SH128x36CK1
****
.SUBCKT RA2SH128x36CLK_DRVS A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTP GTPN GTP_0
+  GTP_1 GTP_2 RST YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3
+  YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36CLK_DRVS: 45 flat devices **
XI0_0 A0A A0A_ A0B A0B_ AGTP CLK GSRCN GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36HCKA
XI1_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36CK
XI2_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_0 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36CK
XI3_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_1 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36CK
XI4_0 A0A A0A_ A0B A0B_ CLK GSRCN GTP_2 GTPN RST YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36CK1
.ENDS RA2SH128x36CLK_DRVS
****
.SUBCKT RA2SH128x36HYP12XL A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YP0_0 YP0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD
** RA2SH128x36HYP12XL: 95 flat devices **
d10 VSS BWENA DN 0.2116P 1.84U
d11 VSS BWENB DN 0.2116P 1.84U
d7 VSS A0 DN 0.2116P 1.84U
d8 VSS WEIA DN 0.2116P 1.84U
d9 VSS WEIB DN 0.2116P 1.84U
m1 N23 N29 VDD VDD P L=0.13U W=2.3U
m12 AP01-APN1 N49 AP01-AIND1 VSS N L=0.13U W=3.32U
m13 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.13U W=4.15U
m14 N49 AGTPT VDD VDD P L=0.13U W=0.58U
m15 N49 AGTPT VSS VSS N L=0.13U W=0.5U
m16 AP01-AIN21 N23 VDD VDD P L=0.13U W=2.03U
m17 AP01-AIN21 N23 VSS VSS N L=0.13U W=1.34U
m18 N43 VSS VDD VDD P L=0.13U W=2.03U
m19 N43 VSS VSS VSS N L=0.13U W=1.34U
m2 N23 N29 VSS VSS N L=0.13U W=1.54U
m20 N44 VSS VDD VDD P L=0.13U W=2.03U
m21 N44 VSS VSS VSS N L=0.13U W=1.34U
m22 N78 N44 VSS VSS N L=0.13U W=3.32U
m23 N77 N43 N78 VSS N L=0.13U W=3.32U
m24 AP01-AIND1 AP01-AIN21 N77 VSS N L=0.13U W=3.32U
m25 AP01-AIND1 N44 VDD VDD P L=0.13U W=4.16U
m26 N76 N44 VSS VSS N L=0.13U W=3.32U
m27 AP01-AIND1 N43 VDD VDD P L=0.13U W=4.16U
m28 N75 N43 N76 VSS N L=0.13U W=3.32U
m29 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.13U W=4.16U
m3 N22 A0 VDD VDD P L=0.13U W=2.3U
m30 AP01-AIND1 AP01-AIN21 N75 VSS N L=0.13U W=3.32U
m31 AP01-APN0 N60 AP01-AIND0 VSS N L=0.13U W=3.32U
m32 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.13U W=4.15U
m33 N60 AGTPB VDD VDD P L=0.13U W=0.58U
m34 N60 AGTPB VSS VSS N L=0.13U W=0.5U
m35 AP01-AIN20 N22 VDD VDD P L=0.13U W=2.03U
m36 AP01-AIN20 N22 VSS VSS N L=0.13U W=1.34U
m37 N82 N44 VSS VSS N L=0.13U W=3.32U
m38 N81 N43 N82 VSS N L=0.13U W=3.32U
m39 AP01-AIND0 AP01-AIN20 N81 VSS N L=0.13U W=3.32U
m4 N22 A0 VSS VSS N L=0.13U W=1.54U
m40 AP01-AIND0 N44 VDD VDD P L=0.13U W=4.16U
m41 N80 N44 VSS VSS N L=0.13U W=3.32U
m42 AP01-AIND0 N43 VDD VDD P L=0.13U W=4.16U
m43 N79 N43 N80 VSS N L=0.13U W=3.32U
m44 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.13U W=4.16U
m45 AP01-AIND0 AP01-AIN20 N79 VSS N L=0.13U W=3.32U
m46 AP01-APN1 YP0_0 VDD VDD P L=0.2U W=0.15U
m47 AP01-APN1 YP0_0 VSS VSS N L=0.39U W=0.15U
m48 YP0_0 AP01-APN1 VDD VDD P L=0.13U W=13.74U
m49 YP0_0 AP01-APN1 VSS VSS N L=0.13U W=9.48U
m5 N29 A0 VDD VDD P L=0.13U W=1.84U
m50 AP01-APN0 YP0_1 VDD VDD P L=0.2U W=0.15U
m51 AP01-APN0 YP0_1 VSS VSS N L=0.39U W=0.15U
m52 YP0_1 AP01-APN0 VDD VDD P L=0.13U W=13.74U
m53 YP0_1 AP01-APN0 VSS VSS N L=0.13U W=9.48U
m54 AP10-APN1 N91 AP10-AIND1 VSS N L=0.13U W=3.32U
m55 AP10-APN1 AGTPT AP10-AIND1 VDD P L=0.13U W=4.15U
m56 N91 AGTPT VDD VDD P L=0.13U W=0.58U
m57 N91 AGTPT VSS VSS N L=0.13U W=0.5U
m58 AP10-AIN21 N23 VDD VDD P L=0.13U W=2.03U
m59 AP10-AIN21 N23 VSS VSS N L=0.13U W=1.34U
m6 N29 A0 VSS VSS N L=0.13U W=1.24U
m60 N85 VSS VDD VDD P L=0.13U W=2.03U
m61 N85 VSS VSS VSS N L=0.13U W=1.34U
m62 N86 VSS VDD VDD P L=0.13U W=2.03U
m63 N86 VSS VSS VSS N L=0.13U W=1.34U
m64 N120 N86 VSS VSS N L=0.13U W=3.32U
m65 N119 N85 N120 VSS N L=0.13U W=3.32U
m66 AP10-AIND1 AP10-AIN21 N119 VSS N L=0.13U W=3.32U
m67 AP10-AIND1 N86 VDD VDD P L=0.13U W=4.16U
m68 N118 N86 VSS VSS N L=0.13U W=3.32U
m69 AP10-AIND1 N85 VDD VDD P L=0.13U W=4.16U
m70 N117 N85 N118 VSS N L=0.13U W=3.32U
m71 AP10-AIND1 AP10-AIN21 VDD VDD P L=0.13U W=4.16U
m72 AP10-AIND1 AP10-AIN21 N117 VSS N L=0.13U W=3.32U
m73 AP10-APN0 N102 AP10-AIND0 VSS N L=0.13U W=3.32U
m74 AP10-APN0 AGTPB AP10-AIND0 VDD P L=0.13U W=4.15U
m75 N102 AGTPB VDD VDD P L=0.13U W=0.58U
m76 N102 AGTPB VSS VSS N L=0.13U W=0.5U
m77 AP10-AIN20 N22 VDD VDD P L=0.13U W=2.03U
m78 AP10-AIN20 N22 VSS VSS N L=0.13U W=1.34U
m79 N124 N86 VSS VSS N L=0.13U W=3.32U
m80 N123 N85 N124 VSS N L=0.13U W=3.32U
m81 AP10-AIND0 AP10-AIN20 N123 VSS N L=0.13U W=3.32U
m82 AP10-AIND0 N86 VDD VDD P L=0.13U W=4.16U
m83 N122 N86 VSS VSS N L=0.13U W=3.32U
m84 AP10-AIND0 N85 VDD VDD P L=0.13U W=4.16U
m85 N121 N85 N122 VSS N L=0.13U W=3.32U
m86 AP10-AIND0 AP10-AIN20 VDD VDD P L=0.13U W=4.16U
m87 AP10-AIND0 AP10-AIN20 N121 VSS N L=0.13U W=3.32U
m88 AP10-APN1 YP0_0 VDD VDD P L=0.2U W=0.15U
m89 AP10-APN1 YP0_0 VSS VSS N L=0.39U W=0.15U
m90 YP0_0 AP10-APN1 VDD VDD P L=0.13U W=13.74U
m91 YP0_0 AP10-APN1 VSS VSS N L=0.13U W=9.48U
m92 AP10-APN0 YP0_1 VDD VDD P L=0.2U W=0.15U
m93 AP10-APN0 YP0_1 VSS VSS N L=0.39U W=0.15U
m94 YP0_1 AP10-APN0 VDD VDD P L=0.13U W=13.74U
m95 YP0_1 AP10-APN0 VSS VSS N L=0.13U W=9.48U
.ENDS RA2SH128x36HYP12XL
****
.SUBCKT RA2SH128x36HYP12XLX_B A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD
** RA2SH128x36HYP12XLX_B: 95 flat devices **
XI0_0 A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPB0_0 YPB0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD RA2SH128x36HYP12XL
.ENDS RA2SH128x36HYP12XLX_B
****
.SUBCKT RA2SH128x36HYP12XR A0 AGTP AY0 AY0A AY0A_ AY0B AY0B_ AY0_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36HYP12XR: 95 flat devices **
d10 VSS BWENA DN 0.2116P 1.84U
d11 VSS BWENB DN 0.2116P 1.84U
d7 VSS A0 DN 0.2116P 1.84U
d8 VSS WEIA DN 0.2116P 1.84U
d9 VSS WEIB DN 0.2116P 1.84U
m1 N37 N43 VDD VDD P L=0.13U W=2.3U
m12 AP0-APN1 N63 AP0-AIND1 VSS N L=0.13U W=3.32U
m13 AP0-APN1 AGTP AP0-AIND1 VDD P L=0.13U W=4.15U
m14 N63 AGTP VDD VDD P L=0.13U W=0.58U
m15 N63 AGTP VSS VSS N L=0.13U W=0.5U
m16 AP0-AIN21 N37 VDD VDD P L=0.13U W=2.03U
m17 AP0-AIN21 N37 VSS VSS N L=0.13U W=1.34U
m18 N57 VSS VDD VDD P L=0.13U W=2.03U
m19 N57 VSS VSS VSS N L=0.13U W=1.34U
m2 N37 N43 VSS VSS N L=0.13U W=1.54U
m20 N58 VSS VDD VDD P L=0.13U W=2.03U
m21 N58 VSS VSS VSS N L=0.13U W=1.34U
m22 N92 N58 VSS VSS N L=0.13U W=3.32U
m23 N91 N57 N92 VSS N L=0.13U W=3.32U
m24 AP0-AIND1 AP0-AIN21 N91 VSS N L=0.13U W=3.32U
m25 AP0-AIND1 N58 VDD VDD P L=0.13U W=4.16U
m26 N90 N58 VSS VSS N L=0.13U W=3.32U
m27 AP0-AIND1 N57 VDD VDD P L=0.13U W=4.16U
m28 N89 N57 N90 VSS N L=0.13U W=3.32U
m29 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.13U W=4.16U
m3 N36 A0 VDD VDD P L=0.13U W=2.3U
m30 AP0-AIND1 AP0-AIN21 N89 VSS N L=0.13U W=3.32U
m31 AP0-APN0 N74 AP0-AIND0 VSS N L=0.13U W=3.32U
m32 AP0-APN0 AGTP AP0-AIND0 VDD P L=0.13U W=4.15U
m33 N74 AGTP VDD VDD P L=0.13U W=0.58U
m34 N74 AGTP VSS VSS N L=0.13U W=0.5U
m35 AP0-AIN20 N36 VDD VDD P L=0.13U W=2.03U
m36 AP0-AIN20 N36 VSS VSS N L=0.13U W=1.34U
m37 N96 N58 VSS VSS N L=0.13U W=3.32U
m38 N95 N57 N96 VSS N L=0.13U W=3.32U
m39 AP0-AIND0 AP0-AIN20 N95 VSS N L=0.13U W=3.32U
m4 N36 A0 VSS VSS N L=0.13U W=1.54U
m40 AP0-AIND0 N58 VDD VDD P L=0.13U W=4.16U
m41 N94 N58 VSS VSS N L=0.13U W=3.32U
m42 AP0-AIND0 N57 VDD VDD P L=0.13U W=4.16U
m43 N93 N57 N94 VSS N L=0.13U W=3.32U
m44 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.13U W=4.16U
m45 AP0-AIND0 AP0-AIN20 N93 VSS N L=0.13U W=3.32U
m46 AP0-APN1 AY0_ VDD VDD P L=0.2U W=0.15U
m47 AP0-APN1 AY0_ VSS VSS N L=0.39U W=0.15U
m48 AY0_ AP0-APN1 VDD VDD P L=0.13U W=13.74U
m49 AY0_ AP0-APN1 VSS VSS N L=0.13U W=9.48U
m5 N43 A0 VDD VDD P L=0.13U W=1.84U
m50 AP0-APN0 AY0 VDD VDD P L=0.2U W=0.15U
m51 AP0-APN0 AY0 VSS VSS N L=0.39U W=0.15U
m52 AY0 AP0-APN0 VDD VDD P L=0.13U W=13.74U
m53 AY0 AP0-APN0 VSS VSS N L=0.13U W=9.48U
m54 AP_I1-APN1 N105 AP_I1-AIND1 VSS N L=0.13U W=3.32U
m55 AP_I1-APN1 AGTP AP_I1-AIND1 VDD P L=0.13U W=4.15U
m56 N105 AGTP VDD VDD P L=0.13U W=0.58U
m57 N105 AGTP VSS VSS N L=0.13U W=0.5U
m58 AP_I1-AIN21 N37 VDD VDD P L=0.13U W=2.03U
m59 AP_I1-AIN21 N37 VSS VSS N L=0.13U W=1.34U
m6 N43 A0 VSS VSS N L=0.13U W=1.24U
m60 N99 VSS VDD VDD P L=0.13U W=2.03U
m61 N99 VSS VSS VSS N L=0.13U W=1.34U
m62 N100 VSS VDD VDD P L=0.13U W=2.03U
m63 N100 VSS VSS VSS N L=0.13U W=1.34U
m64 N134 N100 VSS VSS N L=0.13U W=3.32U
m65 N133 N99 N134 VSS N L=0.13U W=3.32U
m66 AP_I1-AIND1 AP_I1-AIN21 N133 VSS N L=0.13U W=3.32U
m67 AP_I1-AIND1 N100 VDD VDD P L=0.13U W=4.16U
m68 N132 N100 VSS VSS N L=0.13U W=3.32U
m69 AP_I1-AIND1 N99 VDD VDD P L=0.13U W=4.16U
m70 N131 N99 N132 VSS N L=0.13U W=3.32U
m71 AP_I1-AIND1 AP_I1-AIN21 VDD VDD P L=0.13U W=4.16U
m72 AP_I1-AIND1 AP_I1-AIN21 N131 VSS N L=0.13U W=3.32U
m73 AP_I1-APN0 N116 AP_I1-AIND0 VSS N L=0.13U W=3.32U
m74 AP_I1-APN0 AGTP AP_I1-AIND0 VDD P L=0.13U W=4.15U
m75 N116 AGTP VDD VDD P L=0.13U W=0.58U
m76 N116 AGTP VSS VSS N L=0.13U W=0.5U
m77 AP_I1-AIN20 N36 VDD VDD P L=0.13U W=2.03U
m78 AP_I1-AIN20 N36 VSS VSS N L=0.13U W=1.34U
m79 N138 N100 VSS VSS N L=0.13U W=3.32U
m80 N137 N99 N138 VSS N L=0.13U W=3.32U
m81 AP_I1-AIND0 AP_I1-AIN20 N137 VSS N L=0.13U W=3.32U
m82 AP_I1-AIND0 N100 VDD VDD P L=0.13U W=4.16U
m83 N136 N100 VSS VSS N L=0.13U W=3.32U
m84 AP_I1-AIND0 N99 VDD VDD P L=0.13U W=4.16U
m85 N135 N99 N136 VSS N L=0.13U W=3.32U
m86 AP_I1-AIND0 AP_I1-AIN20 VDD VDD P L=0.13U W=4.16U
m87 AP_I1-AIND0 AP_I1-AIN20 N135 VSS N L=0.13U W=3.32U
m88 AP_I1-APN1 AY0_ VDD VDD P L=0.2U W=0.15U
m89 AP_I1-APN1 AY0_ VSS VSS N L=0.39U W=0.15U
m90 AY0_ AP_I1-APN1 VDD VDD P L=0.13U W=13.74U
m91 AY0_ AP_I1-APN1 VSS VSS N L=0.13U W=9.48U
m92 AP_I1-APN0 AY0 VDD VDD P L=0.2U W=0.15U
m93 AP_I1-APN0 AY0 VSS VSS N L=0.39U W=0.15U
m94 AY0 AP_I1-APN0 VDD VDD P L=0.13U W=13.74U
m95 AY0 AP_I1-APN0 VSS VSS N L=0.13U W=9.48U
.ENDS RA2SH128x36HYP12XR
****
.SUBCKT RA2SH128x36HYP12XRX_B A0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK
+  GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36HYP12XRX_B: 95 flat devices **
XI0_0 A0 AGTP AY0B AY0A AY0A_ AY0B AY0B_ AY0B_ BWENA BWENB CLK GSRCN GTPN
+  OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HYP12XR
.ENDS RA2SH128x36HYP12XRX_B
****
.SUBCKT RA2SH128x36Y_DECODEB A0 A0_0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS
+  VDD
** RA2SH128x36Y_DECODEB: 190 flat devices **
XI0_0 A0 AGTP AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD RA2SH128x36HYP12XLX_B
XI1_0 A0_0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK GSRCN GTPN OEIA_ OEIB_
+  RST WEIA WEIB YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS
+  VSS VSS VSS VSS VSS VDD RA2SH128x36HYP12XRX_B
.ENDS RA2SH128x36Y_DECODEB
****
.SUBCKT RA2SH128x36FCMWDX MWLA MWLB XP0 XP1 VSS VDD
** RA2SH128x36FCMWDX: 2 flat devices **
d1 VSS XP1 DN 0.2116P 1.84U
d2 VSS XP0 DN 0.2116P 1.84U
.ENDS RA2SH128x36FCMWDX
****
.SUBCKT RA2SH128x36FCMWD G0F G1F MWLA MWLB XP0F XP1F VSS VDD
** RA2SH128x36FCMWD: 2 flat devices **
d1 VSS XP1F DN 0.2116P 1.84U
d2 VSS XP0F DN 0.2116P 1.84U
.ENDS RA2SH128x36FCMWD
****
.SUBCKT RA2SH128x36MWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7
+  MWG8 MWG9 MWG10 MWG11 MWL MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36MWD: 37 flat devices **
m1 MWL N60 VDD VDD P L=0.13U W=24.42U
m10 MBL MWG1 VSS VSS N L=0.13U W=0.3U
m11 MBL MWG0 VSS VSS N L=0.13U W=0.3U
m12 MBL MWG1 VSS VSS N L=0.13U W=0.3U
m13 MBL MWG0 VSS VSS N L=0.13U W=0.3U
m14 MBL MWG3 VSS VSS N L=0.13U W=0.3U
m15 MBL MWG2 VSS VSS N L=0.13U W=0.3U
m16 MBL MWG3 VSS VSS N L=0.13U W=0.3U
m17 MBL MWG2 VSS VSS N L=0.13U W=0.3U
m18 MBL MWG5 VSS VSS N L=0.13U W=0.3U
m19 MBL MWG4 VSS VSS N L=0.13U W=0.3U
m2 MWL N60 VSS VSS N L=0.13U W=15.04U
m20 MBL MWG5 VSS VSS N L=0.13U W=0.3U
m21 MBL MWG4 VSS VSS N L=0.13U W=0.3U
m22 MBL MWG7 VSS VSS N L=0.13U W=0.3U
m23 MBL MWG6 VSS VSS N L=0.13U W=0.3U
m24 MBL MWG7 VSS VSS N L=0.13U W=0.3U
m25 MBL MWG6 VSS VSS N L=0.13U W=0.3U
m26 MBL MWG9 VSS VSS N L=0.13U W=0.3U
m27 MBL MWG8 VSS VSS N L=0.13U W=0.3U
m28 MBL MWG9 VSS VSS N L=0.13U W=0.3U
m29 MBL MWG8 VSS VSS N L=0.13U W=0.3U
m3 N60 N59 VDD VDD P L=0.13U W=10.21U
m30 MBL MWG11 VSS VSS N L=0.13U W=0.3U
m31 MBL MWG10 VSS VSS N L=0.13U W=0.3U
m32 MBL MWG11 VSS VSS N L=0.13U W=0.3U
m33 MBL MWG10 VSS VSS N L=0.13U W=0.3U
m34 MBL MWLD VSS VSS N L=0.2U W=0.15U
m35 MBL MWLD VSS VSS N L=0.2U W=0.15U
m36 MBL MWLD VSS VSS N L=0.2U W=0.15U
m37 MBL MWLD VSS VSS N L=0.2U W=0.15U
m4 N60 N59 VSS VSS N L=0.13U W=6.53U
m5 MBL GTP VDD VDD P L=0.13U W=5.38U
m6 MBL_ GTP VDD VDD P L=0.13U W=5.38U
m7 MBL GTP MBL_ VDD P L=0.13U W=5.38U
m8 N59 VSS GTP VDD P L=0.26U W=0.9U
m9 N59 VDD GTP VSS N L=0.26U W=0.9U
.ENDS RA2SH128x36MWD
****
.SUBCKT RA2SH128x36MWDX_B GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36MWDX_B: 37 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS MWLB MWLA
+  MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA2SH128x36MWD
.ENDS RA2SH128x36MWDX_B
****
.SUBCKT RA2SH128x36ROW_TOPB G0F G1F GTP MBL MBL_ MWLA MWLB MWLD XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_TOPB: 41 flat devices **
XI0_0 MWLA MWLB XP0 XP1 VSS VDD RA2SH128x36FCMWDX
XI1_0 G0F G1F MWLA MWLB XP0F XP1F VSS VDD RA2SH128x36FCMWD
XI2_0 GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36MWDX_B
.ENDS RA2SH128x36ROW_TOPB
****
.SUBCKT RA2SH128x36HWDB G0 G1 G2_W0 G2_W1 GTP0 GTP1 GTP2 GTP3 GTP4 GTPA GTPB
+  WL0 WL1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA2SH128x36HWDB: 30 flat devices **
m1 N35 WD_I0-RSWN0 GTP4 VDD P L=0.13U W=1.3U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.13U W=15.04U
m11 N34 WD_I0-RSWN1 GTP4 VDD P L=0.13U W=1.3U
m12 N34 WD_I0-WLI1 GTP4 VSS N L=0.13U W=1.3U
m13 N43 G0 VSS VSS N L=0.13U W=0.71U
m14 N44 G1 N43 VSS N L=0.13U W=0.71U
m15 WD_I0-RSWN1 G2_W1 N44 VSS N L=0.13U W=0.71U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.13U W=0.41U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.13U W=0.41U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.13U W=0.41U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.13U W=24.42U
m2 N35 WD_I0-WLI0 GTP4 VSS N L=0.13U W=1.3U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.13U W=15.04U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.13U W=0.29U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.13U W=0.19U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.13U W=0.29U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.13U W=0.19U
m25 N34 WD_I0-RSWN1 VSS VSS N L=0.13U W=0.3U
m26 N35 WD_I0-RSWN0 VSS VSS N L=0.13U W=0.3U
m27 WD_I0-WL1_EN_ N34 VDD VDD P L=0.13U W=7.92U
m28 WD_I0-WL1_EN_ N34 VSS VSS N L=0.13U W=5.07U
m29 WD_I0-WL0_EN_ N35 VDD VDD P L=0.13U W=7.92U
m3 N36 G0 VSS VSS N L=0.13U W=0.71U
m30 WD_I0-WL0_EN_ N35 VSS VSS N L=0.13U W=5.07U
m4 N37 G1 N36 VSS N L=0.13U W=0.71U
m5 WD_I0-RSWN0 G2_W0 N37 VSS N L=0.13U W=0.71U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.13U W=0.41U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.13U W=0.41U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.13U W=0.41U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.13U W=24.42U
.ENDS RA2SH128x36HWDB
****
.SUBCKT RA2SH128x36HWDBX_B G0 G1 G2_W0 G2_W1 GTPA GTPB WLA0 WLA1 WLB0 WLB1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36HWDBX_B: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTPB GTPB GTPB GTPB GTPB GTPA GTPB WLB0 WLB1 WLA0 WLA1
+  WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA2SH128x36HWDB
.ENDS RA2SH128x36HWDBX_B
****
.SUBCKT RA2SH128x36HWDBX_B0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36HWDBX_B0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36HWDBX_B
.ENDS RA2SH128x36HWDBX_B0
****
.SUBCKT RA2SH128x36ROW_BOTTOMB G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0F XP0F_0
+  XP1F XP1F_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_BOTTOMB: 30 flat devices **
XI2_0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA2SH128x36HWDBX_B0
.ENDS RA2SH128x36ROW_BOTTOMB
****
.SUBCKT RA2SH128x36WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 WLA0 WLA1 WLB0 WLB1 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WD: 30 flat devices **
m1 N29 RSWN0 GTP VDD P L=0.13U W=1.3U
m10 WL0 WL0_EN_ VSS VSS N L=0.13U W=15.04U
m11 N28 RSWN1 GTP VDD P L=0.13U W=1.3U
m12 N28 WLI1 GTP VSS N L=0.13U W=1.3U
m13 N37 G0 VSS VSS N L=0.13U W=0.71U
m14 N38 G1 N37 VSS N L=0.13U W=0.71U
m15 RSWN1 G2_W1 N38 VSS N L=0.13U W=0.71U
m16 RSWN1 G0 VDD VDD P L=0.13U W=0.41U
m17 RSWN1 G2_W1 VDD VDD P L=0.13U W=0.41U
m18 RSWN1 G1 VDD VDD P L=0.13U W=0.41U
m19 WL1 WL1_EN_ VDD VDD P L=0.13U W=24.42U
m2 N29 WLI0 GTP VSS N L=0.13U W=1.3U
m20 WL1 WL1_EN_ VSS VSS N L=0.13U W=15.04U
m21 WLI1 RSWN1 VDD VDD P L=0.13U W=0.29U
m22 WLI1 RSWN1 VSS VSS N L=0.13U W=0.19U
m23 WLI0 RSWN0 VDD VDD P L=0.13U W=0.29U
m24 WLI0 RSWN0 VSS VSS N L=0.13U W=0.19U
m25 N28 RSWN1 VSS VSS N L=0.13U W=0.3U
m26 N29 RSWN0 VSS VSS N L=0.13U W=0.3U
m27 WL1_EN_ N28 VDD VDD P L=0.13U W=7.92U
m28 WL1_EN_ N28 VSS VSS N L=0.13U W=5.07U
m29 WL0_EN_ N29 VDD VDD P L=0.13U W=7.92U
m3 N30 G0 VSS VSS N L=0.13U W=0.71U
m30 WL0_EN_ N29 VSS VSS N L=0.13U W=5.07U
m4 N31 G1 N30 VSS N L=0.13U W=0.71U
m5 RSWN0 G2_W0 N31 VSS N L=0.13U W=0.71U
m6 RSWN0 G0 VDD VDD P L=0.13U W=0.41U
m7 RSWN0 G2_W0 VDD VDD P L=0.13U W=0.41U
m8 RSWN0 G1 VDD VDD P L=0.13U W=0.41U
m9 WL0 WL0_EN_ VDD VDD P L=0.13U W=24.42U
.ENDS RA2SH128x36WD
****
.SUBCKT RA2SH128x36WDX_B G0 G1 G2_W0 G2_W1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_B: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTP WLB0 WLB1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WD
.ENDS RA2SH128x36WDX_B
****
.SUBCKT RA2SH128x36WDX_B1 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_B1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_B
.ENDS RA2SH128x36WDX_B1
****
.SUBCKT RA2SH128x36ROW_FILLER1B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER1B: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_B1
.ENDS RA2SH128x36ROW_FILLER1B
****
.SUBCKT RA2SH128x36WDX_B2 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_B2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_B
.ENDS RA2SH128x36WDX_B2
****
.SUBCKT RA2SH128x36ROW_FILLER2B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER2B: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_B2
.ENDS RA2SH128x36ROW_FILLER2B
****
.SUBCKT RA2SH128x36WDX_B3 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_B3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_B
.ENDS RA2SH128x36WDX_B3
****
.SUBCKT RA2SH128x36ROW_FILLER3B G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER3B: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_B3
.ENDS RA2SH128x36ROW_FILLER3B
****
.SUBCKT RA2SH128x36WDX_B0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_B0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_B
.ENDS RA2SH128x36WDX_B0
****
.SUBCKT RA2SH128x36ROW_8B G0 G1 G1B GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0F_0 XP1F
+  XP1F_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_8B: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_B0
.ENDS RA2SH128x36ROW_8B
****
.SUBCKT RA2SH128x36WORD_ROWSB G0 GTPA GTPB MBL MBL_ MWLA MWLB MWLD WLA0 WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA1 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4
+  WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14
+  WLB0 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB1 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA2SH128x36WORD_ROWSB: 521 flat devices **
XI0_0 G0 XP0_0 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_BOTTOMB
XI0_1 G0 XP0_0 GTPB WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1B
XI0_10 G0 XP0 GTPB WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1B
XI0_11 G0 XP0 GTPB WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2B
XI0_12 G0 XP0 GTPB WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3B
XI0_13 G0 XP1 XP0 GTPB WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0 XP0_0 XP1 XP1_0
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8B
XI0_14 G0 XP1 GTPB WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1B
XI0_15 G0 XP1 GTPB WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2B
XI0_16 G0 XP1 GTPB WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3B
XI0_17 G0 XP1 GTPB MBL MBL_ MWLA MWLB MWLD XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_TOPB
XI0_2 G0 XP0_0 GTPB WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2B
XI0_3 G0 XP0_0 GTPB WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3B
XI0_4 G0 XP1_0 XP0_0 GTPB WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0 XP0_0 XP1 XP1_0
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8B
XI0_5 G0 XP1_0 GTPB WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1B
XI0_6 G0 XP1_0 GTPB WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2B
XI0_7 G0 XP1_0 GTPB WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3B
XI0_9 G0 XP0 XP1_0 GTPB WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8B
.ENDS RA2SH128x36WORD_ROWSB
****
.SUBCKT RA2SH128x36HXP24 A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP24: 106 flat devices **
d10 VSS BWENA DN 0.2116P 1.84U
d11 VSS BWENB DN 0.2116P 1.84U
d18 VSS A1 DN 0.2116P 1.84U
d19 VSS WEIA DN 0.2116P 1.84U
d20 VSS WEIB DN 0.2116P 1.84U
d21 VSS BWENA DN 0.2116P 1.84U
d22 VSS BWENB DN 0.2116P 1.84U
d7 VSS A0 DN 0.2116P 1.84U
d8 VSS WEIA DN 0.2116P 1.84U
d9 VSS WEIB DN 0.2116P 1.84U
m1 N37 N50 VDD VDD P L=0.13U W=2.3U
m100 AP_I6-APN1 XP_2 VSS VSS N L=0.39U W=0.15U
m101 XP_2 AP_I6-APN1 VDD VDD P L=0.13U W=13.74U
m102 XP_2 AP_I6-APN1 VSS VSS N L=0.13U W=9.48U
m103 AP_I6-APN0 XP_3 VDD VDD P L=0.2U W=0.15U
m104 AP_I6-APN0 XP_3 VSS VSS N L=0.39U W=0.15U
m105 XP_3 AP_I6-APN0 VDD VDD P L=0.13U W=13.74U
m106 XP_3 AP_I6-APN0 VSS VSS N L=0.13U W=9.48U
m12 N44 N62 VDD VDD P L=0.13U W=2.3U
m13 N44 N62 VSS VSS N L=0.13U W=1.54U
m14 N43 A1 VDD VDD P L=0.13U W=2.3U
m15 N43 A1 VSS VSS N L=0.13U W=1.54U
m16 N62 A1 VDD VDD P L=0.13U W=1.84U
m17 N62 A1 VSS VSS N L=0.13U W=1.24U
m2 N37 N50 VSS VSS N L=0.13U W=1.54U
m23 AP_I5-APN1 N82 AP_I5-AIND1 VSS N L=0.13U W=3.32U
m24 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.13U W=4.15U
m25 N82 AGTPT VDD VDD P L=0.13U W=0.58U
m26 N82 AGTPT VSS VSS N L=0.13U W=0.5U
m27 AP_I5-AIN21 N37 VDD VDD P L=0.13U W=2.03U
m28 AP_I5-AIN21 N37 VSS VSS N L=0.13U W=1.34U
m29 N76 N44 VDD VDD P L=0.13U W=2.03U
m3 N36 A0 VDD VDD P L=0.13U W=2.3U
m30 N76 N44 VSS VSS N L=0.13U W=1.34U
m31 N77 VSS VDD VDD P L=0.13U W=2.03U
m32 N77 VSS VSS VSS N L=0.13U W=1.34U
m33 N111 N77 VSS VSS N L=0.13U W=3.32U
m34 N110 N76 N111 VSS N L=0.13U W=3.32U
m35 AP_I5-AIND1 AP_I5-AIN21 N110 VSS N L=0.13U W=3.32U
m36 AP_I5-AIND1 N77 VDD VDD P L=0.13U W=4.16U
m37 N109 N77 VSS VSS N L=0.13U W=3.32U
m38 AP_I5-AIND1 N76 VDD VDD P L=0.13U W=4.16U
m39 N108 N76 N109 VSS N L=0.13U W=3.32U
m4 N36 A0 VSS VSS N L=0.13U W=1.54U
m40 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.13U W=4.16U
m41 AP_I5-AIND1 AP_I5-AIN21 N108 VSS N L=0.13U W=3.32U
m42 AP_I5-APN0 N93 AP_I5-AIND0 VSS N L=0.13U W=3.32U
m43 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.13U W=4.15U
m44 N93 AGTPB VDD VDD P L=0.13U W=0.58U
m45 N93 AGTPB VSS VSS N L=0.13U W=0.5U
m46 AP_I5-AIN20 N36 VDD VDD P L=0.13U W=2.03U
m47 AP_I5-AIN20 N36 VSS VSS N L=0.13U W=1.34U
m48 N115 N77 VSS VSS N L=0.13U W=3.32U
m49 N114 N76 N115 VSS N L=0.13U W=3.32U
m5 N50 A0 VDD VDD P L=0.13U W=1.84U
m50 AP_I5-AIND0 AP_I5-AIN20 N114 VSS N L=0.13U W=3.32U
m51 AP_I5-AIND0 N77 VDD VDD P L=0.13U W=4.16U
m52 N113 N77 VSS VSS N L=0.13U W=3.32U
m53 AP_I5-AIND0 N76 VDD VDD P L=0.13U W=4.16U
m54 N112 N76 N113 VSS N L=0.13U W=3.32U
m55 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.13U W=4.16U
m56 AP_I5-AIND0 AP_I5-AIN20 N112 VSS N L=0.13U W=3.32U
m57 AP_I5-APN1 XP_0 VDD VDD P L=0.2U W=0.15U
m58 AP_I5-APN1 XP_0 VSS VSS N L=0.39U W=0.15U
m59 XP_0 AP_I5-APN1 VDD VDD P L=0.13U W=13.74U
m6 N50 A0 VSS VSS N L=0.13U W=1.24U
m60 XP_0 AP_I5-APN1 VSS VSS N L=0.13U W=9.48U
m61 AP_I5-APN0 XP_1 VDD VDD P L=0.2U W=0.15U
m62 AP_I5-APN0 XP_1 VSS VSS N L=0.39U W=0.15U
m63 XP_1 AP_I5-APN0 VDD VDD P L=0.13U W=13.74U
m64 XP_1 AP_I5-APN0 VSS VSS N L=0.13U W=9.48U
m65 AP_I6-APN1 N124 AP_I6-AIND1 VSS N L=0.13U W=3.32U
m66 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.13U W=4.15U
m67 N124 AGTPT VDD VDD P L=0.13U W=0.58U
m68 N124 AGTPT VSS VSS N L=0.13U W=0.5U
m69 AP_I6-AIN21 N37 VDD VDD P L=0.13U W=2.03U
m70 AP_I6-AIN21 N37 VSS VSS N L=0.13U W=1.34U
m71 N118 N43 VDD VDD P L=0.13U W=2.03U
m72 N118 N43 VSS VSS N L=0.13U W=1.34U
m73 N119 VSS VDD VDD P L=0.13U W=2.03U
m74 N119 VSS VSS VSS N L=0.13U W=1.34U
m75 N153 N119 VSS VSS N L=0.13U W=3.32U
m76 N152 N118 N153 VSS N L=0.13U W=3.32U
m77 AP_I6-AIND1 AP_I6-AIN21 N152 VSS N L=0.13U W=3.32U
m78 AP_I6-AIND1 N119 VDD VDD P L=0.13U W=4.16U
m79 N151 N119 VSS VSS N L=0.13U W=3.32U
m80 AP_I6-AIND1 N118 VDD VDD P L=0.13U W=4.16U
m81 N150 N118 N151 VSS N L=0.13U W=3.32U
m82 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.13U W=4.16U
m83 AP_I6-AIND1 AP_I6-AIN21 N150 VSS N L=0.13U W=3.32U
m84 AP_I6-APN0 N135 AP_I6-AIND0 VSS N L=0.13U W=3.32U
m85 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.13U W=4.15U
m86 N135 AGTPB VDD VDD P L=0.13U W=0.58U
m87 N135 AGTPB VSS VSS N L=0.13U W=0.5U
m88 AP_I6-AIN20 N36 VDD VDD P L=0.13U W=2.03U
m89 AP_I6-AIN20 N36 VSS VSS N L=0.13U W=1.34U
m90 N157 N119 VSS VSS N L=0.13U W=3.32U
m91 N156 N118 N157 VSS N L=0.13U W=3.32U
m92 AP_I6-AIND0 AP_I6-AIN20 N156 VSS N L=0.13U W=3.32U
m93 AP_I6-AIND0 N119 VDD VDD P L=0.13U W=4.16U
m94 N155 N119 VSS VSS N L=0.13U W=3.32U
m95 AP_I6-AIND0 N118 VDD VDD P L=0.13U W=4.16U
m96 N154 N118 N155 VSS N L=0.13U W=3.32U
m97 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.13U W=4.16U
m98 AP_I6-AIND0 AP_I6-AIN20 N154 VSS N L=0.13U W=3.32U
m99 AP_I6-APN1 XP_2 VDD VDD P L=0.2U W=0.15U
.ENDS RA2SH128x36HXP24
****
.SUBCKT RA2SH128x36HXP24B A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP24B: 106 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HXP24
.ENDS RA2SH128x36HXP24B
****
.SUBCKT RA2SH128x36HXP38 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA
+  BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP38: 201 flat devices **
d175 VSS A2 DN 0.2116P 1.84U
d176 VSS WEIA DN 0.2116P 1.84U
d177 VSS WEIB DN 0.2116P 1.84U
d178 VSS BWENA DN 0.2116P 1.84U
d179 VSS BWENB DN 0.2116P 1.84U
d186 VSS A1 DN 0.2116P 1.84U
d187 VSS WEIA DN 0.2116P 1.84U
d188 VSS WEIB DN 0.2116P 1.84U
d189 VSS BWENA DN 0.2116P 1.84U
d190 VSS BWENB DN 0.2116P 1.84U
d197 VSS A0 DN 0.2116P 1.84U
d198 VSS WEIA DN 0.2116P 1.84U
d199 VSS WEIB DN 0.2116P 1.84U
d200 VSS BWENA DN 0.2116P 1.84U
d201 VSS BWENB DN 0.2116P 1.84U
m1 AP67-APN1 N69 AP67-AIND1 VSS N L=0.13U W=3.32U
m10 N64 AI2_ VSS VSS N L=0.13U W=1.34U
m100 AP23-AIND1 N147 VDD VDD P L=0.13U W=4.16U
m101 N179 N147 N180 VSS N L=0.13U W=3.32U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.13U W=4.16U
m103 AP23-AIND1 AP23-AIN21 N179 VSS N L=0.13U W=3.32U
m104 AP23-APN0 N164 AP23-AIND0 VSS N L=0.13U W=3.32U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.13U W=4.15U
m106 N164 AGTPB VDD VDD P L=0.13U W=0.58U
m107 N164 AGTPB VSS VSS N L=0.13U W=0.5U
m108 AP23-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m109 AP23-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m11 N98 N64 VSS VSS N L=0.13U W=3.32U
m110 N186 N148 VSS VSS N L=0.13U W=3.32U
m111 N185 N147 N186 VSS N L=0.13U W=3.32U
m112 AP23-AIND0 AP23-AIN20 N185 VSS N L=0.13U W=3.32U
m113 AP23-AIND0 N148 VDD VDD P L=0.13U W=4.16U
m114 N184 N148 VSS VSS N L=0.13U W=3.32U
m115 AP23-AIND0 N147 VDD VDD P L=0.13U W=4.16U
m116 N183 N147 N184 VSS N L=0.13U W=3.32U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.13U W=4.16U
m118 AP23-AIND0 AP23-AIN20 N183 VSS N L=0.13U W=3.32U
m119 AP23-APN1 XP_3 VDD VDD P L=0.2U W=0.15U
m12 N97 N63 N98 VSS N L=0.13U W=3.32U
m120 AP23-APN1 XP_3 VSS VSS N L=0.39U W=0.15U
m121 XP_3 AP23-APN1 VDD VDD P L=0.13U W=13.74U
m122 XP_3 AP23-APN1 VSS VSS N L=0.13U W=9.48U
m123 AP23-APN0 XP_2 VDD VDD P L=0.2U W=0.15U
m124 AP23-APN0 XP_2 VSS VSS N L=0.39U W=0.15U
m125 XP_2 AP23-APN0 VDD VDD P L=0.13U W=13.74U
m126 XP_2 AP23-APN0 VSS VSS N L=0.13U W=9.48U
m127 AP01-APN1 N195 AP01-AIND1 VSS N L=0.13U W=3.32U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.13U W=4.15U
m129 N195 AGTPT VDD VDD P L=0.13U W=0.58U
m13 AP67-AIND1 AP67-AIN21 N97 VSS N L=0.13U W=3.32U
m130 N195 AGTPT VSS VSS N L=0.13U W=0.5U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m133 N189 AI1 VDD VDD P L=0.13U W=2.03U
m134 N189 AI1 VSS VSS N L=0.13U W=1.34U
m135 N190 AI2 VDD VDD P L=0.13U W=2.03U
m136 N190 AI2 VSS VSS N L=0.13U W=1.34U
m137 N224 N190 VSS VSS N L=0.13U W=3.32U
m138 N223 N189 N224 VSS N L=0.13U W=3.32U
m139 AP01-AIND1 AP01-AIN21 N223 VSS N L=0.13U W=3.32U
m14 AP67-AIND1 N64 VDD VDD P L=0.13U W=4.16U
m140 AP01-AIND1 N190 VDD VDD P L=0.13U W=4.16U
m141 N222 N190 VSS VSS N L=0.13U W=3.32U
m142 AP01-AIND1 N189 VDD VDD P L=0.13U W=4.16U
m143 N221 N189 N222 VSS N L=0.13U W=3.32U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.13U W=4.16U
m145 AP01-AIND1 AP01-AIN21 N221 VSS N L=0.13U W=3.32U
m146 AP01-APN0 N206 AP01-AIND0 VSS N L=0.13U W=3.32U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.13U W=4.15U
m148 N206 AGTPB VDD VDD P L=0.13U W=0.58U
m149 N206 AGTPB VSS VSS N L=0.13U W=0.5U
m15 N96 N64 VSS VSS N L=0.13U W=3.32U
m150 AP01-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m151 AP01-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m152 N228 N190 VSS VSS N L=0.13U W=3.32U
m153 N227 N189 N228 VSS N L=0.13U W=3.32U
m154 AP01-AIND0 AP01-AIN20 N227 VSS N L=0.13U W=3.32U
m155 AP01-AIND0 N190 VDD VDD P L=0.13U W=4.16U
m156 N226 N190 VSS VSS N L=0.13U W=3.32U
m157 AP01-AIND0 N189 VDD VDD P L=0.13U W=4.16U
m158 N225 N189 N226 VSS N L=0.13U W=3.32U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.13U W=4.16U
m16 AP67-AIND1 N63 VDD VDD P L=0.13U W=4.16U
m160 AP01-AIND0 AP01-AIN20 N225 VSS N L=0.13U W=3.32U
m161 AP01-APN1 XP_1 VDD VDD P L=0.2U W=0.15U
m162 AP01-APN1 XP_1 VSS VSS N L=0.39U W=0.15U
m163 XP_1 AP01-APN1 VDD VDD P L=0.13U W=13.74U
m164 XP_1 AP01-APN1 VSS VSS N L=0.13U W=9.48U
m165 AP01-APN0 XP_0 VDD VDD P L=0.2U W=0.15U
m166 AP01-APN0 XP_0 VSS VSS N L=0.39U W=0.15U
m167 XP_0 AP01-APN0 VDD VDD P L=0.13U W=13.74U
m168 XP_0 AP01-APN0 VSS VSS N L=0.13U W=9.48U
m169 AI2 N229 VDD VDD P L=0.13U W=2.3U
m17 N95 N63 N96 VSS N L=0.13U W=3.32U
m170 AI2 N229 VSS VSS N L=0.13U W=1.54U
m171 AI2_ A2 VDD VDD P L=0.13U W=2.3U
m172 AI2_ A2 VSS VSS N L=0.13U W=1.54U
m173 N229 A2 VDD VDD P L=0.13U W=1.84U
m174 N229 A2 VSS VSS N L=0.13U W=1.24U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.13U W=4.16U
m180 AI1 N241 VDD VDD P L=0.13U W=2.3U
m181 AI1 N241 VSS VSS N L=0.13U W=1.54U
m182 AI1_ A1 VDD VDD P L=0.13U W=2.3U
m183 AI1_ A1 VSS VSS N L=0.13U W=1.54U
m184 N241 A1 VDD VDD P L=0.13U W=1.84U
m185 N241 A1 VSS VSS N L=0.13U W=1.24U
m19 AP67-AIND1 AP67-AIN21 N95 VSS N L=0.13U W=3.32U
m191 AI0 N253 VDD VDD P L=0.13U W=2.3U
m192 AI0 N253 VSS VSS N L=0.13U W=1.54U
m193 AI0_ A0 VDD VDD P L=0.13U W=2.3U
m194 AI0_ A0 VSS VSS N L=0.13U W=1.54U
m195 N253 A0 VDD VDD P L=0.13U W=1.84U
m196 N253 A0 VSS VSS N L=0.13U W=1.24U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.13U W=4.15U
m20 AP67-APN0 N80 AP67-AIND0 VSS N L=0.13U W=3.32U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.13U W=4.15U
m22 N80 AGTPB VDD VDD P L=0.13U W=0.58U
m23 N80 AGTPB VSS VSS N L=0.13U W=0.5U
m24 AP67-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m25 AP67-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m26 N102 N64 VSS VSS N L=0.13U W=3.32U
m27 N101 N63 N102 VSS N L=0.13U W=3.32U
m28 AP67-AIND0 AP67-AIN20 N101 VSS N L=0.13U W=3.32U
m29 AP67-AIND0 N64 VDD VDD P L=0.13U W=4.16U
m3 N69 AGTPT VDD VDD P L=0.13U W=0.58U
m30 N100 N64 VSS VSS N L=0.13U W=3.32U
m31 AP67-AIND0 N63 VDD VDD P L=0.13U W=4.16U
m32 N99 N63 N100 VSS N L=0.13U W=3.32U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.13U W=4.16U
m34 AP67-AIND0 AP67-AIN20 N99 VSS N L=0.13U W=3.32U
m35 AP67-APN1 XP_7 VDD VDD P L=0.2U W=0.15U
m36 AP67-APN1 XP_7 VSS VSS N L=0.39U W=0.15U
m37 XP_7 AP67-APN1 VDD VDD P L=0.13U W=13.74U
m38 XP_7 AP67-APN1 VSS VSS N L=0.13U W=9.48U
m39 AP67-APN0 XP_6 VDD VDD P L=0.2U W=0.15U
m4 N69 AGTPT VSS VSS N L=0.13U W=0.5U
m40 AP67-APN0 XP_6 VSS VSS N L=0.39U W=0.15U
m41 XP_6 AP67-APN0 VDD VDD P L=0.13U W=13.74U
m42 XP_6 AP67-APN0 VSS VSS N L=0.13U W=9.48U
m43 AP45-APN1 N111 AP45-AIND1 VSS N L=0.13U W=3.32U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.13U W=4.15U
m45 N111 AGTPT VDD VDD P L=0.13U W=0.58U
m46 N111 AGTPT VSS VSS N L=0.13U W=0.5U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m49 N105 AI1 VDD VDD P L=0.13U W=2.03U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m50 N105 AI1 VSS VSS N L=0.13U W=1.34U
m51 N106 AI2_ VDD VDD P L=0.13U W=2.03U
m52 N106 AI2_ VSS VSS N L=0.13U W=1.34U
m53 N140 N106 VSS VSS N L=0.13U W=3.32U
m54 N139 N105 N140 VSS N L=0.13U W=3.32U
m55 AP45-AIND1 AP45-AIN21 N139 VSS N L=0.13U W=3.32U
m56 AP45-AIND1 N106 VDD VDD P L=0.13U W=4.16U
m57 N138 N106 VSS VSS N L=0.13U W=3.32U
m58 AP45-AIND1 N105 VDD VDD P L=0.13U W=4.16U
m59 N137 N105 N138 VSS N L=0.13U W=3.32U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.13U W=4.16U
m61 AP45-AIND1 AP45-AIN21 N137 VSS N L=0.13U W=3.32U
m62 AP45-APN0 N122 AP45-AIND0 VSS N L=0.13U W=3.32U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.13U W=4.15U
m64 N122 AGTPB VDD VDD P L=0.13U W=0.58U
m65 N122 AGTPB VSS VSS N L=0.13U W=0.5U
m66 AP45-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m67 AP45-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m68 N144 N106 VSS VSS N L=0.13U W=3.32U
m69 N143 N105 N144 VSS N L=0.13U W=3.32U
m7 N63 AI1_ VDD VDD P L=0.13U W=2.03U
m70 AP45-AIND0 AP45-AIN20 N143 VSS N L=0.13U W=3.32U
m71 AP45-AIND0 N106 VDD VDD P L=0.13U W=4.16U
m72 N142 N106 VSS VSS N L=0.13U W=3.32U
m73 AP45-AIND0 N105 VDD VDD P L=0.13U W=4.16U
m74 N141 N105 N142 VSS N L=0.13U W=3.32U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.13U W=4.16U
m76 AP45-AIND0 AP45-AIN20 N141 VSS N L=0.13U W=3.32U
m77 AP45-APN1 XP_5 VDD VDD P L=0.2U W=0.15U
m78 AP45-APN1 XP_5 VSS VSS N L=0.39U W=0.15U
m79 XP_5 AP45-APN1 VDD VDD P L=0.13U W=13.74U
m8 N63 AI1_ VSS VSS N L=0.13U W=1.34U
m80 XP_5 AP45-APN1 VSS VSS N L=0.13U W=9.48U
m81 AP45-APN0 XP_4 VDD VDD P L=0.2U W=0.15U
m82 AP45-APN0 XP_4 VSS VSS N L=0.39U W=0.15U
m83 XP_4 AP45-APN0 VDD VDD P L=0.13U W=13.74U
m84 XP_4 AP45-APN0 VSS VSS N L=0.13U W=9.48U
m85 AP23-APN1 N153 AP23-AIND1 VSS N L=0.13U W=3.32U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.13U W=4.15U
m87 N153 AGTPT VDD VDD P L=0.13U W=0.58U
m88 N153 AGTPT VSS VSS N L=0.13U W=0.5U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m9 N64 AI2_ VDD VDD P L=0.13U W=2.03U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m91 N147 AI1_ VDD VDD P L=0.13U W=2.03U
m92 N147 AI1_ VSS VSS N L=0.13U W=1.34U
m93 N148 AI2 VDD VDD P L=0.13U W=2.03U
m94 N148 AI2 VSS VSS N L=0.13U W=1.34U
m95 N182 N148 VSS VSS N L=0.13U W=3.32U
m96 N181 N147 N182 VSS N L=0.13U W=3.32U
m97 AP23-AIND1 AP23-AIN21 N181 VSS N L=0.13U W=3.32U
m98 AP23-AIND1 N148 VDD VDD P L=0.13U W=4.16U
m99 N180 N148 VSS VSS N L=0.13U W=3.32U
.ENDS RA2SH128x36HXP38
****
.SUBCKT RA2SH128x36HXP38X_B A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA
+  BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP38X_B: 201 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36HXP38
.ENDS RA2SH128x36HXP38X_B
****
.SUBCKT RA2SH128x36X_PRE_DECODEB A0 A0_0 A1 A1_0 A2 AGTPB AGTPT AY0A AY0A_
+  AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_0_0 XP_1 XP_1_0 XP_2
+  XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36X_PRE_DECODEB: 307 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HXP24B
XI1_0 A0_0 A1_0 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36HXP38X_B
.ENDS RA2SH128x36X_PRE_DECODEB
****
.SUBCKT RA2SH128x36MODEL_COL_B BLB BLB_ MWLAS MWLBD MWLBS MWLD WLA WLA_0 WLA_1
+  WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13
+  WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23
+  WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2
+  WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13
+  WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23
+  WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 VSS VDD
** RA2SH128x36MODEL_COL_B: 256 flat devices **
XI0_0 VDD VDD BLB BLB_ WLA WLB VSS VDD RA2SH128x36CCMB
XI0_1 VDD VDD BLB BLB_ WLA_0 WLB_0 VSS VDD RA2SH128x36CCMB
XI0_10 VDD VDD BLB BLB_ WLA_9 WLB_9 VSS VDD RA2SH128x36CCMB
XI0_11 VDD VDD BLB BLB_ WLA_10 WLB_10 VSS VDD RA2SH128x36CCMB
XI0_12 VDD VDD BLB BLB_ WLA_11 WLB_11 VSS VDD RA2SH128x36CCMB
XI0_13 VDD VDD BLB BLB_ WLA_12 WLB_12 VSS VDD RA2SH128x36CCMB
XI0_14 VDD VDD BLB BLB_ WLA_13 WLB_13 VSS VDD RA2SH128x36CCMB
XI0_15 VDD VDD BLB BLB_ WLA_14 WLB_14 VSS VDD RA2SH128x36CCMB
XI0_17 VDD VDD BLB_ BLB WLA_15 WLB_15 VSS VDD RA2SH128x36CCMB
XI0_18 VDD VDD BLB_ BLB WLA_16 WLB_16 VSS VDD RA2SH128x36CCMB
XI0_19 VDD VDD BLB_ BLB WLA_17 WLB_17 VSS VDD RA2SH128x36CCMB
XI0_2 VDD VDD BLB BLB_ WLA_1 WLB_1 VSS VDD RA2SH128x36CCMB
XI0_20 VDD VDD BLB_ BLB WLA_18 WLB_18 VSS VDD RA2SH128x36CCMB
XI0_21 VDD VDD BLB_ BLB WLA_19 WLB_19 VSS VDD RA2SH128x36CCMB
XI0_22 VDD VDD BLB_ BLB WLA_20 WLB_20 VSS VDD RA2SH128x36CCMB
XI0_23 VDD VDD BLB_ BLB WLA_21 WLB_21 VSS VDD RA2SH128x36CCMB
XI0_24 VDD VDD BLB_ BLB WLA_22 WLB_22 VSS VDD RA2SH128x36CCMB
XI0_25 VDD VDD BLB_ BLB WLA_23 WLB_23 VSS VDD RA2SH128x36CCMB
XI0_26 VDD VDD BLB_ BLB WLA_24 WLB_24 VSS VDD RA2SH128x36CCMB
XI0_27 VDD VDD BLB_ BLB WLA_25 WLB_25 VSS VDD RA2SH128x36CCMB
XI0_28 VDD VDD BLB_ BLB WLA_26 WLB_26 VSS VDD RA2SH128x36CCMB
XI0_29 VDD VDD BLB_ BLB WLA_27 WLB_27 VSS VDD RA2SH128x36CCMB
XI0_3 VDD VDD BLB BLB_ WLA_2 WLB_2 VSS VDD RA2SH128x36CCMB
XI0_30 VDD VDD BLB_ BLB WLA_28 WLB_28 VSS VDD RA2SH128x36CCMB
XI0_31 VDD VDD BLB_ BLB WLA_29 WLB_29 VSS VDD RA2SH128x36CCMB
XI0_32 VDD VDD BLB_ BLB WLA_30 WLB_30 VSS VDD RA2SH128x36CCMB
XI0_4 VDD VDD BLB BLB_ WLA_3 WLB_3 VSS VDD RA2SH128x36CCMB
XI0_5 VDD VDD BLB BLB_ WLA_4 WLB_4 VSS VDD RA2SH128x36CCMB
XI0_6 VDD VDD BLB BLB_ WLA_5 WLB_5 VSS VDD RA2SH128x36CCMB
XI0_7 VDD VDD BLB BLB_ WLA_6 WLB_6 VSS VDD RA2SH128x36CCMB
XI0_8 VDD VDD BLB BLB_ WLA_7 WLB_7 VSS VDD RA2SH128x36CCMB
XI0_9 VDD VDD BLB BLB_ WLA_8 WLB_8 VSS VDD RA2SH128x36CCMB
.ENDS RA2SH128x36MODEL_COL_B
****
.SUBCKT RA2SH128x36MODEL_ROW_LEFT BLA BLA_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5
+  BLA_6 BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16
+  BLA_17 BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26
+  BLA_27 BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36
+  BLA_37 BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46
+  BLA_47 BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56
+  BLA_57 BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66
+  BLA_67 BLA_68 BLA_69 BLA_70 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5
+  BLA__6 BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8
+  BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19
+  BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29
+  BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39
+  BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49
+  BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59
+  BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69
+  BLB_70 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8
+  BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17
+  BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26
+  BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35
+  BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44
+  BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53
+  BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62
+  BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 WLA WLA_0
+  WLB WLB_0 VSS VDD
** RA2SH128x36MODEL_ROW_LEFT: 1728 flat devices **
XI0_0 BLA BLAD_118 BLA_ BLB BLBD_120 BLB_ WLA_0 WLB_0 VSS VDD RA2SH128x36CCMWG
XI0_1 BLA BLAD_118 BLA_ BLB BLBD_120 BLB_ WLA_0 WLB_0 VSS VDD RA2SH128x36CCMWG
XI0_2 BLA BLA_ BLB BLB_ WLA WLB VSS VDD RA2SH128x36CCG
XI10_0 BLA_9 BLAD_18 BLA__9 BLB_9 BLBD_20 BLB__9 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI10_1 BLA_9 BLAD_18 BLA__9 BLB_9 BLBD_20 BLB__9 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI10_2 BLA_9 BLA__9 BLB_9 BLB__9 WLA WLB VSS VDD RA2SH128x36CCP
XI11_0 BLA_10 BLAD_90 BLA__10 BLB_10 BLBD_92 BLB__10 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI11_1 BLA_10 BLAD_90 BLA__10 BLB_10 BLBD_92 BLB__10 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI11_2 BLA_10 BLA__10 BLB_10 BLB__10 WLA WLB VSS VDD RA2SH128x36CCG
XI12_0 BLA_11 BLAD_162 BLA__11 BLB_11 BLBD_164 BLB__11 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI12_1 BLA_11 BLAD_162 BLA__11 BLB_11 BLBD_164 BLB__11 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI12_2 BLA_11 BLA__11 BLB_11 BLB__11 WLA WLB VSS VDD RA2SH128x36CCG
XI13_0 BLA_12 BLAD_238 BLA__12 BLB_12 BLBD_240 BLB__12 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI13_1 BLA_12 BLAD_238 BLA__12 BLB_12 BLBD_240 BLB__12 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI13_2 BLA_12 BLA__12 BLB_12 BLB__12 WLA WLB VSS VDD RA2SH128x36CCP
XI14_0 BLA_13 BLAD_26 BLA__13 BLB_13 BLBD_28 BLB__13 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI14_1 BLA_13 BLAD_26 BLA__13 BLB_13 BLBD_28 BLB__13 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI14_2 BLA_13 BLA__13 BLB_13 BLB__13 WLA WLB VSS VDD RA2SH128x36CCP
XI15_0 BLA_14 BLAD_98 BLA__14 BLB_14 BLBD_100 BLB__14 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI15_1 BLA_14 BLAD_98 BLA__14 BLB_14 BLBD_100 BLB__14 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI15_2 BLA_14 BLA__14 BLB_14 BLB__14 WLA WLB VSS VDD RA2SH128x36CCG
XI16_0 BLA_15 BLAD_174 BLA__15 BLB_15 BLBD_176 BLB__15 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI16_1 BLA_15 BLAD_174 BLA__15 BLB_15 BLBD_176 BLB__15 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI16_2 BLA_15 BLA__15 BLB_15 BLB__15 WLA WLB VSS VDD RA2SH128x36CCG
XI17_0 BLA_16 BLAD_250 BLA__16 BLB_16 BLBD_252 BLB__16 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI17_1 BLA_16 BLAD_250 BLA__16 BLB_16 BLBD_252 BLB__16 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI17_2 BLA_16 BLA__16 BLB_16 BLB__16 WLA WLB VSS VDD RA2SH128x36CCP
XI18_0 BLA_17 BLAD_38 BLA__17 BLB_17 BLBD_40 BLB__17 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI18_1 BLA_17 BLAD_38 BLA__17 BLB_17 BLBD_40 BLB__17 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI18_2 BLA_17 BLA__17 BLB_17 BLB__17 WLA WLB VSS VDD RA2SH128x36CCP
XI19_0 BLA_18 BLAD_110 BLA__18 BLB_18 BLBD_112 BLB__18 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI19_1 BLA_18 BLAD_110 BLA__18 BLB_18 BLBD_112 BLB__18 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI19_2 BLA_18 BLA__18 BLB_18 BLB__18 WLA WLB VSS VDD RA2SH128x36CCG
XI1_0 BLA_0 BLAD_194 BLA__0 BLB_0 BLBD_196 BLB__0 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI1_1 BLA_0 BLAD_194 BLA__0 BLB_0 BLBD_196 BLB__0 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI1_2 BLA_0 BLA__0 BLB_0 BLB__0 WLA WLB VSS VDD RA2SH128x36CCP
XI20_0 BLA_19 BLAD_130 BLA__19 BLB_19 BLBD_132 BLB__19 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI20_1 BLA_19 BLAD_130 BLA__19 BLB_19 BLBD_132 BLB__19 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI20_2 BLA_19 BLA__19 BLB_19 BLB__19 WLA WLB VSS VDD RA2SH128x36CCG
XI21_0 BLA_20 BLAD_206 BLA__20 BLB_20 BLBD_208 BLB__20 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI21_1 BLA_20 BLAD_206 BLA__20 BLB_20 BLBD_208 BLB__20 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI21_2 BLA_20 BLA__20 BLB_20 BLB__20 WLA WLB VSS VDD RA2SH128x36CCP
XI22_0 BLA_21 BLAD_274 BLA__21 BLB_21 BLBD_276 BLB__21 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI22_1 BLA_21 BLAD_274 BLA__21 BLB_21 BLBD_276 BLB__21 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI22_2 BLA_21 BLA__21 BLB_21 BLB__21 WLA WLB VSS VDD RA2SH128x36CCP
XI23_0 BLA_22 BLAD_62 BLA__22 BLB_22 BLBD_64 BLB__22 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI23_1 BLA_22 BLAD_62 BLA__22 BLB_22 BLBD_64 BLB__22 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI23_2 BLA_22 BLA__22 BLB_22 BLB__22 WLA WLB VSS VDD RA2SH128x36CCG
XI24_0 BLA_23 BLAD_138 BLA__23 BLB_23 BLBD_140 BLB__23 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI24_1 BLA_23 BLAD_138 BLA__23 BLB_23 BLBD_140 BLB__23 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI24_2 BLA_23 BLA__23 BLB_23 BLB__23 WLA WLB VSS VDD RA2SH128x36CCG
XI25_0 BLA_24 BLAD_214 BLA__24 BLB_24 BLBD_216 BLB__24 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI25_1 BLA_24 BLAD_214 BLA__24 BLB_24 BLBD_216 BLB__24 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI25_2 BLA_24 BLA__24 BLB_24 BLB__24 WLA WLB VSS VDD RA2SH128x36CCP
XI26_0 BLA_25 BLAD BLA__25 BLB_25 BLBD BLB__25 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI26_1 BLA_25 BLAD BLA__25 BLB_25 BLBD BLB__25 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI26_2 BLA_25 BLA__25 BLB_25 BLB__25 WLA WLB VSS VDD RA2SH128x36CCP
XI27_0 BLA_26 BLAD_74 BLA__26 BLB_26 BLBD_76 BLB__26 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI27_1 BLA_26 BLAD_74 BLA__26 BLB_26 BLBD_76 BLB__26 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI27_2 BLA_26 BLA__26 BLB_26 BLB__26 WLA WLB VSS VDD RA2SH128x36CCG
XI28_0 BLA_27 BLAD_150 BLA__27 BLB_27 BLBD_152 BLB__27 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI28_1 BLA_27 BLAD_150 BLA__27 BLB_27 BLBD_152 BLB__27 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI28_2 BLA_27 BLA__27 BLB_27 BLB__27 WLA WLB VSS VDD RA2SH128x36CCG
XI29_0 BLA_28 BLAD_226 BLA__28 BLB_28 BLBD_228 BLB__28 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI29_1 BLA_28 BLAD_226 BLA__28 BLB_28 BLBD_228 BLB__28 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI29_2 BLA_28 BLA__28 BLB_28 BLB__28 WLA WLB VSS VDD RA2SH128x36CCP
XI2_0 BLA_1 BLAD_266 BLA__1 BLB_1 BLBD_268 BLB__1 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI2_1 BLA_1 BLAD_266 BLA__1 BLB_1 BLBD_268 BLB__1 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI2_2 BLA_1 BLA__1 BLB_1 BLB__1 WLA WLB VSS VDD RA2SH128x36CCP
XI30_0 BLA_29 BLAD_234 BLA__29 BLB_29 BLBD_236 BLB__29 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI30_1 BLA_29 BLAD_234 BLA__29 BLB_29 BLBD_236 BLB__29 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI30_2 BLA_29 BLA__29 BLB_29 BLB__29 WLA WLB VSS VDD RA2SH128x36CCP
XI31_0 BLA_30 BLAD_22 BLA__30 BLB_30 BLBD_24 BLB__30 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI31_1 BLA_30 BLAD_22 BLA__30 BLB_30 BLBD_24 BLB__30 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI31_2 BLA_30 BLA__30 BLB_30 BLB__30 WLA WLB VSS VDD RA2SH128x36CCG
XI32_0 BLA_31 BLAD_94 BLA__31 BLB_31 BLBD_96 BLB__31 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI32_1 BLA_31 BLAD_94 BLA__31 BLB_31 BLBD_96 BLB__31 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI32_2 BLA_31 BLA__31 BLB_31 BLB__31 WLA WLB VSS VDD RA2SH128x36CCG
XI33_0 BLA_32 BLAD_170 BLA__32 BLB_32 BLBD_172 BLB__32 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI33_1 BLA_32 BLAD_170 BLA__32 BLB_32 BLBD_172 BLB__32 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI33_2 BLA_32 BLA__32 BLB_32 BLB__32 WLA WLB VSS VDD RA2SH128x36CCP
XI34_0 BLA_33 BLAD_246 BLA__33 BLB_33 BLBD_248 BLB__33 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI34_1 BLA_33 BLAD_246 BLA__33 BLB_33 BLBD_248 BLB__33 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI34_2 BLA_33 BLA__33 BLB_33 BLB__33 WLA WLB VSS VDD RA2SH128x36CCP
XI35_0 BLA_34 BLAD_34 BLA__34 BLB_34 BLBD_36 BLB__34 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI35_1 BLA_34 BLAD_34 BLA__34 BLB_34 BLBD_36 BLB__34 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI35_2 BLA_34 BLA__34 BLB_34 BLB__34 WLA WLB VSS VDD RA2SH128x36CCG
XI36_0 BLA_35 BLA__35 BLB_35 BLB__35 WLA_0 WLB_0 VSS VDD RA2SH128x36FLMWG
XI36_2 BLA_35 BLA__35 BLB_35 BLB__35 WLA WLB VSS VDD RA2SH128x36CCG
XI37_0 BLA_36 BLAD_186 BLA__36 BLB_36 BLBD_188 BLB__36 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI37_1 BLA_36 BLAD_186 BLA__36 BLB_36 BLBD_188 BLB__36 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI37_2 BLA_36 BLA__36 BLB_36 BLB__36 WLA WLB VSS VDD RA2SH128x36CCP
XI38_0 BLA_37 BLAD_258 BLA__37 BLB_37 BLBD_260 BLB__37 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI38_1 BLA_37 BLAD_258 BLA__37 BLB_37 BLBD_260 BLB__37 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI38_2 BLA_37 BLA__37 BLB_37 BLB__37 WLA WLB VSS VDD RA2SH128x36CCP
XI39_0 BLA_38 BLAD_46 BLA__38 BLB_38 BLBD_48 BLB__38 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI39_1 BLA_38 BLAD_46 BLA__38 BLB_38 BLBD_48 BLB__38 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI39_2 BLA_38 BLA__38 BLB_38 BLB__38 WLA WLB VSS VDD RA2SH128x36CCG
XI3_0 BLA_2 BLAD_50 BLA__2 BLB_2 BLBD_52 BLB__2 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI3_1 BLA_2 BLAD_50 BLA__2 BLB_2 BLBD_52 BLB__2 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI3_2 BLA_2 BLA__2 BLB_2 BLB__2 WLA WLB VSS VDD RA2SH128x36CCG
XI40_0 BLA_39 BLAD_58 BLA__39 BLB_39 BLBD_60 BLB__39 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI40_1 BLA_39 BLAD_58 BLA__39 BLB_39 BLBD_60 BLB__39 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI40_2 BLA_39 BLA__39 BLB_39 BLB__39 WLA WLB VSS VDD RA2SH128x36CCG
XI41_0 BLA_40 BLAD_134 BLA__40 BLB_40 BLBD_136 BLB__40 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI41_1 BLA_40 BLAD_134 BLA__40 BLB_40 BLBD_136 BLB__40 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI41_2 BLA_40 BLA__40 BLB_40 BLB__40 WLA WLB VSS VDD RA2SH128x36CCP
XI42_0 BLA_41 BLAD_210 BLA__41 BLB_41 BLBD_212 BLB__41 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI42_1 BLA_41 BLAD_210 BLA__41 BLB_41 BLBD_212 BLB__41 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI42_2 BLA_41 BLA__41 BLB_41 BLB__41 WLA WLB VSS VDD RA2SH128x36CCP
XI43_0 BLA_42 BLAD_2 BLA__42 BLB_42 BLBD_4 BLB__42 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI43_1 BLA_42 BLAD_2 BLA__42 BLB_42 BLBD_4 BLB__42 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI43_2 BLA_42 BLA__42 BLB_42 BLB__42 WLA WLB VSS VDD RA2SH128x36CCG
XI44_0 BLA_43 BLAD_70 BLA__43 BLB_43 BLBD_72 BLB__43 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI44_1 BLA_43 BLAD_70 BLA__43 BLB_43 BLBD_72 BLB__43 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI44_2 BLA_43 BLA__43 BLB_43 BLB__43 WLA WLB VSS VDD RA2SH128x36CCG
XI45_0 BLA_44 BLAD_146 BLA__44 BLB_44 BLBD_148 BLB__44 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI45_1 BLA_44 BLAD_146 BLA__44 BLB_44 BLBD_148 BLB__44 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI45_2 BLA_44 BLA__44 BLB_44 BLB__44 WLA WLB VSS VDD RA2SH128x36CCP
XI46_0 BLA_45 BLAD_222 BLA__45 BLB_45 BLBD_224 BLB__45 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI46_1 BLA_45 BLAD_222 BLA__45 BLB_45 BLBD_224 BLB__45 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI46_2 BLA_45 BLA__45 BLB_45 BLB__45 WLA WLB VSS VDD RA2SH128x36CCP
XI47_0 BLA_46 BLAD_10 BLA__46 BLB_46 BLBD_12 BLB__46 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI47_1 BLA_46 BLAD_10 BLA__46 BLB_46 BLBD_12 BLB__46 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI47_2 BLA_46 BLA__46 BLB_46 BLB__46 WLA WLB VSS VDD RA2SH128x36CCG
XI48_0 BLA_47 BLAD_82 BLA__47 BLB_47 BLBD_84 BLB__47 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI48_1 BLA_47 BLAD_82 BLA__47 BLB_47 BLBD_84 BLB__47 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI48_2 BLA_47 BLA__47 BLB_47 BLB__47 WLA WLB VSS VDD RA2SH128x36CCG
XI49_0 BLA_48 BLAD_158 BLA__48 BLB_48 BLBD_160 BLB__48 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI49_1 BLA_48 BLAD_158 BLA__48 BLB_48 BLBD_160 BLB__48 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI49_2 BLA_48 BLA__48 BLB_48 BLB__48 WLA WLB VSS VDD RA2SH128x36CCP
XI4_0 BLA_3 BLAD_122 BLA__3 BLB_3 BLBD_124 BLB__3 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI4_1 BLA_3 BLAD_122 BLA__3 BLB_3 BLBD_124 BLB__3 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI4_2 BLA_3 BLA__3 BLB_3 BLB__3 WLA WLB VSS VDD RA2SH128x36CCG
XI50_0 BLA_49 BLAD_166 BLA__49 BLB_49 BLBD_168 BLB__49 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI50_1 BLA_49 BLAD_166 BLA__49 BLB_49 BLBD_168 BLB__49 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI50_2 BLA_49 BLA__49 BLB_49 BLB__49 WLA WLB VSS VDD RA2SH128x36CCP
XI51_0 BLA_50 BLAD_242 BLA__50 BLB_50 BLBD_244 BLB__50 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI51_1 BLA_50 BLAD_242 BLA__50 BLB_50 BLBD_244 BLB__50 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI51_2 BLA_50 BLA__50 BLB_50 BLB__50 WLA WLB VSS VDD RA2SH128x36CCG
XI52_0 BLA_51 BLAD_30 BLA__51 BLB_51 BLBD_32 BLB__51 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI52_1 BLA_51 BLAD_30 BLA__51 BLB_51 BLBD_32 BLB__51 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI52_2 BLA_51 BLA__51 BLB_51 BLB__51 WLA WLB VSS VDD RA2SH128x36CCG
XI53_0 BLA_52 BLAD_106 BLA__52 BLB_52 BLBD_108 BLB__52 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI53_1 BLA_52 BLAD_106 BLA__52 BLB_52 BLBD_108 BLB__52 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI53_2 BLA_52 BLA__52 BLB_52 BLB__52 WLA WLB VSS VDD RA2SH128x36CCP
XI54_0 BLA_53 BLAD_182 BLA__53 BLB_53 BLBD_184 BLB__53 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI54_1 BLA_53 BLAD_182 BLA__53 BLB_53 BLBD_184 BLB__53 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI54_2 BLA_53 BLA__53 BLB_53 BLB__53 WLA WLB VSS VDD RA2SH128x36CCP
XI55_0 BLA_54 BLAD_254 BLA__54 BLB_54 BLBD_256 BLB__54 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI55_1 BLA_54 BLAD_254 BLA__54 BLB_54 BLBD_256 BLB__54 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI55_2 BLA_54 BLA__54 BLB_54 BLB__54 WLA WLB VSS VDD RA2SH128x36CCG
XI56_0 BLA_55 BLAD_42 BLA__55 BLB_55 BLBD_44 BLB__55 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI56_1 BLA_55 BLAD_42 BLA__55 BLB_55 BLBD_44 BLB__55 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI56_2 BLA_55 BLA__55 BLB_55 BLB__55 WLA WLB VSS VDD RA2SH128x36CCG
XI57_0 BLA_56 BLAD_114 BLA__56 BLB_56 BLBD_116 BLB__56 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI57_1 BLA_56 BLAD_114 BLA__56 BLB_56 BLBD_116 BLB__56 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI57_2 BLA_56 BLA__56 BLB_56 BLB__56 WLA WLB VSS VDD RA2SH128x36CCP
XI58_0 BLA_57 BLAD_190 BLA__57 BLB_57 BLBD_192 BLB__57 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI58_1 BLA_57 BLAD_190 BLA__57 BLB_57 BLBD_192 BLB__57 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI58_2 BLA_57 BLA__57 BLB_57 BLB__57 WLA WLB VSS VDD RA2SH128x36CCP
XI59_0 BLA_58 BLAD_262 BLA__58 BLB_58 BLBD_264 BLB__58 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI59_1 BLA_58 BLAD_262 BLA__58 BLB_58 BLBD_264 BLB__58 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI59_2 BLA_58 BLA__58 BLB_58 BLB__58 WLA WLB VSS VDD RA2SH128x36CCG
XI5_0 BLA_4 BLAD_198 BLA__4 BLB_4 BLBD_200 BLB__4 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI5_1 BLA_4 BLAD_198 BLA__4 BLB_4 BLBD_200 BLB__4 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI5_2 BLA_4 BLA__4 BLB_4 BLB__4 WLA WLB VSS VDD RA2SH128x36CCP
XI60_0 BLA_59 BLAD_278 BLA__59 BLB_59 BLBD_280 BLB__59 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI60_1 BLA_59 BLAD_278 BLA__59 BLB_59 BLBD_280 BLB__59 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI60_2 BLA_59 BLA__59 BLB_59 BLB__59 WLA WLB VSS VDD RA2SH128x36CCG
XI61_0 BLA_60 BLAD_66 BLA__60 BLB_60 BLBD_68 BLB__60 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI61_1 BLA_60 BLAD_66 BLA__60 BLB_60 BLBD_68 BLB__60 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI61_2 BLA_60 BLA__60 BLB_60 BLB__60 WLA WLB VSS VDD RA2SH128x36CCP
XI62_0 BLA_61 BLAD_142 BLA__61 BLB_61 BLBD_144 BLB__61 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI62_1 BLA_61 BLAD_142 BLA__61 BLB_61 BLBD_144 BLB__61 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI62_2 BLA_61 BLA__61 BLB_61 BLB__61 WLA WLB VSS VDD RA2SH128x36CCP
XI63_0 BLA_62 BLAD_218 BLA__62 BLB_62 BLBD_220 BLB__62 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI63_1 BLA_62 BLAD_218 BLA__62 BLB_62 BLBD_220 BLB__62 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI63_2 BLA_62 BLA__62 BLB_62 BLB__62 WLA WLB VSS VDD RA2SH128x36CCG
XI64_0 BLA_63 BLAD_6 BLA__63 BLB_63 BLBD_8 BLB__63 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI64_1 BLA_63 BLAD_6 BLA__63 BLB_63 BLBD_8 BLB__63 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI64_2 BLA_63 BLA__63 BLB_63 BLB__63 WLA WLB VSS VDD RA2SH128x36CCG
XI65_0 BLA_64 BLAD_78 BLA__64 BLB_64 BLBD_80 BLB__64 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI65_1 BLA_64 BLAD_78 BLA__64 BLB_64 BLBD_80 BLB__64 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI65_2 BLA_64 BLA__64 BLB_64 BLB__64 WLA WLB VSS VDD RA2SH128x36CCP
XI66_0 BLA_65 BLAD_154 BLA__65 BLB_65 BLBD_156 BLB__65 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI66_1 BLA_65 BLAD_154 BLA__65 BLB_65 BLBD_156 BLB__65 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI66_2 BLA_65 BLA__65 BLB_65 BLB__65 WLA WLB VSS VDD RA2SH128x36CCP
XI67_0 BLA_66 BLAD_230 BLA__66 BLB_66 BLBD_232 BLB__66 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI67_1 BLA_66 BLAD_230 BLA__66 BLB_66 BLBD_232 BLB__66 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI67_2 BLA_66 BLA__66 BLB_66 BLB__66 WLA WLB VSS VDD RA2SH128x36CCG
XI68_0 BLA_67 BLAD_14 BLA__67 BLB_67 BLBD_16 BLB__67 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI68_1 BLA_67 BLAD_14 BLA__67 BLB_67 BLBD_16 BLB__67 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI68_2 BLA_67 BLA__67 BLB_67 BLB__67 WLA WLB VSS VDD RA2SH128x36CCG
XI69_0 BLA_68 BLAD_86 BLA__68 BLB_68 BLBD_88 BLB__68 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI69_1 BLA_68 BLAD_86 BLA__68 BLB_68 BLBD_88 BLB__68 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI69_2 BLA_68 BLA__68 BLB_68 BLB__68 WLA WLB VSS VDD RA2SH128x36CCP
XI6_0 BLA_5 BLAD_270 BLA__5 BLB_5 BLBD_272 BLB__5 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI6_1 BLA_5 BLAD_270 BLA__5 BLB_5 BLBD_272 BLB__5 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI6_2 BLA_5 BLA__5 BLB_5 BLB__5 WLA WLB VSS VDD RA2SH128x36CCP
XI70_0 BLA_69 BLAD_102 BLA__69 BLB_69 BLBD_104 BLB__69 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI70_1 BLA_69 BLAD_102 BLA__69 BLB_69 BLBD_104 BLB__69 VSS VSS VSS VDD
+  RA2SH128x36CCMWP
XI70_2 BLA_69 BLA__69 BLB_69 BLB__69 WLA WLB VSS VDD RA2SH128x36CCP
XI71_0 BLA_70 BLAD_178 BLA__70 BLB_70 BLBD_180 BLB__70 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI71_1 BLA_70 BLAD_178 BLA__70 BLB_70 BLBD_180 BLB__70 VSS VSS VSS VDD
+  RA2SH128x36CCMWG
XI71_2 BLA_70 BLA__70 BLB_70 BLB__70 WLA WLB VSS VDD RA2SH128x36CCG
XI7_0 BLA_6 BLAD_54 BLA__6 BLB_6 BLBD_56 BLB__6 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI7_1 BLA_6 BLAD_54 BLA__6 BLB_6 BLBD_56 BLB__6 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI7_2 BLA_6 BLA__6 BLB_6 BLB__6 WLA WLB VSS VDD RA2SH128x36CCG
XI8_0 BLA_7 BLAD_126 BLA__7 BLB_7 BLBD_128 BLB__7 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI8_1 BLA_7 BLAD_126 BLA__7 BLB_7 BLBD_128 BLB__7 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWG
XI8_2 BLA_7 BLA__7 BLB_7 BLB__7 WLA WLB VSS VDD RA2SH128x36CCG
XI9_0 BLA_8 BLAD_202 BLA__8 BLB_8 BLBD_204 BLB__8 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI9_1 BLA_8 BLAD_202 BLA__8 BLB_8 BLBD_204 BLB__8 WLA_0 WLB_0 VSS VDD
+  RA2SH128x36CCMWP
XI9_2 BLA_8 BLA__8 BLB_8 BLB__8 WLA WLB VSS VDD RA2SH128x36CCP
.ENDS RA2SH128x36MODEL_ROW_LEFT
****
.SUBCKT RA2SH128x36HXP24A A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP24A: 106 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HXP24
.ENDS RA2SH128x36HXP24A
****
.SUBCKT RA2SH128x36HXP38X_A A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA
+  BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0
+  YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2
+  YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
** RA2SH128x36HXP38X_A: 201 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3
+  YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1
+  YPB1_2 YPB1_3 VSS VDD RA2SH128x36HXP38
.ENDS RA2SH128x36HXP38X_A
****
.SUBCKT RA2SH128x36X_PRE_DECODEA A0 A0_0 A1 A1_0 A2 AGTPB AGTPT AY0A AY0A_
+  AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB XP_0 XP_0_0 XP_1 XP_1_0 XP_2
+  XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36X_PRE_DECODEA: 307 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA
+  WEIB XP_0 XP_1 XP_2 XP_3 YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HXP24A
XI1_0 A0_0 A1_0 A2 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_
+  WEIA WEIB XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1
+  YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3
+  YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD RA2SH128x36HXP38X_A
.ENDS RA2SH128x36X_PRE_DECODEA
****
.SUBCKT RA2SH128x36HYP12XLX_A A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  OEIA_ OEIB_ WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD
** RA2SH128x36HYP12XLX_A: 95 flat devices **
XI0_0 A0 AGTPB AGTPT AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD RA2SH128x36HYP12XL
.ENDS RA2SH128x36HYP12XLX_A
****
.SUBCKT RA2SH128x36HYP12XRX_A A0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK
+  GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0
+  YPA1_1 YPA1_2 YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2
+  YPB1_3 VSS VDD
** RA2SH128x36HYP12XRX_A: 95 flat devices **
XI0_0 A0 AGTP AY0A AY0A AY0A_ AY0B AY0B_ AY0A_ BWENA BWENB CLK GSRCN GTPN
+  OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPA0_2 YPA0_3 YPA1_0 YPA1_1 YPA1_2
+  YPA1_3 YPB0_0 YPB0_1 YPB0_2 YPB0_3 YPB1_0 YPB1_1 YPB1_2 YPB1_3 VSS VDD
+  RA2SH128x36HYP12XR
.ENDS RA2SH128x36HYP12XRX_A
****
.SUBCKT RA2SH128x36Y_DECODEA A0 A0_0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB
+  CLK GSRCN GTPN OEIA_ OEIB_ RST WEIA WEIB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS
+  VDD
** RA2SH128x36Y_DECODEA: 190 flat devices **
XI0_0 A0 AGTP AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB OEIA_ OEIB_ WEIA WEIB
+  YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD RA2SH128x36HYP12XLX_A
XI1_0 A0_0 AGTP AY0A AY0A_ AY0B AY0B_ BWENA BWENB CLK GSRCN GTPN OEIA_ OEIB_
+  RST WEIA WEIB YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS
+  VSS VSS VSS VSS VSS VDD RA2SH128x36HYP12XRX_A
.ENDS RA2SH128x36Y_DECODEA
****
.SUBCKT RA2SH128x36HBFX_A CEN CLK GSRCN GTPA GTPB GTPN MBL RST STUBBWA STUBBWB
+  WEIA WEIB WEN VSS VDD
** RA2SH128x36HBFX_A: 76 flat devices **
XI0_0 CEN CLK GSRCN GTPA GTPA GTPB GTPN MBL RST VSS STUBBWA STUBBWB VSS WEIA
+  WEIA WEIB WEN VSS VDD RA2SH128x36HBF4
.ENDS RA2SH128x36HBFX_A
****
.SUBCKT RA2SH128x36MWDX_A GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36MWDX_A: 37 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS MWLA MWLA
+  MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA2SH128x36MWD
.ENDS RA2SH128x36MWDX_A
****
.SUBCKT RA2SH128x36ROW_TOPA G0F G1F GTP MBL MBL_ MWLA MWLB MWLD XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_TOPA: 41 flat devices **
XI0_0 MWLA MWLB XP0 XP1 VSS VDD RA2SH128x36FCMWDX
XI1_0 G0F G1F MWLA MWLB XP0F XP1F VSS VDD RA2SH128x36FCMWD
XI2_0 GTP MBL MBL_ MWLA MWLB MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36MWDX_A
.ENDS RA2SH128x36ROW_TOPA
****
.SUBCKT RA2SH128x36HWDBX_A G0 G1 G2_W0 G2_W1 GTPA GTPB WLA0 WLA1 WLB0 WLB1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36HWDBX_A: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTPA GTPA GTPA GTPA GTPA GTPA GTPB WLA0 WLA1 WLA0 WLA1
+  WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA2SH128x36HWDB
.ENDS RA2SH128x36HWDBX_A
****
.SUBCKT RA2SH128x36HWDBX_A0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36HWDBX_A0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36HWDBX_A
.ENDS RA2SH128x36HWDBX_A0
****
.SUBCKT RA2SH128x36ROW_BOTTOMA G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0F XP0F_0
+  XP1F XP1F_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_BOTTOMA: 30 flat devices **
XI2_0 G0 G1 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD RA2SH128x36HWDBX_A0
.ENDS RA2SH128x36ROW_BOTTOMA
****
.SUBCKT RA2SH128x36WDX_A G0 G1 G2_W0 G2_W1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_A: 30 flat devices **
XI0_0 G0 G1 G2_W0 G2_W1 GTP WLA0 WLA1 WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WD
.ENDS RA2SH128x36WDX_A
****
.SUBCKT RA2SH128x36WDX_A1 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_A1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_A
.ENDS RA2SH128x36WDX_A1
****
.SUBCKT RA2SH128x36ROW_FILLER1A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER1A: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_A1
.ENDS RA2SH128x36ROW_FILLER1A
****
.SUBCKT RA2SH128x36WDX_A2 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_A2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_A
.ENDS RA2SH128x36WDX_A2
****
.SUBCKT RA2SH128x36ROW_FILLER2A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER2A: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_A2
.ENDS RA2SH128x36ROW_FILLER2A
****
.SUBCKT RA2SH128x36WDX_A3 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_A3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_A
.ENDS RA2SH128x36WDX_A3
****
.SUBCKT RA2SH128x36ROW_FILLER3A G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP0 XP0F XP1
+  XP1F XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_FILLER3A: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_A3
.ENDS RA2SH128x36ROW_FILLER3A
****
.SUBCKT RA2SH128x36WDX_A0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36WDX_A0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WDX_A
.ENDS RA2SH128x36WDX_A0
****
.SUBCKT RA2SH128x36ROW_8A G0 G1 G1B GTP WLA0 WLA1 WLB0 WLB1 XP0F XP0F_0 XP1F
+  XP1F_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA2SH128x36ROW_8A: 30 flat devices **
XI2_0 G0 G1 GTP WLA0 WLA1 WLB0 WLB1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA2SH128x36WDX_A0
.ENDS RA2SH128x36ROW_8A
****
.SUBCKT RA2SH128x36WORD_ROWSA G0 GTPA GTPB MBL MBL_ MWLA MWLB MWLD WLA0 WLA0_0
+  WLA0_1 WLA0_2 WLA0_3 WLA0_4 WLA0_5 WLA0_6 WLA0_7 WLA0_8 WLA0_9 WLA0_10
+  WLA0_11 WLA0_12 WLA0_13 WLA0_14 WLA1 WLA1_0 WLA1_1 WLA1_2 WLA1_3 WLA1_4
+  WLA1_5 WLA1_6 WLA1_7 WLA1_8 WLA1_9 WLA1_10 WLA1_11 WLA1_12 WLA1_13 WLA1_14
+  WLB0 WLB0_0 WLB0_1 WLB0_2 WLB0_3 WLB0_4 WLB0_5 WLB0_6 WLB0_7 WLB0_8 WLB0_9
+  WLB0_10 WLB0_11 WLB0_12 WLB0_13 WLB0_14 WLB1 WLB1_0 WLB1_1 WLB1_2 WLB1_3
+  WLB1_4 WLB1_5 WLB1_6 WLB1_7 WLB1_8 WLB1_9 WLB1_10 WLB1_11 WLB1_12 WLB1_13
+  WLB1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA2SH128x36WORD_ROWSA: 521 flat devices **
XI0_0 G0 XP0_0 GTPA GTPB WLA0 WLA1 WLB0 WLB1 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_BOTTOMA
XI0_1 G0 XP0_0 GTPA WLA0_0 WLA1_0 WLB0_0 WLB1_0 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1A
XI0_10 G0 XP0 GTPA WLA0_8 WLA1_8 WLB0_8 WLB1_8 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1A
XI0_11 G0 XP0 GTPA WLA0_9 WLA1_9 WLB0_9 WLB1_9 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2A
XI0_12 G0 XP0 GTPA WLA0_10 WLA1_10 WLB0_10 WLB1_10 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3A
XI0_13 G0 XP1 XP0 GTPA WLA0_11 WLA1_11 WLB0_11 WLB1_11 XP0 XP0_0 XP1 XP1_0
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8A
XI0_14 G0 XP1 GTPA WLA0_12 WLA1_12 WLB0_12 WLB1_12 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1A
XI0_15 G0 XP1 GTPA WLA0_13 WLA1_13 WLB0_13 WLB1_13 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2A
XI0_16 G0 XP1 GTPA WLA0_14 WLA1_14 WLB0_14 WLB1_14 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3A
XI0_17 G0 XP1 GTPA MBL MBL_ MWLA MWLB MWLD XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_TOPA
XI0_2 G0 XP0_0 GTPA WLA0_1 WLA1_1 WLB0_1 WLB1_1 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2A
XI0_3 G0 XP0_0 GTPA WLA0_2 WLA1_2 WLB0_2 WLB1_2 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3A
XI0_4 G0 XP1_0 XP0_0 GTPA WLA0_3 WLA1_3 WLB0_3 WLB1_3 XP0 XP0_0 XP1 XP1_0
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8A
XI0_5 G0 XP1_0 GTPA WLA0_4 WLA1_4 WLB0_4 WLB1_4 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER1A
XI0_6 G0 XP1_0 GTPA WLA0_5 WLA1_5 WLB0_5 WLB1_5 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER2A
XI0_7 G0 XP1_0 GTPA WLA0_6 WLA1_6 WLB0_6 WLB1_6 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_FILLER3A
XI0_9 G0 XP0 XP1_0 GTPA WLA0_7 WLA1_7 WLB0_7 WLB1_7 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36ROW_8A
.ENDS RA2SH128x36WORD_ROWSA
****
.SUBCKT RA2SH128x36 AA[0] AA[1] AA[2] AA[3] AA[4] AA[5] AA[6] AB[0] AB[1]
+  AB[2] AB[3] AB[4] AB[5] AB[6] CENA CENB CLKA CLKB DA[0] DA[1] DA[2] DA[3]
+  DA[4] DA[5] DA[6] DA[7] DA[8] DA[9] DA[10] DA[11] DA[12] DA[13] DA[14]
+  DA[15] DA[16] DA[17] DA[18] DA[19] DA[20] DA[21] DA[22] DA[23] DA[24]
+  DA[25] DA[26] DA[27] DA[28] DA[29] DA[30] DA[31] DA[32] DA[33] DA[34]
+  DA[35] DB[0] DB[1] DB[2] DB[3] DB[4] DB[5] DB[6] DB[7] DB[8] DB[9] DB[10]
+  DB[11] DB[12] DB[13] DB[14] DB[15] DB[16] DB[17] DB[18] DB[19] DB[20]
+  DB[21] DB[22] DB[23] DB[24] DB[25] DB[26] DB[27] DB[28] DB[29] DB[30]
+  DB[31] DB[32] DB[33] DB[34] DB[35] QA[0] QA[1] QA[2] QA[3] QA[4] QA[5]
+  QA[6] QA[7] QA[8] QA[9] QA[10] QA[11] QA[12] QA[13] QA[14] QA[15] QA[16]
+  QA[17] QA[18] QA[19] QA[20] QA[21] QA[22] QA[23] QA[24] QA[25] QA[26]
+  QA[27] QA[28] QA[29] QA[30] QA[31] QA[32] QA[33] QA[34] QA[35] QB[0] QB[1]
+  QB[2] QB[3] QB[4] QB[5] QB[6] QB[7] QB[8] QB[9] QB[10] QB[11] QB[12] QB[13]
+  QB[14] QB[15] QB[16] QB[17] QB[18] QB[19] QB[20] QB[21] QB[22] QB[23]
+  QB[24] QB[25] QB[26] QB[27] QB[28] QB[29] QB[30] QB[31] QB[32] QB[33]
+  QB[34] QB[35] WENA WENB VSS VDD
** RA2SH128x36: 57196 flat devices **
XI0_0 A0A A0A_ A0B A0B_ GTPA_1 GTPA_1 GTPA_1 GTPB_1 GTPB_1 GTPB_1 VSS VSS
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS
+  VSS VSS VSS VDD RA2SH128x36CAP
XI10_2 A0A A0A_ A0B A0B_ CLKA GSRCN GTPA_1 GTPB_1 GTPN MBL MBLA_ VDD VDD
+  YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS
+  VSS VDD RA2SH128x36FLCIOX_A
XI10_4 MBLA_ MBL MWLD MWLBD MWLBD MWLD WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5
+  WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16
+  WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26
+  WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6
+  WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17
+  WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27
+  WLB_28 WLB_29 WLB_30 VSS VDD RA2SH128x36MODEL_COL_A
XI11_0 A0A A0A_ A0B A0B_ BLA BLA_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6
+  BLA_7 BLA_8 BLA_9 BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17
+  BLA_18 BLA_19 BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27
+  BLA_28 BLA_29 BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37
+  BLA_38 BLA_39 BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47
+  BLA_48 BLA_49 BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57
+  BLA_58 BLA_59 BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67
+  BLA_68 BLA_69 BLA_70 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6
+  BLA__7 BLA__8 BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15
+  BLA__16 BLA__17 BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24
+  BLA__25 BLA__26 BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33
+  BLA__34 BLA__35 BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42
+  BLA__43 BLA__44 BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51
+  BLA__52 BLA__53 BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60
+  BLA__61 BLA__62 BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69
+  BLA__70 BLB BLB_ BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8
+  BLB_9 BLB_10 BLB_11 BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19
+  BLB_20 BLB_21 BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29
+  BLB_30 BLB_31 BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39
+  BLB_40 BLB_41 BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49
+  BLB_50 BLB_51 BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59
+  BLB_60 BLB_61 BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69
+  BLB_70 BLB__0 BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8
+  BLB__9 BLB__10 BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17
+  BLB__18 BLB__19 BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26
+  BLB__27 BLB__28 BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35
+  BLB__36 BLB__37 BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44
+  BLB__45 BLB__46 BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53
+  BLB__54 BLB__55 BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62
+  BLB__63 BLB__64 BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 DA[18]
+  DB[18] DB[19] DA[19] DA[20] DB[20] DB[21] DA[21] DA[22] DB[22] DB[23]
+  DA[23] DA[24] DB[24] DB[25] DA[25] DA[26] DB[26] DB[27] DA[27] DA[28]
+  DB[28] DB[29] DA[29] DA[30] DB[30] DB[31] DA[31] DA[32] DB[32] DB[33]
+  DA[33] DA[34] DB[34] DB[35] DA[35] GTPA_1 GTPA_1 GTPA_1 GTPB_1 GTPB_1
+  GTPB_1 VSS VSS QA[18] QB[18] QB[19] QA[19] QA[20] QB[20] QB[21] QA[21]
+  QA[22] QB[22] QB[23] QA[23] QA[24] QB[24] QB[25] QA[25] QA[26] QB[26]
+  QB[27] QA[27] QA[28] QB[28] QB[29] QA[29] QA[30] QB[30] QB[31] QA[31]
+  QA[32] QB[32] QB[33] QA[33] QA[34] QB[34] QB[35] QA[35] VSS VSS STUBDRA_0
+  STUBDRA__0 VSS VSS STUBDRB_0 STUBDRB__0 VSS VSS STUBDWA_0 STUBDWA__0 VSS
+  VSS STUBDWB_0 STUBDWB__0 STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0
+  YPB0_1 VSS VSS VSS VSS VSS VSS VSS VDD RA2SH128x36WING_18_RIGHT
XI11_5 BLA BLA_ BLA_0 BLA_1 BLA_2 BLA_3 BLA_4 BLA_5 BLA_6 BLA_7 BLA_8 BLA_9
+  BLA_10 BLA_11 BLA_12 BLA_13 BLA_14 BLA_15 BLA_16 BLA_17 BLA_18 BLA_19
+  BLA_20 BLA_21 BLA_22 BLA_23 BLA_24 BLA_25 BLA_26 BLA_27 BLA_28 BLA_29
+  BLA_30 BLA_31 BLA_32 BLA_33 BLA_34 BLA_35 BLA_36 BLA_37 BLA_38 BLA_39
+  BLA_40 BLA_41 BLA_42 BLA_43 BLA_44 BLA_45 BLA_46 BLA_47 BLA_48 BLA_49
+  BLA_50 BLA_51 BLA_52 BLA_53 BLA_54 BLA_55 BLA_56 BLA_57 BLA_58 BLA_59
+  BLA_60 BLA_61 BLA_62 BLA_63 BLA_64 BLA_65 BLA_66 BLA_67 BLA_68 BLA_69
+  BLA_70 BLA__0 BLA__1 BLA__2 BLA__3 BLA__4 BLA__5 BLA__6 BLA__7 BLA__8
+  BLA__9 BLA__10 BLA__11 BLA__12 BLA__13 BLA__14 BLA__15 BLA__16 BLA__17
+  BLA__18 BLA__19 BLA__20 BLA__21 BLA__22 BLA__23 BLA__24 BLA__25 BLA__26
+  BLA__27 BLA__28 BLA__29 BLA__30 BLA__31 BLA__32 BLA__33 BLA__34 BLA__35
+  BLA__36 BLA__37 BLA__38 BLA__39 BLA__40 BLA__41 BLA__42 BLA__43 BLA__44
+  BLA__45 BLA__46 BLA__47 BLA__48 BLA__49 BLA__50 BLA__51 BLA__52 BLA__53
+  BLA__54 BLA__55 BLA__56 BLA__57 BLA__58 BLA__59 BLA__60 BLA__61 BLA__62
+  BLA__63 BLA__64 BLA__65 BLA__66 BLA__67 BLA__68 BLA__69 BLA__70 BLB BLB_
+  BLB_0 BLB_1 BLB_2 BLB_3 BLB_4 BLB_5 BLB_6 BLB_7 BLB_8 BLB_9 BLB_10 BLB_11
+  BLB_12 BLB_13 BLB_14 BLB_15 BLB_16 BLB_17 BLB_18 BLB_19 BLB_20 BLB_21
+  BLB_22 BLB_23 BLB_24 BLB_25 BLB_26 BLB_27 BLB_28 BLB_29 BLB_30 BLB_31
+  BLB_32 BLB_33 BLB_34 BLB_35 BLB_36 BLB_37 BLB_38 BLB_39 BLB_40 BLB_41
+  BLB_42 BLB_43 BLB_44 BLB_45 BLB_46 BLB_47 BLB_48 BLB_49 BLB_50 BLB_51
+  BLB_52 BLB_53 BLB_54 BLB_55 BLB_56 BLB_57 BLB_58 BLB_59 BLB_60 BLB_61
+  BLB_62 BLB_63 BLB_64 BLB_65 BLB_66 BLB_67 BLB_68 BLB_69 BLB_70 BLB__0
+  BLB__1 BLB__2 BLB__3 BLB__4 BLB__5 BLB__6 BLB__7 BLB__8 BLB__9 BLB__10
+  BLB__11 BLB__12 BLB__13 BLB__14 BLB__15 BLB__16 BLB__17 BLB__18 BLB__19
+  BLB__20 BLB__21 BLB__22 BLB__23 BLB__24 BLB__25 BLB__26 BLB__27 BLB__28
+  BLB__29 BLB__30 BLB__31 BLB__32 BLB__33 BLB__34 BLB__35 BLB__36 BLB__37
+  BLB__38 BLB__39 BLB__40 BLB__41 BLB__42 BLB__43 BLB__44 BLB__45 BLB__46
+  BLB__47 BLB__48 BLB__49 BLB__50 BLB__51 BLB__52 BLB__53 BLB__54 BLB__55
+  BLB__56 BLB__57 BLB__58 BLB__59 BLB__60 BLB__61 BLB__62 BLB__63 BLB__64
+  BLB__65 BLB__66 BLB__67 BLB__68 BLB__69 BLB__70 VSS MWLD VSS MWLBD VSS VDD
+  RA2SH128x36MODEL_ROW_RIGHT
XI12_0 A0A A0A_ A0B A0B_ GTPA_1 GTPA_1 GTPA_1 GTPB_1 GTPB_1 GTPB_1 VSS VSS
+  STUBWEA STUBWEB WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8
+  WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19
+  WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29
+  WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9
+  WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19
+  WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29
+  WLB_30 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS
+  VSS VSS VSS VDD RA2SH128x36CAP
XI1_0 A0A A0A_ A0B A0B_ BLA_952 BLA__946 BLA_0_938 BLA_1_936 BLA_2_922
+  BLA_3_920 BLA_4_906 BLA_5_904 BLA_6_890 BLA_7_888 BLA_8_874 BLA_9_872
+  BLA_10_858 BLA_11_856 BLA_12_842 BLA_13_840 BLA_14_826 BLA_15_824
+  BLA_16_810 BLA_17_808 BLA_18_794 BLA_19_792 BLA_20_778 BLA_21_776
+  BLA_22_762 BLA_23_760 BLA_24_746 BLA_25_744 BLA_26_730 BLA_27_728
+  BLA_28_714 BLA_29_712 BLA_30_698 BLA_31_696 BLA_32_682 BLA_33_680
+  BLA_34_666 BLA_35_664 BLA_36_650 BLA_37_648 BLA_38_634 BLA_39_632
+  BLA_40_618 BLA_41_616 BLA_42_602 BLA_43_600 BLA_44_586 BLA_45_584
+  BLA_46_570 BLA_47_568 BLA_48_554 BLA_49_552 BLA_50_538 BLA_51_536
+  BLA_52_522 BLA_53_520 BLA_54_506 BLA_55_504 BLA_56_490 BLA_57_488
+  BLA_58_474 BLA_59_472 BLA_60_458 BLA_61_456 BLA_62_442 BLA_63_440
+  BLA_64_426 BLA_65_424 BLA_66_410 BLA_67_408 BLA_68_394 BLA_69_392
+  BLA_70_378 BLA__0_944 BLA__1_930 BLA__2_928 BLA__3_914 BLA__4_912
+  BLA__5_898 BLA__6_896 BLA__7_882 BLA__8_880 BLA__9_866 BLA__10_864
+  BLA__11_850 BLA__12_848 BLA__13_834 BLA__14_832 BLA__15_818 BLA__16_816
+  BLA__17_802 BLA__18_800 BLA__19_786 BLA__20_784 BLA__21_770 BLA__22_768
+  BLA__23_754 BLA__24_752 BLA__25_738 BLA__26_736 BLA__27_722 BLA__28_720
+  BLA__29_706 BLA__30_704 BLA__31_690 BLA__32_688 BLA__33_674 BLA__34_672
+  BLA__35_658 BLA__36_656 BLA__37_642 BLA__38_640 BLA__39_626 BLA__40_624
+  BLA__41_610 BLA__42_608 BLA__43_594 BLA__44_592 BLA__45_578 BLA__46_576
+  BLA__47_562 BLA__48_560 BLA__49_546 BLA__50_544 BLA__51_530 BLA__52_528
+  BLA__53_514 BLA__54_512 BLA__55_498 BLA__56_496 BLA__57_482 BLA__58_480
+  BLA__59_466 BLA__60_464 BLA__61_450 BLA__62_448 BLA__63_434 BLA__64_432
+  BLA__65_418 BLA__66_416 BLA__67_402 BLA__68_400 BLA__69_386 BLA__70_384
+  BLB_950 BLB__948 BLB_0_940 BLB_1_934 BLB_2_924 BLB_3_918 BLB_4_908
+  BLB_5_902 BLB_6_892 BLB_7_886 BLB_8_876 BLB_9_870 BLB_10_860 BLB_11_854
+  BLB_12_844 BLB_13_838 BLB_14_828 BLB_15_822 BLB_16_812 BLB_17_806
+  BLB_18_796 BLB_19_790 BLB_20_780 BLB_21_774 BLB_22_764 BLB_23_758
+  BLB_24_748 BLB_25_742 BLB_26_732 BLB_27_726 BLB_28_716 BLB_29_710
+  BLB_30_700 BLB_31_694 BLB_32_684 BLB_33_678 BLB_34_668 BLB_35_662
+  BLB_36_652 BLB_37_646 BLB_38_636 BLB_39_630 BLB_40_620 BLB_41_614
+  BLB_42_604 BLB_43_598 BLB_44_588 BLB_45_582 BLB_46_572 BLB_47_566
+  BLB_48_556 BLB_49_550 BLB_50_540 BLB_51_534 BLB_52_524 BLB_53_518
+  BLB_54_508 BLB_55_502 BLB_56_492 BLB_57_486 BLB_58_476 BLB_59_470
+  BLB_60_460 BLB_61_454 BLB_62_444 BLB_63_438 BLB_64_428 BLB_65_422
+  BLB_66_412 BLB_67_406 BLB_68_396 BLB_69_390 BLB_70_380 BLB__0_942
+  BLB__1_932 BLB__2_926 BLB__3_916 BLB__4_910 BLB__5_900 BLB__6_894
+  BLB__7_884 BLB__8_878 BLB__9_868 BLB__10_862 BLB__11_852 BLB__12_846
+  BLB__13_836 BLB__14_830 BLB__15_820 BLB__16_814 BLB__17_804 BLB__18_798
+  BLB__19_788 BLB__20_782 BLB__21_772 BLB__22_766 BLB__23_756 BLB__24_750
+  BLB__25_740 BLB__26_734 BLB__27_724 BLB__28_718 BLB__29_708 BLB__30_702
+  BLB__31_692 BLB__32_686 BLB__33_676 BLB__34_670 BLB__35_660 BLB__36_654
+  BLB__37_644 BLB__38_638 BLB__39_628 BLB__40_622 BLB__41_612 BLB__42_606
+  BLB__43_596 BLB__44_590 BLB__45_580 BLB__46_574 BLB__47_564 BLB__48_558
+  BLB__49_548 BLB__50_542 BLB__51_532 BLB__52_526 BLB__53_516 BLB__54_510
+  BLB__55_500 BLB__56_494 BLB__57_484 BLB__58_478 BLB__59_468 BLB__60_462
+  BLB__61_452 BLB__62_446 BLB__63_436 BLB__64_430 BLB__65_420 BLB__66_414
+  BLB__67_404 BLB__68_398 BLB__69_388 BLB__70_382 DA[17] DB[17] DB[16] DA[16]
+  DA[15] DB[15] DB[14] DA[14] DA[13] DB[13] DB[12] DA[12] DA[11] DB[11]
+  DB[10] DA[10] DA[9] DB[9] DB[8] DA[8] DA[7] DB[7] DB[6] DA[6] DA[5] DB[5]
+  DB[4] DA[4] DA[3] DB[3] DB[2] DA[2] DA[1] DB[1] DB[0] DA[0] GTPA_1 GTPA_1
+  GTPA_1 GTPB_1 GTPB_1 GTPB_1 VSS VSS QA[17] QB[17] QB[16] QA[16] QA[15]
+  QB[15] QB[14] QA[14] QA[13] QB[13] QB[12] QA[12] QA[11] QB[11] QB[10]
+  QA[10] QA[9] QB[9] QB[8] QA[8] QA[7] QB[7] QB[6] QA[6] QA[5] QB[5] QB[4]
+  QA[4] QA[3] QB[3] QB[2] QA[2] QA[1] QB[1] QB[0] QA[0] VSS VSS STUBDRA_0_956
+  STUBDRA__0_954 VSS VSS STUBDRB_0_960 STUBDRB__0_958 VSS VSS STUBDWA_0_962
+  STUBDWA__0_964 VSS VSS STUBDWB_0_966 STUBDWB__0_968 STUBWEA STUBWEB WLA
+  WLA_0 WLA_1 WLA_2 WLA_3 WLA_4 WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11
+  WLA_12 WLA_13 WLA_14 WLA_15 WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21
+  WLA_22 WLA_23 WLA_24 WLA_25 WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0
+  WLB_1 WLB_2 WLB_3 WLB_4 WLB_5 WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12
+  WLB_13 WLB_14 WLB_15 WLB_16 WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22
+  WLB_23 WLB_24 WLB_25 WLB_26 WLB_27 WLB_28 WLB_29 WLB_30 YPA0_0 YPA0_1 VSS
+  VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS VSS VSS VSS VDD
+  RA2SH128x36WING_18_LEFT
XI1_5 BLA_952 BLA__946 BLA_0_938 BLA_1_936 BLA_2_922 BLA_3_920 BLA_4_906
+  BLA_5_904 BLA_6_890 BLA_7_888 BLA_8_874 BLA_9_872 BLA_10_858 BLA_11_856
+  BLA_12_842 BLA_13_840 BLA_14_826 BLA_15_824 BLA_16_810 BLA_17_808
+  BLA_18_794 BLA_19_792 BLA_20_778 BLA_21_776 BLA_22_762 BLA_23_760
+  BLA_24_746 BLA_25_744 BLA_26_730 BLA_27_728 BLA_28_714 BLA_29_712
+  BLA_30_698 BLA_31_696 BLA_32_682 BLA_33_680 BLA_34_666 BLA_35_664
+  BLA_36_650 BLA_37_648 BLA_38_634 BLA_39_632 BLA_40_618 BLA_41_616
+  BLA_42_602 BLA_43_600 BLA_44_586 BLA_45_584 BLA_46_570 BLA_47_568
+  BLA_48_554 BLA_49_552 BLA_50_538 BLA_51_536 BLA_52_522 BLA_53_520
+  BLA_54_506 BLA_55_504 BLA_56_490 BLA_57_488 BLA_58_474 BLA_59_472
+  BLA_60_458 BLA_61_456 BLA_62_442 BLA_63_440 BLA_64_426 BLA_65_424
+  BLA_66_410 BLA_67_408 BLA_68_394 BLA_69_392 BLA_70_378 BLA__0_944
+  BLA__1_930 BLA__2_928 BLA__3_914 BLA__4_912 BLA__5_898 BLA__6_896
+  BLA__7_882 BLA__8_880 BLA__9_866 BLA__10_864 BLA__11_850 BLA__12_848
+  BLA__13_834 BLA__14_832 BLA__15_818 BLA__16_816 BLA__17_802 BLA__18_800
+  BLA__19_786 BLA__20_784 BLA__21_770 BLA__22_768 BLA__23_754 BLA__24_752
+  BLA__25_738 BLA__26_736 BLA__27_722 BLA__28_720 BLA__29_706 BLA__30_704
+  BLA__31_690 BLA__32_688 BLA__33_674 BLA__34_672 BLA__35_658 BLA__36_656
+  BLA__37_642 BLA__38_640 BLA__39_626 BLA__40_624 BLA__41_610 BLA__42_608
+  BLA__43_594 BLA__44_592 BLA__45_578 BLA__46_576 BLA__47_562 BLA__48_560
+  BLA__49_546 BLA__50_544 BLA__51_530 BLA__52_528 BLA__53_514 BLA__54_512
+  BLA__55_498 BLA__56_496 BLA__57_482 BLA__58_480 BLA__59_466 BLA__60_464
+  BLA__61_450 BLA__62_448 BLA__63_434 BLA__64_432 BLA__65_418 BLA__66_416
+  BLA__67_402 BLA__68_400 BLA__69_386 BLA__70_384 BLB_950 BLB__948 BLB_0_940
+  BLB_1_934 BLB_2_924 BLB_3_918 BLB_4_908 BLB_5_902 BLB_6_892 BLB_7_886
+  BLB_8_876 BLB_9_870 BLB_10_860 BLB_11_854 BLB_12_844 BLB_13_838 BLB_14_828
+  BLB_15_822 BLB_16_812 BLB_17_806 BLB_18_796 BLB_19_790 BLB_20_780
+  BLB_21_774 BLB_22_764 BLB_23_758 BLB_24_748 BLB_25_742 BLB_26_732
+  BLB_27_726 BLB_28_716 BLB_29_710 BLB_30_700 BLB_31_694 BLB_32_684
+  BLB_33_678 BLB_34_668 BLB_35_662 BLB_36_652 BLB_37_646 BLB_38_636
+  BLB_39_630 BLB_40_620 BLB_41_614 BLB_42_604 BLB_43_598 BLB_44_588
+  BLB_45_582 BLB_46_572 BLB_47_566 BLB_48_556 BLB_49_550 BLB_50_540
+  BLB_51_534 BLB_52_524 BLB_53_518 BLB_54_508 BLB_55_502 BLB_56_492
+  BLB_57_486 BLB_58_476 BLB_59_470 BLB_60_460 BLB_61_454 BLB_62_444
+  BLB_63_438 BLB_64_428 BLB_65_422 BLB_66_412 BLB_67_406 BLB_68_396
+  BLB_69_390 BLB_70_380 BLB__0_942 BLB__1_932 BLB__2_926 BLB__3_916
+  BLB__4_910 BLB__5_900 BLB__6_894 BLB__7_884 BLB__8_878 BLB__9_868
+  BLB__10_862 BLB__11_852 BLB__12_846 BLB__13_836 BLB__14_830 BLB__15_820
+  BLB__16_814 BLB__17_804 BLB__18_798 BLB__19_788 BLB__20_782 BLB__21_772
+  BLB__22_766 BLB__23_756 BLB__24_750 BLB__25_740 BLB__26_734 BLB__27_724
+  BLB__28_718 BLB__29_708 BLB__30_702 BLB__31_692 BLB__32_686 BLB__33_676
+  BLB__34_670 BLB__35_660 BLB__36_654 BLB__37_644 BLB__38_638 BLB__39_628
+  BLB__40_622 BLB__41_612 BLB__42_606 BLB__43_596 BLB__44_590 BLB__45_580
+  BLB__46_574 BLB__47_564 BLB__48_558 BLB__49_548 BLB__50_542 BLB__51_532
+  BLB__52_526 BLB__53_516 BLB__54_510 BLB__55_500 BLB__56_494 BLB__57_484
+  BLB__58_478 BLB__59_468 BLB__60_462 BLB__61_452 BLB__62_446 BLB__63_436
+  BLB__64_430 BLB__65_420 BLB__66_414 BLB__67_404 BLB__68_398 BLB__69_388
+  BLB__70_382 VSS MWLD VSS MWLBD VSS VDD RA2SH128x36MODEL_ROW_LEFT
XI2_0 CENB CLKB GSRCN_974 GTPA_1 GTPB_1 GTPN_972 MBL_970 RST VSS VSS STUBWEA
+  STUBWEB WENB VSS VDD RA2SH128x36HBFX_B
XI2_2 A0A A0A_ A0B A0B_ CLKB GSRCN_974 GTPA_1 GTPB_1 GTPN_972 MBL_970 VDD VDD
+  MBLB_ YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS VSS
+  VSS VSS VSS VDD RA2SH128x36FLCIOX_B
XI2_4 MBLB_ MBL_970 MWLD MWLD MWLBD MWLBD WLA WLA_0 WLA_1 WLA_2 WLA_3 WLA_4
+  WLA_5 WLA_6 WLA_7 WLA_8 WLA_9 WLA_10 WLA_11 WLA_12 WLA_13 WLA_14 WLA_15
+  WLA_16 WLA_17 WLA_18 WLA_19 WLA_20 WLA_21 WLA_22 WLA_23 WLA_24 WLA_25
+  WLA_26 WLA_27 WLA_28 WLA_29 WLA_30 WLB WLB_0 WLB_1 WLB_2 WLB_3 WLB_4 WLB_5
+  WLB_6 WLB_7 WLB_8 WLB_9 WLB_10 WLB_11 WLB_12 WLB_13 WLB_14 WLB_15 WLB_16
+  WLB_17 WLB_18 WLB_19 WLB_20 WLB_21 WLB_22 WLB_23 WLB_24 WLB_25 WLB_26
+  WLB_27 WLB_28 WLB_29 WLB_30 VSS VDD RA2SH128x36MODEL_COL_B
XI3_2 A0A A0A_ A0B A0B_ AGTP CLKB GSRCN_974 GTPB_1 GTPN_972 GTPB_1 GTPB_1
+  GTPB_1 RST YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VSS VDD RA2SH128x36CLK_DRVS
XI3_3 VDD GTPA_1 GTPB_1 MBL_970 MBLB_ MWLD MWLBD MWLBD WLA WLA_2 WLA_3 WLA_6
+  WLA_7 WLA_10 WLA_11 WLA_14 WLA_15 WLA_18 WLA_19 WLA_22 WLA_23 WLA_26 WLA_27
+  WLA_30 WLA_0 WLA_1 WLA_4 WLA_5 WLA_8 WLA_9 WLA_12 WLA_13 WLA_16 WLA_17
+  WLA_20 WLA_21 WLA_24 WLA_25 WLA_28 WLA_29 WLB WLB_2 WLB_3 WLB_6 WLB_7
+  WLB_10 WLB_11 WLB_14 WLB_15 WLB_18 WLB_19 WLB_22 WLB_23 WLB_26 WLB_27
+  WLB_30 WLB_0 WLB_1 WLB_4 WLB_5 WLB_8 WLB_9 WLB_12 WLB_13 WLB_16 WLB_17
+  WLB_20 WLB_21 WLB_24 WLB_25 WLB_28 WLB_29 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA2SH128x36WORD_ROWSB
XI4_1 AB[1] AB[0] AGTP A0A A0A_ A0B A0B_ VSS VSS CLKB GSRCN_974 GTPN_972 VSS
+  VSS RST STUBWEA STUBWEB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD
+  RA2SH128x36Y_DECODEB
XI5_1 AB[5] AB[2] AB[6] AB[3] AB[4] AGTP AGTP A0A A0A_ A0B A0B_ VSS VSS VSS
+  VSS STUBWEA STUBWEB XP0_0 XP2_0 XP1_0 XP2_1 XP0 XP2_2 XP1 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VSS VDD RA2SH128x36X_PRE_DECODEB
XI7_1 AA[5] AA[2] AA[6] AA[3] AA[4] AGTPAT AGTPAT A0A A0A_ A0B A0B_ VSS VSS
+  VSS VSS STUBWEA STUBWEB XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0
+  XP_4 XP_5 XP_6 XP_7 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS
+  VSS VSS VSS VSS VSS VSS VDD RA2SH128x36X_PRE_DECODEA
XI7_3 VDD GTPA_1 GTPB_1 MBL MBLA_ MWLD MWLBD MWLD WLA WLA_2 WLA_3 WLA_6 WLA_7
+  WLA_10 WLA_11 WLA_14 WLA_15 WLA_18 WLA_19 WLA_22 WLA_23 WLA_26 WLA_27
+  WLA_30 WLA_0 WLA_1 WLA_4 WLA_5 WLA_8 WLA_9 WLA_12 WLA_13 WLA_16 WLA_17
+  WLA_20 WLA_21 WLA_24 WLA_25 WLA_28 WLA_29 WLB WLB_2 WLB_3 WLB_6 WLB_7
+  WLB_10 WLB_11 WLB_14 WLB_15 WLB_18 WLB_19 WLB_22 WLB_23 WLB_26 WLB_27
+  WLB_30 WLB_0 WLB_1 WLB_4 WLB_5 WLB_8 WLB_9 WLB_12 WLB_13 WLB_16 WLB_17
+  WLB_20 WLB_21 WLB_24 WLB_25 WLB_28 WLB_29 XP_2 XP_0 XP_3 XP_1 XP_0_0 XP_1_0
+  XP_2_0 XP_3_0 XP_4 XP_5 XP_6 XP_7 VSS VDD RA2SH128x36WORD_ROWSA
XI8_1 AA[1] AA[0] AGTPAT A0A A0A_ A0B A0B_ VSS VSS CLKA GSRCN GTPN VSS VSS
+  RST_1004 STUBWEA STUBWEB YPA0_0 YPA0_1 YPB0_0 YPB0_1 VSS VDD
+  RA2SH128x36Y_DECODEA
XI9_0 CENA CLKA GSRCN GTPA_1 GTPB_1 GTPN MBL RST_1004 VSS VSS STUBWEA STUBWEB
+  WENA VSS VDD RA2SH128x36HBFX_A
XI9_2 A0A A0A_ A0B A0B_ AGTPAT CLKA GSRCN GTPA_1 GTPN GTPA_1 GTPA_1 GTPA_1
+  RST_1004 YPA0_0 YPA0_1 VSS VSS VSS VSS VSS VSS YPB0_0 YPB0_1 VSS VSS VSS
+  VSS VSS VSS VSS VDD RA2SH128x36CLK_DRVS
.ENDS RA2SH128x36
