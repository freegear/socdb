// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannelmi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel Master Interface Block
//                       
//  ----------------------------------------------------------------
//START
//notice :: don't modify this code
// 531 :: Ver 1.2 inserting data channel mask signal  ( WENn )
// Syn 309 :: modify ELAB-292(senstivelist)

`timescale 1 ns/ 10ps
module  SMC_WriteChannelmi(
    
    //Global signal
    ACLK    ,
    ARESETn ,

    //For slave 
    //Write address channel
    AWIDmi2s    ,
    AWADDRmi2s  ,
    AWLENmi2s   ,
    AWSIZEmi2s  ,
    AWBURSTmi2s ,
//ENABLE_LOCK
    AWLOCKmi2s  ,
//ENABLE_CACHE
    AWCACHEmi2s ,
//ENABLE_PROT
    AWPROTmi2s  ,

    AWVALIDmi2s ,
    AWREADYs2mi ,

    //Write data channel
    WIDmi2s     ,
    WDATAmi2s   ,
//ENABLE_WSTRB
    WSTRBmi2s   ,
    WLASTmi2s   ,
    WVALIDmi2s  ,
    WREADYs2mi  ,

    //Write response channel
    BIDs2mi     ,
    BRESPs2mi   ,
    BVALIDs2mi  ,
    BREADYmi2s  ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////


    //Master0
    //Write address channel
    //____________________________________
    AWIDsi02mi    ,
    AWADDRsi02mi  ,
    AWLENsi02mi   ,
    AWSIZEsi02mi  ,
    AWBURSTsi02mi ,
    AWLOCKsi02mi  ,
    AWCACHEsi02mi ,
    AWPROTsi02mi  ,
    //____________________________________
    //Write data channel
    WIDsi02mi   ,     
    WDATAsi02mi ,   
    WSTRBsi02mi , 

    //Master1
    //Write address channel
    //____________________________________
    AWIDsi12mi    ,
    AWADDRsi12mi  ,
    AWLENsi12mi   ,
    AWSIZEsi12mi  ,
    AWBURSTsi12mi ,
    AWLOCKsi12mi  ,
    AWCACHEsi12mi ,
    AWPROTsi12mi  ,
    //____________________________________
    //Write data channel
    WIDsi12mi   ,     
    WDATAsi12mi ,   
    WSTRBsi12mi , 

    //Master2
    //Write address channel
    //____________________________________
    AWIDsi22mi    ,
    AWADDRsi22mi  ,
    AWLENsi22mi   ,
    AWSIZEsi22mi  ,
    AWBURSTsi22mi ,
    AWLOCKsi22mi  ,
    AWCACHEsi22mi ,
    AWPROTsi22mi  ,
    //____________________________________
    //Write data channel
    WIDsi22mi   ,     
    WDATAsi22mi ,   
    WSTRBsi22mi , 

////////////////////////////
    //____________________________________
    //Write response channel

    BIDmi2si0     ,
    BRESPmi2si0   ,

    BIDmi2si1     ,
    BRESPmi2si1   ,

    BIDmi2si2     ,
    BRESPmi2si2   ,

////////////////////////////
    
    BVALIDmi2si  ,
    BREADYsi2mi,
    //____________________________________
    

//LOCKSig_START
    //Lock control
    //____________________________________
    Lock2Wrmi,
    UnLock2Wrmi,

    Lock2Rdmi,
    UnLock2Rdmi,
    ARVALID,

    LockPort,
    ReadIntEmptyWrmi2Rdmi,
    DataCntEmptyRdmi2Wrmi,
    CtlDataWrite2Lock,
    //____________________________________
//LOCKSig_END

    //Master 0/1/2/3
    AWVALIDsi2mi  ,
    AWREADYmi2si  ,

    //Master 0/1/2/3
    WLASTsi2mi   ,
    WVALIDsi2mi  ,

    //output 1port
    WREADYmi2si  
    );
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 3;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 2;
parameter Rd_REQDEPTH_WID= 2;
parameter WrPermit_SLAVECNTWID= 2;
parameter RdPermit_SLAVECNTWID= 2;
parameter ARSIZE_WID= 3;

  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   ACLK;
    input   ARESETn;

    // For slave 
    // 2s (Slave)
    output   [SLAVEID_WID-1:0]  AWIDmi2s;    
    output   [ADDR_WID-1:0]     AWADDRmi2s;
    output   [AWLEN_WID-1:0]    AWLENmi2s;
    output   [AWSIZE_WID-1:0]   AWSIZEmi2s;  
    output   [AWBURST_WID-1:0]  AWBURSTmi2s; 
//ENABLE_LOCK
    output   [AWLOCK_WID-1:0]   AWLOCKmi2s;  
//ENABLE_CACHE
    output   [AWCACHE_WID-1:0]  AWCACHEmi2s; 
//ENABLE_PROT
    output   [AWPROT_WID-1:0]   AWPROTmi2s;  

    output   AWVALIDmi2s; 
    input    AWREADYs2mi; 
    

    //Write data channel
    output   [SLAVEID_WID-1:0]       WIDmi2s;     
    output   [BUS_WID-1:0]      WDATAmi2s;   
//ENABLE_WSTRB
    output   [WSTRB_WID-1:0]    WSTRBmi2s;   
    output   WLASTmi2s;   
    output   WVALIDmi2s;  
    input    WREADYs2mi; 

    //Write response channel
    input   [SLAVEID_WID-1:0]      BIDs2mi;     
    input   [BRESP_WID-1:0]   BRESPs2mi;   
    input   BVALIDs2mi;  
    output  BREADYmi2s;  

    
    //Master0
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi02mi;    
    input   [ADDR_WID-1:0]     AWADDRsi02mi;
    input   [AWLEN_WID-1:0]    AWLENsi02mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi02mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi02mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi02mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi02mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi02mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi02mi;     
    input   [BUS_WID-1:0]  WDATAsi02mi;   
    input   [WSTRB_WID-1:0]WSTRBsi02mi;   
    //__________________________________________________

    
    //Master1
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi12mi;    
    input   [ADDR_WID-1:0]     AWADDRsi12mi;
    input   [AWLEN_WID-1:0]    AWLENsi12mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi12mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi12mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi12mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi12mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi12mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi12mi;     
    input   [BUS_WID-1:0]  WDATAsi12mi;   
    input   [WSTRB_WID-1:0]WSTRBsi12mi;   
    //__________________________________________________

    
    //Master2
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi22mi;    
    input   [ADDR_WID-1:0]     AWADDRsi22mi;
    input   [AWLEN_WID-1:0]    AWLENsi22mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi22mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi22mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi22mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi22mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi22mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi22mi;     
    input   [BUS_WID-1:0]  WDATAsi22mi;   
    input   [WSTRB_WID-1:0]WSTRBsi22mi;   
    //__________________________________________________

////////////////////////////

    input   [MASTER_NUM-1:0]AWVALIDsi2mi;
    output  [MASTER_NUM-1:0]AWREADYmi2si;

    input   [MASTER_NUM-1:0]WLASTsi2mi;   
    input   [MASTER_NUM-1:0]WVALIDsi2mi;  
    output  [MASTER_NUM-1:0]WREADYmi2si;  

    //Write response channel
    output   [MASTERID_WID-1:0]    BIDmi2si0;     
    output   [BRESP_WID-1:0] BRESPmi2si0;   

    output   [MASTERID_WID-1:0]    BIDmi2si1;     
    output   [BRESP_WID-1:0] BRESPmi2si1;   

    output   [MASTERID_WID-1:0]    BIDmi2si2;     
    output   [BRESP_WID-1:0] BRESPmi2si2;   

////////////////////////////

    output   [MASTER_NUM-1:0]BVALIDmi2si;  
    input    [MASTER_NUM-1:0]BREADYsi2mi;    
    //__________________________________________________


//LOCKSig_START
    //Lock signal
    input    Lock2Wrmi;
    input    UnLock2Wrmi;
    input    ARVALID;
    input    DataCntEmptyRdmi2Wrmi;
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER_WID-1:0]LockPort;
    input    [SELMASTER_WID:0]LockPort;

    output   [SELMASTER_WID-1:0]CtlDataWrite2Lock;
    output   ReadIntEmptyWrmi2Rdmi;

    output   Lock2Rdmi;
    output   UnLock2Rdmi;
//LOCKSig_END


    wire     [SELMASTER_WID-1:0]   CtlDataWrite2Lock;
    wire     ReqFull;
    wire     ReqEmpty;
    wire     EnAWMUXn      ;
    wire     EnAWREADYMUXn ;
    wire     ReadIntEmptyWrmi2Rdmi =  ReqEmpty;
    wire     [5:0]  LockArbiter   ; 



    //Arbiter
    //_______________________________________________________________
    reg    [SELMASTER_WID-1:0] CtlData2WrchMux; 
    wire   [SELMASTER_WID-1:0] CtlData2DatachMux;
    assign CtlDataWrite2Lock = CtlData2WrchMux; 

//Response Arbiter
//Arbiter was Generated 
//LockAccess support Aribiter TYPE01
reg   EnArbiter;

always @(
         AWVALIDsi2mi or
         CtlData2WrchMux
        )
begin
    case(CtlData2WrchMux)
        //synopsys parallel_case full_case
        2'd0:    EnArbiter <= AWVALIDsi2mi[0];
        2'd1:    EnArbiter <= AWVALIDsi2mi[1];
        2'd2:    EnArbiter <= AWVALIDsi2mi[2];
        default: EnArbiter <= 1'b0;
    endcase
end

always  @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        CtlData2WrchMux <= 0;
    end
    else if((LockArbiter[1] | LockArbiter[5]) & !LockPort[SELMASTER_WID]) // STATE --> FUll_MASK
    begin                                    // STATE --> VMASK
        CtlData2WrchMux <= LockPort[SELMASTER_WID-1:0];
    end
    else if(!EnArbiter && !ReqFull && LockArbiter[0])
    begin
          if(AWVALIDsi2mi[0]) CtlData2WrchMux <= 2'd0;
          else if(AWVALIDsi2mi[1]) CtlData2WrchMux <= 2'd1;
          else if(AWVALIDsi2mi[2]) CtlData2WrchMux <= 2'd2;
    end
end

    
    //_______________________________________________________________
    // Arbiter Mux to Lock control
    reg     AWVALID2s;
    reg     [AWLOCK_WID-1:0]   AWLOCK2s;

    // Syn 309 :: modify ELAB-292(senstivelist)
    always @(
             AWVALIDsi2mi or 
             AWLOCKsi02mi or
             AWLOCKsi12mi or
             AWLOCKsi22mi or
             CtlData2WrchMux 
            )   
    begin
        case(CtlData2WrchMux)
            // synopsys full_case parallel_case 
            2'd0: 
            begin
                AWVALID2s <= AWVALIDsi2mi[0]; 
                AWLOCK2s  <= AWLOCKsi02mi;
            end
            2'd1: 
            begin
                AWVALID2s <= AWVALIDsi2mi[1]; 
                AWLOCK2s  <= AWLOCKsi12mi;
            end
            2'd2: 
            begin
                AWVALID2s <= AWVALIDsi2mi[2]; 
                AWLOCK2s  <= AWLOCKsi22mi;
            end
        endcase
    end
    //________________________________________________________


    // ADDRESS Channel Mux Demux
    //_______________________________________________________________
    reg    [ADDR_WID-1:0]     AWADDRmi2s;
    reg    [AWLEN_WID-1:0]    AWLENmi2s;
    reg    [AWSIZE_WID-1:0]   AWSIZEmi2s;  
    reg    [AWBURST_WID-1:0]  AWBURSTmi2s; 
    reg    [AWLOCK_WID-1:0]   AWLOCKmi2s;  
    reg    [AWCACHE_WID-1:0]  AWCACHEmi2s; 
    reg    [AWPROT_WID-1:0]   AWPROTmi2s;  

    reg    [MASTER_NUM-1:0]   AWREADYmi2si;
    reg    AWVALIDmi2s; 
    reg    [MASTERID_WID-1:0] regAWIDmi2s;
    wire   [SELMASTER_WID-1:0]wireMASTERNUM;

    assign  AWIDmi2s = {regAWIDmi2s, wireMASTERNUM};

    // if ReqFull , the WriteChannelmi don't send READYmi2si
    wire   WireEnAWREADYMUXn = ReqFull |  EnAWREADYMUXn ;

//MUX TYPE 02 was Generated 
always @(CtlData2WrchMux  or 
         AWREADYs2mi   or
         WireEnAWREADYMUXn
        )
begin

   case({WireEnAWREADYMUXn, CtlData2WrchMux })
   //synopsys parallel_case full_case
        3'd0:   
            begin
                 AWREADYmi2si[0] <= AWREADYs2mi ;
                 AWREADYmi2si[1] <= 1'b0;
                 AWREADYmi2si[2] <= 1'b0;
            end
        3'd1:   
            begin
                 AWREADYmi2si[0] <= 1'b0;
                 AWREADYmi2si[1] <= AWREADYs2mi ;
                 AWREADYmi2si[2] <= 1'b0;
            end
        3'd2:   
            begin
                 AWREADYmi2si[0] <= 1'b0;
                 AWREADYmi2si[1] <= 1'b0;
                 AWREADYmi2si[2] <= AWREADYs2mi ;
            end
         default:
            begin
                AWREADYmi2si[0] <= 1'b0;
                AWREADYmi2si[1] <= 1'b0;
                AWREADYmi2si[2] <= 1'b0;
            end
   endcase
end

    // if ReqFull , the WriteChannelmi don't send  AWVALIDmi2s
    wire   WireEnAWMUXn = ReqFull | EnAWMUXn;
    assign wireMASTERNUM = (WireEnAWMUXn == 1'b0) ? 
                            CtlData2WrchMux : {SELMASTER_WID{1'b0}};
    always @(//0
             AWVALIDsi2mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWVALIDmi2s <= AWVALIDsi2mi[0]; 
            3'd1:   AWVALIDmi2s <= AWVALIDsi2mi[1]; 
            3'd2:   AWVALIDmi2s <= AWVALIDsi2mi[2]; 
            default:   
                    AWVALIDmi2s <= 1'b0; 
        endcase
    end

    always @(//1
             AWADDRsi02mi or    
             AWADDRsi12mi or    
             AWADDRsi22mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWADDRmi2s  <= AWADDRsi02mi;
            3'd1:   AWADDRmi2s  <= AWADDRsi12mi;
            3'd2:   AWADDRmi2s  <= AWADDRsi22mi;
            default:
                    AWADDRmi2s  <= 0;
        endcase
    end


    always @(//2
             AWLENsi02mi or    
             AWLENsi12mi or    
             AWLENsi22mi or    

             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWLENmi2s   <= AWLENsi02mi;
            3'd1:   AWLENmi2s   <= AWLENsi12mi;
            3'd2:   AWLENmi2s   <= AWLENsi22mi;
            default:   
                    AWLENmi2s   <= 0;
        endcase
    end

    always @(//3
             AWSIZEsi02mi or    
             AWSIZEsi12mi or    
             AWSIZEsi22mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWSIZEmi2s  <= AWSIZEsi02mi;
            3'd1:   AWSIZEmi2s  <= AWSIZEsi12mi;
            3'd2:   AWSIZEmi2s  <= AWSIZEsi22mi;
            default:
                    AWSIZEmi2s  <= 0;
        endcase
    end

    always @(//4
             AWBURSTsi02mi or    
             AWBURSTsi12mi or    
             AWBURSTsi22mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWBURSTmi2s <= AWBURSTsi02mi;
            3'd1:   AWBURSTmi2s <= AWBURSTsi12mi;
            3'd2:   AWBURSTmi2s <= AWBURSTsi22mi;
            default:
                    AWBURSTmi2s <= 0;
        endcase
    end

    always @(//5
             AWLOCKsi02mi or    
             AWLOCKsi12mi or    
             AWLOCKsi22mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWLOCKmi2s  <= AWLOCKsi02mi;
            3'd1:   AWLOCKmi2s  <= AWLOCKsi12mi;
            3'd2:   AWLOCKmi2s  <= AWLOCKsi22mi;
            default:
                    AWLOCKmi2s  <= 0;
        endcase
    end

    always @(//6
             AWPROTsi02mi or    
             AWPROTsi12mi or    
             AWPROTsi22mi or    

             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWPROTmi2s  <= AWPROTsi02mi;
            3'd1:   AWPROTmi2s  <= AWPROTsi12mi;
            3'd2:   AWPROTmi2s  <= AWPROTsi22mi;
            default:
                    AWPROTmi2s  <= 0;
        endcase
    end

    always @(//7
             AWIDsi02mi or    
             AWIDsi12mi or    
             AWIDsi22mi or    
             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   regAWIDmi2s    <= AWIDsi02mi;
            3'd1:   regAWIDmi2s    <= AWIDsi12mi;
            3'd2:   regAWIDmi2s    <= AWIDsi22mi;
            default:
                    regAWIDmi2s    <= 0;
        endcase
    end

    always @(//8
             AWCACHEsi02mi or    
             AWCACHEsi12mi or    
             AWCACHEsi22mi or    

             WireEnAWMUXn or
             CtlData2WrchMux
            )
    begin
        case({WireEnAWMUXn, CtlData2WrchMux})
            // synopsys parallel_case full_case
            3'd0:   AWCACHEmi2s <= AWCACHEsi02mi;
            3'd1:   AWCACHEmi2s <= AWCACHEsi12mi;
            3'd2:   AWCACHEmi2s <= AWCACHEsi22mi;
            default:
                    AWCACHEmi2s <= 0;
        endcase
    end
    //_______________________________________________________________
        


    // Write Data Channel Mux Demux
    //_______________________________________________________________

    //Write data channel
    reg   [SLAVEID_WID-1:0]       WIDmi2s;     
    reg   [BUS_WID-1:0]      WDATAmi2s;   
    reg   [WSTRB_WID-1:0]    WSTRBmi2s;   
    reg   WLASTmi2s;   
    reg   WVALIDmi2s;  

    reg   [MASTER_NUM-1:0]   WREADYmi2si;

    //Ver 1.7 (NxReqEmpty)
    wire  NxReqEmpty;
    //Ver 1.2 modified (WENn)
    reg   rWENn;
    wire  AVALID_EMPTY = !(AWVALIDmi2s & ReqEmpty);  // Ver 1.8
    wire  WENn = (rWENn | ReqEmpty) & AVALID_EMPTY;  //Ver1.7
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
        begin
            rWENn <= 1'b0;
        end
        else if(WVALIDmi2s & WLASTmi2s & WREADYs2mi & NxReqEmpty)
        begin
            rWENn <= 1'b1;
        end
        else if(WVALIDmi2s & WLASTmi2s & WREADYs2mi & !NxReqEmpty)
        begin
            rWENn <= 1'b0;
        end
        else if( BVALIDs2mi & BREADYmi2s) //Ver 1.7 modified
        begin
            rWENn <= 1'b0;
        end

    end

//MUX TYPE 02 was Generated 
always @(CtlData2DatachMux  or 
         WREADYs2mi   or
         WENn
        )
begin

   case({WENn, CtlData2DatachMux })
   //synopsys parallel_case full_case
        3'd0:   
            begin
                 WREADYmi2si[0] <= WREADYs2mi ;
                 WREADYmi2si[1] <= 1'b0;
                 WREADYmi2si[2] <= 1'b0;
            end
        3'd1:   
            begin
                 WREADYmi2si[0] <= 1'b0;
                 WREADYmi2si[1] <= WREADYs2mi ;
                 WREADYmi2si[2] <= 1'b0;
            end
        3'd2:   
            begin
                 WREADYmi2si[0] <= 1'b0;
                 WREADYmi2si[1] <= 1'b0;
                 WREADYmi2si[2] <= WREADYs2mi ;
            end
         default:
            begin
                WREADYmi2si[0] <= 1'b0;
                WREADYmi2si[1] <= 1'b0;
                WREADYmi2si[2] <= 1'b0;
            end
   endcase
end


    always @(//1
             WIDsi02mi   or
             WIDsi12mi   or
             WIDsi22mi   or
             CtlData2DatachMux or
             WENn // Ver 1.2
            )
    begin
        case({WENn, CtlData2DatachMux})
            //synopsys full_case
            3'd0:   WIDmi2s   <= {WIDsi02mi, CtlData2DatachMux};
            3'd1:   WIDmi2s   <= {WIDsi12mi, CtlData2DatachMux};
            3'd2:   WIDmi2s   <= {WIDsi22mi, CtlData2DatachMux};
            default:
                    WIDmi2s   <= 0;
        endcase
    end

    always @(//2
             WDATAsi02mi or
             WDATAsi12mi or
             WDATAsi22mi or
             CtlData2DatachMux or
             WENn // Ver 1.2
            )
    begin
        case({WENn, CtlData2DatachMux})
            //synopsys full_case
            3'd0:   WDATAmi2s <= WDATAsi02mi;
            3'd1:   WDATAmi2s <= WDATAsi12mi;
            3'd2:   WDATAmi2s <= WDATAsi22mi;
            default:
                    WDATAmi2s <= 0;
        endcase
    end

    always @(//3
             WSTRBsi02mi or
             WSTRBsi12mi or
             WSTRBsi22mi or
             CtlData2DatachMux or
             WENn // Ver 1.2
            )
    begin
        case({WENn, CtlData2DatachMux})
            //synopsys full_case
            3'd0:   WSTRBmi2s <= WSTRBsi02mi;
            3'd1:   WSTRBmi2s <= WSTRBsi12mi;
            3'd2:   WSTRBmi2s <= WSTRBsi22mi;
            default:
                    WSTRBmi2s <= 0;
        endcase
    end    

    always @(//4
             WLASTsi2mi  or
             CtlData2DatachMux or
             WENn // Ver 1.2
            )
    begin
        case({WENn, CtlData2DatachMux})
            //synopsys full_case
            3'd0:   WLASTmi2s <= WLASTsi2mi[0];
            3'd1:   WLASTmi2s <= WLASTsi2mi[1];
            3'd2:   WLASTmi2s <= WLASTsi2mi[2];
            default:
                    WLASTmi2s <= 1'b0;
        endcase
    end        

    always @(//5
             WVALIDsi2mi or
             CtlData2DatachMux or
             WENn // Ver 1.2
            )
    begin
        case({WENn, CtlData2DatachMux})
            //synopsys full_case
            3'd0:   WVALIDmi2s <= WVALIDsi2mi[0];
            3'd1:   WVALIDmi2s <= WVALIDsi2mi[1];
            3'd2:   WVALIDmi2s <= WVALIDsi2mi[2];
            default:
                    WVALIDmi2s <= 0;
        endcase
    end        
    //_______________________________________________________________


    // Write response Channel Mux Demux
    //_______________________________________________________________
    
    reg    BREADYmi2s; 
    reg    [MASTER_NUM-1:0]BVALIDmi2si;  


    always  @( BIDs2mi[(SELMASTER_WID-1):0] or
               BREADYsi2mi 
             )
    begin
        case(BIDs2mi[(SELMASTER_WID-1):0])
            //synopsys full_case
            2'd0:   BREADYmi2s <= BREADYsi2mi[0];
            2'd1:   BREADYmi2s <= BREADYsi2mi[1];
            2'd2:   BREADYmi2s <= BREADYsi2mi[2];
            default:     BREADYmi2s <= 0;
        endcase
    end
                        
//MUX TYPE 01 was Generated 
always @(BIDs2mi[(SELMASTER_WID-1):0]  or 
         BVALIDs2mi  )
begin

   case(BIDs2mi[(SELMASTER_WID-1):0] )
   //synopsys parallel_case full_case
        2'd0:   
            begin
                 BVALIDmi2si[0] <= BVALIDs2mi ;
                 BVALIDmi2si[1] <= 1'b0;
                 BVALIDmi2si[2] <= 1'b0;
            end
        2'd1:   
            begin
                 BVALIDmi2si[0] <= 1'b0;
                 BVALIDmi2si[1] <= BVALIDs2mi ;
                 BVALIDmi2si[2] <= 1'b0;
            end
        2'd2:   
            begin
                 BVALIDmi2si[0] <= 1'b0;
                 BVALIDmi2si[1] <= 1'b0;
                 BVALIDmi2si[2] <= BVALIDs2mi ;
            end
         default:
            begin
                BVALIDmi2si[0] <= 1'b0;
                BVALIDmi2si[1] <= 1'b0;
                BVALIDmi2si[2] <= 1'b0;
            end
   endcase
end

    //_______________________________________________________________
    
    //Request Interleaving buffer
    //_______________________________________________________________

    wire    AWREADY2ReqInter = (EnAWREADYMUXn | ReqFull) ? 1'b0:AWREADYs2mi;
    SMC_ReqInterBuff 
    U0ReqInterBuff(
        .ACLK       (ACLK),
        .ARESETn    (ARESETn),

        .AWVALID    (AWVALIDmi2s),
        .AWREADY    (AWREADY2ReqInter),
        .MASTERNUM  (CtlData2WrchMux),

        .BVALID     (BVALIDs2mi),
        .BREADY     (BREADYmi2s),
        .CtlData    (CtlData2DatachMux),

        .ReqFull    (ReqFull),
        .ReqEmpty   (ReqEmpty),
        //Ver 1.7 added
        .NxReqEmpty (NxReqEmpty) 
    );

    //_______________________________________________________________


    //Locked access control block
    //_______________________________________________________________
    
SMC_LockCtlWrmi
U0LockCtlWrmi(

        .ACLK(ACLK),
        .ARESETn(ARESETn),

        .ReqIntEmpty(ReadIntEmptyWrmi2Rdmi),
        .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi2Wrmi),

        .ALOCK(AWLOCK2s),
        .AVALID(AWVALID2s),
        .OVALID(ARVALID),

        .LockPort(LockPort),

        .Lock_in(Lock2Wrmi),
        .UnLock_in(UnLock2Wrmi),

        .Lock_out(Lock2Rdmi),
        .UnLock_out(UnLock2Rdmi),

        .CtlData(CtlData2WrchMux),
        //WriteChannel mux CtlData2WrchMux
        //ReadChannel  mux CtlData2RdchMux

        .EnAMUXn(EnAWMUXn),
        .EnAREADYMUXn(EnAWREADYMUXn),
        .LockArbiter(LockArbiter)

        );
    //_______________________________________________________________

    
    //MASTER 0
    wire   [MASTERID_WID-1:0]   BIDmi2si0;     
    wire   [BRESP_WID-1:0]      BRESPmi2si0;   
    assign BIDmi2si0 = BIDs2mi[(SLAVEID_WID-1):SELMASTER_WID];   
    assign BRESPmi2si0 = BRESPs2mi;
    
    //MASTER 1
    wire   [MASTERID_WID-1:0]   BIDmi2si1;     
    wire   [BRESP_WID-1:0]      BRESPmi2si1;   
    assign BIDmi2si1 = BIDs2mi[(SLAVEID_WID-1):SELMASTER_WID];   
    assign BRESPmi2si1 = BRESPs2mi;
    
    //MASTER 2
    wire   [MASTERID_WID-1:0]   BIDmi2si2;     
    wire   [BRESP_WID-1:0]      BRESPmi2si2;   
    assign BIDmi2si2 = BIDs2mi[(SLAVEID_WID-1):SELMASTER_WID];   
    assign BRESPmi2si2 = BRESPs2mi;

endmodule
