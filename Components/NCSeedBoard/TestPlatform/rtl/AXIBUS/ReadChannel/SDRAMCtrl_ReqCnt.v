 // =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
 // File Name           : ReqCnt.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Counting the request in Read Master 
//                       interface block
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  SDRAMCtrl_ReqCnt(

    ACLK,
    ARESETn,

    ARVALID,
    ARREADY,

    RVALID,
    RREADY,
    RLAST,

    DataCNTEmpty,
    DataCNTFull
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 0;
parameter RdPermit_SLAVECNTWID= 0;
parameter ARSIZE_WID= 3;
    input   ACLK;
    input   ARESETn;
    input   ARVALID;
    input   ARREADY;
    input   RVALID;
    input   RREADY;
    input   RLAST;

    output  DataCNTEmpty;
    output  DataCNTFull;

    wire    DataCNTEmpty;
    wire    DataCNTFull;

    reg     [Rd_REQDEPTH_WID-1:0] CNT;

    assign DataCNTFull  = (CNT == {Rd_REQDEPTH_WID{1'b1}}) ? 1'b1 : 1'b0; 
    assign DataCNTEmpty = (CNT == 0) ? 1'b1 : 1'b0;

    wire    CntUp = ARVALID & ARREADY;
    wire    CntDn = RVALID & RREADY & RLAST;

    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
        begin
            CNT <= 0;
        end
        else
        begin
            if(CntUp & CntDn)
                CNT <= CNT;
            else if(CntUp)
                CNT <= CNT + 1;
            else if(CntDn)
                CNT <= CNT - 1;
        end
    end
    
endmodule
