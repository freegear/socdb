// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : BUSTOP.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : BUS TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
//version short name

//`define  ASSERT_ON
`timescale 1 ns/ 10ps
module SBUS(

//Write channel signal
    //_______________________________________________________________
    //For Master 0 :: ARM
    //Write address channel
//Disalbe_id_port
    AWADDR_ARM  ,
    AWLEN_ARM   ,
    AWSIZE_ARM  ,
    AWBURST_ARM ,
    AWLOCK_ARM  ,
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALID_ARM ,
    AWREADY_2_ARM ,

    
    //Write data channel
//Disalbe_id_port
    WDATA_ARM   ,
    WSTRB_ARM   ,
    WLAST_ARM   ,
    WVALID_ARM  ,
    WREADY_2_ARM  ,

    //Write response channel
//Disalbe_id_port
    BRESP_2_ARM   ,
    BVALID_2_ARM  ,
    BREADY_ARM  ,
 
 
    //_______________________________________________________________
    //For Master 2 :: DMACtrl
    //Write address channel
    AWID_DMACtrl    ,
    AWADDR_DMACtrl  ,
    AWLEN_DMACtrl   ,
    AWSIZE_DMACtrl  ,
    AWBURST_DMACtrl ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALID_DMACtrl ,
    AWREADY_2_DMACtrl ,

    
    //Write data channel
    WID_DMACtrl     ,
    WDATA_DMACtrl   ,
    WSTRB_DMACtrl   ,
    WLAST_DMACtrl   ,
    WVALID_DMACtrl  ,
    WREADY_2_DMACtrl  ,

    //Write response channel
    BID_2_DMACtrl     ,
    BRESP_2_DMACtrl   ,
    BVALID_2_DMACtrl  ,
    BREADY_DMACtrl  ,
 
    //_______________________________________________________________
    //For Master 3 :: VideoIn
    //Write address channel
//Disalbe_id_port
    AWADDR_VideoIn  ,
    AWLEN_VideoIn   ,
    AWSIZE_VideoIn  ,
    AWBURST_VideoIn ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALID_VideoIn ,
    AWREADY_2_VideoIn ,

    
    //Write data channel
//Disalbe_id_port
    WDATA_VideoIn   ,
    WSTRB_VideoIn   ,
    WLAST_VideoIn   ,
    WVALID_VideoIn  ,
    WREADY_2_VideoIn  ,

    //Write response channel
//Disalbe_id_port
    BRESP_2_VideoIn   ,
    BVALID_2_VideoIn  ,
    BREADY_VideoIn  ,
 

    //_______________________________________________________________
    //For Slave 0 :: DDRCtrl
    //Write address channel
    AWID_2_DDRCtrl    ,
    AWADDR_2_DDRCtrl  ,
    AWLEN_2_DDRCtrl   ,
    AWSIZE_2_DDRCtrl  ,
    AWBURST_2_DDRCtrl ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port
    AWVALID_2_DDRCtrl ,
    AWREADY_DDRCtrl ,

    //Write data channel
    WID_2_DDRCtrl     ,
    WDATA_2_DDRCtrl   ,
    WSTRB_2_DDRCtrl   ,
    WLAST_2_DDRCtrl   ,
    WVALID_2_DDRCtrl  ,
    WREADY_DDRCtrl  ,

    //Write response channel
    BID_DDRCtrl     ,
    BRESP_DDRCtrl   ,
    BVALID_DDRCtrl  ,
    BREADY_2_DDRCtrl  ,
 
    //_______________________________________________________________
    //For Slave 1 :: APB0
    //Write address channel
    AWID_2_APB0    ,
    AWADDR_2_APB0  ,
    AWLEN_2_APB0   ,
    AWSIZE_2_APB0  ,
    AWBURST_2_APB0 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port
    AWVALID_2_APB0 ,
    AWREADY_APB0 ,

    //Write data channel
    WID_2_APB0     ,
    WDATA_2_APB0   ,
//Disalbe_WSTRB_port
    WLAST_2_APB0   ,
    WVALID_2_APB0  ,
    WREADY_APB0  ,

    //Write response channel
    BID_APB0     ,
    BRESP_APB0   ,
    BVALID_APB0  ,
    BREADY_2_APB0  ,
 
    //_______________________________________________________________
    //For Slave 2 :: APB1
    //Write address channel
    AWID_2_APB1    ,
    AWADDR_2_APB1  ,
    AWLEN_2_APB1   ,
    AWSIZE_2_APB1  ,
    AWBURST_2_APB1 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port
    AWVALID_2_APB1 ,
    AWREADY_APB1 ,

    //Write data channel
    WID_2_APB1     ,
    WDATA_2_APB1   ,
//Disalbe_WSTRB_port
    WLAST_2_APB1   ,
    WVALID_2_APB1  ,
    WREADY_APB1  ,

    //Write response channel
    BID_APB1     ,
    BRESP_APB1   ,
    BVALID_APB1  ,
    BREADY_2_APB1  ,
 
    //_______________________________________________________________
    //For Slave 3 :: SMC
    //Write address channel
    AWID_2_SMC    ,
    AWADDR_2_SMC  ,
    AWLEN_2_SMC   ,
    AWSIZE_2_SMC  ,
    AWBURST_2_SMC ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port
    AWVALID_2_SMC ,
    AWREADY_SMC ,

    //Write data channel
    WID_2_SMC     ,
    WDATA_2_SMC   ,
    WSTRB_2_SMC   ,
    WLAST_2_SMC   ,
    WVALID_2_SMC  ,
    WREADY_SMC  ,

    //Write response channel
    BID_SMC     ,
    BRESP_SMC   ,
    BVALID_SMC  ,
    BREADY_2_SMC  ,
 
    //_______________________________________________________________
    //For Slave 4 :: IntSRAM
    //Write address channel
    AWID_2_IntSRAM    ,
    AWADDR_2_IntSRAM  ,
    AWLEN_2_IntSRAM   ,
    AWSIZE_2_IntSRAM  ,
    AWBURST_2_IntSRAM ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port
    AWVALID_2_IntSRAM ,
    AWREADY_IntSRAM ,

    //Write data channel
    WID_2_IntSRAM     ,
    WDATA_2_IntSRAM   ,
    WSTRB_2_IntSRAM   ,
    WLAST_2_IntSRAM   ,
    WVALID_2_IntSRAM  ,
    WREADY_IntSRAM  ,

    //Write response channel
    BID_IntSRAM     ,
    BRESP_IntSRAM   ,
    BVALID_IntSRAM  ,
    BREADY_2_IntSRAM  ,
 


//Read channel signal
    //_______________________________________________________________
    //For Master 0 :: ARM
    //Read address channel
//Disalbe_id_port
    ARADDR_ARM  ,
    ARLEN_ARM   ,
    ARSIZE_ARM  ,
    ARBURST_ARM ,
    ARLOCK_ARM  ,
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_ARM ,
    ARREADY_2_ARM ,

    //Read data channel
//Disalbe_id_port
    RRESP_2_ARM   ,
    RDATA_2_ARM   ,
    RLAST_2_ARM   ,
    RVALID_2_ARM  ,
    RREADY_ARM  ,
    //_______________________________________________________________
    //For Master 1 :: DisplayCtrl
    //Read address channel
    ARID_DisplayCtrl    ,
    ARADDR_DisplayCtrl  ,
    ARLEN_DisplayCtrl   ,
    ARSIZE_DisplayCtrl  ,
    ARBURST_DisplayCtrl ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_DisplayCtrl ,
    ARREADY_2_DisplayCtrl ,

    //Read data channel
    RID_2_DisplayCtrl     ,
    RRESP_2_DisplayCtrl   ,
    RDATA_2_DisplayCtrl   ,
    RLAST_2_DisplayCtrl   ,
    RVALID_2_DisplayCtrl  ,
    RREADY_DisplayCtrl  ,
    //_______________________________________________________________
    //For Master 2 :: DMACtrl
    //Read address channel
    ARID_DMACtrl    ,
    ARADDR_DMACtrl  ,
    ARLEN_DMACtrl   ,
    ARSIZE_DMACtrl  ,
    ARBURST_DMACtrl ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_DMACtrl ,
    ARREADY_2_DMACtrl ,

    //Read data channel
    RID_2_DMACtrl     ,
    RRESP_2_DMACtrl   ,
    RDATA_2_DMACtrl   ,
    RLAST_2_DMACtrl   ,
    RVALID_2_DMACtrl  ,
    RREADY_DMACtrl  ,
    
    //_______________________________________________________________
    //For Slave 0 :: DDRCtrl
    ARID_2_DDRCtrl    ,
    ARADDR_2_DDRCtrl  ,
    ARLEN_2_DDRCtrl   ,
    ARSIZE_2_DDRCtrl  ,
    ARBURST_2_DDRCtrl ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_2_DDRCtrl ,
    ARREADY_DDRCtrl ,

    //Read data channel
    RID_DDRCtrl     ,
    RRESP_DDRCtrl   ,
    RDATA_DDRCtrl  ,
    RLAST_DDRCtrl  ,
    RVALID_DDRCtrl  ,
    RREADY_2_DDRCtrl  ,
    //_______________________________________________________________
    //For Slave 1 :: APB0
    ARID_2_APB0    ,
    ARADDR_2_APB0  ,
    ARLEN_2_APB0   ,
    ARSIZE_2_APB0  ,
    ARBURST_2_APB0 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_2_APB0 ,
    ARREADY_APB0 ,

    //Read data channel
    RID_APB0     ,
    RRESP_APB0   ,
    RDATA_APB0  ,
    RLAST_APB0  ,
    RVALID_APB0  ,
    RREADY_2_APB0  ,
    //_______________________________________________________________
    //For Slave 2 :: APB1
    ARID_2_APB1    ,
    ARADDR_2_APB1  ,
    ARLEN_2_APB1   ,
    ARSIZE_2_APB1  ,
    ARBURST_2_APB1 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_2_APB1 ,
    ARREADY_APB1 ,

    //Read data channel
    RID_APB1     ,
    RRESP_APB1   ,
    RDATA_APB1  ,
    RLAST_APB1  ,
    RVALID_APB1  ,
    RREADY_2_APB1  ,
    //_______________________________________________________________
    //For Slave 3 :: SMC
    ARID_2_SMC    ,
    ARADDR_2_SMC  ,
    ARLEN_2_SMC   ,
    ARSIZE_2_SMC  ,
    ARBURST_2_SMC ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_2_SMC ,
    ARREADY_SMC ,

    //Read data channel
    RID_SMC     ,
    RRESP_SMC   ,
    RDATA_SMC  ,
    RLAST_SMC  ,
    RVALID_SMC  ,
    RREADY_2_SMC  ,
    //_______________________________________________________________
    //For Slave 4 :: IntSRAM
    ARID_2_IntSRAM    ,
    ARADDR_2_IntSRAM  ,
    ARLEN_2_IntSRAM   ,
    ARSIZE_2_IntSRAM  ,
    ARBURST_2_IntSRAM ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    ARVALID_2_IntSRAM ,
    ARREADY_IntSRAM ,

    //Read data channel
    RID_IntSRAM     ,
    RRESP_IntSRAM   ,
    RDATA_IntSRAM  ,
    RLAST_IntSRAM  ,
    RVALID_IntSRAM  ,
    RREADY_2_IntSRAM  ,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 2;
parameter SLAVEID_WID= 4;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 2;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter WRITECHID0_WID = 1 ;
parameter WRITECHID1_WID = 2 ;
parameter WRITECHID2_WID = 1 ;
parameter WRITECHID3_WID = 1 ;
parameter READCHID0_WID = 1 ;
parameter READCHID1_WID = 2 ;
parameter READCHID2_WID = 1 ;
parameter READCHID3_WID = 1 ;
parameter WR_SLAVEID0_WID = 3 ;
parameter WR_SLAVEID1_WID = 2 ;
parameter WR_SLAVEID2_WID = 2 ;
parameter WR_SLAVEID3_WID = 3 ;
parameter WR_SLAVEID4_WID = 3 ;
parameter WR_SLAVEID5_WID = 3 ;
parameter RD_SLAVEID0_WID = 4 ;
parameter RD_SLAVEID1_WID = 2 ;
parameter RD_SLAVEID2_WID = 2 ;
parameter RD_SLAVEID3_WID = 4 ;
parameter RD_SLAVEID4_WID = 4 ;
parameter RD_SLAVEID5_WID = 4 ;
parameter SELMASTER0_WID = 2 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 2 ;
parameter SELMASTER4_WID = 2 ;
parameter SELMASTER5_WID = 2 ;
parameter SELWRITE0_WID = 2 ;
parameter SELREAD0_WID = 2 ;
parameter SELWRITE1_WID = 1 ;
parameter SELREAD1_WID = 1 ;
parameter SELWRITE2_WID = 1 ;
parameter SELREAD2_WID = 1 ;
parameter SELWRITE3_WID = 2 ;
parameter SELREAD3_WID = 2 ;
parameter SELWRITE4_WID = 2 ;
parameter SELREAD4_WID = 2 ;
parameter SELWRITE5_WID = 2 ;
parameter SELREAD5_WID = 2 ;
parameter SLAVE_WRITEID0_WID = 1 ;
parameter SLAVE_WRITEID1_WID = 1 ;
parameter SLAVE_WRITEID2_WID = 1 ;
parameter SLAVE_WRITEID3_WID = 1 ;
parameter SLAVE_WRITEID4_WID = 1 ;
parameter SLAVE_WRITEID5_WID = 1 ;
parameter SLAVE_READID0_WID = 2 ;
parameter SLAVE_READID1_WID = 1 ;
parameter SLAVE_READID2_WID = 1 ;
parameter SLAVE_READID3_WID = 2 ;
parameter SLAVE_READID4_WID = 2 ;
parameter SLAVE_READID5_WID = 2 ;

    input   ACLK;
    input   ARESETn;

    //Write Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARM
    //Write address channel
//Disalbe_id_port
    input   [ADDR_WID-1:0]          AWADDR_ARM;
    input   [AWLEN_WID-1:0]         AWLEN_ARM;
    input   [AWSIZE_WID-1:0]        AWSIZE_ARM;  
    input   [AWBURST_WID-1:0]       AWBURST_ARM; 
    input   [AWLOCK_WID-1:0]        AWLOCK_ARM;  
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALID_ARM; 
    output  AWREADY_2_ARM; 

    //Write data channel
//Disalbe_id_port
    input   [BUS_WID-1:0]           WDATA_ARM;   
    input   [WSTRB_WID-1:0]         WSTRB_ARM;   
    input   WLAST_ARM;   
    input   WVALID_ARM;  
    output  WREADY_2_ARM;  

    //Write response channel
//Disalbe_id_port
    output   [BRESP_WID-1:0]        BRESP_2_ARM;   
    output   BVALID_2_ARM;  
    input    BREADY_ARM;  
 
 
    
    //For Master 2 :: DMACtrl
    //Write address channel
    input   [WRITECHID2_WID-1:0]   AWID_DMACtrl;    
    input   [ADDR_WID-1:0]          AWADDR_DMACtrl;
    input   [AWLEN_WID-1:0]         AWLEN_DMACtrl;
    input   [AWSIZE_WID-1:0]        AWSIZE_DMACtrl;  
    input   [AWBURST_WID-1:0]       AWBURST_DMACtrl; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALID_DMACtrl; 
    output  AWREADY_2_DMACtrl; 

    //Write data channel
    input   [WRITECHID2_WID-1:0]    WID_DMACtrl;     
    input   [BUS_WID-1:0]           WDATA_DMACtrl;   
    input   [WSTRB_WID-1:0]         WSTRB_DMACtrl;   
    input   WLAST_DMACtrl;   
    input   WVALID_DMACtrl;  
    output  WREADY_2_DMACtrl;  

    //Write response channel
    output   [WRITECHID2_WID-1:0]   BID_2_DMACtrl;     
    output   [BRESP_WID-1:0]        BRESP_2_DMACtrl;   
    output   BVALID_2_DMACtrl;  
    input    BREADY_DMACtrl;  
 
    
    //For Master 3 :: VideoIn
    //Write address channel
//Disalbe_id_port
    input   [ADDR_WID-1:0]          AWADDR_VideoIn;
    input   [AWLEN_WID-1:0]         AWLEN_VideoIn;
    input   [AWSIZE_WID-1:0]        AWSIZE_VideoIn;  
    input   [AWBURST_WID-1:0]       AWBURST_VideoIn; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALID_VideoIn; 
    output  AWREADY_2_VideoIn; 

    //Write data channel
//Disalbe_id_port
    input   [BUS_WID-1:0]           WDATA_VideoIn;   
    input   [WSTRB_WID-1:0]         WSTRB_VideoIn;   
    input   WLAST_VideoIn;   
    input   WVALID_VideoIn;  
    output  WREADY_2_VideoIn;  

    //Write response channel
//Disalbe_id_port
    output   [BRESP_WID-1:0]        BRESP_2_VideoIn;   
    output   BVALID_2_VideoIn;  
    input    BREADY_VideoIn;  
 


    //Write Channel MasterInterface
    //_______________________________________________________________
   
    // For slave 0 :: DDRCtrl
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID0_WID-1:0]AWID_2_DDRCtrl;    
    output   [ADDR_WID-1:0]     AWADDR_2_DDRCtrl;
    output   [AWLEN_WID-1:0]    AWLEN_2_DDRCtrl;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_DDRCtrl;  
    output   [AWBURST_WID-1:0]  AWBURST_2_DDRCtrl; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALID_2_DDRCtrl; 
    input    AWREADY_DDRCtrl; 
    
    //Write data channel
    output   [WR_SLAVEID0_WID-1:0]WID_2_DDRCtrl;     
    output   [BUS_WID-1:0]      WDATA_2_DDRCtrl;   
    output   [WSTRB_WID-1:0]    WSTRB_2_DDRCtrl;   
    output   WLAST_2_DDRCtrl;   
    output   WVALID_2_DDRCtrl;  
    input    WREADY_DDRCtrl; 

    //Write response channel
    input   [WR_SLAVEID0_WID-1:0] BID_DDRCtrl;     
    input   [BRESP_WID-1:0]     BRESP_DDRCtrl;   
    input   BVALID_DDRCtrl;  
    output  BREADY_2_DDRCtrl;  
   
    // For slave 1 :: APB0
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID1_WID-1:0]AWID_2_APB0;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB0;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB0;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB0;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB0; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALID_2_APB0; 
    input    AWREADY_APB0; 
    
    //Write data channel
    output   [WR_SLAVEID1_WID-1:0]WID_2_APB0;     
    output   [BUS_WID-1:0]      WDATA_2_APB0;   
//Disalbe_WSTRB_port
    output   WLAST_2_APB0;   
    output   WVALID_2_APB0;  
    input    WREADY_APB0; 

    //Write response channel
    input   [WR_SLAVEID1_WID-1:0] BID_APB0;     
    input   [BRESP_WID-1:0]     BRESP_APB0;   
    input   BVALID_APB0;  
    output  BREADY_2_APB0;  
   
    // For slave 2 :: APB1
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID2_WID-1:0]AWID_2_APB1;    
    output   [ADDR_WID-1:0]     AWADDR_2_APB1;
    output   [AWLEN_WID-1:0]    AWLEN_2_APB1;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_APB1;  
    output   [AWBURST_WID-1:0]  AWBURST_2_APB1; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALID_2_APB1; 
    input    AWREADY_APB1; 
    
    //Write data channel
    output   [WR_SLAVEID2_WID-1:0]WID_2_APB1;     
    output   [BUS_WID-1:0]      WDATA_2_APB1;   
//Disalbe_WSTRB_port
    output   WLAST_2_APB1;   
    output   WVALID_2_APB1;  
    input    WREADY_APB1; 

    //Write response channel
    input   [WR_SLAVEID2_WID-1:0] BID_APB1;     
    input   [BRESP_WID-1:0]     BRESP_APB1;   
    input   BVALID_APB1;  
    output  BREADY_2_APB1;  
   
    // For slave 3 :: SMC
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID3_WID-1:0]AWID_2_SMC;    
    output   [ADDR_WID-1:0]     AWADDR_2_SMC;
    output   [AWLEN_WID-1:0]    AWLEN_2_SMC;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_SMC;  
    output   [AWBURST_WID-1:0]  AWBURST_2_SMC; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALID_2_SMC; 
    input    AWREADY_SMC; 
    
    //Write data channel
    output   [WR_SLAVEID3_WID-1:0]WID_2_SMC;     
    output   [BUS_WID-1:0]      WDATA_2_SMC;   
    output   [WSTRB_WID-1:0]    WSTRB_2_SMC;   
    output   WLAST_2_SMC;   
    output   WVALID_2_SMC;  
    input    WREADY_SMC; 

    //Write response channel
    input   [WR_SLAVEID3_WID-1:0] BID_SMC;     
    input   [BRESP_WID-1:0]     BRESP_SMC;   
    input   BVALID_SMC;  
    output  BREADY_2_SMC;  
   
    // For slave 4 :: IntSRAM
    //__________________________________________________
    //Write address channel
    output   [WR_SLAVEID4_WID-1:0]AWID_2_IntSRAM;    
    output   [ADDR_WID-1:0]     AWADDR_2_IntSRAM;
    output   [AWLEN_WID-1:0]    AWLEN_2_IntSRAM;
    output   [AWSIZE_WID-1:0]   AWSIZE_2_IntSRAM;  
    output   [AWBURST_WID-1:0]  AWBURST_2_IntSRAM; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALID_2_IntSRAM; 
    input    AWREADY_IntSRAM; 
    
    //Write data channel
    output   [WR_SLAVEID4_WID-1:0]WID_2_IntSRAM;     
    output   [BUS_WID-1:0]      WDATA_2_IntSRAM;   
    output   [WSTRB_WID-1:0]    WSTRB_2_IntSRAM;   
    output   WLAST_2_IntSRAM;   
    output   WVALID_2_IntSRAM;  
    input    WREADY_IntSRAM; 

    //Write response channel
    input   [WR_SLAVEID4_WID-1:0] BID_IntSRAM;     
    input   [BRESP_WID-1:0]     BRESP_IntSRAM;   
    input   BVALID_IntSRAM;  
    output  BREADY_2_IntSRAM;  


    //Read Channel SlaveInterface
    //_______________________________________________________________
    
    //For Master 0 :: ARM
    //Read address channel
//Disalbe_id_port
    input   [ADDR_WID-1:0]     ARADDR_ARM;
    input   [ARLEN_WID-1:0]    ARLEN_ARM;
    input   [ARSIZE_WID-1:0]   ARSIZE_ARM;  
    input   [ARBURST_WID-1:0]  ARBURST_ARM; 
    input   [ARLOCK_WID-1:0]   ARLOCK_ARM;  
//Disalbe_cache_port
//Disalbe_protect_port

    input   ARVALID_ARM; 
    output  ARREADY_2_ARM; 

    //Read data channel
//Disalbe_id_port
    output   [BRESP_WID-1:0]   RRESP_2_ARM;   
    output   [BUS_WID-1:0]     RDATA_2_ARM;
    output   RLAST_2_ARM;
    output   RVALID_2_ARM;  
    input    RREADY_ARM;  
 
    
    //For Master 1 :: DisplayCtrl
    //Read address channel
    input   [READCHID1_WID-1:0]ARID_DisplayCtrl;    
    input   [ADDR_WID-1:0]     ARADDR_DisplayCtrl;
    input   [ARLEN_WID-1:0]    ARLEN_DisplayCtrl;
    input   [ARSIZE_WID-1:0]   ARSIZE_DisplayCtrl;  
    input   [ARBURST_WID-1:0]  ARBURST_DisplayCtrl; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   ARVALID_DisplayCtrl; 
    output  ARREADY_2_DisplayCtrl; 

    //Read data channel
    output   [READCHID1_WID-1:0]RID_2_DisplayCtrl;     
    output   [BRESP_WID-1:0]   RRESP_2_DisplayCtrl;   
    output   [BUS_WID-1:0]     RDATA_2_DisplayCtrl;
    output   RLAST_2_DisplayCtrl;
    output   RVALID_2_DisplayCtrl;  
    input    RREADY_DisplayCtrl;  
 
    
    //For Master 2 :: DMACtrl
    //Read address channel
    input   [READCHID2_WID-1:0]ARID_DMACtrl;    
    input   [ADDR_WID-1:0]     ARADDR_DMACtrl;
    input   [ARLEN_WID-1:0]    ARLEN_DMACtrl;
    input   [ARSIZE_WID-1:0]   ARSIZE_DMACtrl;  
    input   [ARBURST_WID-1:0]  ARBURST_DMACtrl; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   ARVALID_DMACtrl; 
    output  ARREADY_2_DMACtrl; 

    //Read data channel
    output   [READCHID2_WID-1:0]RID_2_DMACtrl;     
    output   [BRESP_WID-1:0]   RRESP_2_DMACtrl;   
    output   [BUS_WID-1:0]     RDATA_2_DMACtrl;
    output   RLAST_2_DMACtrl;
    output   RVALID_2_DMACtrl;  
    input    RREADY_DMACtrl;  
 
 


    //MasterInterface
    //_______________________________________________________________
    
    // For slave 0
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID0_WID-1:0]ARID_2_DDRCtrl;    
    output   [ADDR_WID-1:0]     ARADDR_2_DDRCtrl;
    output   [ARLEN_WID-1:0]    ARLEN_2_DDRCtrl;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_DDRCtrl;  
    output   [ARBURST_WID-1:0]  ARBURST_2_DDRCtrl; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   ARVALID_2_DDRCtrl; 
    input    ARREADY_DDRCtrl; 
    

    //Read data channel
    input   [RD_SLAVEID0_WID-1:0] RID_DDRCtrl;     
    input   [RRESP_WID-1:0]     RRESP_DDRCtrl;   
    input   [BUS_WID-1:0]       RDATA_DDRCtrl;  
    input   RLAST_DDRCtrl;  
    input   RVALID_DDRCtrl;  
    output  RREADY_2_DDRCtrl;  

    
    // For slave 1
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID1_WID-1:0]ARID_2_APB0;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB0;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB0;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB0;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB0; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   ARVALID_2_APB0; 
    input    ARREADY_APB0; 
    

    //Read data channel
    input   [RD_SLAVEID1_WID-1:0] RID_APB0;     
    input   [RRESP_WID-1:0]     RRESP_APB0;   
    input   [BUS_WID-1:0]       RDATA_APB0;  
    input   RLAST_APB0;  
    input   RVALID_APB0;  
    output  RREADY_2_APB0;  

    
    // For slave 2
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID2_WID-1:0]ARID_2_APB1;    
    output   [ADDR_WID-1:0]     ARADDR_2_APB1;
    output   [ARLEN_WID-1:0]    ARLEN_2_APB1;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_APB1;  
    output   [ARBURST_WID-1:0]  ARBURST_2_APB1; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   ARVALID_2_APB1; 
    input    ARREADY_APB1; 
    

    //Read data channel
    input   [RD_SLAVEID2_WID-1:0] RID_APB1;     
    input   [RRESP_WID-1:0]     RRESP_APB1;   
    input   [BUS_WID-1:0]       RDATA_APB1;  
    input   RLAST_APB1;  
    input   RVALID_APB1;  
    output  RREADY_2_APB1;  

    
    // For slave 3
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID3_WID-1:0]ARID_2_SMC;    
    output   [ADDR_WID-1:0]     ARADDR_2_SMC;
    output   [ARLEN_WID-1:0]    ARLEN_2_SMC;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_SMC;  
    output   [ARBURST_WID-1:0]  ARBURST_2_SMC; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   ARVALID_2_SMC; 
    input    ARREADY_SMC; 
    

    //Read data channel
    input   [RD_SLAVEID3_WID-1:0] RID_SMC;     
    input   [RRESP_WID-1:0]     RRESP_SMC;   
    input   [BUS_WID-1:0]       RDATA_SMC;  
    input   RLAST_SMC;  
    input   RVALID_SMC;  
    output  RREADY_2_SMC;  

    
    // For slave 4
    //__________________________________________________

    // Read address channel
    output   [RD_SLAVEID4_WID-1:0]ARID_2_IntSRAM;    
    output   [ADDR_WID-1:0]     ARADDR_2_IntSRAM;
    output   [ARLEN_WID-1:0]    ARLEN_2_IntSRAM;
    output   [ARSIZE_WID-1:0]   ARSIZE_2_IntSRAM;  
    output   [ARBURST_WID-1:0]  ARBURST_2_IntSRAM; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   ARVALID_2_IntSRAM; 
    input    ARREADY_IntSRAM; 
    

    //Read data channel
    input   [RD_SLAVEID4_WID-1:0] RID_IntSRAM;     
    input   [RRESP_WID-1:0]     RRESP_IntSRAM;   
    input   [BUS_WID-1:0]       RDATA_IntSRAM;  
    input   RLAST_IntSRAM;  
    input   RVALID_IntSRAM;  
    output  RREADY_2_IntSRAM;  


//______________________________________________________DEFALUT_SLAVE_START
    // default slave
    // For slave 5 :: default
    //__________________________________________________
    //Write address channel
    wire   [WR_SLAVEID5_WID-1:0]AWID_2_default;    
    wire   [ADDR_WID-1:0]     AWADDR_2_default;
    wire   [AWLEN_WID-1:0]    AWLEN_2_default;
    wire   [AWSIZE_WID-1:0]   AWSIZE_2_default;  
    wire   [AWBURST_WID-1:0]  AWBURST_2_default; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    wire   AWVALID_2_default; 
    wire    AWREADY_default; 
    
    //Write data channel
    wire   [WR_SLAVEID5_WID-1:0]WID_2_default;     
    wire   [BUS_WID-1:0]      WDATA_2_default;   
    wire   [WSTRB_WID-1:0]    WSTRB_2_default;   
    wire   WLAST_2_default;   
    wire   WVALID_2_default;  
    wire    WREADY_default; 

    //Write response channel
    wire   [WR_SLAVEID5_WID-1:0] BID_default;     
    wire   [BRESP_WID-1:0]     BRESP_default;   
    wire   BVALID_default;  
    wire  BREADY_2_default;  

    //__________________________________________________
    // Read address channel
    wire   [RD_SLAVEID5_WID-1:0]ARID_2_default;    
    wire   [ADDR_WID-1:0]     ARADDR_2_default;
    wire   [ARLEN_WID-1:0]    ARLEN_2_default;
    wire   [ARSIZE_WID-1:0]   ARSIZE_2_default;  
    wire   [ARBURST_WID-1:0]  ARBURST_2_default; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    wire   ARVALID_2_default; 
    wire   ARREADY_default; 
    
    //Read data channel
    wire   [RD_SLAVEID5_WID-1:0] RID_default;     
    wire   [RRESP_WID-1:0]     RRESP_default;   
    wire   [BUS_WID-1:0]       RDATA_default;  
    wire   RLAST_default;  
    wire   RVALID_default;  
    wire   RREADY_2_default;  

DefaultSlave #(
	.WID_WIDTH(WR_SLAVEID5_WID),
	.RID_WIDTH(RD_SLAVEID5_WID)
)
DefaultSlave
(
		.ACLK(ACLK),
		.ARESETn(ARESETn),

		.AWID(AWID_2_default),
		.AWADDR(AWADDR_2_default),
		.AWLEN(AWLEN_2_default),
		.AWSIZE(AWSIZE_2_default),
		.AWBURST(AWBURST_2_default),
		.AWVALID(AWVALID_2_default),
		.AWREADY(AWREADY_default),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

		.WID(WID_2_default),
		.WDATA(WDATA_2_default),
		.WLAST(WLAST_2_default),
		.WVALID(WVALID_2_default),
        .WSTRB  (WSTRB_2_default),
		.WREADY (WREADY_default),

		.BID(BID_default),
		.BRESP(BRESP_default),
		.BVALID(BVALID_default),
		.BREADY(BREADY_2_default),

		.ARID(ARID_2_default),
		.ARADDR(ARADDR_2_default),
		.ARLEN(ARLEN_2_default),
		.ARSIZE(ARSIZE_2_default),
		.ARBURST(ARBURST_2_default),
		.ARVALID(ARVALID_2_default),
		.ARREADY(ARREADY_default),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

		// Read Data Channel
		.RID(RID_default),
		.RDATA(RDATA_default),
		.RRESP(RRESP_default),
		.RLAST(RLAST_default),
		.RVALID(RVALID_default),
		.RREADY(RREADY_2_default)
);
//______________________________________________________DEFALUT_SLAVE_END


//version short name
//Slave Lock signals were generated
//Slave module 0  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE0_WID-1:0]CtlDataWrite2Lock0;
    wire   [SELREAD0_WID-1:0]CtlDataRead2Lock0;     
    wire   Lock2wrmi0;
    wire   UnLock2wrmi0;
    wire   UnLock2rdmi0;
    wire   Lock2rdmi0 ;
    //wire   [SELWRITE0_WID:0]LockPort2wrmi0;
    //wire   [SELREAD0_WID:0]LockPort2rdmi0;
    reg   [SELWRITE0_WID:0]LockPort2wrmi0;
    reg   [SELREAD0_WID:0]LockPort2rdmi0;

    //Syn modified
    wire   ReadIntEmptyWrmi02Rdmi0;
    wire   DataCntEmptyRdmi02Wrmi0;

//Slave Lock signals were generated
//Slave module 1  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE1_WID-1:0]CtlDataWrite2Lock1;
    wire   [SELREAD1_WID-1:0]CtlDataRead2Lock1;     
    wire   Lock2wrmi1;
    wire   UnLock2wrmi1;
    wire   UnLock2rdmi1;
    wire   Lock2rdmi1 ;
    //wire   [SELWRITE1_WID:0]LockPort2wrmi1;
    //wire   [SELREAD1_WID:0]LockPort2rdmi1;
    reg   [SELWRITE1_WID:0]LockPort2wrmi1;
    reg   [SELREAD1_WID:0]LockPort2rdmi1;

    //Syn modified
    wire   ReadIntEmptyWrmi12Rdmi1;
    wire   DataCntEmptyRdmi12Wrmi1;

//Slave Lock signals were generated
//Slave module 2  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE2_WID-1:0]CtlDataWrite2Lock2;
    wire   [SELREAD2_WID-1:0]CtlDataRead2Lock2;     
    wire   Lock2wrmi2;
    wire   UnLock2wrmi2;
    wire   UnLock2rdmi2;
    wire   Lock2rdmi2 ;
    //wire   [SELWRITE2_WID:0]LockPort2wrmi2;
    //wire   [SELREAD2_WID:0]LockPort2rdmi2;
    reg   [SELWRITE2_WID:0]LockPort2wrmi2;
    reg   [SELREAD2_WID:0]LockPort2rdmi2;

    //Syn modified
    wire   ReadIntEmptyWrmi22Rdmi2;
    wire   DataCntEmptyRdmi22Wrmi2;

//Slave Lock signals were generated
//Slave module 3  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE3_WID-1:0]CtlDataWrite2Lock3;
    wire   [SELREAD3_WID-1:0]CtlDataRead2Lock3;     
    wire   Lock2wrmi3;
    wire   UnLock2wrmi3;
    wire   UnLock2rdmi3;
    wire   Lock2rdmi3 ;
    //wire   [SELWRITE3_WID:0]LockPort2wrmi3;
    //wire   [SELREAD3_WID:0]LockPort2rdmi3;
    reg   [SELWRITE3_WID:0]LockPort2wrmi3;
    reg   [SELREAD3_WID:0]LockPort2rdmi3;

    //Syn modified
    wire   ReadIntEmptyWrmi32Rdmi3;
    wire   DataCntEmptyRdmi32Wrmi3;

//Slave Lock signals were generated
//Slave module 4  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE4_WID-1:0]CtlDataWrite2Lock4;
    wire   [SELREAD4_WID-1:0]CtlDataRead2Lock4;     
    wire   Lock2wrmi4;
    wire   UnLock2wrmi4;
    wire   UnLock2rdmi4;
    wire   Lock2rdmi4 ;
    //wire   [SELWRITE4_WID:0]LockPort2wrmi4;
    //wire   [SELREAD4_WID:0]LockPort2rdmi4;
    reg   [SELWRITE4_WID:0]LockPort2wrmi4;
    reg   [SELREAD4_WID:0]LockPort2rdmi4;

    //Syn modified
    wire   ReadIntEmptyWrmi42Rdmi4;
    wire   DataCntEmptyRdmi42Wrmi4;

//Slave Lock signals were generated
//Slave module 5  (Lock signal)  
//_____________________________________________________________________

    wire   [SELWRITE5_WID-1:0]CtlDataWrite2Lock5;
    wire   [SELREAD5_WID-1:0]CtlDataRead2Lock5;     
    wire   Lock2wrmi5;
    wire   UnLock2wrmi5;
    wire   UnLock2rdmi5;
    wire   Lock2rdmi5 ;
    //wire   [SELWRITE5_WID:0]LockPort2wrmi5;
    //wire   [SELREAD5_WID:0]LockPort2rdmi5;
    reg   [SELWRITE5_WID:0]LockPort2wrmi5;
    reg   [SELREAD5_WID:0]LockPort2rdmi5;

    //Syn modified
    wire   ReadIntEmptyWrmi52Rdmi5;
    wire   DataCntEmptyRdmi52Wrmi5;

//_____________________________________________________________________



  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

// Protocal Checker for master ARM
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID0_WID ),
    .RID_WIDTH(READCHID0_WID)
 )
ARM_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_ARM  ),
   .AWLEN       (AWLEN_ARM   ),
   .AWSIZE      (AWSIZE_ARM  ),
   .AWBURST     (AWBURST_ARM ),
   .AWLOCK      (AWLOCK_ARM  ),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_ARM ),
   .AWREADY     (AWREADY_2_ARM ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_ARM   ),
   .WDATA       (WDATA_ARM   ),
   .WSTRB       (WSTRB_ARM   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_ARM  ),
   .WREADY      (WREADY_2_ARM  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_ARM   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_ARM  ),
   .BREADY       (BREADY_ARM  ),


   // Read Address Channel
   .ARID(1'd0),
   .ARADDR       (ARADDR_ARM  ),
   .ARLEN        (ARLEN_ARM   ),
   .ARSIZE       (ARSIZE_ARM  ),
   .ARBURST      (ARBURST_ARM ),
   .ARLOCK       (ARLOCK_ARM  ),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_ARM ),
   .ARREADY      (ARREADY_2_ARM ),

   // Read Channel
   .RID(1'd0),
   .RLAST        (RLAST_2_ARM   ),
   .RDATA        (RDATA_2_ARM   ),
   .RRESP        (RRESP_2_ARM   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_ARM  ),
   .RREADY       (RREADY_ARM  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DisplayCtrl
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID1_WID ),
    .RID_WIDTH(READCHID1_WID)
 )
DisplayCtrl_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),

   // Write Address Channel
   .AWID      ({WRITECHID1_WID{1'b0}}),
   .AWADDR    ({ADDR_WID{1'b0}}  ),
   .AWLEN     ({AWLEN_WID{1'b0}}   ),
   .AWSIZE    ({AWSIZE_WID{1'b0}}  ),
   .AWBURST   ({AWBURST_WID{1'b0}} ),
   .AWLOCK    ({AWLOCK_WID{1'b0}}  ),
   .AWCACHE   ({AWCACHE_WID{1'b0}} ),
   .AWPROT    ({AWPROT_WID{1'b0}}  ),
   .AWUSER    ({32{1'b0}}),
   .AWVALID   (1'b0 ),
   .AWREADY   (1'b0 ),
   // Write Channel
   .WID       ({WRITECHID1_WID{1'b0}}),
   .WLAST       (1'b0   ),
   .WDATA       ({BUS_WID{1'b0}}   ),
   .WSTRB       ({WSTRB_WID{1'b1}}   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (1'b0  ),
   .WREADY      (1'b0  ),
   // Write Response Channel
   .BID         ({WRITECHID1_WID{1'b0}}),
   .BRESP        ({BRESP_WID{1'b0}}   ),
   .BUSER        ({32{1'b0}}),
   .BVALID       (1'b0  ),
   .BREADY       (1'b0  ),

   // Read Address Channel
   .ARID         (ARID_DisplayCtrl    ),
   .ARADDR       (ARADDR_DisplayCtrl  ),
   .ARLEN        (ARLEN_DisplayCtrl   ),
   .ARSIZE       (ARSIZE_DisplayCtrl  ),
   .ARBURST      (ARBURST_DisplayCtrl ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DisplayCtrl ),
   .ARREADY      (ARREADY_2_DisplayCtrl ),

   // Read Channel
   .RID          (RID_2_DisplayCtrl     ),
   .RLAST        (RLAST_2_DisplayCtrl   ),
   .RDATA        (RDATA_2_DisplayCtrl   ),
   .RRESP        (RRESP_2_DisplayCtrl   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DisplayCtrl  ),
   .RREADY       (RREADY_DisplayCtrl  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master DMACtrl
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID2_WID ),
    .RID_WIDTH(READCHID2_WID)
 )
DMACtrl_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID        (AWID_DMACtrl    ),
   .AWADDR      (AWADDR_DMACtrl  ),
   .AWLEN       (AWLEN_DMACtrl   ),
   .AWSIZE      (AWSIZE_DMACtrl  ),
   .AWBURST     (AWBURST_DMACtrl ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_DMACtrl ),
   .AWREADY     (AWREADY_2_DMACtrl ),

   // Write Channel
   .WID         (WID_DMACtrl     ),
   .WLAST       (WLAST_DMACtrl   ),
   .WDATA       (WDATA_DMACtrl   ),
   .WSTRB       (WSTRB_DMACtrl   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_DMACtrl  ),
   .WREADY      (WREADY_2_DMACtrl  ),

   // Write Response Channel
   .BID          (BID_2_DMACtrl     ),
   .BRESP        (BRESP_2_DMACtrl   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_DMACtrl  ),
   .BREADY       (BREADY_DMACtrl  ),


   // Read Address Channel
   .ARID         (ARID_DMACtrl    ),
   .ARADDR       (ARADDR_DMACtrl  ),
   .ARLEN        (ARLEN_DMACtrl   ),
   .ARSIZE       (ARSIZE_DMACtrl  ),
   .ARBURST      (ARBURST_DMACtrl ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_DMACtrl ),
   .ARREADY      (ARREADY_2_DMACtrl ),

   // Read Channel
   .RID          (RID_2_DMACtrl     ),
   .RLAST        (RLAST_2_DMACtrl   ),
   .RDATA        (RDATA_2_DMACtrl   ),
   .RRESP        (RRESP_2_DMACtrl   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_2_DMACtrl  ),
   .RREADY       (RREADY_DMACtrl  ),


   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for master VideoIn
//_____________________________________________________________________

// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WRITECHID3_WID ),
    .RID_WIDTH(READCHID3_WID)
 )
VideoIn_AxiPC
  (
   // Global Signals
   .ACLK(ACLK),
   .ARESETn(ARESETn),


   // Write Address Channel
   .AWID(1'd0),
   .AWADDR      (AWADDR_VideoIn  ),
   .AWLEN       (AWLEN_VideoIn   ),
   .AWSIZE      (AWSIZE_VideoIn  ),
   .AWBURST     (AWBURST_VideoIn ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_VideoIn ),
   .AWREADY     (AWREADY_2_VideoIn ),

   // Write Channel
   .WID(1'd0),
   .WLAST       (WLAST_VideoIn   ),
   .WDATA       (WDATA_VideoIn   ),
   .WSTRB       (WSTRB_VideoIn   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_VideoIn  ),
   .WREADY      (WREADY_2_VideoIn  ),

   // Write Response Channel
   .BID(1'd0),
   .BRESP        (BRESP_2_VideoIn   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_2_VideoIn  ),
   .BREADY       (BREADY_VideoIn  ),

   .ARID         ({READCHID3_WID{1'b0}}),
   .ARADDR       ({ADDR_WID{1'b0}}),
   .ARLEN        ({AWLEN_WID{1'b0}}),
   .ARSIZE       ({ARSIZE_WID{1'b0}}  ),
   .ARBURST      ({ARBURST_WID{1'b0}} ),
   .ARLOCK       ({ARLOCK_WID{1'b0}}  ),
   .ARCACHE      ({ARCACHE_WID{1'b0}} ),
   .ARPROT       ({ARPROT_WID{1'b0}}  ),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (1'b0 ),
   .ARREADY      (1'b0 ),
   // Read Channel
   .RID         ({READCHID3_WID{1'b0}}),
   .RLAST        (1'b0),
   .RDATA        ({BUS_WID{1'b0}}),
   .RRESP        ({RRESP_WID{1'b0}}),
   .RUSER        ({32{1'b0}}),
   .RVALID       (1'b0),
   .RREADY       (1'b0),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

// Protocal Checker for slave DDRCtrl
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID0_WID ),
    .RID_WIDTH(RD_SLAVEID0_WID)
 )
DDRCtrl_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_DDRCtrl    ),
   .AWADDR      (AWADDR_2_DDRCtrl  ),
   .AWLEN       (AWLEN_2_DDRCtrl   ),
   .AWSIZE      (AWSIZE_2_DDRCtrl  ),
   .AWBURST     (AWBURST_2_DDRCtrl ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_DDRCtrl ),
   .AWREADY     (AWREADY_DDRCtrl ),

   // Write Channel
   .WID         (WID_2_DDRCtrl     ),
   .WLAST       (WLAST_2_DDRCtrl   ),
   .WDATA       (WDATA_2_DDRCtrl   ),
   .WSTRB       (WSTRB_2_DDRCtrl   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_DDRCtrl  ),
   .WREADY      (WREADY_DDRCtrl  ),

   // Write Response Channel
   .BID          (BID_DDRCtrl     ),
   .BRESP        (BRESP_DDRCtrl   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_DDRCtrl  ),
   .BREADY       (BREADY_2_DDRCtrl  ),

   // Read Address Channel
   .ARID         (ARID_2_DDRCtrl    ),
   .ARADDR       (ARADDR_2_DDRCtrl  ),
   .ARLEN        (ARLEN_2_DDRCtrl   ),
   .ARSIZE       (ARSIZE_2_DDRCtrl  ),
   .ARBURST      (ARBURST_2_DDRCtrl ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_DDRCtrl ),
   .ARREADY      (ARREADY_DDRCtrl ),

   // Read Channel
   .RID          (RID_DDRCtrl     ),
   .RLAST        (RLAST_DDRCtrl   ),
   .RDATA        (RDATA_DDRCtrl   ),
   .RRESP        (RRESP_DDRCtrl   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_DDRCtrl  ),
   .RREADY       (RREADY_2_DDRCtrl  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB0
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID1_WID ),
    .RID_WIDTH(RD_SLAVEID1_WID)
 )
APB0_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB0    ),
   .AWADDR      (AWADDR_2_APB0  ),
   .AWLEN       (AWLEN_2_APB0   ),
   .AWSIZE      (AWSIZE_2_APB0  ),
   .AWBURST     (AWBURST_2_APB0 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB0 ),
   .AWREADY     (AWREADY_APB0 ),

   // Write Channel
   .WID         (WID_2_APB0     ),
   .WLAST       (WLAST_2_APB0   ),
   .WDATA       (WDATA_2_APB0   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB0  ),
   .WREADY      (WREADY_APB0  ),

   // Write Response Channel
   .BID          (BID_APB0     ),
   .BRESP        (BRESP_APB0   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB0  ),
   .BREADY       (BREADY_2_APB0  ),

   // Read Address Channel
   .ARID         (ARID_2_APB0    ),
   .ARADDR       (ARADDR_2_APB0  ),
   .ARLEN        (ARLEN_2_APB0   ),
   .ARSIZE       (ARSIZE_2_APB0  ),
   .ARBURST      (ARBURST_2_APB0 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB0 ),
   .ARREADY      (ARREADY_APB0 ),

   // Read Channel
   .RID          (RID_APB0     ),
   .RLAST        (RLAST_APB0   ),
   .RDATA        (RDATA_APB0   ),
   .RRESP        (RRESP_APB0   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB0  ),
   .RREADY       (RREADY_2_APB0  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave APB1
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID2_WID ),
    .RID_WIDTH(RD_SLAVEID2_WID)
 )
APB1_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_APB1    ),
   .AWADDR      (AWADDR_2_APB1  ),
   .AWLEN       (AWLEN_2_APB1   ),
   .AWSIZE      (AWSIZE_2_APB1  ),
   .AWBURST     (AWBURST_2_APB1 ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_APB1 ),
   .AWREADY     (AWREADY_APB1 ),

   // Write Channel
   .WID         (WID_2_APB1     ),
   .WLAST       (WLAST_2_APB1   ),
   .WDATA       (WDATA_2_APB1   ),
.WSTRB({STRB_MAX{1'b1}}),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_APB1  ),
   .WREADY      (WREADY_APB1  ),

   // Write Response Channel
   .BID          (BID_APB1     ),
   .BRESP        (BRESP_APB1   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_APB1  ),
   .BREADY       (BREADY_2_APB1  ),

   // Read Address Channel
   .ARID         (ARID_2_APB1    ),
   .ARADDR       (ARADDR_2_APB1  ),
   .ARLEN        (ARLEN_2_APB1   ),
   .ARSIZE       (ARSIZE_2_APB1  ),
   .ARBURST      (ARBURST_2_APB1 ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_APB1 ),
   .ARREADY      (ARREADY_APB1 ),

   // Read Channel
   .RID          (RID_APB1     ),
   .RLAST        (RLAST_APB1   ),
   .RDATA        (RDATA_APB1   ),
   .RRESP        (RRESP_APB1   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_APB1  ),
   .RREADY       (RREADY_2_APB1  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave SMC
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID3_WID ),
    .RID_WIDTH(RD_SLAVEID3_WID)
 )
SMC_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_SMC    ),
   .AWADDR      (AWADDR_2_SMC  ),
   .AWLEN       (AWLEN_2_SMC   ),
   .AWSIZE      (AWSIZE_2_SMC  ),
   .AWBURST     (AWBURST_2_SMC ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_SMC ),
   .AWREADY     (AWREADY_SMC ),

   // Write Channel
   .WID         (WID_2_SMC     ),
   .WLAST       (WLAST_2_SMC   ),
   .WDATA       (WDATA_2_SMC   ),
   .WSTRB       (WSTRB_2_SMC   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_SMC  ),
   .WREADY      (WREADY_SMC  ),

   // Write Response Channel
   .BID          (BID_SMC     ),
   .BRESP        (BRESP_SMC   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_SMC  ),
   .BREADY       (BREADY_2_SMC  ),

   // Read Address Channel
   .ARID         (ARID_2_SMC    ),
   .ARADDR       (ARADDR_2_SMC  ),
   .ARLEN        (ARLEN_2_SMC   ),
   .ARSIZE       (ARSIZE_2_SMC  ),
   .ARBURST      (ARBURST_2_SMC ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_SMC ),
   .ARREADY      (ARREADY_SMC ),

   // Read Channel
   .RID          (RID_SMC     ),
   .RLAST        (RLAST_SMC   ),
   .RDATA        (RDATA_SMC   ),
   .RRESP        (RRESP_SMC   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_SMC  ),
   .RREADY       (RREADY_2_SMC  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave IntSRAM
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID4_WID ),
    .RID_WIDTH(RD_SLAVEID4_WID)
 )
IntSRAM_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_IntSRAM    ),
   .AWADDR      (AWADDR_2_IntSRAM  ),
   .AWLEN       (AWLEN_2_IntSRAM   ),
   .AWSIZE      (AWSIZE_2_IntSRAM  ),
   .AWBURST     (AWBURST_2_IntSRAM ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_IntSRAM ),
   .AWREADY     (AWREADY_IntSRAM ),

   // Write Channel
   .WID         (WID_2_IntSRAM     ),
   .WLAST       (WLAST_2_IntSRAM   ),
   .WDATA       (WDATA_2_IntSRAM   ),
   .WSTRB       (WSTRB_2_IntSRAM   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_IntSRAM  ),
   .WREADY      (WREADY_IntSRAM  ),

   // Write Response Channel
   .BID          (BID_IntSRAM     ),
   .BRESP        (BRESP_IntSRAM   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_IntSRAM  ),
   .BREADY       (BREADY_2_IntSRAM  ),

   // Read Address Channel
   .ARID         (ARID_2_IntSRAM    ),
   .ARADDR       (ARADDR_2_IntSRAM  ),
   .ARLEN        (ARLEN_2_IntSRAM   ),
   .ARSIZE       (ARSIZE_2_IntSRAM  ),
   .ARBURST      (ARBURST_2_IntSRAM ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_IntSRAM ),
   .ARREADY      (ARREADY_IntSRAM ),

   // Read Channel
   .RID          (RID_IntSRAM     ),
   .RLAST        (RLAST_IntSRAM   ),
   .RDATA        (RDATA_IntSRAM   ),
   .RRESP        (RRESP_IntSRAM   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_IntSRAM  ),
   .RREADY       (RREADY_2_IntSRAM  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on
// Protocal Checker for slave default
//_____________________________________________________________________
// synopsys translate_off
`ifdef  ASSERT_ON

AxiPC 
#( 
    .DATA_WIDTH(BUS_WID) ,
    .ID_WIDTH(WR_SLAVEID5_WID ),
    .RID_WIDTH(RD_SLAVEID5_WID)
 )
default_AxiPC
  (
   // Global Signals
   .ACLK        (ACLK),
   .ARESETn     (ARESETn),

   // Write Address Channel
   .AWID        (AWID_2_default    ),
   .AWADDR      (AWADDR_2_default  ),
   .AWLEN       (AWLEN_2_default   ),
   .AWSIZE      (AWSIZE_2_default  ),
   .AWBURST     (AWBURST_2_default ),
.AWLOCK(2'd0),
.AWCACHE(4'd0),
.AWPROT(3'd0),
   .AWUSER      ({32{1'b0}}),
   .AWVALID     (AWVALID_2_default ),
   .AWREADY     (AWREADY_default ),

   // Write Channel
   .WID         (WID_2_default     ),
   .WLAST       (WLAST_2_default   ),
   .WDATA       (WDATA_2_default   ),
   .WSTRB       (WSTRB_2_default   ),
   .WUSER       ({32{1'b0}}),
   .WVALID      (WVALID_2_default  ),
   .WREADY      (WREADY_default  ),

   // Write Response Channel
   .BID          (BID_default     ),
   .BRESP        (BRESP_default   ),   
   .BUSER        ({32{1'b0}}),
   .BVALID       (BVALID_default  ),
   .BREADY       (BREADY_2_default  ),

   // Read Address Channel
   .ARID         (ARID_2_default    ),
   .ARADDR       (ARADDR_2_default  ),
   .ARLEN        (ARLEN_2_default   ),
   .ARSIZE       (ARSIZE_2_default  ),
   .ARBURST      (ARBURST_2_default ),
.ARLOCK(2'd0),
.ARCACHE(4'd0),
.ARPROT(3'd0),
   .ARUSER       ({32{1'b0}}),
   .ARVALID      (ARVALID_2_default ),
   .ARREADY      (ARREADY_default ),

   // Read Channel
   .RID          (RID_default     ),
   .RLAST        (RLAST_default   ),
   .RDATA        (RDATA_default   ),
   .RRESP        (RRESP_default   ),
   .RUSER        ({32{1'b0}}),
   .RVALID       (RVALID_default  ),
   .RREADY       (RREADY_2_default  ),

   // Low power interface
   .CACTIVE      (1'b1),
   .CSYSREQ      (1'b1),
   .CSYSACK      (1'b1)   
   );

`endif // `ifdef ASSERT_ON
// synopsys translate_on

//Write Channel 
//_____________________________________________________________________

WriteChannel 

SBUS_WriteChannel(

    //_______________________________________________________________
    //For Master 0
    //Write address channel
//Disalbe_id_port
    .AWADDRm02si0  (AWADDR_ARM  ),
    .AWLENm02si0   (AWLEN_ARM   ),
    .AWSIZEm02si0  (AWSIZE_ARM  ),
    .AWBURSTm02si0 (AWBURST_ARM ),
    .AWLOCKm02si0  (AWLOCK_ARM  ),
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm02si0 (AWVALID_ARM ),
    .AWREADYsi02m0 (AWREADY_2_ARM ),

    //Write data channel
//Disalbe_id_port
    .WDATAm02si0   (WDATA_ARM   ),
    .WSTRBm02si0   (WSTRB_ARM   ),
    .WLASTm02si0   (WLAST_ARM   ),
    .WVALIDm02si0  (WVALID_ARM  ),
    .WREADYsi02m0  (WREADY_2_ARM  ),

    //Write response channel
//Disalbe_id_port
    .BRESPsi02m0   (BRESP_2_ARM   ),
    .BVALIDsi02m0  (BVALID_2_ARM  ),
    .BREADYm02si0  (BREADY_ARM  ),
    //_______________________________________________________________
    //For Master 2
    //Write address channel
    .AWIDm22si2    (AWID_DMACtrl    ),
    .AWADDRm22si2  (AWADDR_DMACtrl  ),
    .AWLENm22si2   (AWLEN_DMACtrl   ),
    .AWSIZEm22si2  (AWSIZE_DMACtrl  ),
    .AWBURSTm22si2 (AWBURST_DMACtrl ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm22si2 (AWVALID_DMACtrl ),
    .AWREADYsi22m2 (AWREADY_2_DMACtrl ),

    //Write data channel
    .WIDm22si2     (WID_DMACtrl     ),
    .WDATAm22si2   (WDATA_DMACtrl   ),
    .WSTRBm22si2   (WSTRB_DMACtrl   ),
    .WLASTm22si2   (WLAST_DMACtrl   ),
    .WVALIDm22si2  (WVALID_DMACtrl  ),
    .WREADYsi22m2  (WREADY_2_DMACtrl  ),

    //Write response channel
    .BIDsi22m2     (BID_2_DMACtrl     ),
    .BRESPsi22m2   (BRESP_2_DMACtrl   ),
    .BVALIDsi22m2  (BVALID_2_DMACtrl  ),
    .BREADYm22si2  (BREADY_DMACtrl  ),
    //_______________________________________________________________
    //For Master 3
    //Write address channel
//Disalbe_id_port
    .AWADDRm32si3  (AWADDR_VideoIn  ),
    .AWLENm32si3   (AWLEN_VideoIn   ),
    .AWSIZEm32si3  (AWSIZE_VideoIn  ),
    .AWBURSTm32si3 (AWBURST_VideoIn ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm32si3 (AWVALID_VideoIn ),
    .AWREADYsi32m3 (AWREADY_2_VideoIn ),

    //Write data channel
//Disalbe_id_port
    .WDATAm32si3   (WDATA_VideoIn   ),
    .WSTRBm32si3   (WSTRB_VideoIn   ),
    .WLASTm32si3   (WLAST_VideoIn   ),
    .WVALIDm32si3  (WVALID_VideoIn  ),
    .WREADYsi32m3  (WREADY_2_VideoIn  ),

    //Write response channel
//Disalbe_id_port
    .BRESPsi32m3   (BRESP_2_VideoIn   ),
    .BVALIDsi32m3  (BVALID_2_VideoIn  ),
    .BREADYm32si3  (BREADY_VideoIn  ),

    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    .AWIDmi02s0    (AWID_2_DDRCtrl    ),
    .AWADDRmi02s0  (AWADDR_2_DDRCtrl  ),
    .AWLENmi02s0   (AWLEN_2_DDRCtrl   ),
    .AWSIZEmi02s0  (AWSIZE_2_DDRCtrl  ),
    .AWBURSTmi02s0 (AWBURST_2_DDRCtrl ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi02s0 (AWVALID_2_DDRCtrl ),
    .AWREADYs02mi0 (AWREADY_DDRCtrl ),

    //Write data channel
    .WIDmi02s0     (WID_2_DDRCtrl     ),
    .WDATAmi02s0   (WDATA_2_DDRCtrl   ),
    .WSTRBmi02s0   (WSTRB_2_DDRCtrl   ),
    .WLASTmi02s0   (WLAST_2_DDRCtrl   ),
    .WVALIDmi02s0  (WVALID_2_DDRCtrl  ),
    .WREADYs02mi0  (WREADY_DDRCtrl  ),

    //Write response channel
    .BIDs02mi0     (BID_DDRCtrl     ),
    .BRESPs02mi0   (BRESP_DDRCtrl   ),
    .BVALIDs02mi0  (BVALID_DDRCtrl  ),
    .BREADYmi02s0  (BREADY_2_DDRCtrl  ),

    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    .AWIDmi12s1    (AWID_2_APB0    ),
    .AWADDRmi12s1  (AWADDR_2_APB0  ),
    .AWLENmi12s1   (AWLEN_2_APB0   ),
    .AWSIZEmi12s1  (AWSIZE_2_APB0  ),
    .AWBURSTmi12s1 (AWBURST_2_APB0 ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi12s1 (AWVALID_2_APB0 ),
    .AWREADYs12mi1 (AWREADY_APB0 ),

    //Write data channel
    .WIDmi12s1     (WID_2_APB0     ),
    .WDATAmi12s1   (WDATA_2_APB0   ),
//Disalbe_WSTRB_port
    .WLASTmi12s1   (WLAST_2_APB0   ),
    .WVALIDmi12s1  (WVALID_2_APB0  ),
    .WREADYs12mi1  (WREADY_APB0  ),

    //Write response channel
    .BIDs12mi1     (BID_APB0     ),
    .BRESPs12mi1   (BRESP_APB0   ),
    .BVALIDs12mi1  (BVALID_APB0  ),
    .BREADYmi12s1  (BREADY_2_APB0  ),

    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    .AWIDmi22s2    (AWID_2_APB1    ),
    .AWADDRmi22s2  (AWADDR_2_APB1  ),
    .AWLENmi22s2   (AWLEN_2_APB1   ),
    .AWSIZEmi22s2  (AWSIZE_2_APB1  ),
    .AWBURSTmi22s2 (AWBURST_2_APB1 ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi22s2 (AWVALID_2_APB1 ),
    .AWREADYs22mi2 (AWREADY_APB1 ),

    //Write data channel
    .WIDmi22s2     (WID_2_APB1     ),
    .WDATAmi22s2   (WDATA_2_APB1   ),
//Disalbe_WSTRB_port
    .WLASTmi22s2   (WLAST_2_APB1   ),
    .WVALIDmi22s2  (WVALID_2_APB1  ),
    .WREADYs22mi2  (WREADY_APB1  ),

    //Write response channel
    .BIDs22mi2     (BID_APB1     ),
    .BRESPs22mi2   (BRESP_APB1   ),
    .BVALIDs22mi2  (BVALID_APB1  ),
    .BREADYmi22s2  (BREADY_2_APB1  ),

    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    .AWIDmi32s3    (AWID_2_SMC    ),
    .AWADDRmi32s3  (AWADDR_2_SMC  ),
    .AWLENmi32s3   (AWLEN_2_SMC   ),
    .AWSIZEmi32s3  (AWSIZE_2_SMC  ),
    .AWBURSTmi32s3 (AWBURST_2_SMC ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi32s3 (AWVALID_2_SMC ),
    .AWREADYs32mi3 (AWREADY_SMC ),

    //Write data channel
    .WIDmi32s3     (WID_2_SMC     ),
    .WDATAmi32s3   (WDATA_2_SMC   ),
    .WSTRBmi32s3   (WSTRB_2_SMC   ),
    .WLASTmi32s3   (WLAST_2_SMC   ),
    .WVALIDmi32s3  (WVALID_2_SMC  ),
    .WREADYs32mi3  (WREADY_SMC  ),

    //Write response channel
    .BIDs32mi3     (BID_SMC     ),
    .BRESPs32mi3   (BRESP_SMC   ),
    .BVALIDs32mi3  (BVALID_SMC  ),
    .BREADYmi32s3  (BREADY_2_SMC  ),

    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    .AWIDmi42s4    (AWID_2_IntSRAM    ),
    .AWADDRmi42s4  (AWADDR_2_IntSRAM  ),
    .AWLENmi42s4   (AWLEN_2_IntSRAM   ),
    .AWSIZEmi42s4  (AWSIZE_2_IntSRAM  ),
    .AWBURSTmi42s4 (AWBURST_2_IntSRAM ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi42s4 (AWVALID_2_IntSRAM ),
    .AWREADYs42mi4 (AWREADY_IntSRAM ),

    //Write data channel
    .WIDmi42s4     (WID_2_IntSRAM     ),
    .WDATAmi42s4   (WDATA_2_IntSRAM   ),
    .WSTRBmi42s4   (WSTRB_2_IntSRAM   ),
    .WLASTmi42s4   (WLAST_2_IntSRAM   ),
    .WVALIDmi42s4  (WVALID_2_IntSRAM  ),
    .WREADYs42mi4  (WREADY_IntSRAM  ),

    //Write response channel
    .BIDs42mi4     (BID_IntSRAM     ),
    .BRESPs42mi4   (BRESP_IntSRAM   ),
    .BVALIDs42mi4  (BVALID_IntSRAM  ),
    .BREADYmi42s4  (BREADY_2_IntSRAM  ),

    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    .AWIDmi52s5    (AWID_2_default    ),
    .AWADDRmi52s5  (AWADDR_2_default  ),
    .AWLENmi52s5   (AWLEN_2_default   ),
    .AWSIZEmi52s5  (AWSIZE_2_default  ),
    .AWBURSTmi52s5 (AWBURST_2_default ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi52s5 (AWVALID_2_default ),
    .AWREADYs52mi5 (AWREADY_default ),

    //Write data channel
    .WIDmi52s5     (WID_2_default     ),
    .WDATAmi52s5   (WDATA_2_default   ),
    .WSTRBmi52s5   (WSTRB_2_default   ),
    .WLASTmi52s5   (WLAST_2_default   ),
    .WVALIDmi52s5  (WVALID_2_default  ),
    .WREADYs52mi5  (WREADY_default  ),

    //Write response channel
    .BIDs52mi5     (BID_default     ),
    .BRESPs52mi5   (BRESP_default   ),
    .BVALIDs52mi5  (BVALID_default  ),
    .BREADYmi52s5  (BREADY_2_default  ),


    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2wrmi0          (Lock2wrmi0      ),
    .Lock2rdmi0          (Lock2rdmi0      ),
    .UnLock2wrmi0        (UnLock2wrmi0    ),
    .UnLock2rdmi0        (UnLock2rdmi0    ),
    .ARVALIDmi02s0      (ARVALID_2_DDRCtrl   ),
    .LockPort2wrmi0      (LockPort2wrmi0  ),
    .ReadIntEmptyWrmi02Rdmi0     (ReadIntEmptyWrmi02Rdmi0     ),
    .DataCntEmptyRdmi02Wrmi0     (DataCntEmptyRdmi02Wrmi0     ),    
    .CtlDataWrite2Lock0          (CtlDataWrite2Lock0          ),
    
    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2wrmi1          (Lock2wrmi1      ),
    .Lock2rdmi1          (Lock2rdmi1      ),
    .UnLock2wrmi1        (UnLock2wrmi1    ),
    .UnLock2rdmi1        (UnLock2rdmi1    ),
    .ARVALIDmi12s1      (ARVALID_2_APB0   ),
    .LockPort2wrmi1      (LockPort2wrmi1  ),
    .ReadIntEmptyWrmi12Rdmi1     (ReadIntEmptyWrmi12Rdmi1     ),
    .DataCntEmptyRdmi12Wrmi1     (DataCntEmptyRdmi12Wrmi1     ),    
    .CtlDataWrite2Lock1          (CtlDataWrite2Lock1          ),
    
    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2wrmi2          (Lock2wrmi2      ),
    .Lock2rdmi2          (Lock2rdmi2      ),
    .UnLock2wrmi2        (UnLock2wrmi2    ),
    .UnLock2rdmi2        (UnLock2rdmi2    ),
    .ARVALIDmi22s2      (ARVALID_2_APB1   ),
    .LockPort2wrmi2      (LockPort2wrmi2  ),
    .ReadIntEmptyWrmi22Rdmi2     (ReadIntEmptyWrmi22Rdmi2     ),
    .DataCntEmptyRdmi22Wrmi2     (DataCntEmptyRdmi22Wrmi2     ),    
    .CtlDataWrite2Lock2          (CtlDataWrite2Lock2          ),
    
    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2wrmi3          (Lock2wrmi3      ),
    .Lock2rdmi3          (Lock2rdmi3      ),
    .UnLock2wrmi3        (UnLock2wrmi3    ),
    .UnLock2rdmi3        (UnLock2rdmi3    ),
    .ARVALIDmi32s3      (ARVALID_2_SMC   ),
    .LockPort2wrmi3      (LockPort2wrmi3  ),
    .ReadIntEmptyWrmi32Rdmi3     (ReadIntEmptyWrmi32Rdmi3     ),
    .DataCntEmptyRdmi32Wrmi3     (DataCntEmptyRdmi32Wrmi3     ),    
    .CtlDataWrite2Lock3          (CtlDataWrite2Lock3          ),
    
    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2wrmi4          (Lock2wrmi4      ),
    .Lock2rdmi4          (Lock2rdmi4      ),
    .UnLock2wrmi4        (UnLock2wrmi4    ),
    .UnLock2rdmi4        (UnLock2rdmi4    ),
    .ARVALIDmi42s4      (ARVALID_2_IntSRAM   ),
    .LockPort2wrmi4      (LockPort2wrmi4  ),
    .ReadIntEmptyWrmi42Rdmi4     (ReadIntEmptyWrmi42Rdmi4     ),
    .DataCntEmptyRdmi42Wrmi4     (DataCntEmptyRdmi42Wrmi4     ),    
    .CtlDataWrite2Lock4          (CtlDataWrite2Lock4          ),
    
    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2wrmi5          (Lock2wrmi5      ),
    .Lock2rdmi5          (Lock2rdmi5      ),
    .UnLock2wrmi5        (UnLock2wrmi5    ),
    .UnLock2rdmi5        (UnLock2rdmi5    ),
    .ARVALIDmi52s5      (ARVALID_2_default   ),
    .LockPort2wrmi5      (LockPort2wrmi5  ),
    .ReadIntEmptyWrmi52Rdmi5     (ReadIntEmptyWrmi52Rdmi5     ),
    .DataCntEmptyRdmi52Wrmi5     (DataCntEmptyRdmi52Wrmi5     ),    
    .CtlDataWrite2Lock5          (CtlDataWrite2Lock5          ),
    
    
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);


//Read Channel 
//_____________________________________________________________________

ReadChannel 
SBUS_ReadChannel (

    //_______________________________________________________________
    //For Master 0
    //Read address channel
//Disalbe_id_port
    .ARADDRm02si0  (ARADDR_ARM  ),
    .ARLENm02si0   (ARLEN_ARM   ),
    .ARSIZEm02si0  (ARSIZE_ARM  ),
    .ARBURSTm02si0 (ARBURST_ARM ),
    .ARLOCKm02si0  (ARLOCK_ARM  ),
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDm02si0 (ARVALID_ARM ),
    .ARREADYsi02m0 (ARREADY_2_ARM ),

    //Read data channel
//Disalbe_id_port
    .RRESPsi02m0   (RRESP_2_ARM   ),
    .RDATAsi02m0   (RDATA_2_ARM   ),
    .RLASTsi02m0   (RLAST_2_ARM   ),
    .RVALIDsi02m0  (RVALID_2_ARM  ),
    .RREADYm02si0  (RREADY_ARM  ),
    //_______________________________________________________________
    //For Master 1
    //Read address channel
    .ARIDm12si1    (ARID_DisplayCtrl    ),
    .ARADDRm12si1  (ARADDR_DisplayCtrl  ),
    .ARLENm12si1   (ARLEN_DisplayCtrl   ),
    .ARSIZEm12si1  (ARSIZE_DisplayCtrl  ),
    .ARBURSTm12si1 (ARBURST_DisplayCtrl ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDm12si1 (ARVALID_DisplayCtrl ),
    .ARREADYsi12m1 (ARREADY_2_DisplayCtrl ),

    //Read data channel
    .RIDsi12m1     (RID_2_DisplayCtrl     ),
    .RRESPsi12m1   (RRESP_2_DisplayCtrl   ),
    .RDATAsi12m1   (RDATA_2_DisplayCtrl   ),
    .RLASTsi12m1   (RLAST_2_DisplayCtrl   ),
    .RVALIDsi12m1  (RVALID_2_DisplayCtrl  ),
    .RREADYm12si1  (RREADY_DisplayCtrl  ),
    //_______________________________________________________________
    //For Master 2
    //Read address channel
    .ARIDm22si2    (ARID_DMACtrl    ),
    .ARADDRm22si2  (ARADDR_DMACtrl  ),
    .ARLENm22si2   (ARLEN_DMACtrl   ),
    .ARSIZEm22si2  (ARSIZE_DMACtrl  ),
    .ARBURSTm22si2 (ARBURST_DMACtrl ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDm22si2 (ARVALID_DMACtrl ),
    .ARREADYsi22m2 (ARREADY_2_DMACtrl ),

    //Read data channel
    .RIDsi22m2     (RID_2_DMACtrl     ),
    .RRESPsi22m2   (RRESP_2_DMACtrl   ),
    .RDATAsi22m2   (RDATA_2_DMACtrl   ),
    .RLASTsi22m2   (RLAST_2_DMACtrl   ),
    .RVALIDsi22m2  (RVALID_2_DMACtrl  ),
    .RREADYm22si2  (RREADY_DMACtrl  ),

    //_______________________________________________________________
    //For Slave 0
    //Read address channel
    .ARIDmi02s0    (ARID_2_DDRCtrl    ),
    .ARADDRmi02s0  (ARADDR_2_DDRCtrl  ),
    .ARLENmi02s0   (ARLEN_2_DDRCtrl   ),
    .ARSIZEmi02s0  (ARSIZE_2_DDRCtrl  ),
    .ARBURSTmi02s0 (ARBURST_2_DDRCtrl ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi02s0 (ARVALID_2_DDRCtrl ),
    .ARREADYs02mi0 (ARREADY_DDRCtrl ),

    //Read data channel
    .RIDs02mi0     (RID_DDRCtrl     ),
    .RRESPs02mi0   (RRESP_DDRCtrl   ),
    .RDATAs02mi0   (RDATA_DDRCtrl   ),
    .RLASTs02mi0   (RLAST_DDRCtrl   ),
    .RVALIDs02mi0  (RVALID_DDRCtrl  ),
    .RREADYmi02s0  (RREADY_2_DDRCtrl  ),
    //_______________________________________________________________
    //For Slave 1
    //Read address channel
    .ARIDmi12s1    (ARID_2_APB0    ),
    .ARADDRmi12s1  (ARADDR_2_APB0  ),
    .ARLENmi12s1   (ARLEN_2_APB0   ),
    .ARSIZEmi12s1  (ARSIZE_2_APB0  ),
    .ARBURSTmi12s1 (ARBURST_2_APB0 ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi12s1 (ARVALID_2_APB0 ),
    .ARREADYs12mi1 (ARREADY_APB0 ),

    //Read data channel
    .RIDs12mi1     (RID_APB0     ),
    .RRESPs12mi1   (RRESP_APB0   ),
    .RDATAs12mi1   (RDATA_APB0   ),
    .RLASTs12mi1   (RLAST_APB0   ),
    .RVALIDs12mi1  (RVALID_APB0  ),
    .RREADYmi12s1  (RREADY_2_APB0  ),
    //_______________________________________________________________
    //For Slave 2
    //Read address channel
    .ARIDmi22s2    (ARID_2_APB1    ),
    .ARADDRmi22s2  (ARADDR_2_APB1  ),
    .ARLENmi22s2   (ARLEN_2_APB1   ),
    .ARSIZEmi22s2  (ARSIZE_2_APB1  ),
    .ARBURSTmi22s2 (ARBURST_2_APB1 ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi22s2 (ARVALID_2_APB1 ),
    .ARREADYs22mi2 (ARREADY_APB1 ),

    //Read data channel
    .RIDs22mi2     (RID_APB1     ),
    .RRESPs22mi2   (RRESP_APB1   ),
    .RDATAs22mi2   (RDATA_APB1   ),
    .RLASTs22mi2   (RLAST_APB1   ),
    .RVALIDs22mi2  (RVALID_APB1  ),
    .RREADYmi22s2  (RREADY_2_APB1  ),
    //_______________________________________________________________
    //For Slave 3
    //Read address channel
    .ARIDmi32s3    (ARID_2_SMC    ),
    .ARADDRmi32s3  (ARADDR_2_SMC  ),
    .ARLENmi32s3   (ARLEN_2_SMC   ),
    .ARSIZEmi32s3  (ARSIZE_2_SMC  ),
    .ARBURSTmi32s3 (ARBURST_2_SMC ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi32s3 (ARVALID_2_SMC ),
    .ARREADYs32mi3 (ARREADY_SMC ),

    //Read data channel
    .RIDs32mi3     (RID_SMC     ),
    .RRESPs32mi3   (RRESP_SMC   ),
    .RDATAs32mi3   (RDATA_SMC   ),
    .RLASTs32mi3   (RLAST_SMC   ),
    .RVALIDs32mi3  (RVALID_SMC  ),
    .RREADYmi32s3  (RREADY_2_SMC  ),
    //_______________________________________________________________
    //For Slave 4
    //Read address channel
    .ARIDmi42s4    (ARID_2_IntSRAM    ),
    .ARADDRmi42s4  (ARADDR_2_IntSRAM  ),
    .ARLENmi42s4   (ARLEN_2_IntSRAM   ),
    .ARSIZEmi42s4  (ARSIZE_2_IntSRAM  ),
    .ARBURSTmi42s4 (ARBURST_2_IntSRAM ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi42s4 (ARVALID_2_IntSRAM ),
    .ARREADYs42mi4 (ARREADY_IntSRAM ),

    //Read data channel
    .RIDs42mi4     (RID_IntSRAM     ),
    .RRESPs42mi4   (RRESP_IntSRAM   ),
    .RDATAs42mi4   (RDATA_IntSRAM   ),
    .RLASTs42mi4   (RLAST_IntSRAM   ),
    .RVALIDs42mi4  (RVALID_IntSRAM  ),
    .RREADYmi42s4  (RREADY_2_IntSRAM  ),
    //_______________________________________________________________
    //For Slave 5
    //Read address channel
    .ARIDmi52s5    (ARID_2_default    ),
    .ARADDRmi52s5  (ARADDR_2_default  ),
    .ARLENmi52s5   (ARLEN_2_default   ),
    .ARSIZEmi52s5  (ARSIZE_2_default  ),
    .ARBURSTmi52s5 (ARBURST_2_default ),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .ARVALIDmi52s5 (ARVALID_2_default ),
    .ARREADYs52mi5 (ARREADY_default ),

    //Read data channel
    .RIDs52mi5     (RID_default     ),
    .RRESPs52mi5   (RRESP_default   ),
    .RDATAs52mi5   (RDATA_default   ),
    .RLASTs52mi5   (RLAST_default   ),
    .RVALIDs52mi5  (RVALID_default  ),
    .RREADYmi52s5  (RREADY_2_default  ),

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

    .Lock2rdmi0          (Lock2rdmi0          ),
    .Lock2wrmi0          (Lock2wrmi0          ),
    .UnLock2rdmi0        (UnLock2rdmi0        ),
    .UnLock2wrmi0        (UnLock2wrmi0        ),
    .AWVALIDmi02s0      (AWVALID_2_DDRCtrl  ),
    .LockPort2rdmi0      (LockPort2rdmi0      ),
    .ReadIntEmptyWrmi02Rdmi0    (ReadIntEmptyWrmi02Rdmi0    ),
    .DataCntEmptyRdmi02Wrmi0    (DataCntEmptyRdmi02Wrmi0    ),
    .CtlDataRead2Lock0           (CtlDataRead2Lock0           ),

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

    .Lock2rdmi1          (Lock2rdmi1          ),
    .Lock2wrmi1          (Lock2wrmi1          ),
    .UnLock2rdmi1        (UnLock2rdmi1        ),
    .UnLock2wrmi1        (UnLock2wrmi1        ),
    .AWVALIDmi12s1      (AWVALID_2_APB0  ),
    .LockPort2rdmi1      (LockPort2rdmi1      ),
    .ReadIntEmptyWrmi12Rdmi1    (ReadIntEmptyWrmi12Rdmi1    ),
    .DataCntEmptyRdmi12Wrmi1    (DataCntEmptyRdmi12Wrmi1    ),
    .CtlDataRead2Lock1           (CtlDataRead2Lock1           ),

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

    .Lock2rdmi2          (Lock2rdmi2          ),
    .Lock2wrmi2          (Lock2wrmi2          ),
    .UnLock2rdmi2        (UnLock2rdmi2        ),
    .UnLock2wrmi2        (UnLock2wrmi2        ),
    .AWVALIDmi22s2      (AWVALID_2_APB1  ),
    .LockPort2rdmi2      (LockPort2rdmi2      ),
    .ReadIntEmptyWrmi22Rdmi2    (ReadIntEmptyWrmi22Rdmi2    ),
    .DataCntEmptyRdmi22Wrmi2    (DataCntEmptyRdmi22Wrmi2    ),
    .CtlDataRead2Lock2           (CtlDataRead2Lock2           ),

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

    .Lock2rdmi3          (Lock2rdmi3          ),
    .Lock2wrmi3          (Lock2wrmi3          ),
    .UnLock2rdmi3        (UnLock2rdmi3        ),
    .UnLock2wrmi3        (UnLock2wrmi3        ),
    .AWVALIDmi32s3      (AWVALID_2_SMC  ),
    .LockPort2rdmi3      (LockPort2rdmi3      ),
    .ReadIntEmptyWrmi32Rdmi3    (ReadIntEmptyWrmi32Rdmi3    ),
    .DataCntEmptyRdmi32Wrmi3    (DataCntEmptyRdmi32Wrmi3    ),
    .CtlDataRead2Lock3           (CtlDataRead2Lock3           ),

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

    .Lock2rdmi4          (Lock2rdmi4          ),
    .Lock2wrmi4          (Lock2wrmi4          ),
    .UnLock2rdmi4        (UnLock2rdmi4        ),
    .UnLock2wrmi4        (UnLock2wrmi4        ),
    .AWVALIDmi42s4      (AWVALID_2_IntSRAM  ),
    .LockPort2rdmi4      (LockPort2rdmi4      ),
    .ReadIntEmptyWrmi42Rdmi4    (ReadIntEmptyWrmi42Rdmi4    ),
    .DataCntEmptyRdmi42Wrmi4    (DataCntEmptyRdmi42Wrmi4    ),
    .CtlDataRead2Lock4           (CtlDataRead2Lock4           ),

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

    .Lock2rdmi5          (Lock2rdmi5          ),
    .Lock2wrmi5          (Lock2wrmi5          ),
    .UnLock2rdmi5        (UnLock2rdmi5        ),
    .UnLock2wrmi5        (UnLock2wrmi5        ),
    .AWVALIDmi52s5      (AWVALID_2_default  ),
    .LockPort2rdmi5      (LockPort2rdmi5      ),
    .ReadIntEmptyWrmi52Rdmi5    (ReadIntEmptyWrmi52Rdmi5    ),
    .DataCntEmptyRdmi52Wrmi5    (DataCntEmptyRdmi52Wrmi5    ),
    .CtlDataRead2Lock5           (CtlDataRead2Lock5           ),


    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

    //_______________________________________________________________
    //For Slave 0 (lock control signal)

//assign  LockPort2wrmi0 = CtlDataRead2Lock0; 
//assign  LockPort2rdmi0 = CtlDataWrite2Lock0;

    //_______________________________________________________________
    //For Slave 1 (lock control signal)

//assign  LockPort2wrmi1 = CtlDataRead2Lock1; 
//assign  LockPort2rdmi1 = CtlDataWrite2Lock1;

    //_______________________________________________________________
    //For Slave 2 (lock control signal)

//assign  LockPort2wrmi2 = CtlDataRead2Lock2; 
//assign  LockPort2rdmi2 = CtlDataWrite2Lock2;

    //_______________________________________________________________
    //For Slave 3 (lock control signal)

//assign  LockPort2wrmi3 = CtlDataRead2Lock3; 
//assign  LockPort2rdmi3 = CtlDataWrite2Lock3;

    //_______________________________________________________________
    //For Slave 4 (lock control signal)

//assign  LockPort2wrmi4 = CtlDataRead2Lock4; 
//assign  LockPort2rdmi4 = CtlDataWrite2Lock4;

    //_______________________________________________________________
    //For Slave 5 (lock control signal)

//assign  LockPort2wrmi5 = CtlDataRead2Lock5; 
//assign  LockPort2rdmi5 = CtlDataWrite2Lock5;


//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataRead2Lock0 or
         LockPort2wrmi0
        )
begin
    case(CtlDataRead2Lock0)
        2'd0:  LockPort2wrmi0 = 3'd0;
        2'd1:  LockPort2wrmi0 = {1'b1, {2{1'b0}}};
        2'd2:  LockPort2wrmi0 = 3'd1;
        default:  LockPort2wrmi0 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataRead2Lock1 or
         LockPort2wrmi1
        )
begin
    case(CtlDataRead2Lock1)
        1'd0:  LockPort2wrmi1 = 2'd0;
        1'd1:  LockPort2wrmi1 = 2'd1;
        default:  LockPort2wrmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataRead2Lock2 or
         LockPort2wrmi2
        )
begin
    case(CtlDataRead2Lock2)
        1'd0:  LockPort2wrmi2 = 2'd0;
        1'd1:  LockPort2wrmi2 = 2'd1;
        default:  LockPort2wrmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataRead2Lock3 or
         LockPort2wrmi3
        )
begin
    case(CtlDataRead2Lock3)
        2'd0:  LockPort2wrmi3 = 3'd0;
        2'd1:  LockPort2wrmi3 = {1'b1, {2{1'b0}}};
        2'd2:  LockPort2wrmi3 = 3'd1;
        default:  LockPort2wrmi3 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataRead2Lock4 or
         LockPort2wrmi4
        )
begin
    case(CtlDataRead2Lock4)
        2'd0:  LockPort2wrmi4 = 3'd0;
        2'd1:  LockPort2wrmi4 = {1'b1, {2{1'b0}}};
        2'd2:  LockPort2wrmi4 = 3'd1;
        default:  LockPort2wrmi4 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataRead2Lock5 or
         LockPort2wrmi5
        )
begin
    case(CtlDataRead2Lock5)
        2'd0:  LockPort2wrmi5 = 3'd0;
        2'd1:  LockPort2wrmi5 = {1'b1, {2{1'b0}}};
        2'd2:  LockPort2wrmi5 = 3'd1;
        default:  LockPort2wrmi5 = {1'b1, {2{1'b0}}};
    endcase
end

//_______________________________________________________________
//For Slave 0 (lock control signal)
always @(CtlDataWrite2Lock0 or 
         LockPort2rdmi0
        )
begin
    case(CtlDataWrite2Lock0)
        2'd0:  LockPort2rdmi0 = 3'd0;
        2'd1:  LockPort2rdmi0 = 3'd2;
        2'd2:  LockPort2rdmi0 = {1'b1, {2{1'b0}}};
        default:  LockPort2rdmi0 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 1 (lock control signal)
always @(CtlDataWrite2Lock1 or 
         LockPort2rdmi1
        )
begin
    case(CtlDataWrite2Lock1)
        1'd0:  LockPort2rdmi1 = 2'd0;
        1'd1:  LockPort2rdmi1 = 2'd1;
        default:  LockPort2rdmi1 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 2 (lock control signal)
always @(CtlDataWrite2Lock2 or 
         LockPort2rdmi2
        )
begin
    case(CtlDataWrite2Lock2)
        1'd0:  LockPort2rdmi2 = 2'd0;
        1'd1:  LockPort2rdmi2 = 2'd1;
        default:  LockPort2rdmi2 = {1'b1, {1{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 3 (lock control signal)
always @(CtlDataWrite2Lock3 or 
         LockPort2rdmi3
        )
begin
    case(CtlDataWrite2Lock3)
        2'd0:  LockPort2rdmi3 = 3'd0;
        2'd1:  LockPort2rdmi3 = 3'd2;
        2'd2:  LockPort2rdmi3 = {1'b1, {2{1'b0}}};
        default:  LockPort2rdmi3 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 4 (lock control signal)
always @(CtlDataWrite2Lock4 or 
         LockPort2rdmi4
        )
begin
    case(CtlDataWrite2Lock4)
        2'd0:  LockPort2rdmi4 = 3'd0;
        2'd1:  LockPort2rdmi4 = 3'd2;
        2'd2:  LockPort2rdmi4 = {1'b1, {2{1'b0}}};
        default:  LockPort2rdmi4 = {1'b1, {2{1'b0}}};
    endcase
end
//_______________________________________________________________
//For Slave 5 (lock control signal)
always @(CtlDataWrite2Lock5 or 
         LockPort2rdmi5
        )
begin
    case(CtlDataWrite2Lock5)
        2'd0:  LockPort2rdmi5 = 3'd0;
        2'd1:  LockPort2rdmi5 = 3'd2;
        2'd2:  LockPort2rdmi5 = {1'b1, {2{1'b0}}};
        default:  LockPort2rdmi5 = {1'b1, {2{1'b0}}};
    endcase
end

endmodule
