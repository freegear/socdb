// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : PermitCtl.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Advanced mode Permit control block 
//                       from AXI_AdvancedLocked directory 
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  WRCH_ARM_PermitCtl(

    ACLK    ,
    ARESETn ,
    SlaveNum,

    SID,
    AREADY,
    AVALID,

    WID,
    WREADY,
    WVALID,
    WLAST,

    LID,
    LAST, 
    READY,
    RVALID,

    CtlData2datach  ,
    CtlData2writech 
    //Mask2resch

);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 3;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

//Code_START
input   ACLK;
input   ARESETn;
input   AREADY;
input   LAST;
input   AVALID;
input   RVALID;
input   [MASTERID_WID-1:0]    SID;  
input   [MASTERID_WID-1:0]    LID;  
input   [MASTERID_WID-1:0]    WID;  

input   [SLAVE_WID-1:0] SlaveNum;
input   READY;  

output  [SLAVE_WID  :0] CtlData2datach;
output  [SLAVE_WID  :0] CtlData2writech;

input   WREADY;
input   WVALID;
input   WLAST;

//BUFFER 
reg [SLAVE_WID-1:0] ID0SlaveBuffer;
reg [SLAVE_WID-1:0] ID1SlaveBuffer;

reg [WrPermit_SLAVECNTWID-1:0]   ID0SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID1SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]  WIDSlaveCnt; //don't move code




//Arbiter Mask signal
reg     [SLAVE_WID-1:0] WIDSlaveBuffer;

wire    EnWIDSlaveCnt = (WIDSlaveCnt > 0) ? 1'b1 : 1'b0;

//ver 1.9
wire   ID0SlaveCntFull = (ID0SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID1SlaveCntFull = (ID1SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;


//________________________________________________________________________
//Control Data channel 

always  @(
            ID0SlaveBuffer or
            ID1SlaveBuffer or
            WID
        )
begin
    case(WID)
    //synopsys parallel_case full_case
    1'd0:   WIDSlaveBuffer = ID0SlaveBuffer;
    1'd1:   WIDSlaveBuffer = ID1SlaveBuffer;
    endcase
end

//Bug Fixed______2006/7/12
always  @(
            ID0SlaveCnt or
            ID1SlaveCnt or
            WID
        )
begin
    case(WID)
    //synopsys parallel_case full_case
    1'd0:   WIDSlaveCnt = ID0SlaveCnt;
    1'd1:   WIDSlaveCnt = ID1SlaveCnt;
    endcase
end


//________________________________________________________________________

// 2^MASTER_WID -> ID0 ~ ID15
//________________________________________________________________________
//SlaveBuffer update ID0 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID0SlaveBuffer <= 0;
    end
    else
    begin
        if(ID0SlaveCnt == 0 && AVALID)
            ID0SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID1 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID1SlaveBuffer <= 0;
    end
    else
    begin
        if(ID1SlaveCnt == 0 && AVALID)
            ID1SlaveBuffer <= SlaveNum;
    end
end


//________________________________________________________________________
//SlaveCnt
//Enable
wire    ID0EnCNTup = ((SID == 0) && (SlaveNum == ID0SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID1EnCNTup = ((SID == 1) && (SlaveNum == ID1SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID0EnCNTdn =  (LID == 0) ? 1'b1 : 1'b0;
wire    ID1EnCNTdn =  (LID == 1) ? 1'b1 : 1'b0;

//________________________________________________________________________

wire    CNTup = (AREADY & AVALID);
wire    CNTdn = (LAST   & READY & RVALID);

reg     CNTdn_1p;

always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
        CNTdn_1p <= 1'b0;
    else
        CNTdn_1p <= CNTdn;
end


//________________________________________________________________________
//ID0 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID0SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID0EnCNTup & CNTdn & ID0EnCNTdn)
            ID0SlaveCnt <= ID0SlaveCnt;
        else if(CNTup & ID0EnCNTup & !ID0SlaveCntFull)
            ID0SlaveCnt <= ID0SlaveCnt + 1;
        else if(CNTdn & ID0EnCNTdn)
            ID0SlaveCnt <= ID0SlaveCnt - 1;
    end
end

//ID1 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID1SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID1EnCNTup & CNTdn & ID1EnCNTdn)
            ID1SlaveCnt <= ID1SlaveCnt;
        else if(CNTup & ID1EnCNTup & !ID1SlaveCntFull)
            ID1SlaveCnt <= ID1SlaveCnt + 1;
        else if(CNTdn & ID1EnCNTdn)
            ID1SlaveCnt <= ID1SlaveCnt - 1;
    end
end

//________________________________________________________________________


//MUX state

reg     InMUX;

always  @(
            ID0EnCNTup or
            ID1EnCNTup or
            AVALID  
        )
begin
    if(AVALID & (
            ID0EnCNTup |
            ID1EnCNTup  
       ))
        InMUX <= 1'b1;
    else
        InMUX <= 1'b0;
end

//MUX 
reg     [SLAVE_WID-1:0] SIDSlaveBuffer;
//Ver 1.9
reg     SIDSlaveFull;
wire    EnData;
//Ver 1.9
assign  CtlData2writech[SLAVE_WID]     = SIDSlaveFull ? 1'b0 : InMUX; 
assign  CtlData2writech[SLAVE_WID-1:0] = SIDSlaveBuffer;

assign  CtlData2datach[SLAVE_WID-1:0]  = WIDSlaveBuffer[SLAVE_WID-1:0];
assign  CtlData2datach[SLAVE_WID]      = EnData;

reg [2:0]StateWID;
reg [2:0]NxStateWID;


parameter WR_WID = 0,
          HOLD_WID = 1,
          WAIT_WID = 2;

assign  EnData = StateWID[WR_WID];
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        StateWID[WR_WID]    <= 1'b1;
        StateWID[HOLD_WID]  <= 1'b0;
        StateWID[WAIT_WID]  <= 1'b0;
    end
    else
    begin
        StateWID <= NxStateWID;
    end
end

//Ver 1.6 Wdata permit control modified
always @(
            CNTdn_1p or
            EnWIDSlaveCnt or
            WREADY or WVALID or WLAST or
            WID or SID or StateWID
        )
begin
    NxStateWID <= 0;
    case(1'b1)
        
        StateWID[WR_WID]:
            if(WREADY & WVALID & WLAST)
                NxStateWID[HOLD_WID]<= 1'b1;
            else
                NxStateWID[WR_WID]  <= 1'b1;

        StateWID[HOLD_WID]:
            if(CNTdn_1p & EnWIDSlaveCnt)
                NxStateWID[WR_WID]  <= 1'b1;
            else if(CNTdn_1p & !EnWIDSlaveCnt)
                NxStateWID[WAIT_WID]  <= 1'b1;
            else
                NxStateWID[HOLD_WID]<= 1'b1;

        StateWID[WAIT_WID]:
            if(EnWIDSlaveCnt)
                NxStateWID[WR_WID]  <= 1'b1;
            else if(!EnWIDSlaveCnt && (SID==WID))
                NxStateWID[WR_WID]  <= 1'b1;
            else
                NxStateWID[WAIT_WID]  <= 1'b1;

        default:
                NxStateWID[WR_WID]  <= 1'b1;
    endcase
end

always  @(
            ID0SlaveBuffer or
            ID1SlaveBuffer or
            SID
        )
begin
    case(SID)
    //synopsys parallel_case full_case
        1'd0:   SIDSlaveBuffer = ID0SlaveBuffer;
        1'd1:   SIDSlaveBuffer = ID1SlaveBuffer;
    endcase
end

//Ver 1.9
always  @(
            ID0SlaveCntFull or
            ID1SlaveCntFull or
            SID
        )
begin
    case(SID)
    //synopsys parallel_case full_case
        1'd0:   SIDSlaveFull = ID0SlaveCntFull;
        1'd1:   SIDSlaveFull = ID1SlaveCntFull;
    endcase
end


endmodule
