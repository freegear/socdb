// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
// 531 :: Ver 1.2 inserting data channel mask signal  ( WENn )
// Syn 309 :: modify ELAB-292(senstivelist)

`timescale 1 ns/ 10ps
module  APB1_RS_WriteChannelmi(
    
    //Global signal
    ACLK    ,
    ARESETn ,

    //For slave 
    //Write address channel
    AWIDmi2s    ,
    AWADDRmi2s  ,
    AWLENmi2s   ,
    AWSIZEmi2s  ,
    AWBURSTmi2s ,
    AWVALIDmi2s ,
    AWREADYs2mi ,

    //Write data channel
    WIDmi2s     ,
    WDATAmi2s   ,
    WLASTmi2s   ,
    WVALIDmi2s  ,
    WREADYs2mi  ,

    //Write response channel
    BIDs2mi     ,
    BRESPs2mi   ,
    BVALIDs2mi  ,
    BREADYmi2s  ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////


    //Master0
    //Write address channel
    //____________________________________
    AWIDsi02mi    ,
    AWADDRsi02mi  ,
    AWLENsi02mi   ,
    AWSIZEsi02mi  ,
    AWBURSTsi02mi ,
    AWLOCKsi02mi  ,
    AWCACHEsi02mi ,
    AWPROTsi02mi  ,
    //____________________________________
    //Write data channel
    WIDsi02mi   ,     
    WDATAsi02mi ,   
    WSTRBsi02mi , 

    //Master1
    //Write address channel
    //____________________________________
    AWIDsi12mi    ,
    AWADDRsi12mi  ,
    AWLENsi12mi   ,
    AWSIZEsi12mi  ,
    AWBURSTsi12mi ,
    AWLOCKsi12mi  ,
    AWCACHEsi12mi ,
    AWPROTsi12mi  ,
    //____________________________________
    //Write data channel
    WIDsi12mi   ,     
    WDATAsi12mi ,   
    WSTRBsi12mi , 

////////////////////////////
    //____________________________________
    //Write response channel

    BIDmi2si0     ,
    BRESPmi2si0   ,

    BIDmi2si1     ,
    BRESPmi2si1   ,

////////////////////////////
    
    BVALIDmi2si  ,
    BREADYsi2mi,
    //____________________________________
    

//LOCKSig_START
    //Lock control
    //____________________________________
    Lock2Wrmi,
    UnLock2Wrmi,

    Lock2Rdmi,
    UnLock2Rdmi,
    ARVALID,

    LockPort,
    ReadIntEmptyWrmi2Rdmi,
    DataCntEmptyRdmi2Wrmi,
    CtlDataWrite2Lock,
    //____________________________________
//LOCKSig_END

    //Master 0/1/2/3
    AWVALIDsi2mi  ,
    AWREADYmi2si  ,

    //Master 0/1/2/3
    WLASTsi2mi   ,
    WVALIDsi2mi  ,

    //output 1port
    WREADYmi2si  
    );
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 1;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 2;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   ACLK;
    input   ARESETn;

    // For slave 
    // 2s (Slave)
    output   [SLAVEID_WID-1:0]  AWIDmi2s;    
    output   [ADDR_WID-1:0]     AWADDRmi2s;
    output   [AWLEN_WID-1:0]    AWLENmi2s;
    output   [AWSIZE_WID-1:0]   AWSIZEmi2s;  
    output   [AWBURST_WID-1:0]  AWBURSTmi2s; 
    output   AWVALIDmi2s; 
    input    AWREADYs2mi; 
    

    //Write data channel
    output   [SLAVEID_WID-1:0]       WIDmi2s;     
    output   [BUS_WID-1:0]      WDATAmi2s;   
    output   WLASTmi2s;   
    output   WVALIDmi2s;  
    input    WREADYs2mi; 

    //Write response channel
    input   [SLAVEID_WID-1:0]      BIDs2mi;     
    input   [BRESP_WID-1:0]   BRESPs2mi;   
    input   BVALIDs2mi;  
    output  BREADYmi2s;  

    
    //Master0
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi02mi;    
    input   [ADDR_WID-1:0]     AWADDRsi02mi;
    input   [AWLEN_WID-1:0]    AWLENsi02mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi02mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi02mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi02mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi02mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi02mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi02mi;     
    input   [BUS_WID-1:0]  WDATAsi02mi;   
    input   [WSTRB_WID-1:0]WSTRBsi02mi;   
    //__________________________________________________

    
    //Master1
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi12mi;    
    input   [ADDR_WID-1:0]     AWADDRsi12mi;
    input   [AWLEN_WID-1:0]    AWLENsi12mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi12mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi12mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi12mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi12mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi12mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi12mi;     
    input   [BUS_WID-1:0]  WDATAsi12mi;   
    input   [WSTRB_WID-1:0]WSTRBsi12mi;   
    //__________________________________________________

////////////////////////////

    input   [MASTER_NUM-1:0]AWVALIDsi2mi;
    output  [MASTER_NUM-1:0]AWREADYmi2si;

    input   [MASTER_NUM-1:0]WLASTsi2mi;   
    input   [MASTER_NUM-1:0]WVALIDsi2mi;  
    output  [MASTER_NUM-1:0]WREADYmi2si;  

    //Write response channel
    output   [MASTERID_WID-1:0]    BIDmi2si0;     
    output   [BRESP_WID-1:0] BRESPmi2si0;   

    output   [MASTERID_WID-1:0]    BIDmi2si1;     
    output   [BRESP_WID-1:0] BRESPmi2si1;   

////////////////////////////

    output   [MASTER_NUM-1:0]BVALIDmi2si;  
    input    [MASTER_NUM-1:0]BREADYsi2mi;    
    //__________________________________________________


//LOCKSig_START
    //Lock signal
    input    Lock2Wrmi;
    input    UnLock2Wrmi;
    input    ARVALID;
    input    DataCntEmptyRdmi2Wrmi;
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER_WID-1:0]LockPort;
    input    [SELMASTER_WID:0]LockPort;

    output   [SELMASTER_WID-1:0]CtlDataWrite2Lock;
    output   ReadIntEmptyWrmi2Rdmi;

    output   Lock2Rdmi;
    output   UnLock2Rdmi;
//LOCKSig_END


//_______________________________________________
//Register Slice for Address write channel
//RS Number = 0

    //for regiter slince
    wire   [SLAVEID_WID-1:0]  w0AWIDmi2s;    
    wire   [ADDR_WID-1:0]     w0AWADDRmi2s;
    wire   [AWLEN_WID-1:0]    w0AWLENmi2s;
    wire   [AWSIZE_WID-1:0]   w0AWSIZEmi2s;  
    wire   [AWBURST_WID-1:0]  w0AWBURSTmi2s; 
//ENABLE_LOCK
    wire   [AWLOCK_WID-1:0]   w0AWLOCKmi2s;  
//ENABLE_CACHE
    wire   [AWCACHE_WID-1:0]  w0AWCACHEmi2s; 
//ENABLE_PROT
    wire   [AWPROT_WID-1:0]   w0AWPROTmi2s;  

    wire   w0AWVALIDmi2s; 
    wire   w0AWREADYs2mi; 

    //for regiter slince
    wire   [SLAVEID_WID-1:0]  w0WIDmi2s;     
    wire   [BUS_WID-1:0]      w0WDATAmi2s;   
//ENABLE_WSTRB
    wire   [WSTRB_WID-1:0]    w0WSTRBmi2s;   
    wire   w0WLASTmi2s;   
    wire   w0WVALIDmi2s;  
    wire   w0WREADYs2mi; 

    //for regiter slince
    wire   [SLAVEID_WID-1:0] w0BIDs2mi;     
    wire   [BRESP_WID-1:0]   w0BRESPs2mi;   
    wire   w0BVALIDs2mi;  
    wire   w0BREADYmi2s;  


//Mater to Slave interface register slice 
//Number == 0
//_________________________________________
APB1_AWMImi2s_registered
APB1_0_AWMImi2s_registered
(
	.ACLK         (ACLK         ), 
    .ARESETn      (ARESETn      ), 

    .INFORMATION_S({w0AWIDmi2s, 
                    w0AWLENmi2s, 
                    w0AWSIZEmi2s,  
                    w0AWBURSTmi2s, 
                    w0AWADDRmi2s 
                    }),

	.VALID_S      (w0AWVALIDmi2s),
	.READY_S      (w0AWREADYs2mi),

	.INFORMATION_R({ AWIDmi2s, 
                     AWLENmi2s, 
                     AWSIZEmi2s,  
                     AWBURSTmi2s, 
                     AWADDRmi2s 
                    }),

	.VALID_R      ( AWVALIDmi2s),
	.READY_R      ( AWREADYs2mi)
);



APB1_WDMImi2s_registered
APB1_0_WDMImi2s_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 
		.INFORMATION_R({ WIDmi2s,
                         WDATAmi2s,
                         WLASTmi2s
                        }),

		.VALID_R      ( WVALIDmi2s),
		.READY_R      ( WREADYs2mi),

		.INFORMATION_S({w0WIDmi2s,
                        w0WDATAmi2s,
                        w0WLASTmi2s
                        }),

		.VALID_S      (w0WVALIDmi2s),
		.READY_S      (w0WREADYs2mi)
);


APB1_WRMImi2s_registered
APB1_0_WRMImi2s_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 
		.INFORMATION_R({w0BIDs2mi, w0BRESPs2mi}), 

		.VALID_R      (w0BVALIDs2mi),
		.READY_R      (w0BREADYmi2s),
        
		.INFORMATION_S({ BIDs2mi,  BRESPs2mi}),

		.VALID_S      ( BVALIDs2mi),
		.READY_S      ( BREADYmi2s)
);


//////////////////////////////////////////////////

//////////////////////////////////////////////////


//Master module     
//__________________________________________________

APB1_WriteChannelmi
APB1_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK    ),
    .ARESETn (ARESETn ),

    //For slave 
    //Write address channel
    .AWIDmi2s    (w0AWIDmi2s    ),
    .AWADDRmi2s  (w0AWADDRmi2s  ),
    .AWLENmi2s   (w0AWLENmi2s   ),
    .AWSIZEmi2s  (w0AWSIZEmi2s  ),
    .AWBURSTmi2s (w0AWBURSTmi2s ),
    .AWLOCKmi2s(), //Disable_lock_port
    .AWCACHEmi2s (), //Disalbe_cache_port
    .AWPROTmi2s  (), //Disalbe_protect_port

    .AWVALIDmi2s (w0AWVALIDmi2s ),
    .AWREADYs2mi (w0AWREADYs2mi ),

    //Write data channel
    .WIDmi2s     (w0WIDmi2s     ),
    .WDATAmi2s   (w0WDATAmi2s   ),
    .WSTRBmi2s   (), //Disalbe_WSTRB_port
    .WLASTmi2s   (w0WLASTmi2s   ),
    .WVALIDmi2s  (w0WVALIDmi2s  ),
    .WREADYs2mi  (w0WREADYs2mi  ),

    //Write response channel
    .BIDs2mi     (w0BIDs2mi     ),
    .BRESPs2mi   (w0BRESPs2mi   ),
    .BVALIDs2mi  (w0BVALIDs2mi  ),
    .BREADYmi2s  (w0BREADYmi2s  ),

    //Slave interface signal
    //Master 0/1/2/3
    .AWVALIDsi2mi  ( AWVALIDsi2mi  ),
    .AWREADYmi2si  ( AWREADYmi2si  ),

    //Master 0/1/2/3
    .WLASTsi2mi   ( WLASTsi2mi   ),
    .WVALIDsi2mi  ( WVALIDsi2mi  ),

    //output 1port
    .WREADYmi2si  ( WREADYmi2si  ),

    .BVALIDmi2si  ( BVALIDmi2si  ),
    .BREADYsi2mi  ( BREADYsi2mi),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 0
    //Write address channel
    .AWIDsi02mi    ( AWIDsi02mi    ),
    .AWADDRsi02mi  ( AWADDRsi02mi  ),
    .AWLENsi02mi   ( AWLENsi02mi   ),
    .AWSIZEsi02mi  ( AWSIZEsi02mi  ),
    .AWBURSTsi02mi ( AWBURSTsi02mi ),
//Disalbe_LockPortWriteChannel(slave)
    .AWLOCKsi02mi  ({AWLOCK_WID{1'b0}} ),
//Disalbe_CachePortWriteChannel(slave)
    .AWCACHEsi02mi ({AWCACHE_WID{1'b0}} ),
//Disalbe_ProtectPortWriteChannel(slave)
    .AWPROTsi02mi  ({AWPROT_WID{1'b0}} ),

    //Write data channel
    .WIDsi02mi   ( WIDsi02mi   ),     
    .WDATAsi02mi ( WDATAsi02mi ),   
//Disalbe_WSTRBPortWriteChannel(slave)
    .WSTRBsi02mi   ({WSTRB_WID{1'b1}} ),

    //Write response channel
    .BIDmi2si0     ( BIDmi2si0     ),
    .BRESPmi2si0   ( BRESPmi2si0   ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 1
    //Write address channel
    .AWIDsi12mi    ( AWIDsi12mi    ),
    .AWADDRsi12mi  ( AWADDRsi12mi  ),
    .AWLENsi12mi   ( AWLENsi12mi   ),
    .AWSIZEsi12mi  ( AWSIZEsi12mi  ),
    .AWBURSTsi12mi ( AWBURSTsi12mi ),
//Disalbe_LockPortWriteChannel(slave)
    .AWLOCKsi12mi  ({AWLOCK_WID{1'b0}} ),
//Disalbe_CachePortWriteChannel(slave)
    .AWCACHEsi12mi ({AWCACHE_WID{1'b0}} ),
//Disalbe_ProtectPortWriteChannel(slave)
    .AWPROTsi12mi  ({AWPROT_WID{1'b0}} ),

    //Write data channel
    .WIDsi12mi   ( WIDsi12mi   ),     
    .WDATAsi12mi ( WDATAsi12mi ),   
//Disalbe_WSTRBPortWriteChannel(slave)
    .WSTRBsi12mi   ({WSTRB_WID{1'b1}} ),

    //Write response channel
    .BIDmi2si1     ( BIDmi2si1     ),
    .BRESPmi2si1   ( BRESPmi2si1   ),

////////////////////////////

    //Lock control
    .Lock2Wrmi(Lock2Wrmi),
    .UnLock2Wrmi(UnLock2Wrmi),

    .Lock2Rdmi(Lock2Rdmi),
    .UnLock2Rdmi(UnLock2Rdmi),

    .ARVALID(ARVALID),

    .LockPort(LockPort),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi2Rdmi),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi2Wrmi),
    .CtlDataWrite2Lock    (CtlDataWrite2Lock    )
    );
endmodule
//STATE_END
