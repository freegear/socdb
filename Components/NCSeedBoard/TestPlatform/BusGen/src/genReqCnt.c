
#include <stdio.h>
#include "Bus.h"
#include "genReqCnt.h"
#include "genDef.h"
#include "MkFile.h"

const char *HeaderReqCnt = {" \
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n \
// File Name           : ReqCnt.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Counting the request in Read Master \n\
//                       interface block\n\
//  ----------------------------------------------------------------\n"};


const char *HeaderLock = {" \
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n \
// File Name           : LockCtl ??.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Lock control signal generation \n\
//                       \n\
//  ----------------------------------------------------------------\n"};


unsigned int genReqCnt(char *OutFileName, DefSlave *VAL_SLAVE)
{

    FILE *Fp;
    char *fileName = "./dataSample/ReqCnt/InOutPart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i;

    buff = (char *)malloc(sizeof(char)*80);

    head_ptr = (struct codeLine *)malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);

    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ InOutPort
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);
        inDataLink(head_ptr, buff);
        if(strcmp(buff,");\n")==0) 
            break;
    }

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Def

    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }

    //__________________________________________________________ Open
    fileName = "./dataSample/ReqCnt/CodePart.v";
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff, buff, "RQCNT_WID","Rd_REQDEPTH_WID");
        inDataLink(head_ptr, buff);
        if(strcmp(buff,"endmodule\n")==0) 
            break;
    }


    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr,HeaderReqCnt,  OutFileName);

    free(buff);
    return 0;
}



unsigned int genLockCtl(char *OutFileName, 
                        DefSlave *VAL_SLAVE, int SlaveMaster)
{

    FILE *Fp;
    char *fileName;
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i;

    buff = (char *)malloc(sizeof(char)*80);
    fileName = (char *)malloc(sizeof(char)*200);

    head_ptr = (struct codeLine *)malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);

    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    if(SlaveMaster == 0)  // Read part
        strcpy(fileName ,"./dataSample/LockCtl/InOutPart_RD.v");
    else
        strcpy(fileName ,"./dataSample/LockCtl/InOutPart_WR.v");


    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ InOutPort
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);
        inDataLink(head_ptr, buff);
        if(strcmp(buff,");\n")==0) 
            break;
    }

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Def

    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }

    //__________________________________________________________ Open
    
    if(SlaveMaster == 0)  // Read part
        strcpy(fileName ,"./dataSample/LockCtl/CodePart_RD.v");
    else
        strcpy(fileName ,"./dataSample/LockCtl/CodePart_WR.v");

    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff, buff, "RQCNT_WID","Rd_REQDEPTH_WID");
        inDataLink(head_ptr, buff);
        if(strcmp(buff,"endmodule\n")==0) 
            break;
    }


    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr,HeaderLock,  OutFileName);

    free(buff);
    return 0;
}
