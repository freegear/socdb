
#include <stdio.h>
#include "Bus.h"
#include "genDef.h"
#include "MkFile.h"
#include "genBusTop.h"


const char *HeaderBusTop = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : BUSTOP.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : BUS TOP Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};


const char *HeaderTestbench = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : tb.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : bus test bench block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};


unsigned int genIntSRAMController(char *OutFileName, DefSlave *VAL_SLAVE) 
{
    FILE *Fp;
    char *fileName = "./dataSample/TestBench/IntSRAMController.v";
    char *buff;
    char *Name;
    int  endi;
    struct codeLine *head_ptr = NULL;
    int i,j,k;
    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable;

    Name = (char *)malloc(sizeof(char) *120);
    buff = (char *)malloc(sizeof(char) *120);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START\n");

    strcpy(Name, VAL_SLAVE->name);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(Name);
        return FILE_PROCESS_ERROR;
    }

    LockEnable      = VAL_SLAVE->WriteChPort.LockEnable;
    CacheEnable     = VAL_SLAVE->WriteChPort.CacheEnable;
    ProtectEnable   = VAL_SLAVE->WriteChPort.ProtectEnable;
    WstrbEnable     = VAL_SLAVE->WriteChPort.WstrbEnable;

    j = 0;
    while(1)
    {
        fgets(buff, (sizeof(char)*120), Fp);

        while(changeStr(buff,buff, "?NAME?", Name)==1);

        if(strcmp(buff, STATE_END) == 0) break;


        if(strcmp(buff,"//ENABLE_LOCK\n")==0) 
        {

            if(LockEnable == ENABLE) 
            {
                fgets(buff, (sizeof(char)*120), Fp);
            }
            else 
            {
                fgets(buff, (sizeof(char)*120), Fp);
                sprintf(buff,"//Disable lock port\n");
            }
        }

        if(strcmp(buff,"//ENABLE_CACHE\n")==0) 
        {
            if(CacheEnable== ENABLE) 
            {
                fgets(buff, (sizeof(char)*120), Fp);
            }
            else 
            {
                fgets(buff, (sizeof(char)*120), Fp);
                sprintf(buff,"//Disable cache port\n");
            }
        }

        if(strcmp(buff,"//ENABLE_PROT\n")==0) 
        {
            if(ProtectEnable   == ENABLE) 
            {
                fgets(buff, (sizeof(char)*120), Fp);
            }
            else 
            {
                fgets(buff, (sizeof(char)*120), Fp);
                sprintf(buff,"//Disable protect port\n");
            }

            if(j == 1)
            {
                LockEnable      = VAL_SLAVE->WriteChPort.LockEnable;
                CacheEnable     = VAL_SLAVE->WriteChPort.CacheEnable;
                ProtectEnable   = VAL_SLAVE->WriteChPort.ProtectEnable;
                WstrbEnable     = VAL_SLAVE->WriteChPort.WstrbEnable;
            }
        }

        if(strcmp(buff,"//ENABLE_WSTRB\n")==0) 
        {
            LockEnable      = VAL_SLAVE->ReadChPort.LockEnable;
            CacheEnable     = VAL_SLAVE->ReadChPort.CacheEnable;
            ProtectEnable   = VAL_SLAVE->ReadChPort.ProtectEnable;

            if(WstrbEnable  == ENABLE) 
            {
                j++;
                fgets(buff, (sizeof(char)*120), Fp);
            }
            else if(j == 0)
            {
                j++;
                fgets(buff, (sizeof(char)*120), Fp);
                sprintf(buff,"//Disable Wstrb\n");
            }
            else if(j == 1)
            {
                j++;
                fgets(buff, (sizeof(char)*120), Fp);
                sprintf(buff,"//Disable Wstrb\n");
                sprintf(buff,"wire  [NUM_BYTE-1:0]   WSTRB = {NUM_BYTE{1'b1}};\n");
            }
        }

        inDataLink(head_ptr, buff);
    }

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(Name);
        return FILE_PROCESS_ERROR;
    }


    free(buff);
    free(Name);
    fprintLink(head_ptr, NULL ,  OutFileName);

    return BUS_ERROR_NONE;
}

#if 1
// check == 0  :: read channel
// check == 1  :: write channel
void bulkTestMaster(struct codeLine *head_ptr, int check, int number)
{
    char *bnum;
    bnum = (char *)malloc(sizeof(char) * 120);

    if(check == 0) //slave bulk protocol checker
    {
        sprintf(bnum,"   .ARID         (),\n");
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .ARADDR       (),\n");

        inDataLink(head_ptr, "   .ARLEN        (),\n");
        inDataLink(head_ptr, "   .ARSIZE       (),\n");
        inDataLink(head_ptr, "   .ARBURST      (),\n");
        inDataLink(head_ptr, "   .ARLOCK       (),\n");
        inDataLink(head_ptr, "   .ARCACHE      (),\n");
        inDataLink(head_ptr, "   .ARPROT       (),\n");
        inDataLink(head_ptr, "   .ARVALID      (),\n");
        inDataLink(head_ptr, "   .ARREADY      (1'b0 ),\n");

        inDataLink(head_ptr, "   // Read Channel\n");
        sprintf(bnum, "   .RID         ({READCHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .RLAST        (1'b0),\n");
        inDataLink(head_ptr, "   .RDATA        ({BUS_WID{1'b0}}),\n");
        inDataLink(head_ptr, "   .RRESP        ({RRESP_WID{1'b0}}),\n");
        inDataLink(head_ptr, "   .RVALID       (1'b0),\n");
        inDataLink(head_ptr, "   .RREADY       (),\n");

    }              //master bulk protocol checker
    else
    {
        inDataLink(head_ptr, "   // Write Address Channel\n");
        sprintf(bnum,"   .AWID      (),\n");
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .AWADDR    (),\n");
        inDataLink(head_ptr, "   .AWLEN     (),\n");
        inDataLink(head_ptr, "   .AWSIZE    (),\n");
        inDataLink(head_ptr, "   .AWBURST   (),\n");
        inDataLink(head_ptr, "   .AWLOCK    (),\n");
        inDataLink(head_ptr, "   .AWCACHE   (),\n");
        inDataLink(head_ptr, "   .AWPROT    (),\n");
        inDataLink(head_ptr, "   .AWVALID   (),\n");
        inDataLink(head_ptr, "   .AWREADY   (1'b0 ),\n");

        inDataLink(head_ptr, "   // Write Channel\n");
        sprintf(bnum,"   .WID       (),\n");
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .WLAST       (),\n");
        inDataLink(head_ptr, "   .WDATA       (),\n");
        inDataLink(head_ptr, "   .WSTRB       (),\n");
        inDataLink(head_ptr, "   .WVALID      (),\n");
        inDataLink(head_ptr, "   .WREADY      (1'b0 ),\n");

        inDataLink(head_ptr, "   // Write Response Channel\n");
        sprintf(bnum,"   .BID         ({WRITECHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .BRESP        ({BRESP_WID{1'b0}}   ),\n");   
        inDataLink(head_ptr, "   .BVALID       (1'b0  ),\n");
        inDataLink(head_ptr, "   .BREADY       (),\n");

    }

    free(bnum);
}
#endif


// check == 0  :: read channel
// check == 1  :: write channel
void bulkPC(struct codeLine *head_ptr, int check, int number)
{
    char *bnum;
    bnum = (char *)malloc(sizeof(char) * 120);

    if(check == 0) //slave bulk protocol checker
    {
        sprintf(bnum,"   .ARID         ({READCHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .ARADDR       ({ADDR_WID{1'b0}}),\n");

        inDataLink(head_ptr, "   .ARLEN        ({AWLEN_WID{1'b0}}),\n");
        inDataLink(head_ptr, "   .ARSIZE       ({ARSIZE_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .ARBURST      ({ARBURST_WID{1'b0}} ),\n");
        inDataLink(head_ptr, "   .ARLOCK       ({ARLOCK_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .ARCACHE      ({ARCACHE_WID{1'b0}} ),\n");
        inDataLink(head_ptr, "   .ARPROT       ({ARPROT_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .ARUSER       ({32{1'b0}}),\n");
        inDataLink(head_ptr, "   .ARVALID      (1'b0 ),\n");
        inDataLink(head_ptr, "   .ARREADY      (1'b0 ),\n");

        inDataLink(head_ptr, "   // Read Channel\n");
        sprintf(bnum, "   .RID         ({READCHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .RLAST        (1'b0),\n");
        inDataLink(head_ptr, "   .RDATA        ({BUS_WID{1'b0}}),\n");
        inDataLink(head_ptr, "   .RRESP        ({RRESP_WID{1'b0}}),\n");
        inDataLink(head_ptr, "   .RUSER        ({32{1'b0}}),\n");
        inDataLink(head_ptr, "   .RVALID       (1'b0),\n");
        inDataLink(head_ptr, "   .RREADY       (1'b0),\n");

    }              //master bulk protocol checker
    else
    {
        inDataLink(head_ptr, "   // Write Address Channel\n");
        sprintf(bnum,"   .AWID      ({WRITECHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .AWADDR    ({ADDR_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .AWLEN     ({AWLEN_WID{1'b0}}   ),\n");
        inDataLink(head_ptr, "   .AWSIZE    ({AWSIZE_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .AWBURST   ({AWBURST_WID{1'b0}} ),\n");
        inDataLink(head_ptr, "   .AWLOCK    ({AWLOCK_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .AWCACHE   ({AWCACHE_WID{1'b0}} ),\n");
        inDataLink(head_ptr, "   .AWPROT    ({AWPROT_WID{1'b0}}  ),\n");
        inDataLink(head_ptr, "   .AWUSER    ({32{1'b0}}),\n");
        inDataLink(head_ptr, "   .AWVALID   (1'b0 ),\n");
        inDataLink(head_ptr, "   .AWREADY   (1'b0 ),\n");

        inDataLink(head_ptr, "   // Write Channel\n");
        sprintf(bnum,"   .WID       ({WRITECHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .WLAST       (1'b0   ),\n");
        inDataLink(head_ptr, "   .WDATA       ({BUS_WID{1'b0}}   ),\n");
        inDataLink(head_ptr, "   .WSTRB       ({WSTRB_WID{1'b1}}   ),\n");
        inDataLink(head_ptr, "   .WUSER       ({32{1'b0}}),\n");
        inDataLink(head_ptr, "   .WVALID      (1'b0  ),\n");
        inDataLink(head_ptr, "   .WREADY      (1'b0  ),\n");

        inDataLink(head_ptr, "   // Write Response Channel\n");
        sprintf(bnum,"   .BID         ({WRITECHID%d_WID{1'b0}}),\n", number);
        inDataLink(head_ptr, bnum);
        inDataLink(head_ptr, "   .BRESP        ({BRESP_WID{1'b0}}   ),\n");   
        inDataLink(head_ptr, "   .BUSER        ({32{1'b0}}),\n");
        inDataLink(head_ptr, "   .BVALID       (1'b0  ),\n");
        inDataLink(head_ptr, "   .BREADY       (1'b0  ),\n");

    }

    free(bnum);
}

unsigned int mkTBusModule(FILE *Fp, 
                          struct codeLine *head_ptr, 
                          int SlaveMaster)
{
    char *buff;
    char *Name;
    int  i, j, k, endMasterBuff, part_a, part_b, part_c; 
    int  middleMasterBuff;
    int  Start_j, End_j;
    int  endi;
    int  LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;
    int  WIDEnable, RIDEnable, ARIDEnable ;

    buff     = (char *)malloc(sizeof(char) *120);
    Name     = (char *)malloc(sizeof(char) *120);

    char BuffMaster[100][120];
    int WriteReadSW_Flag = 0;

    //////////////////////////////////////////////////////

   if(SlaveMaster == 0)       //Write channel Slave
    {
        endi = (int)ValMAIN.SlaveNumber+1;
    }
    else if(SlaveMaster == 1) //Write Channel Master
    {
        endi = (int)ValMAIN.MasterNumber;
    }
    else if(SlaveMaster == 10) //Read Channel Slave
    {
        endi = (int)ValMAIN.SlaveNumber+1;
    }
    else if(SlaveMaster == 11) //Read Channel Master
    {
        endi = (int)ValMAIN.MasterNumber;
    }

/****************************************************************

        SlaveMaster == 3 :: master mode
                1. Write channel mode 
                2. Read channel  mode{//ENABLE_WSTRB}

        SlaveMaster == 4 :: slave mode
                1. Write channel mode 
                2. Read  channel mode {//ENABLE_WSTRB}


        SlaveMaster == 5 :: master bulk input mode
                1. Write channel mode 
                2. Read  channel mode {//ENABLE_WSTRB}

        SlaveMaster == 6 :: slave bulk input mode
                1. Write channel mode 
                2. Read  channel mode {//ENABLE_WSTRB}

example>>>______________________________________________________
   
   .AWLOCK(AWLOCK_2_?NAME?  ),  --> enable
                                   .AWLOCK(AWLOCK_2_?NAME?),
                                --> disable
                                   .AWLOCK(0),
________________________________________________________________


        SlaveMaster == 7 ::Slave Writechannel mode without default slave
        SlaveMaster == 8 ::Slave Readchannel mode without default slave

        SlaveMaster == 9 :: default slave generation

        SlaveMaster == 20 :: Slave channel without default slave


        SlaveMaster == 30 :: master mode (bulk input for testmater)
                1. Write channel mode 
                2. Read channel  mode{//ENABLE_WSTRB}

****************************************************************/
    


    else if(SlaveMaster == 4 || SlaveMaster == 6) //Slave
    {
        endi = (int)ValMAIN.SlaveNumber+1;
    }
    else if(SlaveMaster == 3 || 
            SlaveMaster == 5 ||
            SlaveMaster == 30
           ) 
                                                  //Master
    {
        endi = (int)ValMAIN.MasterNumber;
    }
    else if(SlaveMaster == 7) //Slave WriteChannel without default slave
        endi = (int)ValMAIN.SlaveNumber;
    else if(SlaveMaster == 8) //Slave ReadChannel without default slave
        endi = (int)ValMAIN.SlaveNumber;
    else if(SlaveMaster == 9) //default slave
        endi = (int)ValMAIN.SlaveNumber;
    else if(SlaveMaster == 20)// Slave mode without default slave
        endi = (int)ValMAIN.SlaveNumber;


    endMasterBuff = 0;
    while(1)
    {
        fgets(BuffMaster[endMasterBuff], sizeof(char) * 120, Fp);

        if(strcmp(BuffMaster[endMasterBuff], "//PART_A\n") == 0)
        {
            part_a = endMasterBuff;
            strcpy(BuffMaster[endMasterBuff], "\n");
        }
        else if(strcmp(BuffMaster[endMasterBuff], "//PART_B\n") == 0)
        {
            part_b = endMasterBuff;
            strcpy(BuffMaster[endMasterBuff], "\n");
        }
        else if(strcmp(BuffMaster[endMasterBuff], "//PART_C\n") == 0)
        {
            part_c = endMasterBuff;
            strcpy(BuffMaster[endMasterBuff], "\n");
        }
        else if(strcmp(BuffMaster[endMasterBuff], "//END_CH\n") == 0)
        {
            middleMasterBuff = endMasterBuff;
            strcpy(BuffMaster[endMasterBuff], " \n");
        }


        if(strcmp(BuffMaster[endMasterBuff], STATE_END) == 0) break;
        endMasterBuff++;
    }
    for(i=0; endi >i; i++)
    {
        char ReqNum[4];
        sprintf(ReqNum, "%d", i);

        if(SlaveMaster == 0 )      //Write Channel Slave
        {
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        } 
        else if(SlaveMaster == 1 ) //Write Channel Master
        {
            strcpy(Name, ValMASTER[i].name);
            IDEnable        = ValMASTER[i].WriteChPort.IDEnable;
            WIDEnable       = ValMASTER[i].WriteChPort.IDEnable;
            RIDEnable       = ValMASTER[i].ReadChPort.IDEnable;
            ARIDEnable      = ValMASTER[i].ReadChPort.IDEnable;
            LockEnable      = ValMASTER[i].WriteChPort.LockEnable;
            CacheEnable     = ValMASTER[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValMASTER[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValMASTER[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;

            //2006-9-1-Channel_disable_start
            if(ValMASTER[i].WriteChPort.ChannelEnable != ENABLE)
            {
            //______________________________
                Start_j = middleMasterBuff;
                End_j   = endMasterBuff;
            }// 2006-9-1-Channel_disable_end

        }
        else if(SlaveMaster == 10) //Read Channel Slave
        {
            strcpy(Name, ValSLAVE[i].name);
            LockEnable = ValSLAVE[i].ReadChPort.LockEnable;
            CacheEnable = ValSLAVE[i].ReadChPort.CacheEnable;
            ProtectEnable = ValSLAVE[i].ReadChPort.ProtectEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 11) //Read Channel Master
        {
            strcpy(Name, ValMASTER[i].name);
            IDEnable        = ValMASTER[i].ReadChPort.IDEnable;
            WIDEnable       = ValMASTER[i].WriteChPort.IDEnable;
            RIDEnable       = ValMASTER[i].ReadChPort.IDEnable;
            ARIDEnable      = ValMASTER[i].ReadChPort.IDEnable;
            LockEnable      = ValMASTER[i].ReadChPort.LockEnable;
            CacheEnable     = ValMASTER[i].ReadChPort.CacheEnable;
            ProtectEnable   = ValMASTER[i].ReadChPort.ProtectEnable;
            Start_j = 0; End_j = endMasterBuff;

            //2006-9-1-Channel_disable_start
            if(ValMASTER[i].ReadChPort.ChannelEnable != ENABLE)
            {
            //______________________________
                Start_j = middleMasterBuff;
                End_j   = endMasterBuff;
            }// 2006-9-1-Channel_disable_end
        }
        else if(SlaveMaster == 3 || SlaveMaster == 30) 
                                  //SlaveInterface(master)
                                  //Master 1. write channel
        {                         //       2. read channel
            strcpy(Name, ValMASTER[i].name);
            IDEnable        = ValMASTER[i].WriteChPort.IDEnable;
            WIDEnable       = ValMASTER[i].WriteChPort.IDEnable;
            RIDEnable       = ValMASTER[i].ReadChPort.IDEnable;
            ARIDEnable      = ValMASTER[i].ReadChPort.IDEnable;
            LockEnable      = ValMASTER[i].WriteChPort.LockEnable;
            CacheEnable     = ValMASTER[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValMASTER[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValMASTER[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 5)  //SlaveInterface(master)
                                   //Protocol checker
        {
            strcpy(Name, ValMASTER[i].name);
            IDEnable        = ValMASTER[i].WriteChPort.IDEnable;
            WIDEnable       = ValMASTER[i].WriteChPort.IDEnable;
            RIDEnable       = ValMASTER[i].ReadChPort.IDEnable;
            ARIDEnable      = ValMASTER[i].ReadChPort.IDEnable;
            LockEnable      = ValMASTER[i].WriteChPort.LockEnable;
            CacheEnable     = ValMASTER[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValMASTER[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValMASTER[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 4) //MasterInterface(Slave)
                                  //Slave  1. write channel
        {                         //       2. read channel
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 6) //MasterInterface(Slave) 
                                  //Slave  1. write channel
        {                         //       2. read channel
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }

        else if(SlaveMaster == 7) //Slave WriteChannel without default slave
        {
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 8) //Slave ReadChannel without default slave
        {
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].ReadChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].ReadChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].ReadChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].ReadChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 9) //for default slave
        {
            i = endi;
            sprintf(ReqNum, "%d", i);
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }
        else if(SlaveMaster == 20)
        {
            strcpy(Name, ValSLAVE[i].name);
            LockEnable      = ValSLAVE[i].WriteChPort.LockEnable;
            CacheEnable     = ValSLAVE[i].WriteChPort.CacheEnable;
            ProtectEnable   = ValSLAVE[i].WriteChPort.ProtectEnable;
            WstrbEnable     = ValSLAVE[i].WriteChPort.WstrbEnable;
            Start_j = 0; End_j = endMasterBuff;
        }

        WriteReadSW_Flag  = 0;
        //for(j=0; endMasterBuff >j ; j++)
        for(j=Start_j; End_j >j ; j++)
        {
#if 1
            //Add 2006-9-4-Channel disable
            if(SlaveMaster == 5) // PC
            {
                if((ValMASTER[i].WriteChPort.ChannelEnable != ENABLE) &&
                   (j == part_a)
                  )
                {
                    WriteReadSW_Flag  = 1;
                    j = part_b;
                    RIDEnable     = ValMASTER[i].ReadChPort.IDEnable;
                    ARIDEnable    = ValMASTER[i].ReadChPort.IDEnable;
                    IDEnable      = ValMASTER[i].ReadChPort.IDEnable;
                    WIDEnable     = ValMASTER[i].WriteChPort.IDEnable;
                    LockEnable    = ValMASTER[i].ReadChPort.LockEnable;
                    CacheEnable   = ValMASTER[i].ReadChPort.CacheEnable;
                    ProtectEnable = ValMASTER[i].ReadChPort.ProtectEnable;
                    bulkPC(head_ptr,  1, i); // Writechennel bulk PC
                }

                else if((ValMASTER[i].ReadChPort.ChannelEnable != ENABLE) &&
                   (j == part_b)
                  )
                {
                    j = part_c;
                    bulkPC(head_ptr,  0, i); // Readchennel bulk PC
                }
            }


            if(SlaveMaster == 3) // Master (Write and read channel)
            {
                if((ValMASTER[i].WriteChPort.ChannelEnable != ENABLE) &&
                   (j == part_a)
                  )
                {
                    IDEnable      = ValMASTER[i].ReadChPort.IDEnable;
                    RIDEnable     = ValMASTER[i].ReadChPort.IDEnable;
                    WIDEnable     = ValMASTER[i].WriteChPort.IDEnable;
                    ARIDEnable    = ValMASTER[i].ReadChPort.IDEnable;
                    LockEnable    = ValMASTER[i].ReadChPort.LockEnable;
                    CacheEnable   = ValMASTER[i].ReadChPort.CacheEnable;
                    ProtectEnable = ValMASTER[i].ReadChPort.ProtectEnable;
                    j = part_b;
                }

                else if((ValMASTER[i].ReadChPort.ChannelEnable != ENABLE) &&
                   (j == part_b)
                  )
                {
                    j = part_c;
                }
            }

            if(SlaveMaster == 30) // Master (Bulk input)
            {
                if((ValMASTER[i].WriteChPort.ChannelEnable != ENABLE) &&
                   (j == part_a)
                  )
                {
                    j = part_b;
                    RIDEnable     = ValMASTER[i].ReadChPort.IDEnable;
                    ARIDEnable    = ValMASTER[i].ReadChPort.IDEnable;
                    IDEnable      = ValMASTER[i].ReadChPort.IDEnable;
                    WIDEnable     = ValMASTER[i].WriteChPort.IDEnable;
                    LockEnable    = ValMASTER[i].ReadChPort.LockEnable;
                    CacheEnable   = ValMASTER[i].ReadChPort.CacheEnable;
                    ProtectEnable = ValMASTER[i].ReadChPort.ProtectEnable;

                    // Writechennel bulk TestMaster
                    bulkTestMaster(head_ptr,  1, i); 
                }

                else if((ValMASTER[i].ReadChPort.ChannelEnable != ENABLE) &&
                   (j == part_b)
                  )
                {
                    j = part_c;
                    // Readchennel bulk TestMaster
                    bulkTestMaster(head_ptr,  0, i); 
                }
            }

#endif
            //Add 2006-8-18-port disable______________start
            if(strcmp(BuffMaster[j],"//ENABLE_ID\n") == 0)
            {
                if(IDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                /*
                else 
                {
                    j=j+2; 
                    if( WriteReadSW_Flag  == 0) // Write channel
                        inDataLink(head_ptr, ".AWID(1'd0),\n");
                    else                        // Read channel
                        inDataLink(head_ptr, ".ARID(1'd0),\n");
                }
                */
            }


            if(strcmp(BuffMaster[j],"//ENABLE_AW_ID\n") == 0)
            {
                if(WIDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                else 
                {
                    j=j+2; 
                    inDataLink(head_ptr, "   .AWID(1'd0),\n");
                }
            }
            if(strcmp(BuffMaster[j],"//ENABLE_WID_ID\n") == 0)
            {
                if(WIDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                else 
                {
                    j=j+2; 
                    inDataLink(head_ptr, "   .WID(1'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_BID_ID\n") == 0)
            {
                if(WIDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                else 
                {
                    j=j+2; 
                    inDataLink(head_ptr, "   .BID(1'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_AR_ID\n") == 0)
            {
                if(ARIDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                else 
                {
                    j=j+2; 
                    inDataLink(head_ptr, "   .ARID(1'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_RID_ID\n") == 0)
            {
                if(RIDEnable == ENABLE) 
                    j++;
                else  if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_id_port\n");
                }
                else 
                {
                    j=j+2; 
                    inDataLink(head_ptr, "   .RID(1'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_LOCK\n") == 0)
            {
                if(LockEnable == ENABLE) 
                    j++;
                else if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_lock_port\n");
                }
                else 
                {
                    j=j+2; 
                    if( WriteReadSW_Flag  == 0) // Write channel
                        inDataLink(head_ptr, ".AWLOCK(2'd0),\n");
                    else                        // Read channel
                        inDataLink(head_ptr, ".ARLOCK(2'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_CACHE\n") == 0)
            {
                if(CacheEnable == ENABLE)
                    j++;
                else if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_cache_port\n");
                }
                else
                {
                    j=j+2; 
                    if( WriteReadSW_Flag  == 0) // Write channel
                        inDataLink(head_ptr, ".AWCACHE(4'd0),\n");
                    else                        // Read channel
                        inDataLink(head_ptr, ".ARCACHE(4'd0),\n");
                }

            }

            if(strcmp(BuffMaster[j],"//ENABLE_PROT\n") == 0)
            {
                if(ProtectEnable == ENABLE)
                    j++;
                else if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_protect_port\n");
                }
                else
                {
                    j=j+2; 
                    if( WriteReadSW_Flag  == 0) // Write channel
                        inDataLink(head_ptr, ".AWPROT(3'd0),\n");
                    else                        // Read channel
                        inDataLink(head_ptr, ".ARPROT(3'd0),\n");
                }
            }

            if(strcmp(BuffMaster[j],"//ENABLE_WSTRB\n") == 0)
            {
                WriteReadSW_Flag  = 1; // 1 :: Read channel
                // 2. read channel change
                if(SlaveMaster == 3 || SlaveMaster == 5 || SlaveMaster == 30)
                                                            //Master
                {
                    IDEnable      = ValMASTER[i].ReadChPort.IDEnable;
                    LockEnable    = ValMASTER[i].ReadChPort.LockEnable;
                    CacheEnable   = ValMASTER[i].ReadChPort.CacheEnable;
                    ProtectEnable = ValMASTER[i].ReadChPort.ProtectEnable;
                }
                else if(SlaveMaster == 4 || SlaveMaster == 6 //Slave
                        || SlaveMaster == 9                  //default slave
                        || SlaveMaster == 20 )               //remove default
                {
                    LockEnable    = ValSLAVE[i].ReadChPort.LockEnable;
                    CacheEnable   = ValSLAVE[i].ReadChPort.CacheEnable;
                    ProtectEnable = ValSLAVE[i].ReadChPort.ProtectEnable;
                }

                if(WstrbEnable == ENABLE)
                    j++;
                else if(SlaveMaster != 5 && SlaveMaster != 6)
                {
                    j=j+2; 
                    inDataLink(head_ptr, "//Disalbe_WSTRB_port\n");
                }
                else
                {
                    j=j+2; 
                    inDataLink(head_ptr, ".WSTRB({STRB_MAX{1'b1}}),\n");
                }
            }
            //Add 2006-8-18-port disable______________end
            
            if(changeStr(BuffMaster[j],buff, "??", (char *)ReqNum)==0)
            {
                if(changeStr(BuffMaster[j],buff, "?NAME?", Name)==1)
                {
                    while(changeStr(buff,buff, "?NAME?", Name)==1);
                    inDataLink(head_ptr, buff);
                }
                else
                {

                    char BuffName[100];

                    if((i == (endi-1)) && SlaveMaster != 20)
                    {
                        changeStr(BuffMaster[j],buff, 
                            "?IntSRAMController?", "DefaultSlave");
                    } else {
                        sprintf(BuffName,"%s_IntSRAMController", Name);
                        changeStr(BuffMaster[j],buff, 
                            "?IntSRAMController?", BuffName);
                    }
                    inDataLink(head_ptr, buff);
                }
            } else {
                char ReqNum0[4];
                int masterNumWidth= (int)DefBit(ValMAIN.MasterNumber);
                sprintf(ReqNum0,"%d",masterNumWidth);
                while(changeStr(buff,buff, "??",(char *)ReqNum)==1);
                while(changeStr(buff,buff, "?NAME?", Name)==1);
                changeStr(buff,buff, "?WID?", ReqNum0);
                inDataLink(head_ptr, buff);
            }
        }
    }

    free(Name);
    free(buff);

    return BUS_ERROR_NONE;
}

unsigned int genTestSSRAM(DefSlave *VAL_SLAVE, char *OutFileName)
{
    char *fileName;
    FILE *Fp;
    char *buff;
    char *Name;
    struct codeLine *head_ptr = NULL;

    Name = (char *)malloc(sizeof(char) *120);
    buff = (char *)malloc(sizeof(char) *120);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START\n");

    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/TestBench/TEST_SSRAM32bit.v");
    strcpy(Name, VAL_SLAVE->name);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(fileName);
        free(buff);
        free(Name);
        return FILE_PROCESS_ERROR;
    }


    while(1)
    {
        fgets(buff, (sizeof(char)*120), Fp);
        while(changeStr(buff,buff, "?NAME?", Name)==1);
        if(strcmp(buff, STATE_END) == 0) break;
        inDataLink(head_ptr, buff);
    }


    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(fileName);
        free(buff);
        free(Name);
        return FILE_PROCESS_ERROR;
    }

    free(fileName);
    free(buff);
    free(Name);

    fprintLink(head_ptr, NULL, OutFileName);
    return BUS_ERROR_NONE;
} // end of getTestSSRAM


unsigned int genTestMaster(DefMaster *VAL_MASTER, char *OutFileName)
{
    char *fileName;
    char *buff0;
    char *buff1;
    char *buffOut;
    FILE *Fp;
    int  i, j, endSlaveNum, endMasterNum;
    struct codeLine *head_ptr = NULL;
    
    char MAXADDR[20];
    char MINADDR[20];
    int  Connect[MAXSLAVE];

    //add 2006-8-18-port disable______________START
    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;
    int WIDEnable;
    if(VAL_MASTER->WriteChPort.ChannelEnable == ENABLE)
    {
        IDEnable        = VAL_MASTER->WriteChPort.IDEnable;
        WIDEnable       = VAL_MASTER->WriteChPort.IDEnable;
        LockEnable      = VAL_MASTER->WriteChPort.LockEnable;
        CacheEnable     = VAL_MASTER->WriteChPort.CacheEnable;
        ProtectEnable   = VAL_MASTER->WriteChPort.ProtectEnable;
        WstrbEnable     = VAL_MASTER->WriteChPort.WstrbEnable;
    }
    else
    {
        IDEnable        = ENABLE;
        WIDEnable       = ENABLE;
        LockEnable      = ENABLE;
        CacheEnable     = ENABLE;
        ProtectEnable   = ENABLE;
        WstrbEnable     = ENABLE;
    }
    //add 2006-8-18-port disable______________END

    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;
    j = 0;

    getConnectSlave(VAL_MASTER, Connect);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    buff0 = (char *)malloc(sizeof(char) * 120);
    buff1 = (char *)malloc(sizeof(char) *120);
    buffOut = (char *)malloc(sizeof(char) *120);

    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/TestBench/TestMaster/CodePart.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff0);
        free(buff1);
        free(buffOut);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    //STATE00_START -> Memory mapping
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    if(VAL_MASTER->WriteChPort.IDEnable == ENABLE)
    {
        sprintf(buff0, "`define RANDOM_WID    1\n");
        inDataLink(head_ptr, buff0);
    }
    else
    {
        sprintf(buff0, "`define RANDOM_WID    0\n");
        inDataLink(head_ptr, buff0);
    }

    if(VAL_MASTER->ReadChPort.IDEnable == ENABLE)
    {
        sprintf(buff0, "`define RANDOM_RID    1\n");
        inDataLink(head_ptr, buff0);
    }
    else
    {
        sprintf(buff0, "`define RANDOM_RID    0\n");
        inDataLink(head_ptr, buff0);
    }

    if(VAL_MASTER->WriteChPort.ChannelEnable == ENABLE )
    {
        sprintf(buff0, "`define WRITE_ENABLE  1\n");
        inDataLink(head_ptr, buff0);
    }
    else
    {
        sprintf(buff0, "`define WRITE_ENABLE  0\n");
        inDataLink(head_ptr, buff0);
    }

    if(VAL_MASTER->ReadChPort.ChannelEnable == ENABLE )
    {
        sprintf(buff0, "`define READ_ENABLE  1\n");
        inDataLink(head_ptr, buff0);
    }
    else
    {
        sprintf(buff0, "`define READ_ENABLE  0\n");
        inDataLink(head_ptr, buff0);
    }


    fgets(buff0, sizeof(char) * 120, Fp);
    fgets(buff1, sizeof(char) * 120, Fp);

    for(i=0; endSlaveNum > i; i++)
    {
        char ReqNum[4];
        sprintf(ReqNum, "%d", i);
        sprintf(MAXADDR, "32'h%X", (int)(ValMAIN.Map0[i].StartAddr));
        sprintf(MINADDR, "32'h%X", (int)(ValMAIN.Map0[i].AreaAddr));
        changeStr(buff0,buffOut, "?MAXADDR?", MAXADDR);
        changeStr(buffOut,buffOut, "??", ReqNum);
        inDataLink(head_ptr, buffOut);
        changeStr(buff1,buffOut, "?MINADDR?", MINADDR);
        changeStr(buffOut,buffOut, "??", ReqNum);
        inDataLink(head_ptr, buffOut);
    }
    fgets(buff0, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START -> Name mapping
    fgets(buff0, sizeof(char) * 120, Fp);
    changeStr(buff0,buffOut, "?NAME?", VAL_MASTER->name);
    inDataLink(head_ptr, buffOut);
    fgets(buff0, sizeof(char) * 120, Fp);

    //mkBeforeStr(Fp, head_ptr, DEF_STATE);
    //add 2006-8-18-port disable______________START
    while(1)
    {
        fgets(buff0, sizeof(char) * 120, Fp);

        if(strcmp(buff0, DEF_STATE) == 0) break;

        if(strcmp(buff0, "//ENABLE_ID\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(IDEnable != ENABLE) 
                strcpy(buff0, "//disable id port\n");
        }

        if(strcmp(buff0, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff0, "//disable lock port\n");
        }
    
        if(strcmp(buff0, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff0, "//disable cache port\n");
        }

        if(strcmp(buff0, "//ENABLE_PROT\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff0, "//disable protect port\n");
        }

        if(strcmp(buff0, "//ENABLE_WSTRB\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(WstrbEnable != ENABLE)
                strcpy(buff0, "//disable wstrb port\n");
        
            //change Read channel_____________START
            if(VAL_MASTER->ReadChPort.ChannelEnable == ENABLE )
            {
                IDEnable      = VAL_MASTER->ReadChPort.IDEnable;
                LockEnable    = VAL_MASTER->ReadChPort.LockEnable;
                CacheEnable   = VAL_MASTER->ReadChPort.CacheEnable;
                ProtectEnable = VAL_MASTER->ReadChPort.ProtectEnable;
            }
            else
            {
                IDEnable      = ENABLE;
                LockEnable    = ENABLE;
                CacheEnable   = ENABLE;
                ProtectEnable = ENABLE;
            }
            //change Read channel_____________END

        }

        if(strcmp(buff0, "//ENABLE_WID\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(WIDEnable != ENABLE) 
                strcpy(buff0, "//disable wid port\n");
        }
        inDataLink(head_ptr, buff0);
    }
    //add 2006-8-18-port disable______________END


    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buffOut, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buffOut);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buffOut);
    }


    //mkBeforeStr(Fp, head_ptr, STATE01_START);
    //fgets(buff0, sizeof(char) * 120, Fp);

    //add 2006-8-19-port disable______________START

    //add 2006-8-21-port disable______________START
    if(VAL_MASTER->WriteChPort.ChannelEnable == ENABLE)
    {
        IDEnable        = VAL_MASTER->WriteChPort.IDEnable;
        LockEnable      = VAL_MASTER->WriteChPort.LockEnable;
        CacheEnable     = VAL_MASTER->WriteChPort.CacheEnable;
        ProtectEnable   = VAL_MASTER->WriteChPort.ProtectEnable;
        WstrbEnable     = VAL_MASTER->WriteChPort.WstrbEnable;
    }
    else
    {
        IDEnable        = ENABLE;
        LockEnable      = ENABLE;
        CacheEnable     = ENABLE;
        ProtectEnable   = ENABLE;
        WstrbEnable     = ENABLE;
    }
    //add 2006-8-21-port disable______________END

    while(1)
    {
        fgets(buff0, sizeof(char) * 120, Fp);

        if(strcmp(buff0, STATE01_START) == 0) break;

        if(strcmp(buff0, "//ENABLE_ID\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(IDEnable != ENABLE) 
                strcpy(buff0, "//disable id port\n");
        }

        if(strcmp(buff0, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff0, "//disable lock port\n");
        }
    
        if(strcmp(buff0, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff0, "//disable cache port\n");
        }

        if(strcmp(buff0, "//ENABLE_PROT\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff0, "//disable protect port\n");
        }


        if(strcmp(buff0, "//ENABLE_WID\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(WIDEnable != ENABLE) 
                strcpy(buff0, "wire   [WID_WIDTH-1:0]  BID = {WID_WIDTH{1'b0}};\n");
        }


        if(strcmp(buff0, "//ENABLE_RID\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(IDEnable != ENABLE) 
                strcpy(buff0, "wire   [RID_WIDTH-1:0]  RID = {RID_WIDTH{1'b0}};\n");
        }



        if(strcmp(buff0, "//ENABLE_WSTRB\n") == 0)
        {
            fgets(buff0, (sizeof(char)*120), Fp);
            if(WstrbEnable != ENABLE)
                strcpy(buff0, "//disable wstrb port\n");
        
            //change Read channel_____________START
            if(VAL_MASTER->ReadChPort.ChannelEnable == ENABLE )
            {
                IDEnable      = VAL_MASTER->ReadChPort.IDEnable;
                LockEnable    = VAL_MASTER->ReadChPort.LockEnable;
                CacheEnable   = VAL_MASTER->ReadChPort.CacheEnable;
                ProtectEnable = VAL_MASTER->ReadChPort.ProtectEnable;
            }
            else
            {
                IDEnable      = ENABLE;
                LockEnable    = ENABLE;
                CacheEnable   = ENABLE;
                ProtectEnable = ENABLE;
            }
            //change Read channel_____________END

        }

        inDataLink(head_ptr, buff0);
    }
    //add 2006-8-19-port disable______________END
    fgets(buff0, sizeof(char) * 120, Fp);


    //STATE01_START -> Connect Slave define
    for(i=0; endSlaveNum+1>i; i++)
    {
        char ReqNum[4];
        sprintf(ReqNum, "%d", i);
        changeStr(buff0,buffOut, "??",ReqNum);
        if(Connect[i] == 1){
            sprintf(ReqNum, "1'b1;");
            changeStr(buffOut,buffOut, "?1?",ReqNum);
        }else{
            sprintf(ReqNum, "1'b0;");
            changeStr(buffOut,buffOut, "?1?",ReqNum);
        }
        inDataLink(head_ptr, buffOut);
    }
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START 
    char ReqNum[4];
    int slaveNumWidth = (int)DefBit(ValMAIN.SlaveNumber + 1);
    sprintf(ReqNum, "%d", slaveNumWidth);
    mkBuffChangeSt2St(Fp, head_ptr, 
                        endSlaveNum, "//STATE_END\n",  "?WID?", 
                        (char *)ReqNum, NULL);
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START 
    sprintf(ReqNum, "%d", slaveNumWidth);
    mkBuffChangeSt2St(Fp, head_ptr, 
                        endSlaveNum, "//STATE_END\n",  "?WID?", 
                        (char *)ReqNum, NULL);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START 
    fgets(buff0, sizeof(char) * 120, Fp);
    fgets(buff1, sizeof(char) * 120, Fp);

    for(i=0; endSlaveNum > i; i++)
    {

        if(Connect[i] == 1)
        {
            sprintf(ReqNum, "%d", i);
            if(j == 0)
            {
                changeStr(buff0,buffOut, "?else?", "");
                j = 1;
            }
            else
            {
                changeStr(buff0,buffOut, "?else?", "else");
            }
    
            changeStr(buffOut,buffOut, "??", ReqNum);
            changeStr(buffOut,buffOut, "??", ReqNum);
            inDataLink(head_ptr, buffOut);

            changeStr(buff1,buffOut, "??", ReqNum);
            inDataLink(head_ptr, buffOut);
        }
    }
    fgets(buff0, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff0);
        free(buff1);
        free(buffOut);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff0);
    free(buff1);
    free(buffOut);
    free(fileName);

    printLink(head_ptr);
    fprintLink(head_ptr, NULL ,  OutFileName);

    return BUS_ERROR_NONE; 
}


unsigned int genTestbench(char *OutFileName)
{
    char *fileName;
    char *buff;
    FILE *Fp;
    int  i, endSlaveNum, endMasterNum;
    struct codeLine *head_ptr = NULL;
    
    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    buff = (char *)malloc(sizeof(char) * 120);
    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/TestBench/tb.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }


    int MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter WRITECHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].writeidwid );
        if(ValMASTER[i].writeidwid>MAXID) MAXID = ValMASTER[i].writeidwid;
        inDataLink(head_ptr, buff);
    }

    sprintf(buff, "parameter MAXWRITEID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKWRITEID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter READCHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].readidwid );
        if(ValMASTER[i].readidwid>MAXID) MAXID = ValMASTER[i].readidwid;
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter WR_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter RD_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].readidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SELMASTER%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelMasterWid );
        inDataLink(head_ptr, buff);
    }

    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
    for(i=0; endSlaveNum+1 >i; i++)
    {
        //Write channel width
        sprintf(buff, "parameter SELWRITE%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelWriteWid );
        inDataLink(head_ptr, buff);

        //Read channel width
        sprintf(buff, "parameter SELREAD%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelReadWid );
        inDataLink(head_ptr, buff);
    }
    ///////////////////////////////////////////////////////////

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_WRITEID%d_WID = %d ;\n", 
                i, (ValSLAVE[i].writeidwid - ValSLAVE[i].SelWriteWid));
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_READID%d_WID = %d ;\n", 
                i, (ValSLAVE[i].readidwid - ValSLAVE[i].SelReadWid));
        inDataLink(head_ptr, buff);
    }

    mkBeforeStr(Fp, head_ptr, STATE00_START);
    //__________________________________________________________ Def_end
    
    //STATE00 START process
    mkTBusModule(Fp, head_ptr, 1);    //Write Channel Master
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 START process
    //mkTBusModule(Fp, head_ptr, 0);  //Write Channel Slave
    mkTBusModule(Fp, head_ptr, 7);    //Write Channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 START process
    mkTBusModule(Fp, head_ptr, 11);   //Read Channel Master
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 START process
    //mkTBusModule(Fp, head_ptr, 10); //Read Channel Slave
    mkTBusModule(Fp, head_ptr, 8);    //Read Channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04 START process
    fgets(buff, sizeof(char) * 120, Fp);
    changeStr(buff,buff, "?BUSNAME?", (char *)"SBUS");
                                    //(char *)ValMAIN.name);
    inDataLink(head_ptr, buff);
    fgets(buff, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, STATE05_START);


    //STATE05 START process
    mkTBusModule(Fp, head_ptr, 3);   //Master
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06 START process
    //mkTBusModule(Fp, head_ptr, 0);  //Write channel Slave
    mkTBusModule(Fp, head_ptr, 20);   //Slave without default
    mkBeforeStr(Fp, head_ptr, STATE09_START);


    /*
    //STATE05 START process
    mkTBusModule(Fp, head_ptr, 1);   //Write channel Master
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06 START process
    //mkTBusModule(Fp, head_ptr, 0); //Write channel Slave
    mkTBusModule(Fp, head_ptr, 7);   //Write channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07 START process
    mkTBusModule(Fp, head_ptr, 11); //Read channel Master
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08 START process
    //mkTBusModule(Fp, head_ptr, 10); //Read channel Slave without default
    mkTBusModule(Fp, head_ptr, 8);    //Read channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE09_START);
    */

    //STATE09 START process
    //mkTBusModule(Fp, head_ptr, 3);   //Master
    mkTBusModule(Fp, head_ptr, 30);    //Master Bulk Testbench
    mkBeforeStr(Fp, head_ptr, STATE10_START);

    //STATE10 START process
    //mkTBusModule(Fp, head_ptr, 4);   //Slave
    mkTBusModule(Fp, head_ptr, 20);    //Slave without default
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderTestbench ,  OutFileName);

    return BUS_ERROR_NONE; 
} //the end of genTestbench



unsigned int genTOPBlock(char *OutFileName)
{
    char *fileName;
    char *buff;
    FILE *Fp;
    int  i, endSlaveNum, endMasterNum;
    struct codeLine *head_ptr = NULL;
    
    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    buff = (char *)malloc(sizeof(char) * 120);
    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/TestBench/top_SBUS.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }


    int MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter WRITECHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].writeidwid );
        if(ValMASTER[i].writeidwid>MAXID) MAXID = ValMASTER[i].writeidwid;
        inDataLink(head_ptr, buff);
    }

    sprintf(buff, "parameter MAXWRITEID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKWRITEID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter READCHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].readidwid );
        if(ValMASTER[i].readidwid>MAXID) MAXID = ValMASTER[i].readidwid;
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter WR_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter RD_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].readidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SELMASTER%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelMasterWid );
        inDataLink(head_ptr, buff);
    }

    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
    for(i=0; endSlaveNum+1 >i; i++)
    {
        //Write channel width
        sprintf(buff, "parameter SELWRITE%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelWriteWid );
        inDataLink(head_ptr, buff);

        //Read channel width
        sprintf(buff, "parameter SELREAD%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelReadWid );
        inDataLink(head_ptr, buff);
    }
    ///////////////////////////////////////////////////////////

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_WRITEID%d_WID = %d ;\n", 
    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
                i, (ValSLAVE[i].writeidwid - ValSLAVE[i].SelWriteWid));
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_READID%d_WID = %d ;\n", 
    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
                i, (ValSLAVE[i].readidwid - ValSLAVE[i].SelReadWid));
        inDataLink(head_ptr, buff);
    }

    mkBeforeStr(Fp, head_ptr, STATE00_START);
    //__________________________________________________________ Def_end
    
    //STATE00 START process
    mkTBusModule(Fp, head_ptr, 1);  //Write Channel Master
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 START process
    //mkTBusModule(Fp, head_ptr, 0); //Write Channel Slave
    mkTBusModule(Fp, head_ptr, 7);  //Write Channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 START process
    mkTBusModule(Fp, head_ptr, 11);     //Read Channel Master
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 START process
    //mkTBusModule(Fp, head_ptr, 10);   //Read Channel Slave
    mkTBusModule(Fp, head_ptr, 8);      //Read Channel Slave without default
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04 START process
    fgets(buff, sizeof(char) * 120, Fp);
    changeStr(buff,buff, "?BUSNAME?", (char *)"SBUS");
    inDataLink(head_ptr, buff);
    fgets(buff, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, STATE05_START);
    
    //STATE05 START process
    mkTBusModule(Fp, head_ptr, 3); //Master Channel generation
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06 START process
    mkTBusModule(Fp, head_ptr, 20);//Slave channel generation without slave
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);

    printLink(head_ptr);
    fprintLink(head_ptr, NULL ,  OutFileName);

    return BUS_ERROR_NONE; 
} //the end of genTOPBlock




unsigned int mkBUSTOPInOutPort(struct codeLine *head_ptr)
{
    char *fileName;
    char *buff;
    FILE *Fp;
    int  i, endSlaveNum, endMasterNum;
    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    buff = (char *)malloc(sizeof(char) *120);
    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/TOP/InOutPart.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    //inout definition
    mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);

    //INOUT_STATE00 START process
    fgets(buff, sizeof(char) * 120, Fp);
    changeStr(buff,buff, "?BUSNAME?", (char *)"SBUS");

    inDataLink(head_ptr, buff);
    fgets(buff, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);

    //INOUT_STATE01 START process
    mkTBusModule(Fp, head_ptr, 1); // Write channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE02_START);

    //INOUT_STATE02 START process
    //mkTBusModule(Fp, head_ptr, 0); // Write channel Slave without default
    mkTBusModule(Fp, head_ptr, 7); // Write channel Slave without default
    mkBeforeStr(Fp, head_ptr, INOUT_STATE03_START);

    //INOUT_STATE03 START process
    mkTBusModule(Fp, head_ptr, 11); // Read channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE04_START);

    //INOUT_STATE04 START process
    //mkTBusModule(Fp, head_ptr, 10); // Read channel Slave without default
    mkTBusModule(Fp, head_ptr, 8); // Read channel Slave without default
    mkBeforeStr(Fp, head_ptr, DEF_STATE);



    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }


    int MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter WRITECHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].writeidwid );
        if(ValMASTER[i].writeidwid>MAXID) MAXID = ValMASTER[i].writeidwid;
        inDataLink(head_ptr, buff);
    }

    /*
    sprintf(buff, "parameter MAXWRITEID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKWRITEID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].writeidwid );
        inDataLink(head_ptr, buff);
    }
    */

    MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter READCHID%d_WID = %d ;\n", 
                              i, ValMASTER[i].readidwid );
        if(ValMASTER[i].readidwid>MAXID) MAXID = ValMASTER[i].readidwid;
        inDataLink(head_ptr, buff);
    }

    /*
    sprintf(buff, "parameter MAXREADID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKREADID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].readidwid );
        inDataLink(head_ptr, buff);
    }
    */

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter WR_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter RD_SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].readidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SELMASTER%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelMasterWid );
        inDataLink(head_ptr, buff);
    }

    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
    for(i=0; endSlaveNum+1 >i; i++)
    {
        //Write channel width
        sprintf(buff, "parameter SELWRITE%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelWriteWid );
        inDataLink(head_ptr, buff);

        //Read channel width
        sprintf(buff, "parameter SELREAD%d_WID = %d ;\n", 
                              i, ValSLAVE[i].SelReadWid );
        inDataLink(head_ptr, buff);
    }
    ///////////////////////////////////////////////////////////

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_WRITEID%d_WID = %d ;\n", 
    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
                i, (ValSLAVE[i].writeidwid - ValSLAVE[i].SelWriteWid));
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_READID%d_WID = %d ;\n", 
    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
                i, (ValSLAVE[i].readidwid - ValSLAVE[i].SelReadWid));
        inDataLink(head_ptr, buff);
    }

    //__________________________________________________________ Def_end
    
    mkBeforeStr(Fp, head_ptr, INOUT_STATE05_START);

    //INOUT_STATE05 START process
    mkTBusModule(Fp, head_ptr, 1); //Write Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE06_START);

    //INOUT_STATE06 START process
    //mkTBusModule(Fp, head_ptr, 0); //Write Channel Slave
    mkTBusModule(Fp, head_ptr, 7); //Write Channel Slave without default
    mkBeforeStr(Fp, head_ptr, INOUT_STATE07_START);

    //INOUT_STATE07 START process
    mkTBusModule(Fp, head_ptr, 11); //Read Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE08_START);

    //INOUT_STATE08 START process
    //mkTBusModule(Fp, head_ptr, 10); //Read Channel Slave
    mkTBusModule(Fp, head_ptr, 8); //Read Channel Slave without default
    mkBeforeStr(Fp, head_ptr, INOUT_STATE09_START);

    //INOUT_STATE09 START process
    mkTBusModule(Fp, head_ptr, 9); //Read Channel Slave without default
    mkBeforeStr(Fp, head_ptr, INOUT_STATE10_START);

    //INOUT_STATE10 START process
    mkTBusModule(Fp, head_ptr, 9); //Read Channel Slave without default
    mkBeforeStr(Fp, head_ptr, INOUT_END);


    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);
    return BUS_ERROR_NONE;    
}


unsigned int genBusTop(char *OutFileName)
{
    FILE *Fp;
    char *fileName = "./dataSample/TOP/CodePart.v";
    int    endSlaveNum, endMasterNum;
    char   *buff;
    struct codeLine *head_ptr = NULL;

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");
    buff = (char *)malloc(sizeof(char) * 120);

    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    //__________________________________________________ InOutput/def
    mkBUSTOPInOutPort(head_ptr);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    //mkBeforeStr(Fp, head_ptr, STATE01_START);
    mkBeforeStr(Fp, head_ptr, STATE_START); //protocal checker

    //STATE -> Protocal checker
    mkTBusModule(Fp, head_ptr, 5); //Master bulk input
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE -> Protocal checker
    mkTBusModule(Fp, head_ptr, 6); //Slave bulk input
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    fgets(buff, sizeof(char) * 120, Fp);
    changeStr(buff,buff, "?NAME?", (char *)"SBUS");

    inDataLink(head_ptr, buff);
    fgets(buff, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START process
    mkTBusModule(Fp, head_ptr, 1); //Master
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkTBusModule(Fp, head_ptr, 0); //Slave
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04_START process
    mkTBusModule(Fp, head_ptr, 0); //Slave
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    fgets(buff, sizeof(char) * 120, Fp);
    changeStr(buff,buff, "?NAME?", (char *)"SBUS");
                                   //(char *)ValMAIN.name);
    inDataLink(head_ptr, buff);
    fgets(buff, sizeof(char) * 120, Fp);
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process
    mkTBusModule(Fp, head_ptr, 11); // Read Channel Master
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07_START process
    mkTBusModule(Fp, head_ptr, 10); // Read Channel Slave
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process
    mkTBusModule(Fp, head_ptr, 0); //Slave
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    //STATE09_START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    //mkBeforeStr(Fp, head_ptr, Code_END);
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    mkLockLink( Fp, head_ptr, 1);//ReadChannel
    //mkBeforeStr(Fp, head_ptr, Code_END);
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    mkLockLink( Fp, head_ptr, 0);//WriteChannel
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    printLink(head_ptr);
    fprintLink(head_ptr, HeaderBusTop ,  OutFileName);

    return BUS_ERROR_NONE;
}
