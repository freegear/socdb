
#include <stdio.h>
#include "Bus.h"
#include "genDef.h"
#include "MkFile.h"
#include "genWriteCh.h"

const char *none = " \n";
const char *HeaderWriteChannelSI = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : WriteChannelsi.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : WriteChannel SlaveInterface Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};


const char *HeaderWriteChannelMI = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : WriteChannelmi.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : ReadChannel Master Interface Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};

const char *HeaderWriteChannel = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : WriteChannel.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : WriteChannel TOP Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};


unsigned int mkWriteTOPInOutPort(struct codeLine *head_ptr)
{
    char *fileName;
    char *buff;
    FILE *Fp;
    int  i, endSlaveNum, endMasterNum;
    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    buff = (char *)malloc(sizeof(char) *120);
    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/WriteChannel/InOutPart.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    //inout definition
    mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);

    //INOUT_STATE00 START process
    //mkBuffChange(Fp, head_ptr, endMasterNum, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 1);  //Write Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);

    //INOUT_STATE01 START process
    //mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 0);  //Write Channel Slave
    mkBeforeStr(Fp, head_ptr, INOUT_STATE02_START);

    //INOUT_STATE02 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE03_START);

    //INOUT_STATE03 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE04_START);

    //INOUT_STATE04 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE05_START);

    //INOUT_STATE05 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE06_START);

    //INOUT_STATE06 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE07_START);

    //INOUT_STATE07 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE08_START);

    //INOUT_STATE08 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE09_START);

    //INOUT_STATE09 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE10_START);

    //INOUT_STATE10 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }


    int MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter MASTERID%d_WID = %d ;\n", 
                              i, ValMASTER[i].writeidwid );
        if(ValMASTER[i].writeidwid>MAXID) MAXID = ValMASTER[i].writeidwid;
        inDataLink(head_ptr, buff);
    }

    sprintf(buff, "parameter MAXMASTERID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKMASTERID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].writeidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SELMASTER%d_WID = %d ;\n", 
        //2006-9-8-ID-WIDTH-FIXED
                              i, ValSLAVE[i].SelWriteWid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_MASTERID%d_WID = %d ;\n", 
        //2006-9-8-ID-WIDTH-FIXED
                i, (ValSLAVE[i].writeidwid - ValSLAVE[i].SelWriteWid));
        inDataLink(head_ptr, buff);
    }

    mkBeforeStr(Fp, head_ptr, INOUT_STATE11_START);
    //__________________________________________________________ 

    //INOUT_STATE11 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE12_START);

    //INOUT_STATE12 START process
    //mkBuffChange(Fp, head_ptr, endMasterNum, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 1);  //Write Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE13_START);

    //INOUT_STATE13 START process
    //mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 0);  //Write Channel Slave
    mkBeforeStr(Fp, head_ptr, INOUT_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);
    return BUS_ERROR_NONE;    
}

unsigned int mkWriteInOutPort( DefMaster *VAL_MASTER,
                               DefSlave  *VAL_SLAVE,
                               struct codeLine *head_ptr,
                               int SlaveMaster)
{

    char *fileName;
    char *Name;
    char *buff;
    FILE *Fp;
    int  i;
    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;

    buff = (char *)malloc(sizeof(char) *120);
    Name = (char *)malloc(sizeof(char) *120);
    fileName = (char *)malloc(sizeof(char) *120);


    if(SlaveMaster == 0)
    {
        strcpy(Name, VAL_MASTER->name);
        strcpy(fileName, 
                "./dataSample/WriteChannel_SlaveInterface/InOutPart.v");
    }
    else if(SlaveMaster == 1)
    {
        strcpy(Name, VAL_SLAVE->name);
        strcpy(fileName, 
                "./dataSample/WriteChannel_MasterInterface/InOutPart.v");
    }
    else if(SlaveMaster == 10) //Write channel Master 
    {
        sprintf(Name, "%s_RS", VAL_MASTER->name);
        strcpy(fileName, 
                "./dataSample/WriteChannel_SlaveInterface/InOutPart.v");

        IDEnable        = VAL_MASTER->WriteChPort.IDEnable;
        LockEnable      = VAL_MASTER->WriteChPort.LockEnable;
        CacheEnable     = VAL_MASTER->WriteChPort.CacheEnable;
        ProtectEnable   = VAL_MASTER->WriteChPort.ProtectEnable;
        WstrbEnable     = VAL_MASTER->WriteChPort.WstrbEnable;
    }
    else if(SlaveMaster == 11) //Write cahnnel Slave
    {
        sprintf(Name, "%s_RS", VAL_SLAVE->name);
        strcpy(fileName, 
                "./dataSample/WriteChannel_MasterInterface/InOutPart.v");

        LockEnable      = VAL_SLAVE->WriteChPort.LockEnable;
        CacheEnable     = VAL_SLAVE->WriteChPort.CacheEnable;
        ProtectEnable   = VAL_SLAVE->WriteChPort.ProtectEnable;
        WstrbEnable     = VAL_SLAVE->WriteChPort.WstrbEnable;
    }


    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }
    //__________________________________________________________ InOutPort

    //inout definition
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", Name);

        if(SlaveMaster == 0 || SlaveMaster == 1)
        {
            if(strcmp(buff,INOUT_STATE00_START)==0) break;
        }
        else if(SlaveMaster == 10) 
        {   // port configuration enable disable
            // 2006-8-17-Port disable
            if(strcmp(buff,"//ENABLE_ID\n")==0) break;
        }
        else if(SlaveMaster == 11)
        {
            if(strcmp(buff,"//ENABLE_LOCK\n")==0) break;
        }

        inDataLink(head_ptr, buff);
    }

    // 2006-8-17-Port disable
    if(SlaveMaster == 10 || SlaveMaster == 11)
    {

        //Enable ID WIDTH
        if(strcmp(buff, "//ENABLE_ID\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(IDEnable == ENABLE)
               inDataLink(head_ptr, buff);

            while(1)
            {
                fgets(buff, (sizeof(char)*120), Fp);
                if(strcmp(buff,"//ENABLE_LOCK\n")==0) break;
                inDataLink(head_ptr,buff);
            }
        }

        //Lockport generation
        if(strcmp(buff,"//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(CacheEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //Write Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            if(IDEnable == ENABLE)
            {
                fgets(buff, (sizeof(char)*120), Fp);
                inDataLink(head_ptr, buff);
            }
            else
                fgets(buff, (sizeof(char)*120), Fp);
        }

        //WSTRB port generation
        mkBeforeStr(Fp, head_ptr, "//ENABLE_WSTRB\n");
        if(WstrbEnable== ENABLE)
        {
           fgets(buff, (sizeof(char)*120), Fp);
           inDataLink(head_ptr, buff);
        }
        else
           fgets(buff, (sizeof(char)*120), Fp);


        //Write Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            if(IDEnable == ENABLE)
            {
                fgets(buff, (sizeof(char)*120), Fp);
                inDataLink(head_ptr, buff);
            }
            else
                fgets(buff, (sizeof(char)*120), Fp);
        }

        mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);
    }

    //INOUT_STATE00 START process
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster);
    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }

    // 2006-8-17-Port disable
    if(SlaveMaster == 10 || SlaveMaster == 11)
    {

        if(SlaveMaster == 10)
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
        else
            mkBeforeStr(Fp, head_ptr, "//ENABLE_LOCK\n");

        //Enable ID WIDTH
        if(SlaveMaster == 10) //Enable ID
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(IDEnable == ENABLE)
            {
                inDataLink(head_ptr, buff);
            }
            else
            {
                sprintf(buff, "    wire   [MASTERID_WID-1:0] AWIDm2si = {MASTERID_WID{1'b0}};\n");
                inDataLink(head_ptr, buff);
            }

            fgets(buff, (sizeof(char)*120), Fp);
        }
        else //Enable lock prot
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //Lockport generation
        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(CacheEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(ProtectEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //Write Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable == ENABLE)
                inDataLink(head_ptr, buff);
            else
            {
                sprintf(buff,"     wire    [MASTERID_WID-1:0] WIDm2si = 1'b0;\n");
                inDataLink(head_ptr, buff);
            }

            //fgets(buff, (sizeof(char)*120), Fp);

        }

        //WSTRB port generation
        mkBeforeStr(Fp, head_ptr, "//ENABLE_WSTRB\n");
        if(WstrbEnable== ENABLE)
        {
           fgets(buff, (sizeof(char)*120), Fp);
           inDataLink(head_ptr, buff);
        }
        else
           fgets(buff, (sizeof(char)*120), Fp);

        //Write Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable == ENABLE)
                inDataLink(head_ptr, buff);
            else
            {
                sprintf(buff,"    wire    [MASTERID_WID-1:0]      BIDsi2m;\n");
                inDataLink(head_ptr, buff);
            }

            //fgets(buff, (sizeof(char)*120), Fp);

        }



        mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);
    }
    else
        mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);

    //INOUT_STATE01 START process 0
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);
    //INOUT_STATE01 START process 1
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster);
    mkBeforeStr(Fp, head_ptr, INOUT_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);
    return BUS_ERROR_NONE;
}


unsigned int mkAddrDecoder(char *addressName,
                           struct codeLine *head_ptr, 
                           int endi,
                           char *slaveWid,
                           DefMaster *VAL_MASTER, 
                           DefSlave  *VAL_SLAVE)
{
    char *fileName = "./dataSample/AddressDecoder/AddressDecoder.v";
    char *buff;
    char *buffOut;
    char ReqNum[4];
    FILE *Fp;

    buff    = (char *)malloc(sizeof(char) *120);
    buffOut = (char *)malloc(sizeof(char) *120);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(buffOut);
        return FILE_PROCESS_ERROR;
    }

    //Skip blank
    while(strcmp(buff,"//STATE_MAXMIN_EN\n") != 0)
    {
        fgets(buff, sizeof(char)*120, Fp);
    }
    //__________________________________________________________ Code
    char buffBe[30][120];
    char Tbuff[120];
    char MAXADDR[20];
    char MINADDR[20];

    int  endcheck=0;
    int  i,j,k,l;
    int  lastEnCnt =0;

    //STATE_MAXMIN_EN process ////////////////////////////////////////
    //buffer from file(for STATE_MAXMIN_EN)
    while(strcmp(buffBe[endcheck-1],"//END\n") != 0)
        fgets(buffBe[endcheck++],  (sizeof(char)*100), Fp);    

    for(i=0;endi>i;i++)
    {
        sprintf(ReqNum, "%d", i);
        for(j=0;endi>j;j++)
        {
            if(strcmp(ValSLAVE[i].name,VAL_MASTER->ConnectSlave[j])==0)
            {
                for(k=0;endi>k;k++)
                {

                    sprintf(MAXADDR, "32'h%X", 
                            (int)(ValMAIN.Map0[k].StartAddr));
                    sprintf(MINADDR, "32'h%X", 
                            (int)(ValMAIN.Map0[k].AreaAddr));

                    /*
                    printf("________________________________________________________________\n");
                    printf("StartAdd[%s][%x][%d][%s]\n",
                                ValMAIN.Map0[k].name,
                                ValMAIN.Map0[k].StartAddr,k,MAXADDR);

                    printf("AreaAdd[%s][%x][%d][%s]\n",
                                ValMAIN.Map0[k].name,
                                ValMAIN.Map0[k].AreaAddr,k,MINADDR);
                    printf("\n");
                    */


        if(strcmp(ValSLAVE[i].name,ValMAIN.Map0[k].name)==0) 
        {
            for(l=0;endcheck-1>l;l++)
            {
             changeStr(buffBe[l],Tbuff, "??",(char *)ReqNum);
             while(changeStr(Tbuff,Tbuff, "??",(char *)ReqNum)==1);
             changeStr(Tbuff,Tbuff, "?ADDR?",(char *)addressName);
             changeStr(Tbuff,Tbuff, "?MAXVAL?",(char *)MAXADDR);
             changeStr(Tbuff,Tbuff, "?MINVAL?",(char *)MINADDR);
             inDataLink(head_ptr, Tbuff);

            }//forloop l
            lastEnCnt++;
        } //end if
                    
                }//forloop k
            }
        }//forloop j
    }//forloop j


    //STATE_DEFAULT process
    //////////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, "//STATE_DEFAULT\n");
    fgets(buff,  (sizeof(char)*100), Fp);    
    sprintf(ReqNum, "%d", (endi));
    changeStr(buff,buffOut, "??",(char *)ReqNum);
    inDataLink(head_ptr, buffOut);
    //Skip END
    fgets(buff,  (sizeof(char)*100), Fp);    
    //STATE_EN00 process
    //////////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, "//STATE_EN00\n");
    fgets(buff,  (sizeof(char)*100), Fp);    

    k = 0;
    for(i=0;endi>i;i++)
    {
        sprintf(ReqNum, "%d", i);
        for(j=0;endi>j;j++)
        {
            if(strcmp(ValSLAVE[i].name,VAL_MASTER->ConnectSlave[j])==0)
            {
                k++;
                changeStr(buff,buffOut, "??",(char *)ReqNum);
                if(k!=lastEnCnt)
                    changeStr(buffOut,buffOut, "?&?","&");
                else
                    changeStr(buffOut,buffOut, "?&?",";");

                inDataLink(head_ptr, buffOut);
            }//endif
        }//forloop j
    }//forloop i
    fgets(buff,  (sizeof(char)*100), Fp);    

    //STATE_EN01 process
    //////////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, "//STATE_EN01\n");
    fgets(buff,  (sizeof(char)*100), Fp);    
    k = 0;
    for(i=0;endi>i;i++)
    {
        sprintf(ReqNum, "%d", i);
        for(j=0;endi+1>j;j++)
        {
            if(strcmp(ValSLAVE[i].name,VAL_MASTER->ConnectSlave[j])==0)
            {
                changeStr(buff,buffOut, "??",(char *)ReqNum);
                changeStr(buffOut,buffOut, "?or?","or");

                /*
                if(k!=lastEnCnt)
                    changeStr(buffOut,buffOut, "?or?","or");
                else
                    changeStr(buffOut,buffOut, "?or?"," ");
                */

                inDataLink(head_ptr, buffOut);
                //k++;
            }//endif
        }//forloop j
    }//forloop i

    sprintf(ReqNum, "%d", endi);
    changeStr(buff,buffOut, "??",(char *)ReqNum);
    changeStr(buffOut,buffOut, "?or?"," ");
    inDataLink(head_ptr, buffOut);

    fgets(buff,  (sizeof(char)*100), Fp); 

    //STATE_EN02 process
    //////////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, "//STATE_EN02\n");
    fgets(buff,  (sizeof(char)*100), Fp);    
    
    for(i=0;endi>i;i++)
    {
        sprintf(ReqNum, "%d", i);
        for(j=0;endi>j;j++)
        {
            if(strcmp(ValSLAVE[i].name,VAL_MASTER->ConnectSlave[j])==0)
            {
                changeStr(buff,buffOut, "??",(char *)ReqNum);
                changeStr(buffOut,buffOut, "??",(char *)ReqNum);
                changeStr(buffOut,buffOut, "?WID?",slaveWid);

                inDataLink(head_ptr, buffOut);
            }//endif
        }//forloop j
    }//forloop i

    sprintf(ReqNum, "%d", endi);
    changeStr(buff,buffOut, "??",(char *)ReqNum);
    changeStr(buffOut,buffOut, "??",(char *)ReqNum);
    changeStr(buffOut,buffOut, "?WID?",slaveWid);
    inDataLink(head_ptr, buffOut);

    fgets(buff,  (sizeof(char)*100), Fp); 
    fgets(buff,  (sizeof(char)*100), Fp); 
    changeStr(buff,buffOut, "?WID?",slaveWid);
    inDataLink(head_ptr, buffOut);


    //Code_End process
    //////////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, "//Code_End\n");

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(buffOut);
    return BUS_ERROR_NONE;
}




unsigned int genWriteChMi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/WriteChannel_MasterInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j,k;
    int endi, endj;

    char selMasterWid[5];
    char selMasterWidadd1[5];

    int masterPriority[MAXMASTER];

    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
    sprintf(selMasterWid, "%d", VAL_SLAVE->SelWriteWid);
    sprintf(selMasterWidadd1, "%d", VAL_SLAVE->SelWriteWid+1);
    ///////////////////////////////////////////////////////////

    endi = (int)ValMAIN.MasterNumber;
    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START\n");

    int *ConnectMaster;
    int ConnectCNT = 0;

    ConnectMaster = (int *)malloc(sizeof(int) * MAXSLAVE);
    /*
     * ConnectMaster[??] = 1 --> connect
     * ConnectMaster[??] = 0 --> non-connect
     * ConnectMaster[??] = 2 --> end
     */

    ConnectCNT = getConnectMaster(VAL_SLAVE, ConnectMaster, 0);

////////////////////////////////////////////////////////////////////////////
//Priority Setting /////////////////////////////////////////////////////////
////////////////////////////////////////////////////////////////////////////

    //Priority value////////
    int liveMaster ;
    int liveMasterCnt;
    j = 0;
    liveMasterCnt = 0;
    int tempMasterPriority[MAXMASTER];
    ///////////////////////

    for(i=0; (int)ValMAIN.MasterNumber>i; i++)
        if(ConnectMaster[i] == 1)
        {
            tempMasterPriority[j++] = i; // insert master number
        }

    endj = j;

    for(i=0; (int)ValMAIN.MasterNumber>i; i++)
    {
        for(j=0; endj>j; j++)
        {

            if(strcmp(VAL_SLAVE->OperateArbiter.PriorityMaster[i],
               ValMASTER[tempMasterPriority[j]].name)==0) 
            {
                masterPriority[liveMasterCnt++] = tempMasterPriority[j];
            }
        }
    }

    //setting error display function
    if(liveMasterCnt != endj)
    {
        printf("ERROR:: priority setting are not sufficient in %s\n", 
                VAL_SLAVE->name);
        printf("or have invalide setting name"); 
        return  BUS_ERROR_INVALID_PARA;
    }

    for(j=0; endj>j; j++)
    {
        for(i=0; endj>i; i++)
        {
            if(tempMasterPriority[i] == masterPriority[j] )
            {
                masterPriority[j] = i;
            }
        }
    }

////////////////////////////////////////////////////////////////////////////


    //__________________________________________________ InOutput/def
    mkWriteInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 1);
    
    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    
    mkBeforeStr(Fp, head_ptr, ARBITER_GEN_START);

    //ARBITER_GEN_START process
    //printf("selMasterWid->%s\n", selMasterWid);
    mkArbiter(Fp, head_ptr, ConnectCNT,VAL_MASTER, 
              (char *)selMasterWid, NULL, masterPriority);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, "//STATE_END\n",  "?WID?", 
                      (char *)selMasterWid, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 1
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 2
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 3
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 4
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 5
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 6
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 7
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 8
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 1
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 2
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 3
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 4
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);

    //STATE_START process 5
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);


    //STATE_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWid, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, NULL);
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);
        if(strcmp(buff,STATE_START)==0) 
            break;
        inDataLink(head_ptr, buff);
    }

    mkBuffChange(Fp, head_ptr, ConnectCNT, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, "//Code_END\n");

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderWriteChannelMI, OutFileName);
    free(buff);

    return BUS_ERROR_NONE;
}


unsigned int genWriteCh(char *OutFileName)
{
    FILE *Fp;
    char *fileName = "./dataSample/WriteChannel/CodePart.v";
    struct codeLine *head_ptr = NULL;
    int    endSlaveNum, endMasterNum;

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    //__________________________________________________ InOutput/def
    mkWriteTOPInOutPort(head_ptr);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process  0
    mkBuffChangeWire(Fp, head_ptr, endMasterNum, 
                         endSlaveNum+1, STATE_END, 1);
    mkBeforeStr(Fp, head_ptr, STATE00_START);
    //STATE00_START process  1
    mkBuffChangeENSI(Fp, head_ptr, endMasterNum, STATE_END, NULL, 0); //write
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    mkBuffChangeWire(Fp, head_ptr, endSlaveNum+1, 
                        endMasterNum, STATE_END, 0);
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkChannelLink(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04_START process
    mkChannelLink(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    mkChannelLink(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    //STATE09_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE10_START);

    //STATE10_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE11_START);

    //STATE11_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, STATE12_START);

    //STATE12_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 0);
    mkBeforeStr(Fp, head_ptr, MASTER_MODULE_GEN);

    //MASTER_MODULE_GEN process
    mkModule(head_ptr, 1); // make master module
    mkBeforeStr(Fp, head_ptr, SLAVE_MODULE_GEN);

    //SLAVE_MODULE_GEN process
    mkModule(head_ptr, 0); // make slave module
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderWriteChannel,  OutFileName);

    return BUS_ERROR_NONE;
}

unsigned int genWriteRsMi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{

    FILE *Fp;
    char *fileName = "./dataSample/RegisterSlice/WriteChannel_MasterInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j,k;

    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable;

    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    int *ConnectMaster;
    int ConnectCnt;
    ConnectMaster = (int *)malloc(sizeof(int) * MAXMASTER);
    ConnectCnt = getConnectMaster(VAL_SLAVE, ConnectMaster, 0);

    LockEnable      = VAL_SLAVE->WriteChPort.LockEnable;
    CacheEnable     = VAL_SLAVE->WriteChPort.CacheEnable;
    ProtectEnable   = VAL_SLAVE->WriteChPort.ProtectEnable;
    WstrbEnable     = VAL_SLAVE->WriteChPort.WstrbEnable;

    //__________________________________________________ InOutput/def
    mkWriteInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 11);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        free(ConnectMaster);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }
    //STATE00 ---> generation wire 
    /////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    if(VAL_SLAVE->modeStoMi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_SLAVE->RegisterSliceStoMi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_SLAVE->RegisterSliceStoMi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 ---> generation module
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, NULL, VAL_SLAVE, 0); //toS interface
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 ---> generation wire
    /////////////////////////////////////////////////////////////
    mkRsWire(Fp, head_ptr, NULL, VAL_SLAVE, 10); //Mi2Si interface
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 ---> generation wire 
    /////////////////////////////////////////////////////////////
    if(VAL_SLAVE->modeMitoSi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_SLAVE->RegisterSliceMitoSi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
    {
        mkBuffChange(Fp, head_ptr, VAL_SLAVE->RegisterSliceMitoSi, 
                STATE_END, NULL);
        mkBeforeStr(Fp, head_ptr, STATE04_START);
    }

    //STATE04 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, NULL, VAL_SLAVE, 10);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05 ---> generation module 
    /////////////////////////////////////////////////////////////
    while(1)
    {
        char ReqNum[4];
        char ReqNum1[4];

        fgets(buff, (sizeof(char)*120), Fp);
        if(strcmp(buff,STATE_END)==0) 
            break;
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);


        sprintf(ReqNum, "w%d",VAL_SLAVE->RegisterSliceStoMi-1); 
        sprintf(ReqNum1, "w%d",VAL_SLAVE->RegisterSliceMitoSi-1); 


        // 2006-8-22-Port disable
        //Lockport generation
        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff, "    .AWLOCKmi2s(), //Disable_lock_port\n");
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff, "    .AWCACHEmi2s (), //Disalbe_cache_port\n");
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff, "    .AWPROTmi2s  (), //Disalbe_protect_port\n");
        }

        //WSTRB port generation
        if(strcmp(buff,"//ENABLE_WSTRB\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(WstrbEnable!= ENABLE)
                strcpy(buff, "    .WSTRBmi2s   (), //Disalbe_WSTRB_port\n");
        }

        if(VAL_SLAVE->modeStoMi == 0)//none resgister slice
            changeStr(buff,buff, "?0?", " ");
        else if(VAL_SLAVE->RegisterSliceStoMi == 0) 
            changeStr(buff,buff, "?0?", " ");
        else
            changeStr(buff,buff, "?0?", ReqNum);

        if(VAL_SLAVE->modeMitoSi == 0)//none resgister slice
            changeStr(buff,buff, "?1?", " ");
        else if(VAL_SLAVE->RegisterSliceMitoSi == 0) 
            changeStr(buff,buff, "?1?", " ");
        else
            changeStr(buff,buff, "?1?", ReqNum1);

        inDataLink(head_ptr, buff);
    }
    fgets(buff, (sizeof(char)*120), Fp);

    //STATE06 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, 11);
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(ConnectMaster);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderWriteChannelSI,  OutFileName);

    free(buff);
    free(ConnectMaster);

    return BUS_ERROR_NONE;

}// the End of genWriteRsMi



unsigned int genWriteRsSi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/RegisterSlice/WriteChannel_SlaveInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j,k;
    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;

    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");


    IDEnable        = VAL_MASTER->WriteChPort.IDEnable;
    LockEnable      = VAL_MASTER->WriteChPort.LockEnable;
    CacheEnable     = VAL_MASTER->WriteChPort.CacheEnable;
    ProtectEnable   = VAL_MASTER->WriteChPort.ProtectEnable;
    WstrbEnable     = VAL_MASTER->WriteChPort.WstrbEnable;

    //__________________________________________________ InOutput/def
    mkWriteInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 10);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    /*
    unsigned int modeMtoSi;  // 0 = disable / 1=Full / 2=Forward
    unsigned int RegisterSliceMtoSi;
    unsigned int modeSitoMi;
    unsigned int RegisterSliceSitoMi;
    */

    //STATE00 ---> generation wire 
    /////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    if(VAL_MASTER->modeMtoSi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_MASTER->RegisterSliceMtoSi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_MASTER->RegisterSliceMtoSi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 ---> generation module
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, VAL_MASTER, NULL, 0);
    mkBeforeStr(Fp, head_ptr, STATE02_START);


    //STATE02 ---> generation wire
    /////////////////////////////////////////////////////////////
    mkRsWire(Fp, head_ptr, VAL_MASTER, NULL, 10);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 ---> generation wire 
    /////////////////////////////////////////////////////////////
    if(VAL_MASTER->modeSitoMi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_MASTER->RegisterSliceSitoMi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_MASTER->RegisterSliceSitoMi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, VAL_MASTER, NULL, 10);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05 ---> generation module 
    /////////////////////////////////////////////////////////////
    while(1)
    {
        char ReqNum[4];
        char ReqNum1[4];

        fgets(buff, (sizeof(char)*120), Fp);
        if(strcmp(buff,STATE_END)==0) 
            break;
        changeStr(buff,buff, "?NAME?", VAL_MASTER->name);


        sprintf(ReqNum, "w%d",VAL_MASTER->RegisterSliceMtoSi-1); 
        sprintf(ReqNum1, "w%d",VAL_MASTER->RegisterSliceSitoMi-1); 

        // 2006-8-17-Port disable
        //Lockport generation

        if(strcmp(buff, "//ENABLE_ID\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable != ENABLE)
                strcpy(buff, "    .AWIDm2si    (1'b0),\n");
        }

        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff, "    .AWLOCKm2si  ({AWLOCK_WID{1'b0}}),\n");
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff, "    .AWCACHEm2si ({AWCACHE_WID{1'b0}}),\n");
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff, "    .AWPROTm2si  ({AWPROT_WID{1'b0}}),\n");
        }

        //WSTRB port generation
        if(strcmp(buff,"//ENABLE_WSTRB\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(WstrbEnable!= ENABLE)
                strcpy(buff, "    .WSTRBm2si   ({STRB_MAX{1'b1}}),\n");
        }
         
        if(VAL_MASTER->modeMtoSi == 0)//none resgister slice
            changeStr(buff,buff, "?0?", " ");
        else if(VAL_MASTER->RegisterSliceMtoSi == 0) 
            changeStr(buff,buff, "?0?", " ");
        else
            changeStr(buff,buff, "?0?", ReqNum);
        
        if(VAL_MASTER->modeSitoMi == 0)//none resgister slice
            changeStr(buff,buff, "?1?", " ");
        else if(VAL_MASTER->RegisterSliceSitoMi == 0) 
            changeStr(buff,buff, "?1?", " ");
        else
            changeStr(buff,buff, "?1?", ReqNum1);

        inDataLink(head_ptr, buff);
    }
    fgets(buff, (sizeof(char)*120), Fp);

    //STATE06 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, 10);
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        //free(ConnectSlave);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderWriteChannelMI,  OutFileName);

    free(buff);

    return BUS_ERROR_NONE;
}// end of genWriteRsSi


unsigned int genWriteChSi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/WriteChannel_SlaveInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;
    char slaveWid[4];

    sprintf(slaveWid, "%d", (int)DefBit(ValMAIN.SlaveNumber + 1));
    endi = (int)ValMAIN.SlaveNumber;
    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    int *ConnectSlave;
    ConnectSlave = (int *)malloc(sizeof(int) * MAXSLAVE);

    /*
     * ConnectSlave[??] = 1 --> connect
     * ConnectSlave[??] = 0 --> non-connect
     * ConnectSlave[??] = 2 --> end
     */
    getConnectSlave(VAL_MASTER, ConnectSlave);

    //__________________________________________________ InOutput/def
    mkWriteInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 0);  

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        free(ConnectSlave);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    
    mkBeforeStr(Fp, head_ptr, STATE00_START);
    mkBuffChange(Fp, head_ptr, endi+1, STATE_END, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process
    mkBuffChangeSt2St(Fp, head_ptr, (endi+1), NULL,  "SLAVE_WID", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, ADDRDECODER_GEN_START);

    //get the address name
    fgets(buff, sizeof(char)*100, Fp);
    rmNewLine(buff);

    //ADDRDECODER_GEN_START process
    mkAddrDecoder(buff, head_ptr, endi, slaveWid, VAL_MASTER, VAL_SLAVE); 
                  //buff --> address name

    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  STATE01_START);

    //STATE01_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "SLAVE_WID", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  "//ARBITER_GEN_START\n");

    //ARBITER_GEN_START process
    mkArbiter(Fp, head_ptr, endi,VAL_MASTER, (char *)slaveWid,ConnectSlave, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START process
    
    mkBuffChange(Fp, head_ptr, endi+1, NULL, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "SLAVE_WID", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04_START process
    mkBuffChange(Fp, head_ptr, endi+1, NULL, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "SLAVE_WID", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "SLAVE_WID", 
                      (char *)slaveWid, ConnectSlave);
    //mkBeforeStr(Fp, head_ptr, "//Code_END\n");
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_MASTER->name);
        inDataLink(head_ptr, buff);
        if(strcmp(buff,Code_END)==0) 
            break;
    }



    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(ConnectSlave);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderWriteChannelSI,  OutFileName);

    free(buff);
    free(ConnectSlave);

    return BUS_ERROR_NONE;
}

