
#include <stdio.h>
#include <math.h>
#include "Bus.h"
#include "genReqInter.h"
#include "genDef.h"
#include "MkFile.h"

const char *HeaderReqInter = {" \
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : ReqInterBuff.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Request and interrupt buffer \n\
//                       \n\
//  ----------------------------------------------------------------\n"};

unsigned int genReqInter(char *OutFileName, DefSlave *VAL_SLAVE)
{

    FILE *Fp;
    char *fileName = "./dataSample/ReqInterBuff/InOutPart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;

    buff = (char *)malloc(sizeof(char) *120);

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);


    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    mkSimpleInOutPort(fileName, head_ptr, VAL_SLAVE->name);

    //__________________________________________________________ Open
    fileName = "./dataSample/ReqInterBuff/CodePart.v";
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code

    char WrIssuCAP[4];
    char *buffOut;

    endi = (int)pow(2.0,(double)VAL_SLAVE->WriteIssuingCap);
    sprintf(WrIssuCAP, "%d",VAL_SLAVE->WriteIssuingCap);
    fgets(buff, (sizeof(char)*100), Fp);
    buffOut = (char *)malloc(sizeof(char)*100);

    //inout definition
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00 START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE00 END process
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE01 END process
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL, 
                      "RdPointWID", (char *)WrIssuCAP, NULL);

    //STATE02 END process
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 START process
    //mkBuffChange(Fp, head_ptr, endi, STATE03_END);
    mkBuffChangeSt2St(Fp, head_ptr, endi, STATE03_END, 
                      "RdPointWID", (char *)WrIssuCAP, NULL);
    
    //End process
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buffOut);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderReqInter, OutFileName);

    free(buffOut);
    free(buff);
    return 0;
}// end genReqInter
