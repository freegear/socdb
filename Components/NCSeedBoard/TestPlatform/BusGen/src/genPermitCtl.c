
#include <stdio.h>
#include <math.h>
#include "Bus.h"
#include "genPermitCtl.h"
#include "genDef.h"
#include "MkFile.h"

const char *HeaderSimplePermit = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : PermitCtl.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Simple mode Permit control block \n\
//                       from AXI_SimpleLocked directory \n\
//                       \n\
//  ----------------------------------------------------------------\n"};


const char *HeaderAdvancedPermit = {"\
// =================================================================\n\
// This confidential and proprietary software may be used only as\n\
// authorised by a licensing agreement from SANGHWA MICRO Technology\n\
// ALL RIGHTS RESERVED SANGHWA MICRO Technology\n\
// -----------------------------------------------------------------\n\
// Version and Release information: S-AXI bus Ver 0.1 \n\
//                                  generated by AXI_GEN0.1 \n\
// \n\
// File Name           : PermitCtl.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Advanced mode Permit control block \n\
//                       from AXI_AdvancedLocked directory \n\
//                       \n\
//  ----------------------------------------------------------------\n"};

unsigned int genAdPermitCtl(char *OutFileName, 
                            DefMaster *VAL_MASTER, int mode)
{

    FILE *Fp;
    char *fileName;
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;
    char *buffOut;
    char IssuCAP[4];

    buff = (char *)malloc(sizeof(char) *100);
    fileName = (char *)malloc(sizeof(char) *300);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    if(mode == WRCH)
    {
        endi = (int)pow(2.0,(double)VAL_MASTER->writeidwid);
        sprintf(IssuCAP, "%d",VAL_MASTER->writeidwid);
        strcpy(fileName, "./dataSample/PermitCtl_ADV/InOutPart_WRCH.v");
    }
    else
    {
        endi = (int)pow(2.0,(double)VAL_MASTER->readidwid);
        sprintf(IssuCAP, "%d",VAL_MASTER->readidwid);
        strcpy(fileName, "./dataSample/PermitCtl_ADV/InOutPart_RDCH.v");
    }

    //__________________________________________________ InOutput/def
    mkSimpleInOutPort(fileName, head_ptr, VAL_MASTER->name);

    //__________________________________________________________ Open
    strcpy(fileName,"./dataSample/PermitCtl_ADV/CodePart.v");
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff); free(fileName);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    buffOut = (char *)malloc(sizeof(char)*100);


    //inout definition
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00 START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE00 END process
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    fgets(buff, (sizeof(char)*100), Fp);
    fgets(buffOut, (sizeof(char)*100), Fp);
    for(i=0; endi > i; i++)
    {
        int  temp;
        char ReqNum[4];
        
        temp = sprintf(ReqNum, "%d", i);
        if(temp == -1)
        {
            printf("Error sprintf process");
            return FILE_PROCESS_ERROR;
        }

        if(mode == WRCH) {
            changeStr(buff,buffOut, "SLAVECNTWID","WrPermit_SLAVECNTWID");
        } else {
            changeStr(buff,buffOut, "SLAVECNTWID","RdPermit_SLAVECNTWID");
        }
        changeStr(buffOut,buffOut, ChangeChar,(char *)ReqNum);
        inDataLink(head_ptr, buffOut);
    }
    fgets(buff, (sizeof(char)*100), Fp);
        if(mode == WRCH) {
            changeStr(buff,buffOut, "SLAVECNTWID","WrPermit_SLAVECNTWID");
        } else {
            changeStr(buff,buffOut, "SLAVECNTWID","RdPermit_SLAVECNTWID");
        }
        inDataLink(head_ptr, buffOut);

    //STATE process Ver 1.9
    mkBeforeStr(Fp, head_ptr, STATE_START);
    fgets(buff, (sizeof(char)*100), Fp);
    fgets(buffOut, (sizeof(char)*100), Fp);
    for(i=0; endi > i; i++)
    {
        int  temp;
        char ReqNum[4];
        
        temp = sprintf(ReqNum, "%d", i);
        if(temp == -1)
        {
            printf("Error sprintf process");
            return FILE_PROCESS_ERROR;
        }

        if(mode == WRCH) {
            changeStr(buff,buffOut, "SLAVECNTWID","WrPermit_SLAVECNTWID");
        } else {
            changeStr(buff,buffOut, "SLAVECNTWID","RdPermit_SLAVECNTWID");
        }
        while(changeStr(buffOut,buffOut, ChangeChar,(char *)ReqNum)== 1);
        inDataLink(head_ptr, buffOut);
    }

    //STATE01 END process
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE02 END process
    //mkBeforeStr(Fp, head_ptr, STATE03_START);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL,  "MASTER_WID", 
                      (char *)IssuCAP, NULL);

    //STATE03 END process
    mkBeforeStr(Fp, head_ptr, STATE02_START);


//Debug_FIXED
    
    //STATE02_START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE02 END process
    //mkBeforeStr(Fp, head_ptr, STATE03_START);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL,  "MASTER_WID", 
                      (char *)IssuCAP, NULL);

    //STATE03 END process
    mkBeforeStr(Fp, head_ptr, STATE04_START);




    //STATE04_START process
    mkBuffChange(Fp, head_ptr, endi, STATE04_END, NULL);

    //STATE04 END process
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL, NULL, NULL, NULL);

    //STATE05 END process
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL, NULL, NULL, NULL);

    //STATE06 END process
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, STATE07_END, 
                      NULL, NULL, NULL);

    //STATE07 END process
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE08 END process
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    //STATE09_START process
    fgets(buff, (sizeof(char)*100), Fp);
    fgets(buffOut, (sizeof(char)*100), Fp);

    for(i=0; endi > i; i++)
    {
        int  temp;
        char ReqNum[4];
        
        temp = sprintf(ReqNum, "%d", i);
        //printf("ReqNum[%d]", temp);
        if(temp == -1)
        {
            free(buff); free(buffOut); 
            printf("Error sprintf process ");
            return FILE_PROCESS_ERROR;
        }

        changeStr(buff,buffOut, ChangeChar,(char *)ReqNum);
        if((endi-1) != i)
            changeStr(buffOut,buffOut, ChangeChar,(char *)"|");
        else
            changeStr(buffOut,buffOut, ChangeChar,(char *)" ");

        inDataLink(head_ptr, buffOut);
    }

    //STATE09 END process
    mkBeforeStr(Fp, head_ptr, STATE10_START);

    //STATE10_START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE10 END process
    mkBeforeStr(Fp, head_ptr, STATE11_START);

    //STATE11_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL,  "MASTER_WID", 
                      (char *)IssuCAP, NULL);


    //Ver 1.9
#if 1
    mkBeforeStr(Fp, head_ptr, STATE_START);
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE_START);
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL,  "MASTER_WID", 
                      (char *)IssuCAP, NULL);
#endif

    //END process
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buffOut);
        free(buff); free(fileName);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderAdvancedPermit, OutFileName);

    free(fileName);
    free(buffOut);
    free(buff);

}// end genAdPermitCtl

unsigned int genSimPermitCtl(char *OutFileName, 
                             DefMaster *VAL_MASTER, int mode)
{
    FILE *Fp;
    char *fileName = "./dataSample/PermitCtl_SIM/InOutPart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;

    buff = (char *)malloc(sizeof(char) *100);
    fileName = (char *)malloc(sizeof(char) *200);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    if(mode == WRCH)
        strcpy(fileName, "./dataSample/PermitCtl_SIM/InOutPart_WRCH.v");
    else
        strcpy(fileName, "./dataSample/PermitCtl_SIM/InOutPart_RDCH.v");


    mkSimpleInOutPort(fileName, head_ptr, VAL_MASTER->name);

    //__________________________________________________________ Open
    strcpy(fileName,"./dataSample/PermitCtl_SIM/CodePart.v");
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff); free(fileName);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code

    char ReqNum[4];

    //inout definition
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00 START process
    fgets(buff, (sizeof(char)*100), Fp);
    if(mode == WRCH)
        changeStr(buff,buff, "SLAVECNTWID","WrPermit_SLAVECNTWID");
    else
        changeStr(buff,buff, "SLAVECNTWID","RdPermit_SLAVECNTWID");

    inDataLink(head_ptr, buff);
    fgets(buff, (sizeof(char)*100), Fp);

    //End process
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        free(fileName);
        free(buff);
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, HeaderSimplePermit,  OutFileName);

    free(fileName);
    free(buff);
}// end genSimPermitCtl


