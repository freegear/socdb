library verilog;
use verilog.vl_types.all;
entity apex20ke_upcore is
    generic(
        processor       : string  := "ARM";
        source          : string  := "";
        sdram_width     : integer := 32;
        sdramdqm_width  : integer := 4;
        gpio_width      : integer := 4;
        req_idle        : integer := 0;
        req_first       : integer := 1;
        req_wait        : integer := 5;
        req_masterhold  : integer := 3;
        req_using       : integer := 2;
        req_again       : integer := 7
    );
    port(
        clkref          : in     vl_logic;
        npor            : in     vl_logic;
        nreseti         : in     vl_logic;
        nreseto         : out    vl_logic;
        nresetoe        : out    vl_logic;
        intnmi          : in     vl_logic;
        perreset        : out    vl_logic;
        intpld          : in     vl_logic_vector(5 downto 0);
        intuart         : out    vl_logic;
        inttimer0       : out    vl_logic;
        inttimer1       : out    vl_logic;
        intproc0        : out    vl_logic;
        intproc1        : out    vl_logic;
        debugrq         : in     vl_logic;
        debugext0       : in     vl_logic;
        debugext1       : in     vl_logic;
        debugiebrkpt    : in     vl_logic;
        debugdewpt      : in     vl_logic;
        debugextin      : in     vl_logic_vector(3 downto 0);
        debugack        : out    vl_logic;
        debugrng0       : out    vl_logic;
        debugrng1       : out    vl_logic;
        debugextout     : out    vl_logic_vector(3 downto 0);
        slavehclk       : in     vl_logic;
        slavehwrite     : in     vl_logic;
        slavehreadyi    : in     vl_logic;
        slavehselreg    : in     vl_logic;
        slavehsel       : in     vl_logic;
        slavehmastlock  : in     vl_logic;
        slavehaddr      : in     vl_logic_vector(31 downto 0);
        slavehwdata     : in     vl_logic_vector(31 downto 0);
        slavehtrans     : in     vl_logic_vector(1 downto 0);
        slavehsize      : in     vl_logic_vector(1 downto 0);
        slavehburst     : in     vl_logic_vector(2 downto 0);
        slavehreadyo    : out    vl_logic;
        slavebuserrint  : out    vl_logic;
        slavehrdata     : out    vl_logic_vector(31 downto 0);
        slavehresp      : out    vl_logic_vector(1 downto 0);
        masterhclk      : in     vl_logic;
        masterhrdata    : in     vl_logic_vector(31 downto 0);
        masterhresp     : in     vl_logic_vector(1 downto 0);
        masterhwrite    : out    vl_logic;
        masterhlock     : out    vl_logic;
        masterhbusreq   : out    vl_logic;
        masterhaddr     : out    vl_logic_vector(31 downto 0);
        masterhwdata    : out    vl_logic_vector(31 downto 0);
        masterhtrans    : out    vl_logic_vector(1 downto 0);
        masterhsize     : out    vl_logic_vector(1 downto 0);
        masterhready    : in     vl_logic;
        masterhburst    : out    vl_logic_vector(2 downto 0);
        masterhgrant    : in     vl_logic;
        lockreqdp0      : in     vl_logic;
        lockreqdp1      : in     vl_logic;
        lockgrantdp0    : out    vl_logic;
        lockgrantdp1    : out    vl_logic;
        ebiack          : in     vl_logic;
        ebiwen          : out    vl_logic;
        ebioen          : out    vl_logic;
        ebiclk          : out    vl_logic;
        ebibe           : out    vl_logic_vector(1 downto 0);
        ebicsn          : out    vl_logic_vector(3 downto 0);
        ebiaddr         : out    vl_logic_vector(24 downto 0);
        ebidqoe         : out    vl_logic;
        ebidqout        : out    vl_logic_vector(15 downto 0);
        ebidqin         : in     vl_logic_vector(15 downto 0);
        uarttxd         : out    vl_logic;
        uartrtsn        : out    vl_logic;
        uartdtrn        : out    vl_logic;
        uartctsn        : in     vl_logic;
        uartdsrn        : in     vl_logic;
        uartrxd         : in     vl_logic;
        uartdcdon       : out    vl_logic;
        uartdcdin       : in     vl_logic;
        uartriin        : in     vl_logic;
        uartrion        : out    vl_logic;
        uartdcdrioe     : out    vl_logic;
        sdramclk        : out    vl_logic;
        sdramclkn       : out    vl_logic;
        sdramclke       : out    vl_logic;
        sdramwen        : out    vl_logic;
        sdramcasn       : out    vl_logic;
        sdramrasn       : out    vl_logic;
        sdramdqm        : out    vl_logic_vector(3 downto 0);
        sdramaddr       : out    vl_logic_vector(14 downto 0);
        sdramdqoe       : out    vl_logic_vector(3 downto 0);
        sdramdqout      : out    vl_logic_vector(31 downto 0);
        sdramdqin       : in     vl_logic_vector(31 downto 0);
        sdramdqsoe      : out    vl_logic;
        sdramcsn        : out    vl_logic_vector(1 downto 0);
        sdramdqsout     : out    vl_logic_vector(3 downto 0);
        sdramdqsin      : in     vl_logic_vector(3 downto 0);
        intextpin       : in     vl_logic;
        traceclk        : out    vl_logic;
        tracesync       : out    vl_logic;
        tracepipestat   : out    vl_logic_vector(2 downto 0);
        tracepkt        : out    vl_logic_vector(15 downto 0);
        gpi             : in     vl_logic_vector(7 downto 0);
        gpo             : out    vl_logic_vector(7 downto 0)
    );
end apex20ke_upcore;
