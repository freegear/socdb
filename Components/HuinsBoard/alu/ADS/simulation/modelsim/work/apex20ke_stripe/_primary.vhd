library verilog;
use verilog.vl_types.all;
entity apex20ke_stripe is
    generic(
        dp0crambits     : integer := 0;
        dp1crambits     : integer := 0;
        globaldpcrambits: integer := 0;
        device_size     : integer := 1000;
        spare_width     : integer := 4;
        dpram_a0width   : integer := 16;
        processor       : string  := "ARM";
        boot_from_flash : string  := "true";
        debug_extensions: string  := "false";
        ebi0_width      : integer := 16;
        use_short_reset : string  := "true";
        use_initialisation_files: string  := "true"
    );
    port(
        clkref          : in     vl_logic;
        npor            : in     vl_logic;
        nreseti         : in     vl_logic;
        nreseto         : out    vl_logic;
        nresetoe        : out    vl_logic;
        masthclk        : in     vl_logic;
        mhready         : in     vl_logic;
        mhgrant         : in     vl_logic;
        mhaddr          : out    vl_logic_vector(31 downto 0);
        mhwdata         : out    vl_logic_vector(31 downto 0);
        mhburst         : out    vl_logic_vector(2 downto 0);
        mhtrans         : out    vl_logic_vector(1 downto 0);
        mhsize          : out    vl_logic_vector(1 downto 0);
        mhlock          : out    vl_logic;
        mhwrite         : out    vl_logic;
        mhbusreq        : out    vl_logic;
        mhrdata         : in     vl_logic_vector(31 downto 0);
        mhresp          : in     vl_logic_vector(1 downto 0);
        slavhclk        : in     vl_logic;
        shwrite         : in     vl_logic;
        shreadyi        : in     vl_logic;
        shselreg        : in     vl_logic;
        shsel           : in     vl_logic;
        shmastlock      : in     vl_logic;
        shrdata         : out    vl_logic_vector(31 downto 0);
        shresp          : out    vl_logic_vector(1 downto 0);
        shaddr          : in     vl_logic_vector(31 downto 0);
        shwdata         : in     vl_logic_vector(31 downto 0);
        shtrans         : in     vl_logic_vector(1 downto 0);
        shsize          : in     vl_logic_vector(1 downto 0);
        shburst         : in     vl_logic_vector(2 downto 0);
        shready         : out    vl_logic;
        mberrorint      : out    vl_logic;
        debugbusout     : in     vl_logic_vector(8 downto 0);
        intbusout       : in     vl_logic_vector(5 downto 0);
        intbusin        : out    vl_logic_vector(4 downto 0);
        intextpin       : in     vl_logic;
        debugbusin      : out    vl_logic_vector(6 downto 0);
        ebiack          : in     vl_logic;
        ebiwen          : out    vl_logic;
        ebioen          : out    vl_logic;
        ebiclk          : out    vl_logic;
        ebiaddress      : out    vl_logic_vector(24 downto 0);
        ebicsn          : out    vl_logic_vector(3 downto 0);
        ebibe           : out    vl_logic_vector(1 downto 0);
        ebidqin         : in     vl_logic_vector(15 downto 0);
        ebidqout        : out    vl_logic_vector(15 downto 0);
        ebidqoe         : out    vl_logic;
        uartctsn        : in     vl_logic;
        uartdsrn        : in     vl_logic;
        uartrxd         : in     vl_logic;
        uarttxd         : out    vl_logic;
        uartrtsn        : out    vl_logic;
        uartdtrn        : out    vl_logic;
        uartdcdin       : in     vl_logic;
        uartriin        : in     vl_logic;
        uartdcdon       : out    vl_logic;
        uartrion        : out    vl_logic;
        uartdcdrioe     : out    vl_logic;
        sdramclk        : out    vl_logic;
        sdramclkn       : out    vl_logic;
        sdramclke       : out    vl_logic;
        sdramwen        : out    vl_logic;
        sdramcasn       : out    vl_logic;
        sdramrasn       : out    vl_logic;
        sdramdqm        : out    vl_logic_vector(3 downto 0);
        sdramcsn        : out    vl_logic_vector(1 downto 0);
        sdramaddress    : out    vl_logic_vector(14 downto 0);
        sdramdqin       : in     vl_logic_vector(31 downto 0);
        sdramdqsin      : in     vl_logic_vector(3 downto 0);
        sdramdqout      : out    vl_logic_vector(31 downto 0);
        sdramdqsout     : out    vl_logic_vector(3 downto 0);
        sdramdqoe       : out    vl_logic_vector(3 downto 0);
        sdramdqsoe      : out    vl_logic;
        traceclk        : out    vl_logic;
        tracesync       : out    vl_logic;
        tracepipestat   : out    vl_logic_vector(2 downto 0);
        tracepkt        : out    vl_logic_vector(15 downto 0);
        clk0dp0         : in     vl_logic;
        clk1dp0         : in     vl_logic;
        clk0dp1         : in     vl_logic;
        clk1dp1         : in     vl_logic;
        r0a0            : in     vl_logic_vector;
        r0a1            : in     vl_logic_vector;
        r0ce0           : in     vl_logic;
        r0ce1           : in     vl_logic;
        r0rd            : in     vl_logic_vector(31 downto 0);
        r0rw0           : in     vl_logic;
        r0rw1           : in     vl_logic;
        r0rq            : out    vl_logic_vector(31 downto 0);
        r0lockrequest   : in     vl_logic;
        r0lockgrant     : out    vl_logic;
        r1a0            : in     vl_logic_vector;
        r1a1            : in     vl_logic_vector;
        r1ce0           : in     vl_logic;
        r1ce1           : in     vl_logic;
        r1rd            : in     vl_logic_vector(31 downto 0);
        r1rw0           : in     vl_logic;
        r1rw1           : in     vl_logic;
        r1rq            : out    vl_logic_vector(31 downto 0);
        r1lockrequest   : in     vl_logic;
        r1lockgrant     : out    vl_logic;
        highaddress     : in     vl_logic;
        spareinr        : out    vl_logic_vector;
        spareinl        : out    vl_logic_vector;
        spareoutr       : in     vl_logic_vector;
        spareoutl       : in     vl_logic_vector
    );
end apex20ke_stripe;
