-- megafunction wizard: %ARM-Based Excalibur%
-- GENERATION: STANDARD
-- VERSION: WM1.0
-- MODULE: ARM-Based Excalibur
-- PROJECT: arm_top
-- ============================================================
-- File Name: /SoCMasterXP8000/tftlcd/quartus/stripe.vhd
-- Megafunction Name(s): ARM-Based Excalibur
-- ============================================================
-- ************************************************************
-- THIS IS A WIZARD-GENERATED FILE. DO NOT EDIT THIS FILE!
-- ************************************************************
-- 
-- Copyright (C) 1991-2004 Altera Corporation
-- Any  megafunction  design,  and related netlist (encrypted  or  decrypted),
-- support information,  device programming or simulation file,  and any other
-- associated  documentation or information  provided by  Altera  or a partner
-- under  Altera's   Megafunction   Partnership   Program  may  be  used  only
-- to program  PLD  devices (but not masked  PLD  devices) from  Altera.   Any
-- other  use  of such  megafunction  design,  netlist,  support  information,
-- device programming or simulation file,  or any other  related documentation
-- or information  is prohibited  for  any  other purpose,  including, but not
-- limited to  modification,  reverse engineering,  de-compiling, or use  with
-- any other  silicon devices,  unless such use is  explicitly  licensed under
-- a separate agreement with  Altera  or a megafunction partner.  Title to the
-- intellectual property,  including patents,  copyrights,  trademarks,  trade
-- secrets,  or maskworks,  embodied in any such megafunction design, netlist,
-- support  information,  device programming or simulation file,  or any other
-- related documentation or information provided by  Altera  or a megafunction
-- partner, remains with Altera, the megafunction partner, or their respective
-- licensors. No other licenses, including any licenses needed under any third
-- party's intellectual property, are provided herein.
-- 
LIBRARY IEEE;
USE IEEE.std_logic_1164.all;

ENTITY stripe IS
	PORT (
		clk_ref	: IN	STD_LOGIC;
		npor	: IN	STD_LOGIC;
		nreset	: INOUT	STD_LOGIC;
		uartrxd	: IN	STD_LOGIC;
		uartdsrn	: IN	STD_LOGIC;
		uartctsn	: IN	STD_LOGIC;
		uartrin	: INOUT	STD_LOGIC;
		uartdcdn	: INOUT	STD_LOGIC;
		uarttxd	: OUT	STD_LOGIC;
		uartrtsn	: OUT	STD_LOGIC;
		uartdtrn	: OUT	STD_LOGIC;
		intextpin	: IN	STD_LOGIC;
		ebiack	: IN	STD_LOGIC;
		ebidq	: INOUT	STD_LOGIC_VECTOR(15 downto 0);
		ebiclk	: OUT	STD_LOGIC;
		ebiwen	: OUT	STD_LOGIC;
		ebioen	: OUT	STD_LOGIC;
		ebiaddr	: OUT	STD_LOGIC_VECTOR(24 downto 0);
		ebibe	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		ebicsn	: OUT	STD_LOGIC_VECTOR(3 downto 0);
		sdramdq	: INOUT	STD_LOGIC_VECTOR(31 downto 0);
		sdramdqs	: INOUT	STD_LOGIC_VECTOR(3 downto 0);
		sdramclk	: OUT	STD_LOGIC;
		sdramclkn	: OUT	STD_LOGIC;
		sdramclke	: OUT	STD_LOGIC;
		sdramwen	: OUT	STD_LOGIC;
		sdramcasn	: OUT	STD_LOGIC;
		sdramrasn	: OUT	STD_LOGIC;
		sdramaddr	: OUT	STD_LOGIC_VECTOR(14 downto 0);
		sdramcsn	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		sdramdqm	: OUT	STD_LOGIC_VECTOR(3 downto 0);
		slavehclk	: IN	STD_LOGIC;
		slavehwrite	: IN	STD_LOGIC;
		slavehreadyi	: IN	STD_LOGIC;
		slavehselreg	: IN	STD_LOGIC;
		slavehsel	: IN	STD_LOGIC;
		slavehmastlock	: IN	STD_LOGIC;
		slavehaddr	: IN	STD_LOGIC_VECTOR(31 downto 0);
		slavehtrans	: IN	STD_LOGIC_VECTOR(1 downto 0);
		slavehsize	: IN	STD_LOGIC_VECTOR(1 downto 0);
		slavehburst	: IN	STD_LOGIC_VECTOR(2 downto 0);
		slavehwdata	: IN	STD_LOGIC_VECTOR(31 downto 0);
		slavehreadyo	: OUT	STD_LOGIC;
		slavebuserrint	: OUT	STD_LOGIC;
		slavehresp	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		slavehrdata	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		masterhclk	: IN	STD_LOGIC;
		masterhready	: IN	STD_LOGIC;
		masterhgrant	: IN	STD_LOGIC;
		masterhrdata	: IN	STD_LOGIC_VECTOR(31 downto 0);
		masterhresp	: IN	STD_LOGIC_VECTOR(1 downto 0);
		masterhwrite	: OUT	STD_LOGIC;
		masterhlock	: OUT	STD_LOGIC;
		masterhbusreq	: OUT	STD_LOGIC;
		masterhaddr	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		masterhburst	: OUT	STD_LOGIC_VECTOR(2 downto 0);
		masterhsize	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		masterhtrans	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		masterhwdata	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		intpld	: IN	STD_LOGIC_VECTOR(5 downto 0)
	);

attribute noopt : boolean;
attribute noopt of stripe: entity is TRUE;

END stripe;

ARCHITECTURE structure OF stripe IS
COMPONENT alt_exc_stripe
GENERIC
(
		processor	: STRING	:= "ARM";
		device_size	: INTEGER	:= 1000;
		sdram_width	: INTEGER	:= 32;
		sdramdqm_width	: INTEGER	:= 4;
		gpio_width	: INTEGER	:= 4;
		boot_from_flash	: STRING	:= "FALSE";
		debug_extensions	: STRING	:= "TRUE";
		ebi0_width	: INTEGER	:= 16;
		use_short_reset	: STRING	:= "FALSE";
		use_initialisation_files	: STRING	:= "FALSE";
		dp0_mode	: STRING	:= "UNUSED";
		dp1_mode	: STRING	:= "UNUSED";
		dp0_width	: INTEGER	:= 2;
		dp1_width	: INTEGER	:= 2;
		dp0_widthad	: INTEGER	:= 2;
		dp1_widthad	: INTEGER	:= 2;
		dp0_output_mode	: STRING	:= "REG";
		dp1_output_mode	: STRING	:= "REG";
		dp0_lpm_file	: STRING	:= "";
		dp1_lpm_file	: STRING	:= "";
		dp2_lpm_file	: STRING	:= "";
		dp3_lpm_file	: STRING	:= ""
);
PORT
(
		clk_ref	: IN	STD_LOGIC;
		npor	: IN	STD_LOGIC;
		nreset	: INOUT	STD_LOGIC;
		uartrxd	: IN	STD_LOGIC;
		uartdsrn	: IN	STD_LOGIC;
		uartctsn	: IN	STD_LOGIC;
		uartrin	: INOUT	STD_LOGIC;
		uartdcdn	: INOUT	STD_LOGIC;
		uarttxd	: OUT	STD_LOGIC;
		uartrtsn	: OUT	STD_LOGIC;
		uartdtrn	: OUT	STD_LOGIC;
		intextpin	: IN	STD_LOGIC;
		ebiack	: IN	STD_LOGIC;
		ebidq	: INOUT	STD_LOGIC_VECTOR(15 downto 0);
		ebiclk	: OUT	STD_LOGIC;
		ebiwen	: OUT	STD_LOGIC;
		ebioen	: OUT	STD_LOGIC;
		ebiaddr	: OUT	STD_LOGIC_VECTOR(24 downto 0);
		ebibe	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		ebicsn	: OUT	STD_LOGIC_VECTOR(3 downto 0);
		sdramdq	: INOUT	STD_LOGIC_VECTOR(31 downto 0);
		sdramdqs	: INOUT	STD_LOGIC_VECTOR(3 downto 0);
		sdramclk	: OUT	STD_LOGIC;
		sdramclkn	: OUT	STD_LOGIC;
		sdramclke	: OUT	STD_LOGIC;
		sdramwen	: OUT	STD_LOGIC;
		sdramcasn	: OUT	STD_LOGIC;
		sdramrasn	: OUT	STD_LOGIC;
		sdramaddr	: OUT	STD_LOGIC_VECTOR(14 downto 0);
		sdramcsn	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		sdramdqm	: OUT	STD_LOGIC_VECTOR(3 downto 0);
		slavehclk	: IN	STD_LOGIC;
		slavehwrite	: IN	STD_LOGIC;
		slavehreadyi	: IN	STD_LOGIC;
		slavehselreg	: IN	STD_LOGIC;
		slavehsel	: IN	STD_LOGIC;
		slavehmastlock	: IN	STD_LOGIC;
		slavehaddr	: IN	STD_LOGIC_VECTOR(31 downto 0);
		slavehtrans	: IN	STD_LOGIC_VECTOR(1 downto 0);
		slavehsize	: IN	STD_LOGIC_VECTOR(1 downto 0);
		slavehburst	: IN	STD_LOGIC_VECTOR(2 downto 0);
		slavehwdata	: IN	STD_LOGIC_VECTOR(31 downto 0);
		slavehreadyo	: OUT	STD_LOGIC;
		slavebuserrint	: OUT	STD_LOGIC;
		slavehresp	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		slavehrdata	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		masterhclk	: IN	STD_LOGIC;
		masterhready	: IN	STD_LOGIC;
		masterhgrant	: IN	STD_LOGIC;
		masterhrdata	: IN	STD_LOGIC_VECTOR(31 downto 0);
		masterhresp	: IN	STD_LOGIC_VECTOR(1 downto 0);
		masterhwrite	: OUT	STD_LOGIC;
		masterhlock	: OUT	STD_LOGIC;
		masterhbusreq	: OUT	STD_LOGIC;
		masterhaddr	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		masterhburst	: OUT	STD_LOGIC_VECTOR(2 downto 0);
		masterhsize	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		masterhtrans	: OUT	STD_LOGIC_VECTOR(1 downto 0);
		masterhwdata	: OUT	STD_LOGIC_VECTOR(31 downto 0);
		intpld	: IN	STD_LOGIC_VECTOR(5 downto 0);
		proc_ntrst	: IN	STD_LOGIC;
		proc_tck	: IN	STD_LOGIC;
		proc_tdi	: IN	STD_LOGIC;
		proc_tms	: IN	STD_LOGIC;
		proc_tdo	: INOUT	STD_LOGIC;
		intuart	: OUT	STD_LOGIC;
		inttimer0	: OUT	STD_LOGIC;
		inttimer1	: OUT	STD_LOGIC;
		intcommtx	: OUT	STD_LOGIC;
		intcommrx	: OUT	STD_LOGIC;
		debugrq	: IN	STD_LOGIC;
		debugext0	: IN	STD_LOGIC;
		debugext1	: IN	STD_LOGIC;
		debugextin	: IN	STD_LOGIC_VECTOR(3 downto 0);
		debugack	: OUT	STD_LOGIC;
		debugrng0	: OUT	STD_LOGIC;
		debugrng1	: OUT	STD_LOGIC;
		debugextout	: OUT	STD_LOGIC_VECTOR(3 downto 0)
);
END COMPONENT;

SIGNAL proc_ntrst : STD_LOGIC;
SIGNAL proc_tck : STD_LOGIC;
SIGNAL proc_tdi : STD_LOGIC;
SIGNAL proc_tms : STD_LOGIC;
SIGNAL proc_tdo : STD_LOGIC;
SIGNAL intuart : STD_LOGIC;
SIGNAL inttimer0 : STD_LOGIC;
SIGNAL inttimer1 : STD_LOGIC;
SIGNAL intcommtx : STD_LOGIC;
SIGNAL intcommrx : STD_LOGIC;
SIGNAL debugrq : STD_LOGIC;
SIGNAL debugext0 : STD_LOGIC;
SIGNAL debugext1 : STD_LOGIC;
SIGNAL debugextin : STD_LOGIC_VECTOR(3 downto 0);
SIGNAL debugack : STD_LOGIC;
SIGNAL debugrng0 : STD_LOGIC;
SIGNAL debugrng1 : STD_LOGIC;
SIGNAL debugextout : STD_LOGIC_VECTOR(3 downto 0);

BEGIN

proc_ntrst <= '1';
proc_tck <= '0';
proc_tdi <= '0';
proc_tms <= '0';
debugrq <= '0';
debugext0 <= '0';
debugext1 <= '0';
debugextin <= (OTHERS => '0');


lpm_instance : alt_exc_stripe
GENERIC MAP
(
	sdram_width => 32,
	sdramdqm_width => 4,
	processor => "ARM",
	device_size => 1000,
	boot_from_flash => "TRUE",
	debug_extensions => "FALSE",
	ebi0_width => 16,
	use_initialisation_files => "TRUE",
	use_short_reset => "TRUE",
	dp0_output_mode => "UNREG",
	dp1_output_mode => "UNREG",
	dp0_mode => "UNUSED",
	dp1_mode => "UNUSED"
)
PORT MAP
(
	clk_ref => clk_ref,
	npor => npor,
	nreset => nreset,
	uartrxd => uartrxd,
	uartdsrn => uartdsrn,
	uartctsn => uartctsn,
	uartrin => uartrin,
	uartdcdn => uartdcdn,
	uarttxd => uarttxd,
	uartrtsn => uartrtsn,
	uartdtrn => uartdtrn,
	intextpin => intextpin,
	ebiack => ebiack,
	ebidq => ebidq,
	ebiclk => ebiclk,
	ebiwen => ebiwen,
	ebioen => ebioen,
	ebiaddr => ebiaddr,
	ebibe => ebibe,
	ebicsn => ebicsn,
	sdramdq => sdramdq,
	sdramdqs => sdramdqs,
	sdramclk => sdramclk,
	sdramclkn => sdramclkn,
	sdramclke => sdramclke,
	sdramwen => sdramwen,
	sdramcasn => sdramcasn,
	sdramrasn => sdramrasn,
	sdramaddr => sdramaddr,
	sdramcsn => sdramcsn,
	sdramdqm => sdramdqm,
	slavehclk => slavehclk,
	slavehwrite => slavehwrite,
	slavehreadyi => slavehreadyi,
	slavehselreg => slavehselreg,
	slavehsel => slavehsel,
	slavehmastlock => slavehmastlock,
	slavehaddr => slavehaddr,
	slavehtrans => slavehtrans,
	slavehsize => slavehsize,
	slavehburst => slavehburst,
	slavehwdata => slavehwdata,
	slavehreadyo => slavehreadyo,
	slavebuserrint => slavebuserrint,
	slavehresp => slavehresp,
	slavehrdata => slavehrdata,
	masterhclk => masterhclk,
	masterhready => masterhready,
	masterhgrant => masterhgrant,
	masterhrdata => masterhrdata,
	masterhresp => masterhresp,
	masterhwrite => masterhwrite,
	masterhlock => masterhlock,
	masterhbusreq => masterhbusreq,
	masterhaddr => masterhaddr,
	masterhburst => masterhburst,
	masterhsize => masterhsize,
	masterhtrans => masterhtrans,
	masterhwdata => masterhwdata,
	intpld => intpld,
	proc_ntrst => proc_ntrst,
	proc_tck => proc_tck,
	proc_tdi => proc_tdi,
	proc_tms => proc_tms,
	proc_tdo => proc_tdo,
	intuart => intuart,
	inttimer0 => inttimer0,
	inttimer1 => inttimer1,
	intcommtx => intcommtx,
	intcommrx => intcommrx,
	debugrq => debugrq,
	debugext0 => debugext0,
	debugext1 => debugext1,
	debugextin => debugextin,
	debugack => debugack,
	debugrng0 => debugrng0,
	debugrng1 => debugrng1,
	debugextout => debugextout
);
END;

