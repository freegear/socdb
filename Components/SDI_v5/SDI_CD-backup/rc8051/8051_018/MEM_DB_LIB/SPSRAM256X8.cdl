*
* Copyright 2005 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
** Generated by bif2cdl v3.0k **
** Version: 2002Q2V0
** Name: SRAM-SP-HS SRAM Generator|TSMC CL018G Process
** Comment: 
** Configuration:  -instname SPSRAM256X8 -words 256 -bits 8 -frequen\
** Configuration: cy 1 -ring_width 4 -mux 8 -drive 12 -write_mask of\
** Configuration: f -wp_size 8 -top_layer met6 -power_type rings -ho\
** Configuration: riz met3 -vert met4 -cust_comment "" -left_bus_del\
** Configuration: im "[" -right_bus_delim "]" -pwr_gnd_rename "VDD:V\
** Configuration: DD,GND:VSS" -prefix "" -pin_space 0.0 -name_case u\
** Configuration: pper -check_instname on -diodes on -inside_ring_ty\
** Configuration: pe GND
** Codefile: 
*
** begin lvs.header
** $Revision: 1.2 $
*.SCALE meter
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT SPSRAM256X8CCG BL BL_ WL WP VSS VDD
** SPSRAM256X8CCG: 6 flat devices **
m1 BL WP CORED VSS N L=0.295U W=0.215U
m2 BL_ WP CORED_ VSS N L=0.295U W=0.215U
m3 CORED_ CORED VDD VDD P L=0.184U W=0.21U
m4 CORED_ CORED VSS VSS N L=0.175U W=0.215U
m5 CORED CORED_ VDD VDD P L=0.184U W=0.21U
m6 CORED CORED_ VSS VSS N L=0.175U W=0.215U
.ENDS SPSRAM256X8CCG
****
.SUBCKT SPSRAM256X8FCIO8 GTP OE_ WE VSS VDD
** SPSRAM256X8FCIO8: 3 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d2 VSS OE_ DN 0.3364P 2.32U
d3 VSS WE DN 0.3364P 2.32U
.ENDS SPSRAM256X8FCIO8
****
.SUBCKT SPSRAM256X8FCSA8 GTP VSS VDD
** SPSRAM256X8FCSA8: 1 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
.ENDS SPSRAM256X8FCSA8
****
.SUBCKT SPSRAM256X8FCCDL A0 A0_ DR DR_ DW DW_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FCCDL: 1 flat devices **
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS SPSRAM256X8FCCDL
****
.SUBCKT SPSRAM256X8LEFT_CAP A0 A0_ DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8LEFT_CAP: 215 flat devices **
XI0_0 GTP_1 OE_ WE VSS VDD SPSRAM256X8FCIO8
XI0_1 GTP_0 VSS VDD SPSRAM256X8FCSA8
XI0_10 BL BL WL_23 WL_23 VSS VDD SPSRAM256X8CCG
XI0_11 BL BL WL_22 WL_22 VSS VDD SPSRAM256X8CCG
XI0_12 BL BL WL_21 WL_21 VSS VDD SPSRAM256X8CCG
XI0_13 BL BL WL_20 WL_20 VSS VDD SPSRAM256X8CCG
XI0_14 BL BL WL_19 WL_19 VSS VDD SPSRAM256X8CCG
XI0_15 BL BL WL_18 WL_18 VSS VDD SPSRAM256X8CCG
XI0_16 BL BL WL_17 WL_17 VSS VDD SPSRAM256X8CCG
XI0_17 BL BL WL_16 WL_16 VSS VDD SPSRAM256X8CCG
XI0_18 BL BL WL_15 WL_15 VSS VDD SPSRAM256X8CCG
XI0_19 BL BL WL_14 WL_14 VSS VDD SPSRAM256X8CCG
XI0_2 A0 A0_ DR DR_ DW DW_ GTP BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8FCCDL
XI0_20 BL BL WL_13 WL_13 VSS VDD SPSRAM256X8CCG
XI0_21 BL BL WL_12 WL_12 VSS VDD SPSRAM256X8CCG
XI0_22 BL BL WL_11 WL_11 VSS VDD SPSRAM256X8CCG
XI0_23 BL BL WL_10 WL_10 VSS VDD SPSRAM256X8CCG
XI0_24 BL BL WL_9 WL_9 VSS VDD SPSRAM256X8CCG
XI0_25 BL BL WL_8 WL_8 VSS VDD SPSRAM256X8CCG
XI0_26 BL BL WL_7 WL_7 VSS VDD SPSRAM256X8CCG
XI0_27 BL BL WL_6 WL_6 VSS VDD SPSRAM256X8CCG
XI0_28 BL BL WL_5 WL_5 VSS VDD SPSRAM256X8CCG
XI0_29 BL BL WL_4 WL_4 VSS VDD SPSRAM256X8CCG
XI0_3 BL BL WL_30 WL_30 VSS VDD SPSRAM256X8CCG
XI0_30 BL BL WL_3 WL_3 VSS VDD SPSRAM256X8CCG
XI0_31 BL BL WL_2 WL_2 VSS VDD SPSRAM256X8CCG
XI0_32 BL BL WL_1 WL_1 VSS VDD SPSRAM256X8CCG
XI0_33 BL BL WL_0 WL_0 VSS VDD SPSRAM256X8CCG
XI0_34 BL BL WL WL VSS VDD SPSRAM256X8CCG
XI0_35 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_36 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_37 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_4 BL BL WL_29 WL_29 VSS VDD SPSRAM256X8CCG
XI0_5 BL BL WL_28 WL_28 VSS VDD SPSRAM256X8CCG
XI0_6 BL BL WL_27 WL_27 VSS VDD SPSRAM256X8CCG
XI0_7 BL BL WL_26 WL_26 VSS VDD SPSRAM256X8CCG
XI0_8 BL BL WL_25 WL_25 VSS VDD SPSRAM256X8CCG
XI0_9 BL BL WL_24 WL_24 VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8LEFT_CAP
****
.SUBCKT SPSRAM256X8FCBWM8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWM8: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS SPSRAM256X8FCBWM8
****
.SUBCKT SPSRAM256X8IO8 BWE BWEMX BWEN D DI_ DPN DPU DW DW_ D_ GBWEN GTP OE_ Q
+  QI SP STUBWE STUBWEI UTIDMX WE VSS VDD
** SPSRAM256X8IO8: 60 flat devices **
m1 QI DPU VSS VSS N L=0.18U W=3.47U
m10 QPD OEI_ VSS VSS N L=0.18U W=0.72U
m11 QIL QI VDD VDD P L=0.18U W=1.27U
m12 QIL QI VSS VSS N L=0.18U W=0.72U
m13 SPN SP VDD VDD P L=0.18U W=0.47U
m14 SPN SP VSS VSS N L=0.18U W=0.31U
m15 DWPD GTPND DWI VSS N L=0.18U W=0.72U
m16 DWPD DW VDD VDD P L=0.27U W=0.22U
m17 DWPD DW VSS VSS N L=0.54U W=0.22U
m18 DWPD GTP DWI VDD P L=0.18U W=0.91U
m19 DW_PU GTPND DNWI VSS N L=0.18U W=0.72U
m2 QI DPN VDD VDD P L=0.18U W=9.12U
m20 DW_PU GTP DNWI VDD P L=0.18U W=0.91U
m21 GTPND GTP VDD VDD P L=0.18U W=0.5U
m22 GTPND GTP VSS VSS N L=0.18U W=0.34U
m23 DI DI_ VDD VDD P L=0.18U W=1.82U
m24 DI DI_ VSS VSS N L=0.18U W=0.89U
m25 DN DI VDD VDD P L=0.18U W=1.25U
m26 DN DI VSS VSS N L=0.18U W=0.61U
m27 WEI N58 VDD VDD P L=0.18U W=1.47U
m28 WEI N58 VSS VSS N L=0.18U W=0.86U
m29 OEI OEI_ VDD VDD P L=0.18U W=1.23U
m3 Q QPU VDD VDD P L=0.18U W=10.8U
m30 OEI OEI_ VSS VSS N L=0.18U W=0.64U
m31 QI SP N84 VDD P L=0.18U W=2U
m32 N84 QIL VDD VDD P L=0.18U W=2U
m33 QI SPN N83 VSS N L=0.18U W=2U
m34 N83 QIL VSS VSS N L=0.18U W=2U
m35 N41 OE_ VDD VDD P L=0.18U W=0.78U
m36 N41 OE_ VSS VSS N L=0.18U W=0.4U
m37 N58 WE VDD VDD P L=0.18U W=0.58U
m38 N58 WE VSS VSS N L=0.18U W=0.29U
m39 DWI WEI VDD VDD P L=0.18U W=1.77U
m4 Q QPD VSS VSS N L=0.18U W=7.2U
m40 N85 WEI VSS VSS N L=0.18U W=1.58U
m41 DWI DI VDD VDD P L=0.18U W=1.77U
m42 DWI DI N85 VSS N L=0.18U W=1.58U
m43 DNWI WEI VDD VDD P L=0.18U W=1.77U
m44 N86 WEI VSS VSS N L=0.18U W=1.58U
m45 DNWI DN VDD VDD P L=0.18U W=1.77U
m46 DNWI DN N86 VSS N L=0.18U W=1.58U
m47 D_ D VDD VDD P L=0.18U W=0.71U
m48 D_ D VSS VSS N L=0.18U W=0.35U
m49 QPU OEI_ QI VDD P L=0.18U W=0.34U
m5 OEI_ N41 VDD VDD P L=0.18U W=2.18U
m50 QPD OEI QI VSS N L=0.18U W=0.65U
m51 DW DWPD VDD VDD P L=0.18U W=5.98U
m52 DW DWPD VSS VSS N L=0.18U W=2.95U
m53 DW_PU DW_ VDD VDD P L=0.27U W=0.22U
m54 DW_PU DW_ VSS VSS N L=0.54U W=0.22U
m55 DW_ DW_PU VDD VDD P L=0.18U W=5.98U
m56 DW_ DW_PU VSS VSS N L=0.18U W=2.95U
m57 N87 VSS VDD VDD P L=0.18U W=0.44U
m58 BWE VSS VSS VSS N L=0.18U W=0.22U
m59 BWE GBWEN N87 VDD P L=0.18U W=0.44U
m6 OEI_ N41 VSS VSS N L=0.18U W=1.11U
m60 BWE GBWEN VSS VSS N L=0.18U W=0.22U
m7 QPD OEI_ QI VDD P L=0.18U W=6.92U
m8 QPU OEI QI VSS N L=0.18U W=3.24U
m9 QPU OEI VDD VDD P L=0.18U W=1.74U
.ENDS SPSRAM256X8IO8
****
.SUBCKT SPSRAM256X8IOX BWE D DI_ DPN DPU DW DW_ GTP OE_ Q QI SP STUBWE VSS VDD
** SPSRAM256X8IOX: 60 flat devices **
XI0_0 BWE VSS VSS D DI_ DPN DPU DW DW_ DI_ VSS GTP OE_ Q QI SP STUBWE STUBWE
+  VSS STUBWE VSS VDD SPSRAM256X8IO8
.ENDS SPSRAM256X8IOX
****
.SUBCKT SPSRAM256X8SA8 DPN DPU DR DR_ DW DW_ GTP SP VSS VDD
** SPSRAM256X8SA8: 41 flat devices **
m1 N22 SRCD VSS VSS N L=0.18U W=1.5U
m10 DPN SDN VDD VDD P L=0.18U W=1.54U
m11 DPN SDN VSS VSS N L=0.18U W=2.9U
m12 SP SPN VDD VDD P L=0.18U W=1.98U
m13 SP SPN VSS VSS N L=0.18U W=1.33U
m14 GTPN GTP VDD VDD P L=0.18U W=1U
m15 GTPN GTP VSS VSS N L=0.18U W=0.31U
m16 ND1 GTPN VDD VDD P L=0.18U W=0.58U
m17 ND1 GTPN VSS VSS N L=0.18U W=0.33U
m18 ND2 ND1 VDD VDD P L=0.18U W=1.65U
m19 ND2 ND1 VSS VSS N L=0.18U W=0.71U
m2 SD SP DR VDD P L=0.189U W=3.195U
m20 N40 DRP VSS VSS N L=0.18U W=1.22U
m21 SPN GTPN N40 VSS N L=0.18U W=0.83U
m22 SPN DRP VDD VDD P L=0.18U W=1.11U
m23 SPN GTPN VDD VDD P L=0.18U W=0.66U
m24 DRP ND2 VDD VDD P L=0.18U W=3U
m25 DRP ND2 VSS VSS N L=0.18U W=2.01U
m26 DR_ DRP VDD VDD P L=0.18U W=3.65U
m27 DR DRP VDD VDD P L=0.18U W=3.65U
m28 DR DRP DR_ VDD P L=0.18U W=4.68U
m29 SD_ SD SRC VSS N L=0.257U W=3.56U
m3 SD_ SP DR_ VDD P L=0.189U W=3.195U
m30 SD SD_ SRC VSS N L=0.257U W=3.56U
m31 SD_ SD SRC VSS N L=0.257U W=3.56U
m32 SD SD_ SRC VSS N L=0.257U W=3.56U
m33 SRC GTPN N22 VSS N L=0.18U W=1.65U
m34 SRCD SRCPU VDD VDD P L=0.18U W=0.62U
m35 SRCD SRCPU VSS VSS N L=0.18U W=0.22U
m36 SRCPU DRP VDD VDD P L=0.18U W=0.91U
m37 SRCPU DRP VSS VSS N L=0.18U W=0.33U
m38 VDD SRCPU SRC VSS N L=0.18U W=1.66U
m39 SD SRCD SD_ VDD P L=0.18U W=0.68U
m4 SD_ SD VDD VDD P L=0.18U W=0.68U
m40 SRC GTPN N52 VSS N L=0.18U W=1.65U
m41 N52 SRCD VSS VSS N L=0.18U W=1.5U
m5 SD SD_ VDD VDD P L=0.18U W=0.68U
m6 SDN SD VDD VDD P L=0.18U W=1.64U
m7 SDN SD VSS VSS N L=0.18U W=0.58U
m8 DPU SD_ VDD VDD P L=0.18U W=1.64U
m9 DPU SD_ VSS VSS N L=0.18U W=0.58U
.ENDS SPSRAM256X8SA8
****
.SUBCKT SPSRAM256X8CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.18U W=3.24U
m10 BL1_ BL1PD VSS VSS N L=0.18U W=6.72U
m11 BL1_PD CS1 DW_ VDD P L=0.18U W=1.72U
m12 BL1_PD CS1 VSS VSS N L=0.18U W=0.88U
m13 BL1_ CS1 DR_ VDD P L=0.18U W=3.24U
m14 BL1PD CS1 DW VDD P L=0.18U W=1.72U
m15 BL1PD CS1 VSS VSS N L=0.18U W=0.88U
m16 BL1 BL1_PD VSS VSS N L=0.18U W=6.72U
m17 BL0_ YI VDD VDD P L=0.18U W=11.8U
m18 BL0 YI VDD VDD P L=0.18U W=11.8U
m19 BL0 YI BL0_ VDD P L=0.18U W=11.8U
m2 BL0 BL0PD VSS VSS N L=0.18U W=6.72U
m20 BL1 YI VDD VDD P L=0.18U W=11.8U
m21 BL1_ YI VDD VDD P L=0.18U W=11.8U
m22 BL1_ YI BL1 VDD P L=0.18U W=11.8U
m23 CS0 A0_ VDD VDD P L=0.18U W=2.09U
m24 N65 A0_ VSS VSS N L=0.18U W=2.13U
m25 CS0 YI VDD VDD P L=0.18U W=2.09U
m26 CS0 YI N65 VSS N L=0.18U W=2.13U
m27 CS1 A0 VDD VDD P L=0.18U W=2.09U
m28 N66 A0 VSS VSS N L=0.18U W=2.13U
m29 CS1 YI VDD VDD P L=0.18U W=2.09U
m3 BL0_PD CS0 DW VDD P L=0.18U W=1.72U
m30 CS1 YI N66 VSS N L=0.18U W=2.13U
m31 YCDSEL_ G0 VDD VDD P L=0.18U W=0.81U
m32 N67 G0 VSS VSS N L=0.18U W=0.76U
m33 YCDSEL_ G1 VDD VDD P L=0.18U W=0.81U
m34 YCDSEL_ G1 N67 VSS N L=0.18U W=0.76U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.18U W=0.47U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.18U W=0.22U
m37 N37 YCDSEL_ GTP VDD P L=0.18U W=0.66U
m38 N37 YCDSEL_ VSS VSS N L=0.18U W=1.06U
m39 YI WL1_EN_ VDD VDD P L=0.18U W=13.14U
m4 BL0_PD CS0 VSS VSS N L=0.18U W=0.88U
m40 YI WL1_EN_ VSS VSS N L=0.18U W=7.69U
m41 WL1_EN_ N37 VDD VDD P L=0.18U W=4U
m42 WL1_EN_ N37 VSS VSS N L=0.18U W=2.97U
m43 N37 YCDSEL GTP VSS N L=0.18U W=0.66U
m5 BL0 CS0 DR VDD P L=0.18U W=3.24U
m6 BL0PD CS0 DW_ VDD P L=0.18U W=1.72U
m7 BL0PD CS0 VSS VSS N L=0.18U W=0.88U
m8 BL0_ BL0_PD VSS VSS N L=0.18U W=6.72U
m9 BL1 CS1 DR VDD P L=0.18U W=3.24U
.ENDS SPSRAM256X8CD
****
.SUBCKT SPSRAM256X8CDX A0 A0_ BL0 BL0_ BL1 BL1_ DRSA DWSA G0 G1 GTP STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** SPSRAM256X8CDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL1 BL1_ STUBDR DRSA STUBDR_ STUBDW DWSA STUBDW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8CD
.ENDS SPSRAM256X8CDX
****
.SUBCKT SPSRAM256X8MUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0__0 BL0__1
+  BL0__2 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1__0 BL1__1 BL1__2 DRSA DRSA_0 DRSA_1
+  DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_1 DRSA_2 DRSA_0 DWSA_1 DWSA_2
+  DWSA_0 YP0_3 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8CD
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_1 DWSA_1 YP0_2 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CDX
XI2_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_0 DWSA_0 YP0_1 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CDX
XI3_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA DWSA YP0_0 VDD GTP DRSA_1 DRSA_0 DWSA_1
+  DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8CDX
.ENDS SPSRAM256X8MUX_CD_ODD
****
.SUBCKT SPSRAM256X8CCP BL BL_ WL WP VSS VDD
** SPSRAM256X8CCP: 6 flat devices **
m1 BL WP CORED VSS N L=0.295U W=0.215U
m2 BL_ WP CORED_ VSS N L=0.295U W=0.215U
m3 CORED_ CORED VDD VDD P L=0.184U W=0.21U
m4 CORED_ CORED VSS VSS N L=0.175U W=0.215U
m5 CORED CORED_ VDD VDD P L=0.184U W=0.21U
m6 CORED CORED_ VSS VSS N L=0.175U W=0.215U
.ENDS SPSRAM256X8CCP
****
.SUBCKT SPSRAM256X8BIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** SPSRAM256X8BIT_MUX_1: 48 flat devices **
XI0_0 BL_6 BL__6 WL WP VSS VDD SPSRAM256X8CCG
XI1_0 BL_5 BL__5 WL WP VSS VDD SPSRAM256X8CCP
XI2_0 BL_4 BL__4 WL WP VSS VDD SPSRAM256X8CCP
XI3_0 BL_3 BL__3 WL WP VSS VDD SPSRAM256X8CCG
XI4_0 BL_2 BL__2 WL WP VSS VDD SPSRAM256X8CCG
XI5_0 BL_1 BL__1 WL WP VSS VDD SPSRAM256X8CCP
XI6_0 BL_0 BL__0 WL WP VSS VDD SPSRAM256X8CCP
XI7_0 BL BL_ WL WP VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8BIT_MUX_1
****
.SUBCKT SPSRAM256X8BIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** SPSRAM256X8BIT_MUX_0: 48 flat devices **
XI0_0 BL_6 BL__6 WL WP VSS VDD SPSRAM256X8CCG
XI1_0 BL_5 BL__5 WL WP VSS VDD SPSRAM256X8CCP
XI2_0 BL_4 BL__4 WL WP VSS VDD SPSRAM256X8CCP
XI3_0 BL_3 BL__3 WL WP VSS VDD SPSRAM256X8CCG
XI4_0 BL_2 BL__2 WL WP VSS VDD SPSRAM256X8CCG
XI5_0 BL_1 BL__1 WL WP VSS VDD SPSRAM256X8CCP
XI6_0 BL_0 BL__0 WL WP VSS VDD SPSRAM256X8CCP
XI7_0 BL BL_ WL WP VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8BIT_MUX_0
****
.SUBCKT SPSRAM256X8BIT_COL BL BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8
+  BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 VSS VDD
** SPSRAM256X8BIT_COL: 1536 flat devices **
XI0_0 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_30 WP_30 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_1 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_29 WP_29 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_10 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_20 WP_20 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_11 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_19 WP_19 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_12 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_18 WP_18 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_13 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_17 WP_17 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_14 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_16 WP_16 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_15 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_15 WP_15 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_16 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_14 WP_14 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_17 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_13 WP_13 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_18 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_12 WP_12 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_19 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_11 WP_11 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_2 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_28 WP_28 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_20 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_10 WP_10 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_21 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_9 WP_9 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_22 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_8 WP_8 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_23 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_7 WP_7 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_24 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_6 WP_6 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_25 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_5 WP_5 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_26 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_4 WP_4 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_27 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_3 WP_3 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_28 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_2 WP_2 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_29 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_1 WP_1 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_3 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_27 WP_27 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_30 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_0 WP_0 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_31 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL WP VSS VDD SPSRAM256X8BIT_MUX_1
XI0_4 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_26 WP_26 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_5 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_25 WP_25 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_6 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_24 WP_24 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_7 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_23 WP_23 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_8 BL_0 BL BL_2 BL_4 BL_6 BL_8 BL_10 BL_12 BL_14 BL_1 BL_3 BL_5 BL_7 BL_9
+  BL_11 BL_13 WL_22 WP_22 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_9 BL BL_0 BL_1 BL_3 BL_5 BL_7 BL_9 BL_11 BL_13 BL_2 BL_4 BL_6 BL_8 BL_10
+  BL_12 BL_14 WL_21 WP_21 VSS VDD SPSRAM256X8BIT_MUX_1
.ENDS SPSRAM256X8BIT_COL
****
.SUBCKT SPSRAM256X8MCOL_ODD_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MCOL_ODD_M8: 1811 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWM8
XI0_1 BWE D DI_ DPN DPU STUBDW STUBDW_ GTP_1 OE_ Q QI SP STUBWE VSS VDD
+  SPSRAM256X8IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_2 BL__3 BL_6 BL__0 BL_0 BL_1 BL__4
+  BL_5 BL__1 BL_4 BL__5 VSS STUBDR_ STUBDR VSS VSS STUBDW_ STUBDW VSS GTP
+  STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS
+  VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_ODD_M8
****
.SUBCKT SPSRAM256X8MUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0__0 BL0__1
+  BL0__2 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1__0 BL1__1 BL1__2 DRSA DRSA_0 DRSA_1
+  DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0_2 BL0__2 BL1_2 BL1__2 DRSA_2 DWSA_2 YP0_0 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CDX
XI1_0 A0 A0_ BL0_1 BL0__1 BL1_1 BL1__1 DRSA_1 DWSA_1 YP0_1 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CDX
XI2_0 A0 A0_ BL0_0 BL0__0 BL1_0 BL1__0 DRSA_0 DWSA_0 YP0_2 VDD GTP DRSA_1
+  DRSA_0 DWSA_1 DWSA_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CDX
XI3_0 A0 A0_ BL0 BL0_ BL1 BL1_ DRSA_1 DRSA DRSA_0 DWSA_1 DWSA DWSA_0 YP0_3 VDD
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8CD
.ENDS SPSRAM256X8MUX_CD_EVEN
****
.SUBCKT SPSRAM256X8MCOL_EVEN_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MCOL_EVEN_M8: 1811 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWM8
XI0_1 BWE D DI_ DPN DPU STUBDW_0 STUBDW__0 GTP_1 OE_ Q QI SP STUBWE VSS VDD
+  SPSRAM256X8IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  SPSRAM256X8SA8
XI0_3 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_2 BL__3 BL_6 BL__0 BL_0 BL_1 BL__4
+  BL_5 BL__1 BL_4 BL__5 VSS STUBDR__0 STUBDR_0 VSS VSS STUBDW__0 STUBDW_0 VSS
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS
+  VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_EVEN_M8
****
.SUBCKT SPSRAM256X8FCBWLE8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWLE8: 3 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS BWEN DN 0.3364P 2.32U
d3 VSS D DN 0.3364P 2.32U
.ENDS SPSRAM256X8FCBWLE8
****
.SUBCKT SPSRAM256X8FCBWLX BWEN D Q VSS VDD
** SPSRAM256X8FCBWLX: 3 flat devices **
XI0_0 BWEN D Q VSS VDD SPSRAM256X8FCBWLE8
.ENDS SPSRAM256X8FCBWLX
****
.SUBCKT SPSRAM256X8MCOL_EVEN_LX8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MCOL_EVEN_LX8: 1812 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWLX
XI0_1 BWE D DI_ DPN DPU STUBDW_0 STUBDW__0 GTP_1 OE_ Q QI SP STUBWE VSS VDD
+  SPSRAM256X8IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  SPSRAM256X8SA8
XI0_3 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_2 BL__3 BL_6 BL__0 BL_0 BL_1 BL__4
+  BL_5 BL__1 BL_4 BL__5 VSS STUBDR__0 STUBDR_0 VSS VSS STUBDW__0 STUBDW_0 VSS
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS
+  VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_EVEN_LX8
****
.SUBCKT SPSRAM256X8WING_4_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D D_0 D_1
+  D_2 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 STUBDR STUBDR_ STUBDR_0 STUBDR__0
+  STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8WING_4_LEFT: 7245 flat devices **
XI0_0 A0 A0_ BL_23 BL__23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_3 STUBDR__1 STUBDR_0 STUBDR__0 STUBDW_5 STUBDW__7 STUBDW_0 STUBDW__0
+  STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI1_0 A0 A0_ BL_22 BL__22 BL_21 BL_20 BL_19 BL_18 BL_17 BL_16 BL_15 BL__21
+  BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI2_0 A0 A0_ BL_7 BL__7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_19
+  STUBDR__17 STUBDR_0_11 STUBDR__0_9 STUBDW_21 STUBDW__23 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI3_0 A0 A0_ BL_6 BL__6 BL_5 BL_4 BL_3 BL_2 BL_1 BL_0 BL BL__5 BL__4 BL__3
+  BL__2 BL__1 BL__0 BL_ D GTP GTP_0 GTP_1 OE_ Q STUBDR_19 STUBDR__17 STUBDR
+  STUBDR_ STUBDW_21 STUBDW__23 STUBDW STUBDW_ STUBWE WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8MCOL_EVEN_LX8
.ENDS SPSRAM256X8WING_4_LEFT
****
.SUBCKT SPSRAM256X8HXP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0 AY0_
+  BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8HXP24: 100 flat devices **
d15 VSS A1 DN 0.3364P 2.32U
d16 VSS BWEN DN 0.3364P 2.32U
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N29 N36 VDD VDD P L=0.18U W=8.16U
m10 N33 N45 VSS VSS N L=0.18U W=4U
m100 XP_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.13U
m11 N32 ACONN1 VDD VDD P L=0.18U W=8.16U
m12 N32 ACONN1 VSS VSS N L=0.18U W=4.02U
m13 N45 ACONN1 VDD VDD P L=0.18U W=6.52U
m14 N45 ACONN1 VSS VSS N L=0.18U W=3.2U
m17 AP_I5-APN1 N62 AP_I5-AIND1 VSS N L=0.18U W=6.24U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U
m19 N62 AGTPT VDD VDD P L=0.18U W=1.48U
m2 N29 N36 VSS VSS N L=0.18U W=4U
m20 N62 AGTPT VSS VSS N L=0.18U W=0.94U
m21 AP_I5-AIN21 N29 VDD VDD P L=0.18U W=5.94U
m22 AP_I5-AIN21 N29 VSS VSS N L=0.18U W=2.87U
m23 N56 N33 VDD VDD P L=0.18U W=5.94U
m24 N56 N33 VSS VSS N L=0.18U W=2.87U
m25 N57 VSS VDD VDD P L=0.18U W=5.94U
m26 N57 VSS VSS VSS N L=0.18U W=2.87U
m27 N91 N57 VSS VSS N L=0.18U W=6.24U
m28 N90 N56 N91 VSS N L=0.18U W=6.24U
m29 AP_I5-AIND1 AP_I5-AIN21 N90 VSS N L=0.18U W=6.24U
m3 N28 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 AP_I5-AIND1 N57 VDD VDD P L=0.18U W=10.66U
m31 N89 N57 VSS VSS N L=0.18U W=6.24U
m32 AP_I5-AIND1 N56 VDD VDD P L=0.18U W=10.66U
m33 N88 N56 N89 VSS N L=0.18U W=6.24U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U
m35 AP_I5-AIND1 AP_I5-AIN21 N88 VSS N L=0.18U W=6.24U
m36 AP_I5-APN0 N73 AP_I5-AIND0 VSS N L=0.18U W=6.24U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U
m38 N73 AGTPB VDD VDD P L=0.18U W=1.48U
m39 N73 AGTPB VSS VSS N L=0.18U W=0.94U
m4 N28 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 AP_I5-AIN20 N28 VDD VDD P L=0.18U W=5.94U
m41 AP_I5-AIN20 N28 VSS VSS N L=0.18U W=2.87U
m42 N95 N57 VSS VSS N L=0.18U W=6.24U
m43 N94 N56 N95 VSS N L=0.18U W=6.24U
m44 AP_I5-AIND0 AP_I5-AIN20 N94 VSS N L=0.18U W=6.24U
m45 AP_I5-AIND0 N57 VDD VDD P L=0.18U W=10.66U
m46 N93 N57 VSS VSS N L=0.18U W=6.24U
m47 AP_I5-AIND0 N56 VDD VDD P L=0.18U W=10.66U
m48 N92 N56 N93 VSS N L=0.18U W=6.24U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U
m5 N36 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AP_I5-AIND0 AP_I5-AIN20 N92 VSS N L=0.18U W=6.24U
m51 AP_I5-APN1 XP_0 VDD VDD P L=0.27U W=0.22U
m52 AP_I5-APN1 XP_0 VSS VSS N L=0.54U W=0.22U
m53 XP_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U
m54 XP_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.13U
m55 AP_I5-APN0 XP_1 VDD VDD P L=0.27U W=0.22U
m56 AP_I5-APN0 XP_1 VSS VSS N L=0.54U W=0.22U
m57 XP_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U
m58 XP_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.13U
m59 AP_I6-APN1 N104 AP_I6-AIND1 VSS N L=0.18U W=6.24U
m6 N36 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U
m61 N104 AGTPT VDD VDD P L=0.18U W=1.48U
m62 N104 AGTPT VSS VSS N L=0.18U W=0.94U
m63 AP_I6-AIN21 N29 VDD VDD P L=0.18U W=5.94U
m64 AP_I6-AIN21 N29 VSS VSS N L=0.18U W=2.87U
m65 N98 N32 VDD VDD P L=0.18U W=5.94U
m66 N98 N32 VSS VSS N L=0.18U W=2.87U
m67 N99 VSS VDD VDD P L=0.18U W=5.94U
m68 N99 VSS VSS VSS N L=0.18U W=2.87U
m69 N133 N99 VSS VSS N L=0.18U W=6.24U
m70 N132 N98 N133 VSS N L=0.18U W=6.24U
m71 AP_I6-AIND1 AP_I6-AIN21 N132 VSS N L=0.18U W=6.24U
m72 AP_I6-AIND1 N99 VDD VDD P L=0.18U W=10.66U
m73 N131 N99 VSS VSS N L=0.18U W=6.24U
m74 AP_I6-AIND1 N98 VDD VDD P L=0.18U W=10.66U
m75 N130 N98 N131 VSS N L=0.18U W=6.24U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U
m77 AP_I6-AIND1 AP_I6-AIN21 N130 VSS N L=0.18U W=6.24U
m78 AP_I6-APN0 N115 AP_I6-AIND0 VSS N L=0.18U W=6.24U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U
m80 N115 AGTPB VDD VDD P L=0.18U W=1.48U
m81 N115 AGTPB VSS VSS N L=0.18U W=0.94U
m82 AP_I6-AIN20 N28 VDD VDD P L=0.18U W=5.94U
m83 AP_I6-AIN20 N28 VSS VSS N L=0.18U W=2.87U
m84 N137 N99 VSS VSS N L=0.18U W=6.24U
m85 N136 N98 N137 VSS N L=0.18U W=6.24U
m86 AP_I6-AIND0 AP_I6-AIN20 N136 VSS N L=0.18U W=6.24U
m87 AP_I6-AIND0 N99 VDD VDD P L=0.18U W=10.66U
m88 N135 N99 VSS VSS N L=0.18U W=6.24U
m89 AP_I6-AIND0 N98 VDD VDD P L=0.18U W=10.66U
m9 N33 N45 VDD VDD P L=0.18U W=8.16U
m90 N134 N98 N135 VSS N L=0.18U W=6.24U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U
m92 AP_I6-AIND0 AP_I6-AIN20 N134 VSS N L=0.18U W=6.24U
m93 AP_I6-APN1 XP_2 VDD VDD P L=0.27U W=0.22U
m94 AP_I6-APN1 XP_2 VSS VSS N L=0.54U W=0.22U
m95 XP_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U
m96 XP_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.13U
m97 AP_I6-APN0 XP_3 VDD VDD P L=0.27U W=0.22U
m98 AP_I6-APN0 XP_3 VSS VSS N L=0.54U W=0.22U
m99 XP_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U
.ENDS SPSRAM256X8HXP24
****
.SUBCKT SPSRAM256X8HXP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HXP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8HXP24
.ENDS SPSRAM256X8HXP24X
****
.SUBCKT SPSRAM256X8HXP38 A0 A1 A2 ACONN0 ACONN1 ACONN2 AGTPB AGTPT AMX0 AMX1
+  AMX2 AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HXP38: 192 flat devices **
d175 VSS A2 DN 0.3364P 2.32U
d176 VSS BWEN DN 0.3364P 2.32U
d183 VSS A1 DN 0.3364P 2.32U
d184 VSS BWEN DN 0.3364P 2.32U
d191 VSS A0 DN 0.3364P 2.32U
d192 VSS BWEN DN 0.3364P 2.32U
m1 AP67-APN1 N54 AP67-AIND1 VSS N L=0.18U W=6.24U
m10 N49 AI2_ VSS VSS N L=0.18U W=2.87U
m100 AP23-AIND1 N132 VDD VDD P L=0.18U W=10.66U
m101 N164 N132 N165 VSS N L=0.18U W=6.24U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.18U W=10.66U
m103 AP23-AIND1 AP23-AIN21 N164 VSS N L=0.18U W=6.24U
m104 AP23-APN0 N149 AP23-AIND0 VSS N L=0.18U W=6.24U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.18U W=10.66U
m106 N149 AGTPB VDD VDD P L=0.18U W=1.48U
m107 N149 AGTPB VSS VSS N L=0.18U W=0.94U
m108 AP23-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m109 AP23-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m11 N83 N49 VSS VSS N L=0.18U W=6.24U
m110 N171 N133 VSS VSS N L=0.18U W=6.24U
m111 N170 N132 N171 VSS N L=0.18U W=6.24U
m112 AP23-AIND0 AP23-AIN20 N170 VSS N L=0.18U W=6.24U
m113 AP23-AIND0 N133 VDD VDD P L=0.18U W=10.66U
m114 N169 N133 VSS VSS N L=0.18U W=6.24U
m115 AP23-AIND0 N132 VDD VDD P L=0.18U W=10.66U
m116 N168 N132 N169 VSS N L=0.18U W=6.24U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.18U W=10.66U
m118 AP23-AIND0 AP23-AIN20 N168 VSS N L=0.18U W=6.24U
m119 AP23-APN1 XP_3 VDD VDD P L=0.27U W=0.22U
m12 N82 N48 N83 VSS N L=0.18U W=6.24U
m120 AP23-APN1 XP_3 VSS VSS N L=0.54U W=0.22U
m121 XP_3 AP23-APN1 VDD VDD P L=0.18U W=28.56U
m122 XP_3 AP23-APN1 VSS VSS N L=0.18U W=15.13U
m123 AP23-APN0 XP_2 VDD VDD P L=0.27U W=0.22U
m124 AP23-APN0 XP_2 VSS VSS N L=0.54U W=0.22U
m125 XP_2 AP23-APN0 VDD VDD P L=0.18U W=28.56U
m126 XP_2 AP23-APN0 VSS VSS N L=0.18U W=15.13U
m127 AP01-APN1 N180 AP01-AIND1 VSS N L=0.18U W=6.24U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.18U W=10.66U
m129 N180 AGTPT VDD VDD P L=0.18U W=1.48U
m13 AP67-AIND1 AP67-AIN21 N82 VSS N L=0.18U W=6.24U
m130 N180 AGTPT VSS VSS N L=0.18U W=0.94U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m133 N174 AI1 VDD VDD P L=0.18U W=5.94U
m134 N174 AI1 VSS VSS N L=0.18U W=2.87U
m135 N175 AI2 VDD VDD P L=0.18U W=5.94U
m136 N175 AI2 VSS VSS N L=0.18U W=2.87U
m137 N209 N175 VSS VSS N L=0.18U W=6.24U
m138 N208 N174 N209 VSS N L=0.18U W=6.24U
m139 AP01-AIND1 AP01-AIN21 N208 VSS N L=0.18U W=6.24U
m14 AP67-AIND1 N49 VDD VDD P L=0.18U W=10.66U
m140 AP01-AIND1 N175 VDD VDD P L=0.18U W=10.66U
m141 N207 N175 VSS VSS N L=0.18U W=6.24U
m142 AP01-AIND1 N174 VDD VDD P L=0.18U W=10.66U
m143 N206 N174 N207 VSS N L=0.18U W=6.24U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.18U W=10.66U
m145 AP01-AIND1 AP01-AIN21 N206 VSS N L=0.18U W=6.24U
m146 AP01-APN0 N191 AP01-AIND0 VSS N L=0.18U W=6.24U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.18U W=10.66U
m148 N191 AGTPB VDD VDD P L=0.18U W=1.48U
m149 N191 AGTPB VSS VSS N L=0.18U W=0.94U
m15 N81 N49 VSS VSS N L=0.18U W=6.24U
m150 AP01-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m151 AP01-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m152 N213 N175 VSS VSS N L=0.18U W=6.24U
m153 N212 N174 N213 VSS N L=0.18U W=6.24U
m154 AP01-AIND0 AP01-AIN20 N212 VSS N L=0.18U W=6.24U
m155 AP01-AIND0 N175 VDD VDD P L=0.18U W=10.66U
m156 N211 N175 VSS VSS N L=0.18U W=6.24U
m157 AP01-AIND0 N174 VDD VDD P L=0.18U W=10.66U
m158 N210 N174 N211 VSS N L=0.18U W=6.24U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.18U W=10.66U
m16 AP67-AIND1 N48 VDD VDD P L=0.18U W=10.66U
m160 AP01-AIND0 AP01-AIN20 N210 VSS N L=0.18U W=6.24U
m161 AP01-APN1 XP_1 VDD VDD P L=0.27U W=0.22U
m162 AP01-APN1 XP_1 VSS VSS N L=0.54U W=0.22U
m163 XP_1 AP01-APN1 VDD VDD P L=0.18U W=28.56U
m164 XP_1 AP01-APN1 VSS VSS N L=0.18U W=15.13U
m165 AP01-APN0 XP_0 VDD VDD P L=0.27U W=0.22U
m166 AP01-APN0 XP_0 VSS VSS N L=0.54U W=0.22U
m167 XP_0 AP01-APN0 VDD VDD P L=0.18U W=28.56U
m168 XP_0 AP01-APN0 VSS VSS N L=0.18U W=15.13U
m169 AI2 N214 VDD VDD P L=0.18U W=8.16U
m17 N80 N48 N81 VSS N L=0.18U W=6.24U
m170 AI2 N214 VSS VSS N L=0.18U W=4U
m171 AI2_ ACONN2 VDD VDD P L=0.18U W=8.16U
m172 AI2_ ACONN2 VSS VSS N L=0.18U W=4.02U
m173 N214 ACONN2 VDD VDD P L=0.18U W=6.52U
m174 N214 ACONN2 VSS VSS N L=0.18U W=3.2U
m177 AI1 N223 VDD VDD P L=0.18U W=8.16U
m178 AI1 N223 VSS VSS N L=0.18U W=4U
m179 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.18U W=10.66U
m180 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m181 N223 ACONN1 VDD VDD P L=0.18U W=6.52U
m182 N223 ACONN1 VSS VSS N L=0.18U W=3.2U
m185 AI0 N232 VDD VDD P L=0.18U W=8.16U
m186 AI0 N232 VSS VSS N L=0.18U W=4U
m187 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m188 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m189 N232 ACONN0 VDD VDD P L=0.18U W=6.52U
m19 AP67-AIND1 AP67-AIN21 N80 VSS N L=0.18U W=6.24U
m190 N232 ACONN0 VSS VSS N L=0.18U W=3.2U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.18U W=10.66U
m20 AP67-APN0 N65 AP67-AIND0 VSS N L=0.18U W=6.24U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.18U W=10.66U
m22 N65 AGTPB VDD VDD P L=0.18U W=1.48U
m23 N65 AGTPB VSS VSS N L=0.18U W=0.94U
m24 AP67-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m25 AP67-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m26 N87 N49 VSS VSS N L=0.18U W=6.24U
m27 N86 N48 N87 VSS N L=0.18U W=6.24U
m28 AP67-AIND0 AP67-AIN20 N86 VSS N L=0.18U W=6.24U
m29 AP67-AIND0 N49 VDD VDD P L=0.18U W=10.66U
m3 N54 AGTPT VDD VDD P L=0.18U W=1.48U
m30 N85 N49 VSS VSS N L=0.18U W=6.24U
m31 AP67-AIND0 N48 VDD VDD P L=0.18U W=10.66U
m32 N84 N48 N85 VSS N L=0.18U W=6.24U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.18U W=10.66U
m34 AP67-AIND0 AP67-AIN20 N84 VSS N L=0.18U W=6.24U
m35 AP67-APN1 XP_7 VDD VDD P L=0.27U W=0.22U
m36 AP67-APN1 XP_7 VSS VSS N L=0.54U W=0.22U
m37 XP_7 AP67-APN1 VDD VDD P L=0.18U W=28.56U
m38 XP_7 AP67-APN1 VSS VSS N L=0.18U W=15.13U
m39 AP67-APN0 XP_6 VDD VDD P L=0.27U W=0.22U
m4 N54 AGTPT VSS VSS N L=0.18U W=0.94U
m40 AP67-APN0 XP_6 VSS VSS N L=0.54U W=0.22U
m41 XP_6 AP67-APN0 VDD VDD P L=0.18U W=28.56U
m42 XP_6 AP67-APN0 VSS VSS N L=0.18U W=15.13U
m43 AP45-APN1 N96 AP45-AIND1 VSS N L=0.18U W=6.24U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.18U W=10.66U
m45 N96 AGTPT VDD VDD P L=0.18U W=1.48U
m46 N96 AGTPT VSS VSS N L=0.18U W=0.94U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m49 N90 AI1 VDD VDD P L=0.18U W=5.94U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m50 N90 AI1 VSS VSS N L=0.18U W=2.87U
m51 N91 AI2_ VDD VDD P L=0.18U W=5.94U
m52 N91 AI2_ VSS VSS N L=0.18U W=2.87U
m53 N125 N91 VSS VSS N L=0.18U W=6.24U
m54 N124 N90 N125 VSS N L=0.18U W=6.24U
m55 AP45-AIND1 AP45-AIN21 N124 VSS N L=0.18U W=6.24U
m56 AP45-AIND1 N91 VDD VDD P L=0.18U W=10.66U
m57 N123 N91 VSS VSS N L=0.18U W=6.24U
m58 AP45-AIND1 N90 VDD VDD P L=0.18U W=10.66U
m59 N122 N90 N123 VSS N L=0.18U W=6.24U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.18U W=10.66U
m61 AP45-AIND1 AP45-AIN21 N122 VSS N L=0.18U W=6.24U
m62 AP45-APN0 N107 AP45-AIND0 VSS N L=0.18U W=6.24U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.18U W=10.66U
m64 N107 AGTPB VDD VDD P L=0.18U W=1.48U
m65 N107 AGTPB VSS VSS N L=0.18U W=0.94U
m66 AP45-AIN20 AI0 VDD VDD P L=0.18U W=5.94U
m67 AP45-AIN20 AI0 VSS VSS N L=0.18U W=2.87U
m68 N129 N91 VSS VSS N L=0.18U W=6.24U
m69 N128 N90 N129 VSS N L=0.18U W=6.24U
m7 N48 AI1_ VDD VDD P L=0.18U W=5.94U
m70 AP45-AIND0 AP45-AIN20 N128 VSS N L=0.18U W=6.24U
m71 AP45-AIND0 N91 VDD VDD P L=0.18U W=10.66U
m72 N127 N91 VSS VSS N L=0.18U W=6.24U
m73 AP45-AIND0 N90 VDD VDD P L=0.18U W=10.66U
m74 N126 N90 N127 VSS N L=0.18U W=6.24U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.18U W=10.66U
m76 AP45-AIND0 AP45-AIN20 N126 VSS N L=0.18U W=6.24U
m77 AP45-APN1 XP_5 VDD VDD P L=0.27U W=0.22U
m78 AP45-APN1 XP_5 VSS VSS N L=0.54U W=0.22U
m79 XP_5 AP45-APN1 VDD VDD P L=0.18U W=28.56U
m8 N48 AI1_ VSS VSS N L=0.18U W=2.87U
m80 XP_5 AP45-APN1 VSS VSS N L=0.18U W=15.13U
m81 AP45-APN0 XP_4 VDD VDD P L=0.27U W=0.22U
m82 AP45-APN0 XP_4 VSS VSS N L=0.54U W=0.22U
m83 XP_4 AP45-APN0 VDD VDD P L=0.18U W=28.56U
m84 XP_4 AP45-APN0 VSS VSS N L=0.18U W=15.13U
m85 AP23-APN1 N138 AP23-AIND1 VSS N L=0.18U W=6.24U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.18U W=10.66U
m87 N138 AGTPT VDD VDD P L=0.18U W=1.48U
m88 N138 AGTPT VSS VSS N L=0.18U W=0.94U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.18U W=5.94U
m9 N49 AI2_ VDD VDD P L=0.18U W=5.94U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.18U W=2.87U
m91 N132 AI1_ VDD VDD P L=0.18U W=5.94U
m92 N132 AI1_ VSS VSS N L=0.18U W=2.87U
m93 N133 AI2 VDD VDD P L=0.18U W=5.94U
m94 N133 AI2 VSS VSS N L=0.18U W=2.87U
m95 N167 N133 VSS VSS N L=0.18U W=6.24U
m96 N166 N132 N167 VSS N L=0.18U W=6.24U
m97 AP23-AIND1 AP23-AIN21 N166 VSS N L=0.18U W=6.24U
m98 AP23-AIND1 N133 VDD VDD P L=0.18U W=10.66U
m99 N165 N133 VSS VSS N L=0.18U W=6.24U
.ENDS SPSRAM256X8HXP38
****
.SUBCKT SPSRAM256X8HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HXP38X: 192 flat devices **
XI0_0 A0 A1 A2 A0 A1 A2 AGTPB AGTPT VSS VSS VSS AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8HXP38
.ENDS SPSRAM256X8HXP38X
****
.SUBCKT SPSRAM256X8X_PRE_DECODE A0 A0_0 A1 A1_0 A2 AGTPB AGTPT AY0 AY0_ BWEN
+  OEI_ WEI XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6
+  XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8X_PRE_DECODE: 292 flat devices **
XI0_0 A0_0 A1_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HXP24X
XI1_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4
+  XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8HXP38X
.ENDS SPSRAM256X8X_PRE_DECODE
****
.SUBCKT SPSRAM256X8HYP24 A0 A1 ACONN0 ACONN1 AGTPB AGTPT AMX0 AMX1 AY0 AY0_
+  BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** SPSRAM256X8HYP24: 100 flat devices **
d15 VSS A1 DN 0.3364P 2.32U
d16 VSS BWEN DN 0.3364P 2.32U
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 AI0 N28 VDD VDD P L=0.18U W=8.16U
m10 AI1 N37 VSS VSS N L=0.18U W=4U
m100 YP0_3 AP_I6-APN0 VSS VSS N L=0.18U W=15.13U
m11 AI1_ ACONN1 VDD VDD P L=0.18U W=8.16U
m12 AI1_ ACONN1 VSS VSS N L=0.18U W=4.02U
m13 N37 ACONN1 VDD VDD P L=0.18U W=6.52U
m14 N37 ACONN1 VSS VSS N L=0.18U W=3.2U
m17 AP_I5-APN1 N54 AP_I5-AIND1 VSS N L=0.18U W=6.24U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.18U W=10.66U
m19 N54 AGTPT VDD VDD P L=0.18U W=1.48U
m2 AI0 N28 VSS VSS N L=0.18U W=4U
m20 N54 AGTPT VSS VSS N L=0.18U W=0.94U
m21 AP_I5-AIN21 AI0 VDD VDD P L=0.18U W=5.94U
m22 AP_I5-AIN21 AI0 VSS VSS N L=0.18U W=2.87U
m23 N48 AI1 VDD VDD P L=0.18U W=5.94U
m24 N48 AI1 VSS VSS N L=0.18U W=2.87U
m25 N49 VSS VDD VDD P L=0.18U W=5.94U
m26 N49 VSS VSS VSS N L=0.18U W=2.87U
m27 N83 N49 VSS VSS N L=0.18U W=6.24U
m28 N82 N48 N83 VSS N L=0.18U W=6.24U
m29 AP_I5-AIND1 AP_I5-AIN21 N82 VSS N L=0.18U W=6.24U
m3 AI0_ ACONN0 VDD VDD P L=0.18U W=8.16U
m30 AP_I5-AIND1 N49 VDD VDD P L=0.18U W=10.66U
m31 N81 N49 VSS VSS N L=0.18U W=6.24U
m32 AP_I5-AIND1 N48 VDD VDD P L=0.18U W=10.66U
m33 N80 N48 N81 VSS N L=0.18U W=6.24U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.18U W=10.66U
m35 AP_I5-AIND1 AP_I5-AIN21 N80 VSS N L=0.18U W=6.24U
m36 AP_I5-APN0 N65 AP_I5-AIND0 VSS N L=0.18U W=6.24U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.18U W=10.66U
m38 N65 AGTPB VDD VDD P L=0.18U W=1.48U
m39 N65 AGTPB VSS VSS N L=0.18U W=0.94U
m4 AI0_ ACONN0 VSS VSS N L=0.18U W=4.02U
m40 AP_I5-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U
m41 AP_I5-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U
m42 N87 N49 VSS VSS N L=0.18U W=6.24U
m43 N86 N48 N87 VSS N L=0.18U W=6.24U
m44 AP_I5-AIND0 AP_I5-AIN20 N86 VSS N L=0.18U W=6.24U
m45 AP_I5-AIND0 N49 VDD VDD P L=0.18U W=10.66U
m46 N85 N49 VSS VSS N L=0.18U W=6.24U
m47 AP_I5-AIND0 N48 VDD VDD P L=0.18U W=10.66U
m48 N84 N48 N85 VSS N L=0.18U W=6.24U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.18U W=10.66U
m5 N28 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AP_I5-AIND0 AP_I5-AIN20 N84 VSS N L=0.18U W=6.24U
m51 AP_I5-APN1 YP0_0 VDD VDD P L=0.27U W=0.22U
m52 AP_I5-APN1 YP0_0 VSS VSS N L=0.54U W=0.22U
m53 YP0_0 AP_I5-APN1 VDD VDD P L=0.18U W=28.56U
m54 YP0_0 AP_I5-APN1 VSS VSS N L=0.18U W=15.13U
m55 AP_I5-APN0 YP0_1 VDD VDD P L=0.27U W=0.22U
m56 AP_I5-APN0 YP0_1 VSS VSS N L=0.54U W=0.22U
m57 YP0_1 AP_I5-APN0 VDD VDD P L=0.18U W=28.56U
m58 YP0_1 AP_I5-APN0 VSS VSS N L=0.18U W=15.13U
m59 AP_I6-APN1 N96 AP_I6-AIND1 VSS N L=0.18U W=6.24U
m6 N28 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.18U W=10.66U
m61 N96 AGTPT VDD VDD P L=0.18U W=1.48U
m62 N96 AGTPT VSS VSS N L=0.18U W=0.94U
m63 AP_I6-AIN21 AI0 VDD VDD P L=0.18U W=5.94U
m64 AP_I6-AIN21 AI0 VSS VSS N L=0.18U W=2.87U
m65 N90 AI1_ VDD VDD P L=0.18U W=5.94U
m66 N90 AI1_ VSS VSS N L=0.18U W=2.87U
m67 N91 VSS VDD VDD P L=0.18U W=5.94U
m68 N91 VSS VSS VSS N L=0.18U W=2.87U
m69 N125 N91 VSS VSS N L=0.18U W=6.24U
m70 N124 N90 N125 VSS N L=0.18U W=6.24U
m71 AP_I6-AIND1 AP_I6-AIN21 N124 VSS N L=0.18U W=6.24U
m72 AP_I6-AIND1 N91 VDD VDD P L=0.18U W=10.66U
m73 N123 N91 VSS VSS N L=0.18U W=6.24U
m74 AP_I6-AIND1 N90 VDD VDD P L=0.18U W=10.66U
m75 N122 N90 N123 VSS N L=0.18U W=6.24U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.18U W=10.66U
m77 AP_I6-AIND1 AP_I6-AIN21 N122 VSS N L=0.18U W=6.24U
m78 AP_I6-APN0 N107 AP_I6-AIND0 VSS N L=0.18U W=6.24U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.18U W=10.66U
m80 N107 AGTPB VDD VDD P L=0.18U W=1.48U
m81 N107 AGTPB VSS VSS N L=0.18U W=0.94U
m82 AP_I6-AIN20 AI0_ VDD VDD P L=0.18U W=5.94U
m83 AP_I6-AIN20 AI0_ VSS VSS N L=0.18U W=2.87U
m84 N129 N91 VSS VSS N L=0.18U W=6.24U
m85 N128 N90 N129 VSS N L=0.18U W=6.24U
m86 AP_I6-AIND0 AP_I6-AIN20 N128 VSS N L=0.18U W=6.24U
m87 AP_I6-AIND0 N91 VDD VDD P L=0.18U W=10.66U
m88 N127 N91 VSS VSS N L=0.18U W=6.24U
m89 AP_I6-AIND0 N90 VDD VDD P L=0.18U W=10.66U
m9 AI1 N37 VDD VDD P L=0.18U W=8.16U
m90 N126 N90 N127 VSS N L=0.18U W=6.24U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.18U W=10.66U
m92 AP_I6-AIND0 AP_I6-AIN20 N126 VSS N L=0.18U W=6.24U
m93 AP_I6-APN1 YP0_2 VDD VDD P L=0.27U W=0.22U
m94 AP_I6-APN1 YP0_2 VSS VSS N L=0.54U W=0.22U
m95 YP0_2 AP_I6-APN1 VDD VDD P L=0.18U W=28.56U
m96 YP0_2 AP_I6-APN1 VSS VSS N L=0.18U W=15.13U
m97 AP_I6-APN0 YP0_3 VDD VDD P L=0.27U W=0.22U
m98 AP_I6-APN0 YP0_3 VSS VSS N L=0.54U W=0.22U
m99 YP0_3 AP_I6-APN0 VDD VDD P L=0.18U W=28.56U
.ENDS SPSRAM256X8HYP24
****
.SUBCKT SPSRAM256X8HYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** SPSRAM256X8HYP24X: 100 flat devices **
XI0_0 A0 A1 A0 A1 AGTPB AGTPT VSS VSS AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VDD SPSRAM256X8HYP24
.ENDS SPSRAM256X8HYP24X
****
.SUBCKT SPSRAM256X8HYP12XR A0 ACONN0 AGTP AMX0 AY0 AY0_ BWEN CLK GSRCN GTPN
+  OEI_ RST WEI YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HYP12XR: 92 flat devices **
d7 VSS A0 DN 0.3364P 2.32U
d8 VSS BWEN DN 0.3364P 2.32U
m1 N24 N27 VDD VDD P L=0.18U W=8.16U
m10 AP0-APN1 AGTP AP0-AIND1 VDD P L=0.18U W=10.66U
m11 N44 AGTP VDD VDD P L=0.18U W=1.48U
m12 N44 AGTP VSS VSS N L=0.18U W=0.94U
m13 AP0-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m14 AP0-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m15 N38 VSS VDD VDD P L=0.18U W=5.94U
m16 N38 VSS VSS VSS N L=0.18U W=2.87U
m17 N39 VSS VDD VDD P L=0.18U W=5.94U
m18 N39 VSS VSS VSS N L=0.18U W=2.87U
m19 N73 N39 VSS VSS N L=0.18U W=6.24U
m2 N24 N27 VSS VSS N L=0.18U W=4U
m20 N72 N38 N73 VSS N L=0.18U W=6.24U
m21 AP0-AIND1 AP0-AIN21 N72 VSS N L=0.18U W=6.24U
m22 AP0-AIND1 N39 VDD VDD P L=0.18U W=10.66U
m23 N71 N39 VSS VSS N L=0.18U W=6.24U
m24 AP0-AIND1 N38 VDD VDD P L=0.18U W=10.66U
m25 N70 N38 N71 VSS N L=0.18U W=6.24U
m26 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.18U W=10.66U
m27 AP0-AIND1 AP0-AIN21 N70 VSS N L=0.18U W=6.24U
m28 AP0-APN0 N55 AP0-AIND0 VSS N L=0.18U W=6.24U
m29 AP0-APN0 AGTP AP0-AIND0 VDD P L=0.18U W=10.66U
m3 N23 ACONN0 VDD VDD P L=0.18U W=8.16U
m30 N55 AGTP VDD VDD P L=0.18U W=1.48U
m31 N55 AGTP VSS VSS N L=0.18U W=0.94U
m32 AP0-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m33 AP0-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m34 N77 N39 VSS VSS N L=0.18U W=6.24U
m35 N76 N38 N77 VSS N L=0.18U W=6.24U
m36 AP0-AIND0 AP0-AIN20 N76 VSS N L=0.18U W=6.24U
m37 AP0-AIND0 N39 VDD VDD P L=0.18U W=10.66U
m38 N75 N39 VSS VSS N L=0.18U W=6.24U
m39 AP0-AIND0 N38 VDD VDD P L=0.18U W=10.66U
m4 N23 ACONN0 VSS VSS N L=0.18U W=4.02U
m40 N74 N38 N75 VSS N L=0.18U W=6.24U
m41 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.18U W=10.66U
m42 AP0-AIND0 AP0-AIN20 N74 VSS N L=0.18U W=6.24U
m43 AP0-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m44 AP0-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m45 AY0_ AP0-APN1 VDD VDD P L=0.18U W=28.56U
m46 AY0_ AP0-APN1 VSS VSS N L=0.18U W=15.13U
m47 AP0-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m48 AP0-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m49 AY0 AP0-APN0 VDD VDD P L=0.18U W=28.56U
m5 N27 ACONN0 VDD VDD P L=0.18U W=6.52U
m50 AY0 AP0-APN0 VSS VSS N L=0.18U W=15.13U
m51 AP_I1-APN1 N86 AP_I1-AIND1 VSS N L=0.18U W=6.24U
m52 AP_I1-APN1 AGTP AP_I1-AIND1 VDD P L=0.18U W=10.66U
m53 N86 AGTP VDD VDD P L=0.18U W=1.48U
m54 N86 AGTP VSS VSS N L=0.18U W=0.94U
m55 AP_I1-AIN21 N24 VDD VDD P L=0.18U W=5.94U
m56 AP_I1-AIN21 N24 VSS VSS N L=0.18U W=2.87U
m57 N80 VSS VDD VDD P L=0.18U W=5.94U
m58 N80 VSS VSS VSS N L=0.18U W=2.87U
m59 N81 VSS VDD VDD P L=0.18U W=5.94U
m6 N27 ACONN0 VSS VSS N L=0.18U W=3.2U
m60 N81 VSS VSS VSS N L=0.18U W=2.87U
m61 N115 N81 VSS VSS N L=0.18U W=6.24U
m62 N114 N80 N115 VSS N L=0.18U W=6.24U
m63 AP_I1-AIND1 AP_I1-AIN21 N114 VSS N L=0.18U W=6.24U
m64 AP_I1-AIND1 N81 VDD VDD P L=0.18U W=10.66U
m65 N113 N81 VSS VSS N L=0.18U W=6.24U
m66 AP_I1-AIND1 N80 VDD VDD P L=0.18U W=10.66U
m67 N112 N80 N113 VSS N L=0.18U W=6.24U
m68 AP_I1-AIND1 AP_I1-AIN21 VDD VDD P L=0.18U W=10.66U
m69 AP_I1-AIND1 AP_I1-AIN21 N112 VSS N L=0.18U W=6.24U
m70 AP_I1-APN0 N97 AP_I1-AIND0 VSS N L=0.18U W=6.24U
m71 AP_I1-APN0 AGTP AP_I1-AIND0 VDD P L=0.18U W=10.66U
m72 N97 AGTP VDD VDD P L=0.18U W=1.48U
m73 N97 AGTP VSS VSS N L=0.18U W=0.94U
m74 AP_I1-AIN20 N23 VDD VDD P L=0.18U W=5.94U
m75 AP_I1-AIN20 N23 VSS VSS N L=0.18U W=2.87U
m76 N119 N81 VSS VSS N L=0.18U W=6.24U
m77 N118 N80 N119 VSS N L=0.18U W=6.24U
m78 AP_I1-AIND0 AP_I1-AIN20 N118 VSS N L=0.18U W=6.24U
m79 AP_I1-AIND0 N81 VDD VDD P L=0.18U W=10.66U
m80 N117 N81 VSS VSS N L=0.18U W=6.24U
m81 AP_I1-AIND0 N80 VDD VDD P L=0.18U W=10.66U
m82 N116 N80 N117 VSS N L=0.18U W=6.24U
m83 AP_I1-AIND0 AP_I1-AIN20 VDD VDD P L=0.18U W=10.66U
m84 AP_I1-AIND0 AP_I1-AIN20 N116 VSS N L=0.18U W=6.24U
m85 AP_I1-APN1 AY0_ VDD VDD P L=0.27U W=0.22U
m86 AP_I1-APN1 AY0_ VSS VSS N L=0.54U W=0.22U
m87 AY0_ AP_I1-APN1 VDD VDD P L=0.18U W=28.56U
m88 AY0_ AP_I1-APN1 VSS VSS N L=0.18U W=15.13U
m89 AP_I1-APN0 AY0 VDD VDD P L=0.27U W=0.22U
m9 AP0-APN1 N44 AP0-AIND1 VSS N L=0.18U W=6.24U
m90 AP_I1-APN0 AY0 VSS VSS N L=0.54U W=0.22U
m91 AY0 AP_I1-APN0 VDD VDD P L=0.18U W=28.56U
m92 AY0 AP_I1-APN0 VSS VSS N L=0.18U W=15.13U
.ENDS SPSRAM256X8HYP12XR
****
.SUBCKT SPSRAM256X8HYP12XRX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HYP12XRX: 92 flat devices **
XI0_0 A0 A0 AGTP VSS AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HYP12XR
.ENDS SPSRAM256X8HYP12XRX
****
.SUBCKT SPSRAM256X8Y_DECODE A0 A0_0 A1 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_
+  RST WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** SPSRAM256X8Y_DECODE: 192 flat devices **
XI0_0 A0_0 A1 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  SPSRAM256X8HYP24X
XI1_0 A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8HYP12XRX
.ENDS SPSRAM256X8Y_DECODE
****
.SUBCKT SPSRAM256X8HBF8 CEMX CEN CENI_ CEN_ CLK GSRCN GTP GTPN MBL OEI_ OEMX
+  OEN OENI_ OEN_ RST STOV STUBWE TMS WE WEI WEMX WEN WENI_ WEN_ VSS VDD
** SPSRAM256X8HBF8: 91 flat devices **
d86 VSS WEN DN 0.3364P 2.32U
d87 VSS OEN DN 0.3364P 2.32U
d88 VSS CEN DN 0.3364P 2.32U
d89 VSS STOV DN 0.3364P 2.32U
d90 VSS CLK DN 0.3364P 2.32U
d91 VSS TMS DN 0.3364P 2.32U
m1 WE N44 VDD VDD P L=0.18U W=13.78U
m10 BF-CLKN CLK VSS VSS N L=0.36U W=1.44U
m11 N44 BF-TMS_ VDD VDD P L=0.18U W=6.12U
m12 N97 BF-TMS_ VSS VSS N L=0.18U W=4.59U
m13 N44 WENI_ VDD VDD P L=0.18U W=6.12U
m14 N44 WENI_ N97 VSS N L=0.18U W=4.59U
m15 BF-TMS_ TMS VDD VDD P L=0.18U W=2.95U
m16 BF-TMS_ TMS VSS VSS N L=0.18U W=1.52U
m17 OEI_ N57 VDD VDD P L=0.18U W=15.86U
m18 OEI_ N57 VSS VSS N L=0.18U W=8.16U
m19 N57 N60 VDD VDD P L=0.18U W=5.85U
m2 WE N44 VSS VSS N L=0.18U W=7.09U
m20 N57 N60 VSS VSS N L=0.18U W=3.01U
m21 N60 BF-TMS_ VDD VDD P L=0.18U W=2.27U
m22 N98 BF-TMS_ VSS VSS N L=0.18U W=2.22U
m23 N60 OENI_ VDD VDD P L=0.18U W=2.27U
m24 N60 OENI_ N98 VSS N L=0.18U W=2.22U
m25 N100 GTP VSS VSS N L=0.18U W=2.67U
m26 BF-RSRCN BF-CKSTOV N100 VSS N L=0.18U W=2.67U
m27 BF-RSRCN GTP VDD VDD P L=0.18U W=5.7U
m28 N99 GTP VSS VSS N L=0.18U W=2.67U
m29 BF-RSRCN BF-CKSTOV VDD VDD P L=0.18U W=5.7U
m3 BF-CENMML BF-CLKN N96 VDD P L=0.18U W=0.22U
m30 BF-RSRCN BF-CKSTOV N99 VSS N L=0.18U W=2.67U
m31 BF-RSTSRC BF-RSRCN VDD VDD P L=0.18U W=14.16U
m32 BF-RSTSRC BF-RSRCN VSS VSS N L=0.18U W=6.62U
m33 BF-CKSTOV STOV VDD VDD P L=0.18U W=2.68U
m34 N101 STOV VSS VSS N L=0.18U W=2.51U
m35 BF-CKSTOV CLK VDD VDD P L=0.18U W=2.68U
m36 BF-CKSTOV CLK N101 VSS N L=0.18U W=2.51U
m37 GTPN BF-GTPI N71 VSS N L=0.18U W=0.22U
m38 N37 N37 VDD VDD P L=0.18U W=0.22U
m39 GTPN BF-GTPI VDD VDD P L=0.18U W=0.22U
m4 N96 BF-CEL VDD VDD P L=0.18U W=0.22U
m40 N37 VDD VDD VDD P L=0.18U W=0.22U
m41 BF-GTPI GTPN VDD VDD P L=0.18U W=0.44U
m42 BF-GTPI GTPN VSS VSS N L=0.18U W=0.22U
m43 N71 N37 VSS VSS N L=0.18U W=0.22U
m44 N103 BF-CLKN VSS VSS N L=0.18U W=3.35U
m45 GSRCN BF-CEL N103 VSS N L=0.18U W=3.35U
m46 GSRCN BF-CLKN VDD VDD P L=0.18U W=5.72U
m47 N102 BF-CLKN VSS VSS N L=0.18U W=3.35U
m48 GSRCN BF-CEL VDD VDD P L=0.18U W=5.72U
m49 GSRCN BF-CEL N102 VSS N L=0.18U W=3.35U
m5 BF-CENMML CLK N95 VSS N L=0.18U W=0.22U
m50 N80 BF-CLKN VSS VSS N L=0.18U W=0.86U
m51 N82 CLK VDD VDD P L=0.18U W=2.17U
m52 BF-CENMML CENI_ N84 VDD P L=0.18U W=2.17U
m53 BF-CENMML CENI_ N80 VSS N L=0.18U W=0.85U
m54 N84 TMS N82 VDD P L=0.18U W=2.17U
m55 BF-CENMML TMS N80 VSS N L=0.18U W=0.85U
m56 RST BF-MBLN VDD VDD P L=0.18U W=3.3U
m57 RST BF-RSTSRC VDD VDD P L=0.18U W=22.49U
m58 BF-MBLN MBL VDD VDD P L=0.18U W=9.16U
m59 BF-MBLN MBL VSS VSS N L=0.18U W=3.06U
m6 N95 BF-CEL VSS VSS N L=0.18U W=0.22U
m60 WEN_ WEN VDD VDD P L=0.18U W=3.12U
m61 WEN_ WEN VSS VSS N L=0.18U W=1.53U
m62 OEN_ OEN VDD VDD P L=0.18U W=1.21U
m63 OEN_ OEN VSS VSS N L=0.18U W=0.59U
m64 CEN_ CEN VDD VDD P L=0.18U W=2.6U
m65 CEN_ CEN VSS VSS N L=0.18U W=1.28U
m66 RST BF-MBLN N113 VSS N L=0.18U W=2.74U
m67 N113 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m68 RST BF-MBLN N112 VSS N L=0.18U W=2.74U
m69 N112 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m7 BF-CEL BF-CENMML VDD VDD P L=0.18U W=2.63U
m70 RST BF-MBLN N111 VSS N L=0.18U W=2.74U
m71 N111 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m72 RST BF-MBLN N110 VSS N L=0.18U W=2.74U
m73 N110 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m74 RST BF-MBLN N109 VSS N L=0.18U W=2.74U
m75 N109 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m76 RST BF-MBLN N108 VSS N L=0.18U W=2.74U
m77 N108 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m78 RST BF-MBLN N107 VSS N L=0.18U W=2.74U
m79 N107 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m8 BF-CEL BF-CENMML VSS VSS N L=0.18U W=1.37U
m80 RST BF-MBLN N106 VSS N L=0.18U W=2.74U
m81 N106 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m82 RST BF-MBLN N105 VSS N L=0.18U W=2.74U
m83 N105 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m84 RST BF-MBLN N104 VSS N L=0.18U W=2.74U
m85 N104 BF-RSTSRC VSS VSS N L=0.18U W=3.55U
m9 BF-CLKN CLK VDD VDD P L=0.18U W=3.07U
.ENDS SPSRAM256X8HBF8
****
.SUBCKT SPSRAM256X8HBFX CEN CENI_ CLK GSRCN GTP GTPN MBL OEI_ OEN OENI_ RST
+  STUBWE WEI WEN WENI_ VSS VDD
** SPSRAM256X8HBFX: 91 flat devices **
XI0_0 VSS CEN CENI_ CENI_ CLK GSRCN GTP GTPN MBL OEI_ VSS OEN OENI_ OENI_ RST
+  VSS STUBWE VSS WEI WEI VSS WEN WENI_ WENI_ VSS VDD SPSRAM256X8HBF8
.ENDS SPSRAM256X8HBFX
****
.SUBCKT SPSRAM256X8CCMWP BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** SPSRAM256X8CCMWP: 12 flat devices **
m1 BL MWPT N8 VSS N L=0.295U W=0.215U
m10 N14 VSS VDD VDD P L=0.184U W=0.21U
m11 N16 VSS VDD VDD P L=0.184U W=0.21U
m12 N18 VSS VDD VDD P L=0.184U W=0.21U
m2 BL_ MWPT N9 VSS N L=0.295U W=0.215U
m3 BL MWPB N10 VSS N L=0.295U W=0.215U
m4 BL_ MWPB N11 VSS N L=0.295U W=0.215U
m5 N8 VSS VSS VSS N L=0.175U W=0.215U
m6 N9 VSS VSS VSS N L=0.175U W=0.215U
m7 N10 VSS VSS VSS N L=0.175U W=0.215U
m8 N11 VSS VSS VSS N L=0.175U W=0.215U
m9 N12 VSS VDD VDD P L=0.184U W=0.21U
.ENDS SPSRAM256X8CCMWP
****
.SUBCKT SPSRAM256X8CCMWG BL BL_ MWLB MWLT MWPB MWPT VSS VDD
** SPSRAM256X8CCMWG: 12 flat devices **
m1 BL MWPT N8 VSS N L=0.295U W=0.215U
m10 N14 VSS VDD VDD P L=0.184U W=0.21U
m11 N16 VSS VDD VDD P L=0.184U W=0.21U
m12 N18 VSS VDD VDD P L=0.184U W=0.21U
m2 BL_ MWPT N9 VSS N L=0.295U W=0.215U
m3 BL MWPB N10 VSS N L=0.295U W=0.215U
m4 BL_ MWPB N11 VSS N L=0.295U W=0.215U
m5 N8 VSS VSS VSS N L=0.175U W=0.215U
m6 N9 VSS VSS VSS N L=0.175U W=0.215U
m7 N10 VSS VSS VSS N L=0.175U W=0.215U
m8 N11 VSS VSS VSS N L=0.175U W=0.215U
m9 N12 VSS VDD VDD P L=0.184U W=0.21U
.ENDS SPSRAM256X8CCMWG
****
.SUBCKT SPSRAM256X8FLMWG BL0 BL0_ BL1 BL1_ MWL WP0 WP1 WP2 WP3 VSS VDD
** SPSRAM256X8FLMWG: 24 flat devices **
m1 BL0 WP1 N11 VSS N L=0.295U W=0.215U
m10 BL1_ WP3 N16 VSS N L=0.295U W=0.215U
m11 BL1 WP2 N17 VSS N L=0.295U W=0.215U
m12 BL1_ WP2 N18 VSS N L=0.295U W=0.215U
m13 N15 VSS VSS VSS N L=0.175U W=0.215U
m14 N16 VSS VSS VSS N L=0.175U W=0.215U
m15 N17 VSS VSS VSS N L=0.175U W=0.215U
m16 N18 VSS VSS VSS N L=0.175U W=0.215U
m17 N19 VSS VDD VDD P L=0.184U W=0.21U
m18 N21 VSS VDD VDD P L=0.184U W=0.21U
m19 N23 VSS VDD VDD P L=0.184U W=0.21U
m2 BL0_ WP3 N12 VSS N L=0.295U W=0.215U
m20 N25 VSS VDD VDD P L=0.184U W=0.21U
m21 N27 VSS VDD VDD P L=0.184U W=0.21U
m22 N29 VSS VDD VDD P L=0.184U W=0.21U
m23 N31 VSS VDD VDD P L=0.184U W=0.21U
m24 N33 VSS VDD VDD P L=0.184U W=0.21U
m3 BL0 WP0 N13 VSS N L=0.295U W=0.215U
m4 BL0_ WP2 N14 VSS N L=0.295U W=0.215U
m5 N11 VSS VSS VSS N L=0.175U W=0.215U
m6 N12 VSS VSS VSS N L=0.175U W=0.215U
m7 N13 VSS VSS VSS N L=0.175U W=0.215U
m8 N14 VSS VSS VSS N L=0.175U W=0.215U
m9 BL1 WP3 N15 VSS N L=0.295U W=0.215U
.ENDS SPSRAM256X8FLMWG
****
.SUBCKT SPSRAM256X8MODEL_ROW_4 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 MWLB MWPB MWPB_0 MWPT
+  MWPT_0 WL WP VSS VDD
** SPSRAM256X8MODEL_ROW_4: 576 flat devices **
XI0_0 BL_28 BL__28 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI0_2 BL_28 BL__28 WL WP VSS VDD SPSRAM256X8CCG
XI10_0 BL_18 BL__18 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI10_2 BL_18 BL__18 WL WP VSS VDD SPSRAM256X8CCP
XI11_0 BL_17 BL__17 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI11_2 BL_17 BL__17 WL WP VSS VDD SPSRAM256X8CCG
XI12_0 BL_16 BL__16 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI12_2 BL_16 BL__16 WL WP VSS VDD SPSRAM256X8CCG
XI13_0 BL_15 BL__15 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI13_2 BL_15 BL__15 WL WP VSS VDD SPSRAM256X8CCP
XI14_0 BL_14 BL__14 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI14_2 BL_14 BL__14 WL WP VSS VDD SPSRAM256X8CCP
XI15_0 BL_13 BL__13 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI15_2 BL_13 BL__13 WL WP VSS VDD SPSRAM256X8CCG
XI16_0 BL0 BL0_ BL1 BL1_ MWLB MWPB_0 MWPT_0 MWPB MWPT VSS VDD SPSRAM256X8FLMWG
XI16_2 BL0 BL0_ WL WP VSS VDD SPSRAM256X8CCG
XI17_2 BL1 BL1_ WL WP VSS VDD SPSRAM256X8CCP
XI18_0 BL_12 BL__12 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI18_2 BL_12 BL__12 WL WP VSS VDD SPSRAM256X8CCP
XI19_0 BL_11 BL__11 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI19_2 BL_11 BL__11 WL WP VSS VDD SPSRAM256X8CCG
XI1_0 BL_27 BL__27 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI1_2 BL_27 BL__27 WL WP VSS VDD SPSRAM256X8CCP
XI20_0 BL_10 BL__10 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI20_2 BL_10 BL__10 WL WP VSS VDD SPSRAM256X8CCG
XI21_0 BL_9 BL__9 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI21_2 BL_9 BL__9 WL WP VSS VDD SPSRAM256X8CCP
XI22_0 BL_8 BL__8 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI22_2 BL_8 BL__8 WL WP VSS VDD SPSRAM256X8CCP
XI23_0 BL_7 BL__7 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI23_2 BL_7 BL__7 WL WP VSS VDD SPSRAM256X8CCG
XI24_0 BL_6 BL__6 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI24_2 BL_6 BL__6 WL WP VSS VDD SPSRAM256X8CCG
XI25_0 BL_5 BL__5 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI25_2 BL_5 BL__5 WL WP VSS VDD SPSRAM256X8CCP
XI26_0 BL_4 BL__4 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI26_2 BL_4 BL__4 WL WP VSS VDD SPSRAM256X8CCP
XI27_0 BL_3 BL__3 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI27_2 BL_3 BL__3 WL WP VSS VDD SPSRAM256X8CCG
XI28_0 BL_2 BL__2 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI28_2 BL_2 BL__2 WL WP VSS VDD SPSRAM256X8CCG
XI29_0 BL_1 BL__1 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI29_2 BL_1 BL__1 WL WP VSS VDD SPSRAM256X8CCP
XI2_0 BL_26 BL__26 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI2_2 BL_26 BL__26 WL WP VSS VDD SPSRAM256X8CCP
XI30_0 BL_0 BL__0 VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWP
XI30_2 BL_0 BL__0 WL WP VSS VDD SPSRAM256X8CCP
XI31_0 BL BL_ VSS VSS MWPB MWPT VSS VDD SPSRAM256X8CCMWG
XI31_2 BL BL_ WL WP VSS VDD SPSRAM256X8CCG
XI3_0 BL_25 BL__25 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI3_2 BL_25 BL__25 WL WP VSS VDD SPSRAM256X8CCG
XI4_0 BL_24 BL__24 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI4_2 BL_24 BL__24 WL WP VSS VDD SPSRAM256X8CCG
XI5_0 BL_23 BL__23 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI5_2 BL_23 BL__23 WL WP VSS VDD SPSRAM256X8CCP
XI6_0 BL_22 BL__22 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI6_2 BL_22 BL__22 WL WP VSS VDD SPSRAM256X8CCP
XI7_0 BL_21 BL__21 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI7_2 BL_21 BL__21 WL WP VSS VDD SPSRAM256X8CCG
XI8_0 BL_20 BL__20 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWG
XI8_2 BL_20 BL__20 WL WP VSS VDD SPSRAM256X8CCG
XI9_0 BL_19 BL__19 MWLB MWLB MWPB_0 MWPT_0 VSS VDD SPSRAM256X8CCMWP
XI9_2 BL_19 BL__19 WL WP VSS VDD SPSRAM256X8CCP
.ENDS SPSRAM256X8MODEL_ROW_4
****
.SUBCKT SPSRAM256X8HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8HWDB: 30 flat devices **
m1 N25 WD_I0-RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 WD_I0-RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WD_I0-WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 WD_I0-RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WD_I0-WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 WD_I0-RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 WD_I0-RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WD_I0-WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WD_I0-WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WD_I0-WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WD_I0-WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 WD_I0-RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS SPSRAM256X8HWDB
****
.SUBCKT SPSRAM256X8HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8HWDB
.ENDS SPSRAM256X8HWDB0
****
.SUBCKT SPSRAM256X8ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0 XP0_0 XP1 XP1_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_BOTTOM: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8HWDB0
.ENDS SPSRAM256X8ROW_BOTTOM
****
.SUBCKT SPSRAM256X8WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD: 30 flat devices **
m1 N25 RSWN0 GTP VDD P L=0.18U W=2.08U
m10 WL0 WL0_EN_ VSS VSS N L=0.18U W=15.71U
m11 N24 RSWN1 GTP VDD P L=0.18U W=2.08U
m12 N24 WLI1 GTP VSS N L=0.18U W=2.08U
m13 N33 G0 VSS VSS N L=0.18U W=1.73U
m14 N34 G1 N33 VSS N L=0.18U W=1.73U
m15 RSWN1 G2_W1 N34 VSS N L=0.18U W=1.73U
m16 RSWN1 G0 VDD VDD P L=0.18U W=1.35U
m17 RSWN1 G2_W1 VDD VDD P L=0.18U W=1.35U
m18 RSWN1 G1 VDD VDD P L=0.18U W=1.35U
m19 WL1 WL1_EN_ VDD VDD P L=0.18U W=30.96U
m2 N25 WLI0 GTP VSS N L=0.18U W=2.08U
m20 WL1 WL1_EN_ VSS VSS N L=0.18U W=15.71U
m21 WLI1 RSWN1 VDD VDD P L=0.18U W=0.61U
m22 WLI1 RSWN1 VSS VSS N L=0.18U W=0.29U
m23 WLI0 RSWN0 VDD VDD P L=0.18U W=0.61U
m24 WLI0 RSWN0 VSS VSS N L=0.18U W=0.29U
m25 N24 RSWN1 VSS VSS N L=0.18U W=2.08U
m26 N25 RSWN0 VSS VSS N L=0.18U W=2.08U
m27 WL1_EN_ N24 VDD VDD P L=0.18U W=14.22U
m28 WL1_EN_ N24 VSS VSS N L=0.18U W=6.66U
m29 WL0_EN_ N25 VDD VDD P L=0.18U W=14.22U
m3 N26 G0 VSS VSS N L=0.18U W=1.73U
m30 WL0_EN_ N25 VSS VSS N L=0.18U W=6.66U
m4 N27 G1 N26 VSS N L=0.18U W=1.73U
m5 RSWN0 G2_W0 N27 VSS N L=0.18U W=1.73U
m6 RSWN0 G0 VDD VDD P L=0.18U W=1.35U
m7 RSWN0 G2_W0 VDD VDD P L=0.18U W=1.35U
m8 RSWN0 G1 VDD VDD P L=0.18U W=1.35U
m9 WL0 WL0_EN_ VDD VDD P L=0.18U W=30.96U
.ENDS SPSRAM256X8WD
****
.SUBCKT SPSRAM256X8WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD1
****
.SUBCKT SPSRAM256X8ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER1: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD1
.ENDS SPSRAM256X8ROW_FILLER1
****
.SUBCKT SPSRAM256X8WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD2
****
.SUBCKT SPSRAM256X8ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER2: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD2
.ENDS SPSRAM256X8ROW_FILLER2
****
.SUBCKT SPSRAM256X8WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD3
****
.SUBCKT SPSRAM256X8ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER3: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD3
.ENDS SPSRAM256X8ROW_FILLER3
****
.SUBCKT SPSRAM256X8WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD0
****
.SUBCKT SPSRAM256X8ROW_8 G0 G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP1F XP1F_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_8: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD0
.ENDS SPSRAM256X8ROW_8
****
.SUBCKT SPSRAM256X8MWD GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8MWD: 9 flat devices **
m1 MWL N15 VDD VDD P L=0.18U W=30.96U
m2 MWL N15 VSS VSS N L=0.18U W=15.71U
m3 N15 N18 VDD VDD P L=0.18U W=16.51U
m4 N15 N18 VSS VSS N L=0.18U W=7.73U
m5 MBL GTP VDD VDD P L=0.18U W=15.35U
m6 MBL_ GTP VDD VDD P L=0.18U W=15.35U
m7 MBL GTP MBL_ VDD P L=0.18U W=15.35U
m8 N18 VSS GTP VDD P L=0.35U W=2U
m9 N18 VDD GTP VSS N L=0.35U W=2U
.ENDS SPSRAM256X8MWD
****
.SUBCKT SPSRAM256X8ROW_TOP G0F G1F GTP MBL MBL_ MWL XP0 XP0F XP1 XP1F XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_TOP: 9 flat devices **
XI2_0 GTP MBL MBL_ MWL XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  SPSRAM256X8MWD
.ENDS SPSRAM256X8ROW_TOP
****
.SUBCKT SPSRAM256X8WORD_ROWS G0 GTP MBL MBL_ MWL WL0 WL0_0 WL0_1 WL0_2 WL0_3
+  WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13 WL0_14 WL1
+  WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11
+  WL1_12 WL1_13 WL1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WORD_ROWS: 489 flat devices **
XI0_0 G0 XP0 GTP WL0_14 WL1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_BOTTOM
XI0_1 G0 XP0 GTP WL0_13 WL1_13 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_10 G0 XP0_0 GTP WL0_4 WL1_4 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_11 G0 XP0_0 GTP WL0_3 WL1_3 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_12 G0 XP1_0 XP0_0 GTP WL0_2 WL1_2 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_13 G0 XP1_0 GTP WL0_1 WL1_1 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_14 G0 XP1_0 GTP WL0_0 WL1_0 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_15 G0 XP1_0 GTP WL0 WL1 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_16 G0 XP1_0 GTP MBL MBL_ MWL XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_TOP
XI0_2 G0 XP0 GTP WL0_12 WL1_12 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_3 G0 XP0 GTP WL0_11 WL1_11 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_4 G0 XP1 XP0 GTP WL0_10 WL1_10 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_5 G0 XP1 GTP WL0_9 WL1_9 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_6 G0 XP1 GTP WL0_8 WL1_8 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_7 G0 XP1 GTP WL0_7 WL1_7 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_8 G0 XP0_0 XP1 GTP WL0_6 WL1_6 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_9 G0 XP0_0 GTP WL0_5 WL1_5 XP0_0 XP0 XP1_0 XP1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
.ENDS SPSRAM256X8WORD_ROWS
****
.SUBCKT SPSRAM256X8HCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK CK-GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 AGTP GTPN VDD VDD P L=0.18U W=42.64U
m5 AGTP GTPN VSS VSS N L=0.18U W=20U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.18U W=9.84U
m9 CK-GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS SPSRAM256X8HCKA
****
.SUBCKT SPSRAM256X8CKP A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CKP: 3 flat devices **
m1 GTPN RST VDD VDD P L=0.18U W=19.12U
m2 GTP GTPN VDD VDD P L=0.18U W=42.64U
m3 GTP GTPN VSS VSS N L=0.18U W=20U
.ENDS SPSRAM256X8CKP
****
.SUBCKT SPSRAM256X8CK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.18U W=29.52U
m2 GTPN CLK GTPFEED VSS N L=0.18U W=9.84U
m3 GTPN RST VDD VDD P L=0.18U W=19.12U
m4 GTP GTPN VDD VDD P L=0.18U W=42.64U
m5 GTP GTPN VSS VSS N L=0.18U W=20U
m6 GTPNSRC GSRCN VDD VDD P L=0.18U W=4.48U
m7 GTPNSRC GSRCN VSS VSS N L=0.18U W=2.52U
m8 GTPFEED CLK SRCFEED VSS N L=0.18U W=9.84U
m9 GTPFEED GTPN VDD VSS N L=0.18U W=2.46U
.ENDS SPSRAM256X8CK
****
.SUBCKT SPSRAM256X8CLK_DRVS A0 A0_ AGTP CLK GSRCN GTP GTPN GTP_0 GTP_1 GTP_2
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CLK_DRVS: 33 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8HCKA
XI1_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CKP
XI2_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CKP
XI3_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CK
XI4_0 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8CK
.ENDS SPSRAM256X8CLK_DRVS
****
.SUBCKT SPSRAM256X8FCBWRO8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWRO8: 2 flat devices **
d1 VSS Q DN 0.3364P 2.32U
d2 VSS D DN 0.3364P 2.32U
.ENDS SPSRAM256X8FCBWRO8
****
.SUBCKT SPSRAM256X8MCOL_ODD_R8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MCOL_ODD_R8: 1811 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWRO8
XI0_1 BWE D DI_ DPN DPU STUBDW STUBDW_ GTP_1 OE_ Q QI SP STUBWE VSS VDD
+  SPSRAM256X8IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL BL_ BL__2 BL_3 BL__6 BL_2 BL__3 BL_6 BL__0 BL_0 BL_1 BL__4
+  BL_5 BL__1 BL_4 BL__5 VSS STUBDR_ STUBDR VSS VSS STUBDW_ STUBDW VSS GTP
+  STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL__0 BL_1 BL__1 BL_2 BL__2 BL_3 BL__3 BL_4 BL__4 BL_5 BL__5
+  BL_6 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS
+  VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_ODD_R8
****
.SUBCKT SPSRAM256X8WING_4_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D D_0 D_1
+  D_2 GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 STUBDR STUBDR_ STUBDR_0 STUBDR__0
+  STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8WING_4_RIGHT: 7244 flat devices **
XI0_0 A0 A0_ BL_23 BL__23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_3 STUBDR__1 STUBDR_0 STUBDR__0 STUBDW_5 STUBDW__7 STUBDW_0 STUBDW__0
+  STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI1_0 A0 A0_ BL_22 BL__22 BL_21 BL_20 BL_19 BL_18 BL_17 BL_16 BL_15 BL__21
+  BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI2_0 A0 A0_ BL_7 BL__7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__8 BL__9
+  BL__10 BL__11 BL__12 BL__13 BL__14 D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_19
+  STUBDR__17 STUBDR_0_11 STUBDR__0_9 STUBDW_21 STUBDW__23 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI3_0 A0 A0_ BL_6 BL__6 BL_5 BL_4 BL_3 BL_2 BL_1 BL_0 BL BL__5 BL__4 BL__3
+  BL__2 BL__1 BL__0 BL_ D GTP GTP_0 GTP_1 OE_ Q STUBDR_19 STUBDR__17 STUBDR
+  STUBDR_ STUBDW_21 STUBDW__23 STUBDW STUBDW_ STUBWE WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8MCOL_ODD_R8
.ENDS SPSRAM256X8WING_4_RIGHT
****
.SUBCKT SPSRAM256X8FLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FLCIO: 11 flat devices **
d1 VSS GTP DN 0.3364P 2.32U
d10 VSS A0_ DN 0.3364P 2.32U
d11 VSS A0 DN 0.3364P 2.32U
d2 VSS YP0_0 DN 0.3364P 2.32U
d3 VSS YP1_0 DN 0.3364P 2.32U
d4 VSS YP0_1 DN 0.3364P 2.32U
d5 VSS YP0_2 DN 0.3364P 2.32U
d6 VSS YP0_3 DN 0.3364P 2.32U
d7 VSS YP1_1 DN 0.3364P 2.32U
d8 VSS YP1_2 DN 0.3364P 2.32U
d9 VSS YP1_3 DN 0.3364P 2.32U
.ENDS SPSRAM256X8FLCIO
****
.SUBCKT SPSRAM256X8FCCDR A0 A0_ GTP VD YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FCCDR: 1 flat devices **
m1 VDD VSS VD VDD P L=0.18U W=0.22U
.ENDS SPSRAM256X8FCCDR
****
.SUBCKT SPSRAM256X8RIGHT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8RIGHT_CAP: 215 flat devices **
XI0_0 GTP_1 OE_ WE VSS VDD SPSRAM256X8FCIO8
XI0_1 GTP_0 VSS VDD SPSRAM256X8FCSA8
XI0_10 BL BL WL_23 WL_23 VSS VDD SPSRAM256X8CCG
XI0_11 BL BL WL_22 WL_22 VSS VDD SPSRAM256X8CCG
XI0_12 BL BL WL_21 WL_21 VSS VDD SPSRAM256X8CCG
XI0_13 BL BL WL_20 WL_20 VSS VDD SPSRAM256X8CCG
XI0_14 BL BL WL_19 WL_19 VSS VDD SPSRAM256X8CCG
XI0_15 BL BL WL_18 WL_18 VSS VDD SPSRAM256X8CCG
XI0_16 BL BL WL_17 WL_17 VSS VDD SPSRAM256X8CCG
XI0_17 BL BL WL_16 WL_16 VSS VDD SPSRAM256X8CCG
XI0_18 BL BL WL_15 WL_15 VSS VDD SPSRAM256X8CCG
XI0_19 BL BL WL_14 WL_14 VSS VDD SPSRAM256X8CCG
XI0_2 A0 A0_ GTP BL YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8FCCDR
XI0_20 BL BL WL_13 WL_13 VSS VDD SPSRAM256X8CCG
XI0_21 BL BL WL_12 WL_12 VSS VDD SPSRAM256X8CCG
XI0_22 BL BL WL_11 WL_11 VSS VDD SPSRAM256X8CCG
XI0_23 BL BL WL_10 WL_10 VSS VDD SPSRAM256X8CCG
XI0_24 BL BL WL_9 WL_9 VSS VDD SPSRAM256X8CCG
XI0_25 BL BL WL_8 WL_8 VSS VDD SPSRAM256X8CCG
XI0_26 BL BL WL_7 WL_7 VSS VDD SPSRAM256X8CCG
XI0_27 BL BL WL_6 WL_6 VSS VDD SPSRAM256X8CCG
XI0_28 BL BL WL_5 WL_5 VSS VDD SPSRAM256X8CCG
XI0_29 BL BL WL_4 WL_4 VSS VDD SPSRAM256X8CCG
XI0_3 BL BL WL_30 WL_30 VSS VDD SPSRAM256X8CCG
XI0_30 BL BL WL_3 WL_3 VSS VDD SPSRAM256X8CCG
XI0_31 BL BL WL_2 WL_2 VSS VDD SPSRAM256X8CCG
XI0_32 BL BL WL_1 WL_1 VSS VDD SPSRAM256X8CCG
XI0_33 BL BL WL_0 WL_0 VSS VDD SPSRAM256X8CCG
XI0_34 BL BL WL WL VSS VDD SPSRAM256X8CCG
XI0_35 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_36 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_37 BL BL VSS VSS VSS VDD SPSRAM256X8CCG
XI0_4 BL BL WL_29 WL_29 VSS VDD SPSRAM256X8CCG
XI0_5 BL BL WL_28 WL_28 VSS VDD SPSRAM256X8CCG
XI0_6 BL BL WL_27 WL_27 VSS VDD SPSRAM256X8CCG
XI0_7 BL BL WL_26 WL_26 VSS VDD SPSRAM256X8CCG
XI0_8 BL BL WL_25 WL_25 VSS VDD SPSRAM256X8CCG
XI0_9 BL BL WL_24 WL_24 VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8RIGHT_CAP
****
.SUBCKT SPSRAM256X8CCMBT MBL MBL_ TIEDOWN WL VSS VDD
** SPSRAM256X8CCMBT: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.295U W=0.215U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.295U W=0.215U
m3 CORED_ CORED VDD VDD P L=0.184U W=0.21U
m4 CORED_ CORED VSS VSS N L=0.175U W=0.215U
m5 CORED CORED_ VDD VDD P L=0.184U W=0.21U
m6 CORED CORED_ VSS VSS N L=0.175U W=0.215U
.ENDS SPSRAM256X8CCMBT
****
.SUBCKT SPSRAM256X8CCMBB MBL MBL_ TIEDOWN WL VSS VDD
** SPSRAM256X8CCMBB: 6 flat devices **
m1 MBL TIEDOWN CORED VSS N L=0.295U W=0.215U
m2 MBL_ TIEDOWN CORED_ VSS N L=0.295U W=0.215U
m3 CORED_ CORED VDD VDD P L=0.184U W=0.21U
m4 CORED_ CORED VSS VSS N L=0.175U W=0.215U
m5 CORED CORED_ VDD VDD P L=0.184U W=0.21U
m6 CORED CORED_ VSS VSS N L=0.175U W=0.215U
.ENDS SPSRAM256X8CCMBB
****
.SUBCKT SPSRAM256X8CCPDBB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** SPSRAM256X8CCPDBB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.295U W=0.215U
m2 MBL_ MWL N9 VSS N L=0.295U W=0.215U
m3 CORED GTP VSS VSS N L=0.175U W=0.215U
m4 N10 GTP VDD VDD P L=0.184U W=0.21U
m5 N12 CORED VDD VDD P L=0.184U W=0.21U
.ENDS SPSRAM256X8CCPDBB
****
.SUBCKT SPSRAM256X8CCPDT GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** SPSRAM256X8CCPDT: 5 flat devices **
m1 MBL MWL N9 VSS N L=0.295U W=0.215U
m2 MBL_ MWL CORED_ VSS N L=0.295U W=0.215U
m3 CORED_ GTP VSS VSS N L=0.175U W=0.215U
m4 N11 GTP VDD VDD P L=0.184U W=0.21U
m5 N13 CORED_ VDD VDD P L=0.184U W=0.21U
.ENDS SPSRAM256X8CCPDT
****
.SUBCKT SPSRAM256X8CCPDB GTP MBL MBL_ MWL TIEDOWN WL VSS VDD
** SPSRAM256X8CCPDB: 5 flat devices **
m1 MBL MWL CORED VSS N L=0.295U W=0.215U
m2 MBL_ MWL N9 VSS N L=0.295U W=0.215U
m3 CORED GTP VSS VSS N L=0.175U W=0.215U
m4 N10 GTP VDD VDD P L=0.184U W=0.21U
m5 N12 CORED VDD VDD P L=0.184U W=0.21U
.ENDS SPSRAM256X8CCPDB
****
.SUBCKT SPSRAM256X8MBLBASE GTP MBL MBL_ MWLD MWLS VSS VDD
** SPSRAM256X8MBLBASE: 12 flat devices **
m1 N13 GTP VSS VSS N L=0.175U W=0.215U
m10 MBL MWLD NODE7 VSS N L=0.295U W=0.215U
m11 NODE8 GTP VSS VSS N L=0.175U W=0.215U
m12 MBL MWLD NODE8 VSS N L=0.295U W=0.215U
m2 MBL MWLD N13 VSS N L=0.295U W=0.215U
m3 NODE3 GTP VSS VSS N L=0.175U W=0.215U
m4 MBL MWLD NODE3 VSS N L=0.295U W=0.215U
m5 NODE4 GTP VSS VSS N L=0.175U W=0.215U
m6 MBL MWLD NODE4 VSS N L=0.295U W=0.215U
m7 NODE6 GTP VSS VSS N L=0.175U W=0.215U
m8 MBL MWLD NODE6 VSS N L=0.295U W=0.215U
m9 NODE7 GTP VSS VSS N L=0.175U W=0.215U
.ENDS SPSRAM256X8MBLBASE
****
.SUBCKT SPSRAM256X8MODEL_COL GTP MBL MBL_ MWLD MWLS WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 VSS VDD
** SPSRAM256X8MODEL_COL: 198 flat devices **
XI0_0 MBL MBL_ VSS WL_30 VSS VDD SPSRAM256X8CCMBB
XI0_1 MBL_ MBL VSS WL_29 VSS VDD SPSRAM256X8CCMBT
XI0_10 MBL MBL_ VSS WL_20 VSS VDD SPSRAM256X8CCMBB
XI0_11 MBL_ MBL VSS WL_19 VSS VDD SPSRAM256X8CCMBT
XI0_12 MBL MBL_ VSS WL_18 VSS VDD SPSRAM256X8CCMBB
XI0_13 MBL_ MBL VSS WL_17 VSS VDD SPSRAM256X8CCMBT
XI0_14 MBL MBL_ VSS WL_16 VSS VDD SPSRAM256X8CCMBB
XI0_15 MBL_ MBL VSS WL_15 VSS VDD SPSRAM256X8CCMBT
XI0_16 MBL MBL_ VSS WL_14 VSS VDD SPSRAM256X8CCMBB
XI0_17 MBL_ MBL VSS WL_13 VSS VDD SPSRAM256X8CCMBT
XI0_18 MBL MBL_ VSS WL_12 VSS VDD SPSRAM256X8CCMBB
XI0_19 MBL_ MBL VSS WL_11 VSS VDD SPSRAM256X8CCMBT
XI0_2 MBL MBL_ VSS WL_28 VSS VDD SPSRAM256X8CCMBB
XI0_20 MBL MBL_ VSS WL_10 VSS VDD SPSRAM256X8CCMBB
XI0_21 MBL_ MBL VSS WL_9 VSS VDD SPSRAM256X8CCMBT
XI0_22 MBL MBL_ VSS WL_8 VSS VDD SPSRAM256X8CCMBB
XI0_23 MBL_ MBL VSS WL_7 VSS VDD SPSRAM256X8CCMBT
XI0_24 MBL MBL_ VSS WL_6 VSS VDD SPSRAM256X8CCMBB
XI0_25 MBL_ MBL VSS WL_5 VSS VDD SPSRAM256X8CCMBT
XI0_26 GTP MBL MBL_ MWLD VSS WL_4 VSS VDD SPSRAM256X8CCPDBB
XI0_27 GTP MBL_ MBL MWLD VSS WL_3 VSS VDD SPSRAM256X8CCPDT
XI0_28 GTP MBL MBL_ MWLD VSS WL_2 VSS VDD SPSRAM256X8CCPDB
XI0_29 GTP MBL_ MBL MWLD VSS WL_1 VSS VDD SPSRAM256X8CCPDT
XI0_3 MBL_ MBL VSS WL_27 VSS VDD SPSRAM256X8CCMBT
XI0_30 GTP MBL MBL_ MWLD VSS WL_0 VSS VDD SPSRAM256X8CCPDB
XI0_31 GTP MBL_ MBL MWLD VSS WL VSS VDD SPSRAM256X8CCPDT
XI0_32 GTP MBL MBL_ MWLD MWLS VSS VDD SPSRAM256X8MBLBASE
XI0_4 MBL MBL_ VSS WL_26 VSS VDD SPSRAM256X8CCMBB
XI0_5 MBL_ MBL VSS WL_25 VSS VDD SPSRAM256X8CCMBT
XI0_6 MBL MBL_ VSS WL_24 VSS VDD SPSRAM256X8CCMBB
XI0_7 MBL_ MBL VSS WL_23 VSS VDD SPSRAM256X8CCMBT
XI0_8 MBL MBL_ VSS WL_22 VSS VDD SPSRAM256X8CCMBB
XI0_9 MBL_ MBL VSS WL_21 VSS VDD SPSRAM256X8CCMBT
.ENDS SPSRAM256X8MODEL_COL
****
.SUBCKT SPSRAM256X8 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] CEN CLK D[0] D[1]
+  D[2] D[3] D[4] D[5] D[6] D[7] OEN Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7]
+  WEN VSS VDD
** SPSRAM256X8: 17377 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP GTP GTP OE_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8LEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D[0] D[1] D[2] D[3] GTP GTP GTP
+  OE_ Q[0] Q[1] Q[2] Q[3] DR DR_ VSS VSS DW DW_ VSS VSS WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8WING_4_LEFT
XI1_5 BL BL__14 BL_14 BL__13 BL_13 BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20
+  BL_21 BL_22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL__15
+  BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL_23 BL_24 BL_25 BL_26
+  BL_27 BL_28 BL_29 BL_30 MWLB VSS MWLB VSS MWLB VSS VSS VSS VDD
+  SPSRAM256X8MODEL_ROW_4
XI3_0 A[3] A[6] A[4] A[7] A[5] AGTPT AGTPT A0 A0_ VSS OE_ WE XP_0 XP_0_0 XP_1
+  XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3
+  VSS VSS VSS VSS VSS VDD SPSRAM256X8X_PRE_DECODE
XI3_3 VDD GTP MBL MBL_ MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14 WL_15
+  WL_18 WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_0 WL_1 WL_4 WL_5 WL_8 WL_9
+  WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24 WL_25 WL_28 WL_29 XP_0_0 XP_2_0
+  XP_1_0 XP_3_0 XP_0 XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 VSS VDD
+  SPSRAM256X8WORD_ROWS
XI4_0 A[0] A[1] A[2] AGTPT A0 A0_ VSS CLK GSRCN GTPN OE_ RST WE YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD SPSRAM256X8Y_DECODE
XI5_0 CEN CENI_ CLK GSRCN GTP GTPN MBL OE_ OEN OENI_ RST VSS WE WEN WENI_ VSS
+  VDD SPSRAM256X8HBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTP GTPN GTP GTP GTP RST YP0_0 YP0_1 YP0_2 YP0_3
+  VSS VSS VSS VSS VSS VDD SPSRAM256X8CLK_DRVS
XI6_2 A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS
+  VSS VSS VSS VDD SPSRAM256X8FLCIO
XI6_4 GTP MBL MBL_ MWLB MWLB WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VDD
+  SPSRAM256X8MODEL_COL
XI7_0 A0 A0_ BL_133 BL__131 BL_0_137 BL_1_141 BL_2_145 BL_3_149 BL_4_153
+  BL_5_157 BL_6_161 BL_7_163 BL_8_167 BL_9_171 BL_10_175 BL_11_179 BL_12_183
+  BL_13_187 BL_14_191 BL_15_197 BL_16_201 BL_17_205 BL_18_209 BL_19_213
+  BL_20_217 BL_21_221 BL_22_225 BL_23_227 BL_24_231 BL_25_235 BL_26_239
+  BL_27_243 BL_28_247 BL_29_251 BL_30_255 BL__0_135 BL__1_139 BL__2_143
+  BL__3_147 BL__4_151 BL__5_155 BL__6_159 BL__7_165 BL__8_169 BL__9_173
+  BL__10_177 BL__11_181 BL__12_185 BL__13_189 BL__14_193 BL__15_195
+  BL__16_199 BL__17_203 BL__18_207 BL__19_211 BL__20_215 BL__21_219
+  BL__22_223 BL__23_229 BL__24_233 BL__25_237 BL__26_241 BL__27_245
+  BL__28_249 BL__29_253 BL__30_257 D[7] D[6] D[5] D[4] GTP GTP GTP OE_ Q[7]
+  Q[6] Q[5] Q[4] VSS VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0 STUBDW__0 WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8WING_4_RIGHT
XI7_5 BL_133 BL__14_193 BL_14_191 BL__13_189 BL_13_187 BL__131 BL_0_137
+  BL_1_141 BL_2_145 BL_3_149 BL_4_153 BL_5_157 BL_6_161 BL__7_165 BL__8_169
+  BL__9_173 BL__10_177 BL__11_181 BL__12_185 BL_15_197 BL_16_201 BL_17_205
+  BL_18_209 BL_19_213 BL_20_217 BL_21_221 BL_22_225 BL__23_229 BL__24_233
+  BL__25_237 BL__26_241 BL__27_245 BL__28_249 BL__29_253 BL__30_257 BL__0_135
+  BL__1_139 BL__2_143 BL__3_147 BL__4_151 BL__5_155 BL__6_159 BL_7_163
+  BL_8_167 BL_9_171 BL_10_175 BL_11_179 BL_12_183 BL__15_195 BL__16_199
+  BL__17_203 BL__18_207 BL__19_211 BL__20_215 BL__21_219 BL__22_223 BL_23_227
+  BL_24_231 BL_25_235 BL_26_239 BL_27_243 BL_28_247 BL_29_251 BL_30_255 MWLB
+  VSS MWLB VSS MWLB VSS VSS VSS VDD SPSRAM256X8MODEL_ROW_4
XI8_0 A0 A0_ GTP GTP GTP OE_ WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8RIGHT_CAP
.ENDS SPSRAM256X8
