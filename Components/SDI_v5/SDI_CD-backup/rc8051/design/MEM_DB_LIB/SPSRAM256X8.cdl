* 
* Copyright 2005 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.3f
* Version: 2004Q2V1
* Name: SRAM-SP-HS-HC SRAM Generator|TSMC CL013G Process
* Comment: 
* Configuration:  -instname SPSRAM256X8 -words 256 -bits 8 -frequen\
* Configuration: cy 50 -ring_width 6 -mux 8 -drive 6 -write_mask of\
* Configuration: f -wp_size 8 -redundancy off -redundancy_bits 1 -t\
* Configuration: op_layer met8 -power_type rings -horiz met3 -vert \
* Configuration: met4 -cust_comment "" -left_bus_delim "[" -right_b\
* Configuration: us_delim "]" -pwr_gnd_rename "VDD:VDD,GND:VSS" -pr\
* Configuration: efix "" -pin_space 0.0 -name_case upper -check_ins\
* Configuration: tname on -diodes on -inside_ring_type GND -fuse_en\
* Configuration: coding encoded -insert_fuse yes -fusebox_name FUSE\
* Configuration:  -rtl_style mux
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT SPSRAM256X8FCIO8 DPU2 DW DW_ GTP WE WESA VSS VDD
** SPSRAM256X8FCIO8: 2 flat devices **
D0 VSS WE DN 0.2116P 1.84U
D1 VSS GTP DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCIO8
****
.SUBCKT SPSRAM256X8FCSA8 GTP YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FCSA8: 1 flat devices **
D0 VSS GTP DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCSA8
****
.SUBCKT SPSRAM256X8LEFT_CAP A0 A0_ DPU2 DW DW_ GTP GTP_0 GTP_1 WE WESA WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** SPSRAM256X8LEFT_CAP: 3 flat devices **
XI0_0 DPU2 DW DW_ GTP WE WESA VSS VDD SPSRAM256X8FCIO8
XI0_1 GTP_0 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8FCSA8
.ENDS SPSRAM256X8LEFT_CAP
****
.SUBCKT SPSRAM256X8FCBWM8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWM8: 2 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS Q DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCBWM8
****
.SUBCKT SPSRAM256X8IO8 BWE BWEN D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4 DW
+  DW_ GTP Q STUBDPN1I STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW
+  STUBDWI STUBDWI_ STUBDW_ STUBWE STUBWEI STUBWESA STUBWESAI WE WESA VSS VDD
** SPSRAM256X8IO8: 68 flat devices **
M0 NET0302 NET37 QPD VDD P W=1.27U L=0.13U M=1
M1 NET0302 GTPND VDD VDD P W=1.27U L=0.13U M=1
M10 NET60 GGTPBUF VSS VSS N W=1.62U L=0.13U M=1
M11 QPD DW NET60 VSS N W=1.62U L=0.13U M=1
M12 DILATCH GTPND DI VSS N W=0.19U L=0.13U M=1
M13 QPD DPU4 VSS VSS N W=1.69U L=0.13U M=1
M14 QPD DPU2 VSS VSS N W=1.69U L=0.13U M=1
M15 QPD DPU3 VSS VSS N W=1.69U L=0.13U M=1
M16 QPD DPU1 VSS VSS N W=1.69U L=0.13U M=1
M17 WEIBLATCH GTPND WEIB VSS N W=0.19U L=0.13U M=1
M18 GWE_FB-NET7 WESA VSS VSS N W=0.15U L=0.13U M=1
M19 WEIBLATCH GGTPBUF GWE_FB-NET7 VSS N W=0.15U L=0.13U M=1
M2 NET39 GTPND VDD VDD P W=1.27U L=0.13U M=1
M20 GWE_FB-NET15 GTPND WEIBLATCH VDD P W=0.15U L=0.13U M=1
M21 VDD WESA GWE_FB-NET15 VDD P W=0.15U L=0.13U M=1
M22 GDW_FB-NET7 DIN VSS VSS N W=0.15U L=0.13U M=1
M23 DILATCH GGTPBUF GDW_FB-NET7 VSS N W=0.15U L=0.13U M=1
M24 GDW_FB-NET15 GTPND DILATCH VDD P W=0.15U L=0.13U M=1
M25 VDD DIN GDW_FB-NET15 VDD P W=0.15U L=0.13U M=1
M26 GDWU-NET8 WESA VSS VSS N W=0.46U L=0.13U M=1
M27 NET37 NET90 GDWU-NET8 VSS N W=0.46U L=0.13U M=1
M28 VDD WESA NET37 VDD P W=0.46U L=0.13U M=1
M29 VDD NET90 NET37 VDD P W=0.46U L=0.13U M=1
M3 NET39 NET37 QPD VDD P W=1.27U L=0.13U M=1
M30 GDW-NET8 WESA VSS VSS N W=0.46U L=0.13U M=1
M31 NET101 DIN GDW-NET8 VSS N W=0.46U L=0.13U M=1
M32 VDD WESA NET101 VDD P W=0.46U L=0.13U M=1
M33 VDD DIN NET101 VDD P W=0.46U L=0.13U M=1
M34 VDD WE WEIB VDD P W=0.62U L=0.13U M=1
M35 WEIB WE VSS VSS N W=0.37U L=0.13U M=1
M36 VDD NET37 DW_ VDD P W=1U L=0.13U M=1
M37 DW_ NET37 VSS VSS N W=0.5U L=0.13U M=1
M38 VDD NET101 DW VDD P W=1U L=0.13U M=1
M39 DW NET101 VSS VSS N W=0.5U L=0.13U M=1
M4 DILATCH GGTPBUF DI VDD P W=0.22U L=0.13U M=1
M40 VDD QPD Q VDD P W=6U L=0.13U M=1
M41 Q QPD VSS VSS N W=6U L=0.13U M=1
M42 VDD QPU QPD VDD P W=0.3U L=0.26U M=1
M43 QPD QPU VSS VSS N W=0.3U L=0.26U M=1
M44 VDD QPD QPU VDD P W=0.3U L=0.13U M=1
M45 QPU QPD VSS VSS N W=0.3U L=0.13U M=1
M46 VDD GTP GTPND VDD P W=0.27U L=0.13U M=1
M47 GTPND GTP VSS VSS N W=0.25U L=0.13U M=1
M48 VDD GTPND GGTPBUF VDD P W=0.57U L=0.13U M=1
M49 GGTPBUF GTPND VSS VSS N W=0.37U L=0.13U M=1
M5 QPD DPN4 VDD VDD P W=3.4U L=0.13U M=1
M50 VDD DILATCH DIN VDD P W=0.36U L=0.13U M=1
M51 DIN DILATCH VSS VSS N W=0.23U L=0.13U M=1
M52 VDD WEIBLATCH WESA VDD P W=0.4U L=0.13U M=1
M53 WESA WEIBLATCH VSS VSS N W=0.39U L=0.13U M=1
M54 VDD NET122 NET116 VDD P W=0.23U L=0.13U M=1
M55 NET116 NET122 VSS VSS N W=0.15U L=0.13U M=1
M56 VDD DIN NET90 VDD P W=0.23U L=0.13U M=1
M57 NET90 DIN VSS VSS N W=0.15U L=0.13U M=1
M58 VDD NET116 DI VDD P W=0.23U L=0.13U M=1
M59 DI NET116 VSS VSS N W=0.15U L=0.13U M=1
M6 QPD DPN3 VDD VDD P W=3.4U L=0.13U M=1
M60 VDD D NET122 VDD P W=0.23U L=0.13U M=1
M61 NET122 D VSS VSS N W=0.15U L=0.13U M=1
M62 VDD NET128 NET124 VDD P W=0.23U L=0.13U M=1
M63 NET124 NET128 VSS VSS N W=0.15U L=0.13U M=1
M64 VDD NET124 BWE VDD P W=0.47U L=0.13U M=1
M65 BWE NET124 VSS VSS N W=0.3U L=0.13U M=1
M66 VDD BWEN NET128 VDD P W=0.23U L=0.13U M=1
M67 NET128 BWEN VSS VSS N W=0.15U L=0.13U M=1
M7 QPD DPN2 VDD VDD P W=3.4U L=0.13U M=1
M8 QPD DPN1 VDD VDD P W=3.4U L=0.13U M=1
M9 WEIBLATCH GGTPBUF WEIB VDD P W=0.22U L=0.13U M=1
.ENDS SPSRAM256X8IO8
****
.SUBCKT SPSRAM256X8IOX BWE D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4 DW DW_
+  GTP Q STUBDPN1I STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW
+  STUBDWI STUBDWI_ STUBDW_ STUBWEI STUBWESA STUBWESAI WESA VSS VDD
** SPSRAM256X8IOX: 68 flat devices **
XI0_0 BWE VSS D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4 DW DW_ GTP Q STUBDPN1I
+  STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW STUBDWI STUBDWI_
+  STUBDW_ STUBWEI STUBWEI STUBWESA STUBWESAI STUBWEI WESA VSS VDD
+  SPSRAM256X8IO8
.ENDS SPSRAM256X8IOX
****
.SUBCKT SPSRAM256X8SA8 DPN DPU DR DR_ DW DWCD DWCD_ DW_ G1 GTP WESA YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8SA8: 55 flat devices **
M0 SRCDB GTP2D VDD VDD P W=1.4U L=0.13U M=1
M1 SRCDB WESAB VDD VDD P W=0.15U L=0.13U M=1
M10 DW_ NET42 DWCD_ VDD P W=0.99U L=0.13U M=1
M11 DW NET42 DWCD VDD P W=0.99U L=0.13U M=1
M12 DR DRP VDD VDD P W=2U L=0.13U M=1
M13 DR DRP DR_ VDD P W=2U L=0.13U M=1
M14 SD SP DR VDD P W=1.65U L=0.13U M=1
M15 SD_ SP DR_ VDD P W=1.65U L=0.13U M=1
M16 SD SD_ VDD VDD P W=0.34U L=0.13U M=1
M17 SD_ SDPCH VDD VDD P W=0.3U L=0.13U M=1
M18 DR_ DRP VDD VDD P W=2U L=0.13U M=1
M19 SRC GTPN NET89 VSS N W=1.76U L=0.13U M=1
M2 DRP SRCDB VDD VDD P W=0.5U L=0.13U M=1
M20 NET82 GTP2D VSS VSS N W=1.09U L=0.13U M=1
M21 SRCDB WESAB NET82 VSS N W=0.3U L=0.13U M=1
M22 DRP SRCDB NET104 VSS N W=1U L=0.13U M=1
M23 NET89 SRCD VSS VSS N W=1.6U L=0.13U M=1
M24 SD_ SD SRC VSS N W=2.7U L=0.19U M=1
M25 SDPCH SP VSS VSS N W=0.15U L=0.13U M=1
M26 DRP WESAB SDPCH VSS N W=0.3U L=0.13U M=1
M27 NET44 G1 GTP VSS N W=0.3U L=0.13U M=1
M28 NET104 GTPN VSS VSS N W=0.3U L=0.13U M=1
M29 DWCD NET42 VSS VSS N W=0.15U L=0.13U M=1
M3 SD_ SD VDD VDD P W=0.34U L=0.13U M=1
M30 DWCD_ NET42 VSS VSS N W=0.15U L=0.13U M=1
M31 SRC GTPN NET125 VSS N W=1.76U L=0.13U M=1
M32 SD_ SD SRC VSS N W=2.7U L=0.19U M=1
M33 SD SD_ SRC VSS N W=2.7U L=0.19U M=1
M34 SD SD_ SRC VSS N W=2.7U L=0.19U M=1
M35 NET125 SRCD VSS VSS N W=1.6U L=0.13U M=1
M36 NET44 NET42 VSS VSS N W=0.15U L=0.13U M=1
M37 VDD G1 NET42 VDD P W=0.15U L=0.13U M=1
M38 NET42 G1 VSS VSS N W=0.15U L=0.13U M=1
M39 VDD WESA WESAB VDD P W=0.23U L=0.13U M=1
M4 SD SDPCH VDD VDD P W=0.3U L=0.13U M=1
M40 WESAB WESA VSS VSS N W=0.15U L=0.13U M=1
M41 VDD SRCDB SRCD VDD P W=0.36U L=0.13U M=1
M42 SRCD SRCDB VSS VSS N W=0.15U L=0.13U M=1
M43 VDD WESAB SP VDD P W=0.6U L=0.13U M=1
M44 SP WESAB VSS VSS N W=0.5U L=0.13U M=1
M45 VDD SD SDN VDD P W=0.7U L=0.13U M=1
M46 SDN SD VSS VSS N W=0.24U L=0.13U M=1
M47 VDD GTPN GTP2D VDD P W=0.46U L=0.13U M=1
M48 GTP2D GTPN VSS VSS N W=0.3U L=0.13U M=1
M49 VDD NET44 GTPN VDD P W=2U L=0.13U M=1
M5 SD SDPCH SD_ VDD P W=0.3U L=0.13U M=1
M50 GTPN NET44 VSS VSS N W=0.5U L=0.13U M=1
M51 VDD SDN DPN VDD P W=0.35U L=0.13U M=1
M52 DPN SDN VSS VSS N W=0.94U L=0.13U M=1
M53 VDD SD_ DPU VDD P W=0.7U L=0.13U M=1
M54 DPU SD_ VSS VSS N W=0.24U L=0.13U M=1
M6 DRP SP SDPCH VDD P W=0.3U L=0.13U M=1
M7 SD_ VDD SD VDD P W=0.34U L=0.13U M=1
M8 NET44 NET42 GTP VDD P W=0.3U L=0.13U M=1
M9 DRP GTPN VDD VDD P W=1.5U L=0.13U M=1
.ENDS SPSRAM256X8SA8
****
.SUBCKT SPSRAM256X8CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1
+  GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CD: 43 flat devices **
M0 BL0PD CS0 DW_ VDD P W=0.99U L=0.13U M=1
M1 NET85 YCDSEL_ GTP VDD P W=0.3U L=0.13U M=1
M10 BL1_ CS1 DR_ VDD P W=2.28U L=0.13U M=1
M11 BL0_ CS0 DR_ VDD P W=2.28U L=0.13U M=1
M12 BL0_ YI VDD VDD P W=4.64U L=0.13U M=1
M13 BL1 YI VDD VDD P W=4.64U L=0.13U M=1
M14 BL1_ YI VDD VDD P W=4.64U L=0.13U M=1
M15 BL0PD CS0 VSS VSS N W=0.68U L=0.13U M=1
M16 BL0 BL0PD VSS VSS N W=5.21U L=0.13U M=1
M17 NET85 YCDSEL_ VSS VSS N W=0.3U L=0.13U M=1
M18 NET85 YCDSEL GTP VSS N W=0.3U L=0.13U M=1
M19 BL1_PD CS1 VSS VSS N W=0.68U L=0.13U M=1
M2 BL0 CS0 DR VDD P W=2.28U L=0.13U M=1
M20 BL1PD CS1 VSS VSS N W=0.68U L=0.13U M=1
M21 BL0_PD CS0 VSS VSS N W=0.68U L=0.13U M=1
M22 BL1 BL1_PD VSS VSS N W=5.21U L=0.13U M=1
M23 BL1_ BL1PD VSS VSS N W=5.21U L=0.13U M=1
M24 BL0_ BL0_PD VSS VSS N W=5.21U L=0.13U M=1
M25 VDD NET85 WL1_EN_ VDD P W=1.64U L=0.13U M=1
M26 WL1_EN_ NET85 VSS VSS N W=1.04U L=0.13U M=1
M27 VDD WL1_EN_ YI VDD P W=4.08U L=0.13U M=1
M28 YI WL1_EN_ VSS VSS N W=3.24U L=0.13U M=1
M29 VDD YCDSEL_ YCDSEL VDD P W=0.15U L=0.13U M=1
M3 BL0 YI VDD VDD P W=4.64U L=0.13U M=1
M30 YCDSEL YCDSEL_ VSS VSS N W=0.15U L=0.13U M=1
M31 SC_NAND_C0_I0-NET8 G0 VSS VSS N W=0.19U L=0.13U M=1
M32 YCDSEL_ G1 SC_NAND_C0_I0-NET8 VSS N W=0.19U L=0.13U M=1
M33 VDD G0 YCDSEL_ VDD P W=0.15U L=0.13U M=1
M34 VDD G1 YCDSEL_ VDD P W=0.15U L=0.13U M=1
M35 GCSR-NET8 A0 VSS VSS N W=1.57U L=0.13U M=1
M36 CS1 YI GCSR-NET8 VSS N W=1.57U L=0.13U M=1
M37 VDD A0 CS1 VDD P W=1.14U L=0.13U M=1
M38 VDD YI CS1 VDD P W=1.14U L=0.13U M=1
M39 GCS-NET8 A0_ VSS VSS N W=1.57U L=0.13U M=1
M4 BL0 YI BL0_ VDD P W=4.64U L=0.13U M=1
M40 CS0 YI GCS-NET8 VSS N W=1.57U L=0.13U M=1
M41 VDD A0_ CS0 VDD P W=1.14U L=0.13U M=1
M42 VDD YI CS0 VDD P W=1.14U L=0.13U M=1
M5 BL1_ YI BL1 VDD P W=4.64U L=0.13U M=1
M6 BL1_PD CS1 DW_ VDD P W=0.99U L=0.13U M=1
M7 BL1PD CS1 DW VDD P W=0.99U L=0.13U M=1
M8 BL0_PD CS0 DW VDD P W=0.99U L=0.13U M=1
M9 BL1 CS1 DR VDD P W=2.28U L=0.13U M=1
.ENDS SPSRAM256X8CD
****
.SUBCKT SPSRAM256X8MUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0__0 BL0_0 DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_3
+  VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8CD
XI2_0 A0 A0_ BL0_2 BL0__2 BL0__1 BL0_1 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
XI4_0 A0 A0_ BL0_3 BL0__3 BL0__4 BL0_4 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
XI6_0 A0 A0_ BL0_6 BL0__6 BL0__5 BL0_5 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
.ENDS SPSRAM256X8MUX_CD_ODD
****
.SUBCKT SPSRAM256X8CCG BL BL_ WL WP VSS VDD
** SPSRAM256X8CCG: 6 flat devices **
M0 BL WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BL_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS SPSRAM256X8CCG
****
.SUBCKT SPSRAM256X8CCP BL BL_ WL WP VSS VDD
** SPSRAM256X8CCP: 6 flat devices **
M0 BL WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BL_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS SPSRAM256X8CCP
****
.SUBCKT SPSRAM256X8BIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** SPSRAM256X8BIT_MUX_1: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD SPSRAM256X8CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD SPSRAM256X8CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD SPSRAM256X8CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD SPSRAM256X8CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD SPSRAM256X8CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD SPSRAM256X8CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD SPSRAM256X8CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8BIT_MUX_1
****
.SUBCKT SPSRAM256X8BIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** SPSRAM256X8BIT_MUX_0: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD SPSRAM256X8CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD SPSRAM256X8CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD SPSRAM256X8CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD SPSRAM256X8CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD SPSRAM256X8CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD SPSRAM256X8CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD SPSRAM256X8CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD SPSRAM256X8CCG
.ENDS SPSRAM256X8BIT_MUX_0
****
.SUBCKT SPSRAM256X8BIT_COL BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26
+  WP_27 WP_28 WP_29 WP_30 VSS VDD
** SPSRAM256X8BIT_COL: 1536 flat devices **
XI0_0 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL WP VSS VDD SPSRAM256X8BIT_MUX_0
XI0_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_0 WP_0 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_10 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_9 WP_9 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_11 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_10 WP_10 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_12 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_11 WP_11 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_13 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_12 WP_12 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_14 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_13 WP_13 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_15 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_14 WP_14 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_16 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_15 WP_15 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_17 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_16 WP_16 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_18 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_17 WP_17 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_19 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_18 WP_18 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_2 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_1 WP_1 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_20 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_19 WP_19 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_21 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_20 WP_20 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_22 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_21 WP_21 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_23 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_22 WP_22 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_24 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_23 WP_23 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_25 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_24 WP_24 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_26 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_25 WP_25 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_27 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_26 WP_26 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_28 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_27 WP_27 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_29 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_28 WP_28 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_3 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_2 WP_2 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_30 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_29 WP_29 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_31 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_30 WP_30 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_4 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_3 WP_3 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_5 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_4 WP_4 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_6 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_5 WP_5 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_7 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_6 WP_6 VSS VDD SPSRAM256X8BIT_MUX_1
XI0_8 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_7 WP_7 VSS VDD SPSRAM256X8BIT_MUX_0
XI0_9 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_8 WP_8 VSS VDD SPSRAM256X8BIT_MUX_1
.ENDS SPSRAM256X8BIT_COL
****
.SUBCKT SPSRAM256X8MCOL_ODD_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0
+  VSS VDD
** SPSRAM256X8MCOL_ODD_M8: 1833 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWM8
XI0_1 BWE D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS STUBWEI VSS VSS WESA VSS VDD SPSRAM256X8IOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD SPSRAM256X8MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 VSS VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_ODD_M8
****
.SUBCKT SPSRAM256X8MUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8MUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0__0 BL0_0 DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_0
+  VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8CD
XI2_0 A0 A0_ BL0_2 BL0__2 BL0__1 BL0_1 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
XI4_0 A0 A0_ BL0_3 BL0__3 BL0__4 BL0_4 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
XI6_0 A0 A0_ BL0_6 BL0__6 BL0__5 BL0_5 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_3 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD SPSRAM256X8CD
.ENDS SPSRAM256X8MUX_CD_EVEN
****
.SUBCKT SPSRAM256X8MCOL_EVEN_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0
+  VSS VDD
** SPSRAM256X8MCOL_EVEN_M8: 1833 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWM8
XI0_1 BWE D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS STUBWEI VSS VSS WESA VSS VDD SPSRAM256X8IOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD SPSRAM256X8MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 VSS VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_EVEN_M8
****
.SUBCKT SPSRAM256X8FCBWLE8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWLE8: 3 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D2 VSS Q DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCBWLE8
****
.SUBCKT SPSRAM256X8FCBWLX BWEN D Q VSS VDD
** SPSRAM256X8FCBWLX: 3 flat devices **
XI0_0 BWEN D Q VSS VDD SPSRAM256X8FCBWLE8
.ENDS SPSRAM256X8FCBWLX
****
.SUBCKT SPSRAM256X8MCOL_EVEN_LX8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0
+  VSS VDD
** SPSRAM256X8MCOL_EVEN_LX8: 1834 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWLX
XI0_1 BWE D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS STUBWEI VSS VSS WESA VSS VDD SPSRAM256X8IOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD SPSRAM256X8MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 VSS VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_EVEN_LX8
****
.SUBCKT SPSRAM256X8WING_4_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D D_0 D_1
+  D_2 GTP GTP_0 GTP_1 Q Q_0 Q_1 Q_2 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1
+  YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** SPSRAM256X8WING_4_LEFT: 7333 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 D_0 GTP GTP_0 GTP_1 Q_0 STUBWE WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9
+  WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21
+  WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 D_1 GTP GTP_0 GTP_1 Q_1 STUBWE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 D_2 GTP GTP_0 GTP_1 Q_2 STUBWE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_EVEN_LX8
.ENDS SPSRAM256X8WING_4_LEFT
****
.SUBCKT SPSRAM256X8HXP24 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HXP24: 100 flat devices **
D0 VSS A0 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D8 VSS A1 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A1 NET181 VDD P W=3.06U L=0.13U M=1
M11 NET181 A1 VSS VSS N W=2.05U L=0.13U M=1
M12 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M13 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M14 VDD AI_2-NET28 NET165 VDD P W=3.06U L=0.13U M=1
M15 NET165 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M16 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M17 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M18 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M19 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M2 VDD A0 NET180 VDD P W=3.06U L=0.13U M=1
M20 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M21 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M22 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M23 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M24 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M25 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M26 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M27 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M28 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M29 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M3 NET180 A0 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M31 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M32 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M33 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M34 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M35 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M37 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M38 VDD AP_2-APN0 XP_3 VDD P W=18U L=0.13U M=1
M39 XP_3 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M4 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M40 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M41 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M42 VDD NET180 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M43 AP_2-AIN20 NET180 VSS VSS N W=1.78U L=0.13U M=1
M44 VDD XP_3 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M45 AP_2-APN0 XP_3 VSS VSS N W=0.15U L=0.39U M=1
M46 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M47 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M48 VDD XP_2 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M49 AP_2-APN1 XP_2 VSS VSS N W=0.15U L=0.39U M=1
M5 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD AP_2-APN1 XP_2 VDD P W=18U L=0.13U M=1
M51 XP_2 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M52 VDD NET179 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M53 AP_2-AIN21 NET179 VSS VSS N W=1.78U L=0.13U M=1
M54 VDD VSS AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M55 AP_2-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M56 VDD NET181 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M57 AP_2-NET57 NET181 VSS VSS N W=1.78U L=0.13U M=1
M58 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M59 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M6 VDD AI_1-NET28 NET179 VDD P W=3.06U L=0.13U M=1
M60 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M61 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M62 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M63 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M64 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M65 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M66 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M67 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M68 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M69 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M7 NET179 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M71 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M72 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M73 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M74 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M75 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M76 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M77 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M79 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M80 VDD AP_1-APN0 XP_1 VDD P W=18U L=0.13U M=1
M81 XP_1 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M82 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M83 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M84 VDD NET180 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M85 AP_1-AIN20 NET180 VSS VSS N W=1.78U L=0.13U M=1
M86 VDD XP_1 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M87 AP_1-APN0 XP_1 VSS VSS N W=0.15U L=0.39U M=1
M88 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M89 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M90 VDD XP_0 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M91 AP_1-APN1 XP_0 VSS VSS N W=0.15U L=0.39U M=1
M92 VDD AP_1-APN1 XP_0 VDD P W=18U L=0.13U M=1
M93 XP_0 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M94 VDD NET179 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M95 AP_1-AIN21 NET179 VSS VSS N W=1.78U L=0.13U M=1
M96 VDD VSS AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M97 AP_1-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M98 VDD NET165 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M99 AP_1-NET57 NET165 VSS VSS N W=1.78U L=0.13U M=1
.ENDS SPSRAM256X8HXP24
****
.SUBCKT SPSRAM256X8HXP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2
+  XP_3 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HXP24X: 100 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HXP24
.ENDS SPSRAM256X8HXP24X
****
.SUBCKT SPSRAM256X8HXP38 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2
+  XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD
** SPSRAM256X8HXP38: 192 flat devices **
D0 VSS A2 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D16 VSS A0 DN 0.2116P 1.84U
D17 VSS BWEN DN 0.2116P 1.84U
D8 VSS A1 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A1 NET189 VDD P W=3.06U L=0.13U M=1
M100 VDD AP_3-APN1 XP_5 VDD P W=18U L=0.13U M=1
M101 XP_5 AP_3-APN1 VSS VSS N W=12.66U L=0.13U M=1
M102 VDD NET187 AP_3-AIN21 VDD P W=2.71U L=0.13U M=1
M103 AP_3-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M104 VDD NET190 AP_3-NET55 VDD P W=2.71U L=0.13U M=1
M105 AP_3-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M106 VDD NET171 AP_3-NET57 VDD P W=2.71U L=0.13U M=1
M107 AP_3-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M108 AP_4-APN1 AGTPT AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M109 AP_4-APN0 AGTPB AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M11 NET189 A1 VSS VSS N W=2.05U L=0.13U M=1
M110 AP_4-APN1 AP_4-NET47 AP_4-AIND1 VSS N W=4.38U L=0.13U M=1
M111 AP_4-APN0 AP_4-NET41 AP_4-AIND0 VSS N W=4.38U L=0.13U M=1
M112 AP_4-SC_NAND_C0_I14-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M113 AP_4-SC_NAND_C0_I14-NET12 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M114 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M115 AP_4-SC_NAND_C0_I14-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M116 AP_4-SC_NAND_C0_I14-NET21 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M117 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M118 VDD AP_4-NET55 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M119 VDD AP_4-NET57 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M12 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M120 VDD AP_4-AIN20 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M121 AP_4-GAPND-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M122 AP_4-GAPND-NET12 AP_4-NET57 AP_4-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M123 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M124 AP_4-GAPND-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M125 AP_4-GAPND-NET21 AP_4-NET57 AP_4-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M126 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M127 VDD AP_4-NET55 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M128 VDD AP_4-NET57 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M129 VDD AP_4-AIN21 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M13 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M130 VDD AP_4-APN0 XP_6 VDD P W=18U L=0.13U M=1
M131 XP_6 AP_4-APN0 VSS VSS N W=12.66U L=0.13U M=1
M132 VDD AGTPB AP_4-NET41 VDD P W=0.77U L=0.13U M=1
M133 AP_4-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M134 VDD NET188 AP_4-AIN20 VDD P W=2.71U L=0.13U M=1
M135 AP_4-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M136 VDD XP_6 AP_4-APN0 VDD P W=0.15U L=0.2U M=1
M137 AP_4-APN0 XP_6 VSS VSS N W=0.15U L=0.39U M=1
M138 VDD AGTPT AP_4-NET47 VDD P W=0.77U L=0.13U M=1
M139 AP_4-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M14 VDD AI_2-NET28 NET171 VDD P W=3.06U L=0.13U M=1
M140 VDD XP_7 AP_4-APN1 VDD P W=0.15U L=0.2U M=1
M141 AP_4-APN1 XP_7 VSS VSS N W=0.15U L=0.39U M=1
M142 VDD AP_4-APN1 XP_7 VDD P W=18U L=0.13U M=1
M143 XP_7 AP_4-APN1 VSS VSS N W=12.66U L=0.13U M=1
M144 VDD NET187 AP_4-AIN21 VDD P W=2.71U L=0.13U M=1
M145 AP_4-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M146 VDD NET190 AP_4-NET55 VDD P W=2.71U L=0.13U M=1
M147 AP_4-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M148 VDD NET189 AP_4-NET57 VDD P W=2.71U L=0.13U M=1
M149 AP_4-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M15 NET171 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M150 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M151 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M152 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M153 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M154 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M155 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M156 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M157 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M158 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M159 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M160 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M161 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M162 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M163 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M164 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M165 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M166 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M167 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M168 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M169 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M170 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M171 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M172 VDD AP_1-APN0 XP_0 VDD P W=18U L=0.13U M=1
M173 XP_0 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M174 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M175 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M176 VDD NET188 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M177 AP_1-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M178 VDD XP_0 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M179 AP_1-APN0 XP_0 VSS VSS N W=0.15U L=0.39U M=1
M18 VDD A0 NET187 VDD P W=3.06U L=0.13U M=1
M180 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M181 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M182 VDD XP_1 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M183 AP_1-APN1 XP_1 VSS VSS N W=0.15U L=0.39U M=1
M184 VDD AP_1-APN1 XP_1 VDD P W=18U L=0.13U M=1
M185 XP_1 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M186 VDD NET187 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M187 AP_1-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M188 VDD NET127 AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M189 AP_1-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M19 NET187 A0 VSS VSS N W=2.05U L=0.13U M=1
M190 VDD NET171 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M191 AP_1-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M2 VDD A2 NET190 VDD P W=3.06U L=0.13U M=1
M20 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M21 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M22 VDD AI_1-NET28 NET188 VDD P W=3.06U L=0.13U M=1
M23 NET188 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M24 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M25 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M26 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M27 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M28 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M29 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M3 NET190 A2 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M31 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M32 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M33 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M34 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M35 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M37 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M38 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M39 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M4 VDD A2 AI_3-NET28 VDD P W=2.45U L=0.13U M=1
M40 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M41 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M42 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M43 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M44 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M45 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M46 VDD AP_2-APN0 XP_2 VDD P W=18U L=0.13U M=1
M47 XP_2 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M48 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M49 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M5 AI_3-NET28 A2 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD NET188 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M51 AP_2-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M52 VDD XP_2 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M53 AP_2-APN0 XP_2 VSS VSS N W=0.15U L=0.39U M=1
M54 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M55 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M56 VDD XP_3 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M57 AP_2-APN1 XP_3 VSS VSS N W=0.15U L=0.39U M=1
M58 VDD AP_2-APN1 XP_3 VDD P W=18U L=0.13U M=1
M59 XP_3 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M6 VDD AI_3-NET28 NET127 VDD P W=3.06U L=0.13U M=1
M60 VDD NET187 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M61 AP_2-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M62 VDD NET127 AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M63 AP_2-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M64 VDD NET189 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M65 AP_2-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M66 AP_3-APN1 AGTPT AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M67 AP_3-APN0 AGTPB AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M68 AP_3-APN1 AP_3-NET47 AP_3-AIND1 VSS N W=4.38U L=0.13U M=1
M69 AP_3-APN0 AP_3-NET41 AP_3-AIND0 VSS N W=4.38U L=0.13U M=1
M7 NET127 AI_3-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 AP_3-SC_NAND_C0_I14-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M71 AP_3-SC_NAND_C0_I14-NET12 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M72 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M73 AP_3-SC_NAND_C0_I14-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M74 AP_3-SC_NAND_C0_I14-NET21 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M75 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M76 VDD AP_3-NET55 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M77 VDD AP_3-NET57 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_3-AIN20 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M79 AP_3-GAPND-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M80 AP_3-GAPND-NET12 AP_3-NET57 AP_3-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M81 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M82 AP_3-GAPND-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M83 AP_3-GAPND-NET21 AP_3-NET57 AP_3-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M84 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M85 VDD AP_3-NET55 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M86 VDD AP_3-NET57 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M87 VDD AP_3-AIN21 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M88 VDD AP_3-APN0 XP_4 VDD P W=18U L=0.13U M=1
M89 XP_4 AP_3-APN0 VSS VSS N W=12.66U L=0.13U M=1
M90 VDD AGTPB AP_3-NET41 VDD P W=0.77U L=0.13U M=1
M91 AP_3-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M92 VDD NET188 AP_3-AIN20 VDD P W=2.71U L=0.13U M=1
M93 AP_3-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M94 VDD XP_4 AP_3-APN0 VDD P W=0.15U L=0.2U M=1
M95 AP_3-APN0 XP_4 VSS VSS N W=0.15U L=0.39U M=1
M96 VDD AGTPT AP_3-NET47 VDD P W=0.77U L=0.13U M=1
M97 AP_3-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M98 VDD XP_5 AP_3-APN1 VDD P W=0.15U L=0.2U M=1
M99 AP_3-APN1 XP_5 VSS VSS N W=0.15U L=0.39U M=1
.ENDS SPSRAM256X8HXP38
****
.SUBCKT SPSRAM256X8HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** SPSRAM256X8HXP38X: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8HXP38
.ENDS SPSRAM256X8HXP38X
****
.SUBCKT SPSRAM256X8X_PRE_DECODE A0 A0_0 A1 A1_0 A2 AGTPB AGTPT AY0 AY0_ BWEN
+  WEI XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8X_PRE_DECODE: 292 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HXP24X
XI1_0 A0_0 A1_0 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  SPSRAM256X8HXP38X
.ENDS SPSRAM256X8X_PRE_DECODE
****
.SUBCKT SPSRAM256X8HYP24 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VDD
** SPSRAM256X8HYP24: 100 flat devices **
D0 VSS A1 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D8 VSS A0 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A0 NET106 VDD P W=3.06U L=0.13U M=1
M11 NET106 A0 VSS VSS N W=2.05U L=0.13U M=1
M12 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M13 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M14 VDD AI_1-NET28 NET105 VDD P W=3.06U L=0.13U M=1
M15 NET105 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M16 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M17 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M18 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M19 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M2 VDD A1 NET107 VDD P W=3.06U L=0.13U M=1
M20 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M21 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M22 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M23 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M24 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M25 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M26 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M27 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M28 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M29 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M3 NET107 A1 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M31 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M32 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M33 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M34 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M35 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M37 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M38 VDD AP_2-APN0 YP0_3 VDD P W=18U L=0.13U M=1
M39 YP0_3 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M4 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M40 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M41 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M42 VDD NET106 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M43 AP_2-AIN20 NET106 VSS VSS N W=1.78U L=0.13U M=1
M44 VDD YP0_3 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M45 AP_2-APN0 YP0_3 VSS VSS N W=0.15U L=0.39U M=1
M46 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M47 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M48 VDD YP0_2 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M49 AP_2-APN1 YP0_2 VSS VSS N W=0.15U L=0.39U M=1
M5 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD AP_2-APN1 YP0_2 VDD P W=18U L=0.13U M=1
M51 YP0_2 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M52 VDD NET105 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M53 AP_2-AIN21 NET105 VSS VSS N W=1.78U L=0.13U M=1
M54 VDD VSS AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M55 AP_2-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M56 VDD NET107 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M57 AP_2-NET57 NET107 VSS VSS N W=1.78U L=0.13U M=1
M58 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M59 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M6 VDD AI_2-NET28 NET86 VDD P W=3.06U L=0.13U M=1
M60 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M61 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M62 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M63 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M64 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M65 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M66 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M67 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M68 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M69 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M7 NET86 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M71 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M72 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M73 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M74 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M75 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M76 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M77 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M79 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M80 VDD AP_1-APN0 YP0_1 VDD P W=18U L=0.13U M=1
M81 YP0_1 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M82 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M83 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M84 VDD NET106 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M85 AP_1-AIN20 NET106 VSS VSS N W=1.78U L=0.13U M=1
M86 VDD YP0_1 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M87 AP_1-APN0 YP0_1 VSS VSS N W=0.15U L=0.39U M=1
M88 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M89 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M90 VDD YP0_0 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M91 AP_1-APN1 YP0_0 VSS VSS N W=0.15U L=0.39U M=1
M92 VDD AP_1-APN1 YP0_0 VDD P W=18U L=0.13U M=1
M93 YP0_0 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M94 VDD NET105 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M95 AP_1-AIN21 NET105 VSS VSS N W=1.78U L=0.13U M=1
M96 VDD VSS AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M97 AP_1-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M98 VDD NET86 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M99 AP_1-NET57 NET86 VSS VSS N W=1.78U L=0.13U M=1
.ENDS SPSRAM256X8HYP24
****
.SUBCKT SPSRAM256X8HYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** SPSRAM256X8HYP24X: 100 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  SPSRAM256X8HYP24
.ENDS SPSRAM256X8HYP24X
****
.SUBCKT SPSRAM256X8HYP12XR A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HYP12XR: 92 flat devices **
D0 VSS A0 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
M10 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M11 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M12 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M13 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M14 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M15 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M16 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M17 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M18 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M19 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M2 VDD A0 NET94 VDD P W=3.06U L=0.13U M=1
M20 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M21 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M22 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M23 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M24 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M25 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M26 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M27 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M28 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M29 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M3 NET94 A0 VSS VSS N W=2.05U L=0.13U M=1
M30 VDD AP_2-APN0 AY0 VDD P W=18U L=0.13U M=1
M31 AY0 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M32 VDD AGTP AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M33 AP_2-NET41 AGTP VSS VSS N W=0.66U L=0.13U M=1
M34 VDD NET94 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M35 AP_2-AIN20 NET94 VSS VSS N W=1.78U L=0.13U M=1
M36 VDD AY0 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M37 AP_2-APN0 AY0 VSS VSS N W=0.15U L=0.39U M=1
M38 VDD AGTP AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M39 AP_2-NET47 AGTP VSS VSS N W=0.66U L=0.13U M=1
M4 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M40 VDD AY0_ AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M41 AP_2-APN1 AY0_ VSS VSS N W=0.15U L=0.39U M=1
M42 VDD AP_2-APN1 AY0_ VDD P W=18U L=0.13U M=1
M43 AY0_ AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M44 VDD NET93 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M45 AP_2-AIN21 NET93 VSS VSS N W=1.78U L=0.13U M=1
M46 VDD VSS AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M47 AP_2-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M48 VDD VSS AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M49 AP_2-NET57 VSS VSS VSS N W=1.78U L=0.13U M=1
M5 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M50 AP_1-APN1 AGTP AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M51 AP_1-APN0 AGTP AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M52 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M53 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M54 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M55 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M56 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M57 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M58 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M59 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M6 VDD AI_1-NET28 NET93 VDD P W=3.06U L=0.13U M=1
M60 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M61 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M62 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M63 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M64 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M65 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M66 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M67 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M68 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M69 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M7 NET93 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M71 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M72 VDD AP_1-APN0 AY0 VDD P W=18U L=0.13U M=1
M73 AY0 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M74 VDD AGTP AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M75 AP_1-NET41 AGTP VSS VSS N W=0.66U L=0.13U M=1
M76 VDD NET94 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M77 AP_1-AIN20 NET94 VSS VSS N W=1.78U L=0.13U M=1
M78 VDD AY0 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M79 AP_1-APN0 AY0 VSS VSS N W=0.15U L=0.39U M=1
M8 AP_2-APN1 AGTP AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M80 VDD AGTP AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M81 AP_1-NET47 AGTP VSS VSS N W=0.66U L=0.13U M=1
M82 VDD AY0_ AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M83 AP_1-APN1 AY0_ VSS VSS N W=0.15U L=0.39U M=1
M84 VDD AP_1-APN1 AY0_ VDD P W=18U L=0.13U M=1
M85 AY0_ AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M86 VDD NET93 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M87 AP_1-AIN21 NET93 VSS VSS N W=1.78U L=0.13U M=1
M88 VDD VSS AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M89 AP_1-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M9 AP_2-APN0 AGTP AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M90 VDD VSS AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M91 AP_1-NET57 VSS VSS VSS N W=1.78U L=0.13U M=1
.ENDS SPSRAM256X8HYP12XR
****
.SUBCKT SPSRAM256X8HYP12XRX A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HYP12XRX: 92 flat devices **
XI0_0 A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HYP12XR
.ENDS SPSRAM256X8HYP12XRX
****
.SUBCKT SPSRAM256X8Y_DECODE A0 A0_0 A1 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST
+  WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** SPSRAM256X8Y_DECODE: 192 flat devices **
XI0_0 A0 A1 AGTP AGTP AY0 AY0_ BWEN WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  SPSRAM256X8HYP24X
XI1_0 A0_0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI YP0_0 YP0_1 YP0_2 YP0_3
+  VSS VSS VSS VSS VSS VDD SPSRAM256X8HYP12XRX
.ENDS SPSRAM256X8Y_DECODE
****
.SUBCKT SPSRAM256X8HBF8 CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL RST
+  STOV STUBWE TMS WE WEI WEN WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HBF8: 79 flat devices **
D0 VSS WEN DN 0.2116P 1.84U
D1 VSS TMS DN 0.2116P 1.84U
D2 VSS CLK DN 0.2116P 1.84U
D3 VSS STOV DN 0.2116P 1.84U
D4 VSS CEN DN 0.2116P 1.84U
M10 BF-CENMML CLK BF-SC_TRIINV_C8_I0-NET7 VSS N W=0.15U L=0.13U M=1
M11 BF-SC_TRIINV_C8_I0-NET15 CLKB BF-CENMML VDD P W=0.15U L=0.13U M=1
M12 VDD BF-CEL BF-SC_TRIINV_C8_I0-NET15 VDD P W=0.15U L=0.13U M=1
M13 RST BF-RSTSRC VDD VDD P W=10.55U L=0.13U M=1
M14 RST BF-MBLN VDD VDD P W=2.25U L=0.13U M=1
M15 BF-CENMML BF-NET223 BF-NET113 VDD P W=0.15U L=0.13U M=1
M16 BF-MBLN MBL VDD VDD P W=0.88U L=0.13U M=1
M17 BF-NET113 TMS BF-NET123 VDD P W=0.15U L=0.13U M=1
M18 BF-NET123 CLK VDD VDD P W=0.15U L=0.13U M=1
M19 BF-NET128 CLKB VSS VSS N W=0.15U L=0.13U M=1
M20 BF-CENMML BF-NET223 BF-NET128 VSS N W=0.15U L=0.13U M=1
M21 BF-MBLN MBL VSS VSS N W=0.4U L=0.13U M=1
M22 BF-NET135 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M23 BF-NET138 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M24 BF-NET141 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M25 BF-NET144 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M26 BF-NET147 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M27 BF-NET150 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M28 BF-NET153 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M29 BF-NET156 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M30 BF-NET159 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M31 RST BF-MBLN BF-NET135 VSS N W=1.74U L=0.13U M=1
M32 RST BF-MBLN BF-NET138 VSS N W=1.74U L=0.13U M=1
M33 RST BF-MBLN BF-NET141 VSS N W=1.74U L=0.13U M=1
M34 RST BF-MBLN BF-NET144 VSS N W=1.74U L=0.13U M=1
M35 RST BF-MBLN BF-NET147 VSS N W=1.74U L=0.13U M=1
M36 RST BF-MBLN BF-NET150 VSS N W=1.74U L=0.13U M=1
M37 RST BF-MBLN BF-NET153 VSS N W=1.74U L=0.13U M=1
M38 RST BF-MBLN BF-NET156 VSS N W=1.74U L=0.13U M=1
M39 RST BF-MBLN BF-NET159 VSS N W=1.74U L=0.13U M=1
M40 BF-CENMML TMS BF-NET128 VSS N W=0.15U L=0.13U M=1
M41 RST BF-MBLN BF-NET195 VSS N W=1.74U L=0.13U M=1
M42 BF-NET195 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M43 BF-GGSRCND-NET9 GTPN VSS VSS N W=0.28U L=0.13U M=1
M44 BF-GGSRCND-NET12 CLKB BF-GGSRCND-NET9 VSS N W=0.28U L=0.13U M=1
M45 BF-NET212 BF-CEL BF-GGSRCND-NET12 VSS N W=0.28U L=0.13U M=1
M46 VDD GTPN BF-NET212 VDD P W=0.15U L=0.13U M=1
M47 VDD CLKB BF-NET212 VDD P W=0.15U L=0.13U M=1
M48 VDD BF-CEL BF-NET212 VDD P W=0.15U L=0.13U M=1
M49 BF-GRSRC-NET8 GTP VSS VSS N W=0.48U L=0.13U M=1
M5 BF-GCKSTOV-NET8 STOV VSS VSS N W=0.41U L=0.13U M=1
M50 BF-RSRCN BF-CKSTOV BF-GRSRC-NET8 VSS N W=0.48U L=0.13U M=1
M51 BF-GRSRC-NET12 GTP VSS VSS N W=0.48U L=0.13U M=1
M52 BF-RSRCN BF-CKSTOV BF-GRSRC-NET12 VSS N W=0.48U L=0.13U M=1
M53 VDD GTP BF-RSRCN VDD P W=0.76U L=0.13U M=1
M54 VDD BF-CKSTOV BF-RSRCN VDD P W=0.76U L=0.13U M=1
M55 VDD BF-NET205 BF-NET203 VDD P W=3.16U L=0.13U M=1
M56 BF-NET203 BF-NET205 VSS VSS N W=2.01U L=0.13U M=1
M57 VDD WEN BF-NET205 VDD P W=1.12U L=0.13U M=1
M58 BF-NET205 WEN VSS VSS N W=0.74U L=0.13U M=1
M59 VDD BF-NET203 WE VDD P W=10.76U L=0.13U M=1
M6 BF-CKSTOV CLK BF-GCKSTOV-NET8 VSS N W=0.41U L=0.13U M=1
M60 WE BF-NET203 VSS VSS N W=7.5U L=0.13U M=1
M61 VDD BF-RSRCN BF-RSTSRC VDD P W=2.3U L=0.13U M=1
M62 BF-RSTSRC BF-RSRCN VSS VSS N W=1.46U L=0.13U M=1
M63 VDD BF-NET212 BF-NET211 VDD P W=0.4U L=0.13U M=1
M64 BF-NET211 BF-NET212 VSS VSS N W=0.26U L=0.13U M=1
M65 VDD BF-NET211 BF-NET216 VDD P W=2.21U L=0.13U M=1
M66 BF-NET216 BF-NET211 VSS VSS N W=1.4U L=0.13U M=1
M67 VDD BF-NET216 GSRCN VDD P W=12U L=0.13U M=1
M68 GSRCN BF-NET216 VSS VSS N W=7.65U L=0.13U M=1
M69 VDD BF-GTPI GTPN VDD P W=0.15U L=0.13U M=1
M7 VDD STOV BF-CKSTOV VDD P W=0.31U L=0.13U M=1
M70 GTPN BF-GTPI VSS VSS N W=0.15U L=0.13U M=1
M71 VDD GTPN BF-GTPI VDD P W=0.15U L=0.13U M=1
M72 BF-GTPI GTPN VSS VSS N W=0.15U L=0.13U M=1
M73 VDD CLK CLKB VDD P W=6.68U L=0.13U M=1
M74 CLKB CLK VSS VSS N W=26.73U L=0.13U M=1
M75 VDD CEN BF-NET223 VDD P W=0.15U L=0.13U M=1
M76 BF-NET223 CEN VSS VSS N W=0.15U L=0.13U M=1
M77 VDD BF-CENMML BF-CEL VDD P W=0.15U L=0.13U M=1
M78 BF-CEL BF-CENMML VSS VSS N W=0.15U L=0.13U M=1
M8 VDD CLK BF-CKSTOV VDD P W=0.31U L=0.13U M=1
M9 BF-SC_TRIINV_C8_I0-NET7 BF-CEL VSS VSS N W=0.15U L=0.13U M=1
.ENDS SPSRAM256X8HBF8
****
.SUBCKT SPSRAM256X8HBFX CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL RST
+  STUBWE WEI WEN WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HBFX: 79 flat devices **
XI0_0 CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL RST VSS STUBWE VSS WEI
+  WEI WEN WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8HBF8
.ENDS SPSRAM256X8HBFX
****
.SUBCKT SPSRAM256X8CCMWP BL BLD BLD_ BL_ WL WP VSS VDD
** SPSRAM256X8CCMWP: 6 flat devices **
M0 BLD WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BLD_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS SPSRAM256X8CCMWP
****
.SUBCKT SPSRAM256X8CCMWG BL BLD BLD_ BL_ WL WP VSS VDD
** SPSRAM256X8CCMWG: 6 flat devices **
M0 BLD WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BLD_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS SPSRAM256X8CCMWG
****
.SUBCKT SPSRAM256X8FLMWG BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** SPSRAM256X8FLMWG: 24 flat devices **
M0 NET25 WP1 CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 NET34 WP3 CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M10 VDD NODE5 NODE4 VDD PCH_SRAM W=0.165U L=0.14U M=1
M11 NODE4 NODE5 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M12 VDD NODE2 NODE1 VDD PCH_SRAM W=0.165U L=0.14U M=1
M13 NODE1 NODE2 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M14 VDD NODE3 NODE0 VDD PCH_SRAM W=0.165U L=0.14U M=1
M15 NODE0 NODE3 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M16 VDD NODE4 NODE5 VDD PCH_SRAM W=0.165U L=0.14U M=1
M17 NODE5 NODE4 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M18 VDD NODE1 NODE2 VDD PCH_SRAM W=0.165U L=0.14U M=1
M19 NODE2 NODE1 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M2 NET19 WP2 NODE4 VSS NCH_SRAM W=0.23U L=0.145U M=1
M20 VDD NODE0 NODE3 VDD PCH_SRAM W=0.165U L=0.14U M=1
M21 NODE3 NODE0 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M22 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M23 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M3 NET19 WP3 NODE1 VSS NCH_SRAM W=0.23U L=0.145U M=1
M4 NET25 WP0 NODE0 VSS NCH_SRAM W=0.23U L=0.145U M=1
M5 NET28 WP2 NODE5 VSS NCH_SRAM W=0.23U L=0.145U M=1
M6 NET28 WP3 NODE2 VSS NCH_SRAM W=0.23U L=0.145U M=1
M7 NET34 WP2 NODE3 VSS NCH_SRAM W=0.23U L=0.145U M=1
M8 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M9 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS SPSRAM256X8FLMWG
****
.SUBCKT SPSRAM256X8MODEL_ROW_4 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 WL WP WP_0 WP_1 WP_2 VSS
+  VDD
** SPSRAM256X8MODEL_ROW_4: 384 flat devices **
XI0_0 BL BLD_58 BLD__60 BL_ WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI0_1 BL_ BLD__60 BLD_58 BL WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI10_0 BL_9 BLD_18 BLD__20 BL__9 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI10_1 BL__9 BLD__20 BLD_18 BL_9 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI11_0 BL_10 BLD_22 BLD__24 BL__10 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI11_1 BL__10 BLD__24 BLD_22 BL_10 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI12_0 BL_11 BLD_30 BLD__32 BL__11 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI12_1 BL__11 BLD__32 BLD_30 BL_11 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI13_0 BL_12 BLD_38 BLD__40 BL__12 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI13_1 BL__12 BLD__40 BLD_38 BL_12 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI14_0 BL_13 BLD_42 BLD__44 BL__13 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI14_1 BL__13 BLD__44 BLD_42 BL_13 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI15_0 BL_14 BLD_46 BLD__48 BL__14 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI15_1 BL__14 BLD__48 BLD_46 BL_14 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI16_0 BL0 BL0_ BL1 BL1_ WL WP_1 WP_2 WP WP_0 VSS VDD SPSRAM256X8FLMWG
XI18_0 BL_15 BLD_50 BLD__52 BL__15 VSS WP VSS VDD SPSRAM256X8CCMWP
XI18_1 BL__15 BLD__52 BLD_50 BL_15 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI19_0 BL_16 BLD_54 BLD__56 BL__16 VSS WP VSS VDD SPSRAM256X8CCMWG
XI19_1 BL__16 BLD__56 BLD_54 BL_16 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI1_0 BL_0 BLD_62 BLD__64 BL__0 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI1_1 BL__0 BLD__64 BLD_62 BL_0 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI20_0 BL_17 BLD_98 BLD__100 BL__17 VSS WP VSS VDD SPSRAM256X8CCMWG
XI20_1 BL__17 BLD__100 BLD_98 BL_17 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI21_0 BL_18 BLD_102 BLD__104 BL__18 VSS WP VSS VDD SPSRAM256X8CCMWP
XI21_1 BL__18 BLD__104 BLD_102 BL_18 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI22_0 BL_19 BLD_106 BLD__108 BL__19 VSS WP VSS VDD SPSRAM256X8CCMWP
XI22_1 BL__19 BLD__108 BLD_106 BL_19 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI23_0 BL_20 BLD_110 BLD__112 BL__20 VSS WP VSS VDD SPSRAM256X8CCMWG
XI23_1 BL__20 BLD__112 BLD_110 BL_20 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI24_0 BL_21 BLD_114 BLD__116 BL__21 VSS WP VSS VDD SPSRAM256X8CCMWG
XI24_1 BL__21 BLD__116 BLD_114 BL_21 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI25_0 BL_22 BLD_ BLD BL__22 VSS WP VSS VDD SPSRAM256X8CCMWP
XI25_1 BL__22 BLD BLD_ BL_22 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI26_0 BL_23 BLD_2 BLD__4 BL__23 VSS WP VSS VDD SPSRAM256X8CCMWP
XI26_1 BL__23 BLD__4 BLD_2 BL_23 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI27_0 BL_24 BLD_6 BLD__8 BL__24 VSS WP VSS VDD SPSRAM256X8CCMWG
XI27_1 BL__24 BLD__8 BLD_6 BL_24 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI28_0 BL_25 BLD_10 BLD__12 BL__25 VSS WP VSS VDD SPSRAM256X8CCMWG
XI28_1 BL__25 BLD__12 BLD_10 BL_25 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI29_0 BL_26 BLD_14 BLD__16 BL__26 VSS WP VSS VDD SPSRAM256X8CCMWP
XI29_1 BL__26 BLD__16 BLD_14 BL_26 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI2_0 BL_1 BLD_66 BLD__68 BL__1 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI2_1 BL__1 BLD__68 BLD_66 BL_1 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI30_0 BL_27 BLD_26 BLD__28 BL__27 VSS WP VSS VDD SPSRAM256X8CCMWP
XI30_1 BL__27 BLD__28 BLD_26 BL_27 VSS WP_0 VSS VDD SPSRAM256X8CCMWP
XI31_0 BL_28 BLD_34 BLD__36 BL__28 VSS WP VSS VDD SPSRAM256X8CCMWG
XI31_1 BL__28 BLD__36 BLD_34 BL_28 VSS WP_0 VSS VDD SPSRAM256X8CCMWG
XI3_0 BL_2 BLD_70 BLD__72 BL__2 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI3_1 BL__2 BLD__72 BLD_70 BL_2 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI4_0 BL_3 BLD_74 BLD__76 BL__3 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI4_1 BL__3 BLD__76 BLD_74 BL_3 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI5_0 BL_4 BLD_78 BLD__80 BL__4 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI5_1 BL__4 BLD__80 BLD_78 BL_4 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI6_0 BL_5 BLD_82 BLD__84 BL__5 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI6_1 BL__5 BLD__84 BLD_82 BL_5 WL WP_2 VSS VDD SPSRAM256X8CCMWP
XI7_0 BL_6 BLD_86 BLD__88 BL__6 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI7_1 BL__6 BLD__88 BLD_86 BL_6 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI8_0 BL_7 BLD_90 BLD__92 BL__7 WL WP_1 VSS VDD SPSRAM256X8CCMWG
XI8_1 BL__7 BLD__92 BLD_90 BL_7 WL WP_2 VSS VDD SPSRAM256X8CCMWG
XI9_0 BL_8 BLD_94 BLD__96 BL__8 WL WP_1 VSS VDD SPSRAM256X8CCMWP
XI9_1 BL__8 BLD__96 BLD_94 BL_8 WL WP_2 VSS VDD SPSRAM256X8CCMWP
.ENDS SPSRAM256X8MODEL_ROW_4
****
.SUBCKT SPSRAM256X8HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8HWDB: 30 flat devices **
M0 I0-NET120 I0-RSWN1 GTP VDD P W=1.61U L=0.13U M=1
M1 I0-NET123 I0-RSWN0 GTP VDD P W=1.61U L=0.13U M=1
M10 I0-NET123 I0-WLI0 GTP VSS N W=1.61U L=0.13U M=1
M11 I0-RSWN0 G2_W0 I0-NET129 VSS N W=0.86U L=0.13U M=1
M12 I0-NET129 G1 I0-NET132 VSS N W=0.86U L=0.13U M=1
M13 I0-NET132 G0 VSS VSS N W=0.86U L=0.13U M=1
M14 I0-RSWN1 G2_W1 I0-NET134 VSS N W=0.86U L=0.13U M=1
M15 I0-NET134 G1 I0-NET137 VSS N W=0.86U L=0.13U M=1
M16 I0-NET137 G0 VSS VSS N W=0.86U L=0.13U M=1
M17 I0-NET120 I0-RSWN1 VSS VSS N W=0.3U L=0.13U M=1
M18 VDD I0-WL1_EN_ WL1 VDD P W=27.12U L=0.13U M=1
M19 WL1 I0-WL1_EN_ VSS VSS N W=16.68U L=0.13U M=1
M2 I0-RSWN0 G2_W0 VDD VDD P W=0.49U L=0.13U M=1
M20 VDD I0-NET120 I0-WL1_EN_ VDD P W=9.85U L=0.13U M=1
M21 I0-WL1_EN_ I0-NET120 VSS VSS N W=6.26U L=0.13U M=1
M22 VDD I0-NET123 I0-WL0_EN_ VDD P W=9.85U L=0.13U M=1
M23 I0-WL0_EN_ I0-NET123 VSS VSS N W=6.26U L=0.13U M=1
M24 VDD I0-WL0_EN_ WL0 VDD P W=27.12U L=0.13U M=1
M25 WL0 I0-WL0_EN_ VSS VSS N W=16.68U L=0.13U M=1
M26 VDD I0-RSWN0 I0-WLI0 VDD P W=0.36U L=0.13U M=1
M27 I0-WLI0 I0-RSWN0 VSS VSS N W=0.23U L=0.13U M=1
M28 VDD I0-RSWN1 I0-WLI1 VDD P W=0.36U L=0.13U M=1
M29 I0-WLI1 I0-RSWN1 VSS VSS N W=0.23U L=0.13U M=1
M3 I0-RSWN0 G1 VDD VDD P W=0.49U L=0.13U M=1
M4 I0-RSWN0 G0 VDD VDD P W=0.49U L=0.13U M=1
M5 I0-RSWN1 G0 VDD VDD P W=0.49U L=0.13U M=1
M6 I0-RSWN1 G1 VDD VDD P W=0.49U L=0.13U M=1
M7 I0-RSWN1 G2_W1 VDD VDD P W=0.49U L=0.13U M=1
M8 I0-NET123 I0-RSWN0 VSS VSS N W=0.3U L=0.13U M=1
M9 I0-NET120 I0-WLI1 GTP VSS N W=1.61U L=0.13U M=1
.ENDS SPSRAM256X8HWDB
****
.SUBCKT SPSRAM256X8HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8HWDB
.ENDS SPSRAM256X8HWDB0
****
.SUBCKT SPSRAM256X8ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F XP0F_0 XP1F XP1F_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_BOTTOM: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8HWDB0
.ENDS SPSRAM256X8ROW_BOTTOM
****
.SUBCKT SPSRAM256X8WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD: 30 flat devices **
M0 NET120 RSWN1 GTP VDD P W=1.61U L=0.13U M=1
M1 NET123 RSWN0 GTP VDD P W=1.61U L=0.13U M=1
M10 NET123 WLI0 GTP VSS N W=1.61U L=0.13U M=1
M11 RSWN0 G2_W0 NET129 VSS N W=0.86U L=0.13U M=1
M12 NET129 G1 NET132 VSS N W=0.86U L=0.13U M=1
M13 NET132 G0 VSS VSS N W=0.86U L=0.13U M=1
M14 RSWN1 G2_W1 NET134 VSS N W=0.86U L=0.13U M=1
M15 NET134 G1 NET137 VSS N W=0.86U L=0.13U M=1
M16 NET137 G0 VSS VSS N W=0.86U L=0.13U M=1
M17 NET120 RSWN1 VSS VSS N W=0.3U L=0.13U M=1
M18 VDD WL1_EN_ WL1 VDD P W=27.12U L=0.13U M=1
M19 WL1 WL1_EN_ VSS VSS N W=16.68U L=0.13U M=1
M2 RSWN0 G2_W0 VDD VDD P W=0.49U L=0.13U M=1
M20 VDD NET120 WL1_EN_ VDD P W=9.85U L=0.13U M=1
M21 WL1_EN_ NET120 VSS VSS N W=6.26U L=0.13U M=1
M22 VDD NET123 WL0_EN_ VDD P W=9.85U L=0.13U M=1
M23 WL0_EN_ NET123 VSS VSS N W=6.26U L=0.13U M=1
M24 VDD WL0_EN_ WL0 VDD P W=27.12U L=0.13U M=1
M25 WL0 WL0_EN_ VSS VSS N W=16.68U L=0.13U M=1
M26 VDD RSWN0 WLI0 VDD P W=0.36U L=0.13U M=1
M27 WLI0 RSWN0 VSS VSS N W=0.23U L=0.13U M=1
M28 VDD RSWN1 WLI1 VDD P W=0.36U L=0.13U M=1
M29 WLI1 RSWN1 VSS VSS N W=0.23U L=0.13U M=1
M3 RSWN0 G1 VDD VDD P W=0.49U L=0.13U M=1
M4 RSWN0 G0 VDD VDD P W=0.49U L=0.13U M=1
M5 RSWN1 G0 VDD VDD P W=0.49U L=0.13U M=1
M6 RSWN1 G1 VDD VDD P W=0.49U L=0.13U M=1
M7 RSWN1 G2_W1 VDD VDD P W=0.49U L=0.13U M=1
M8 NET123 RSWN0 VSS VSS N W=0.3U L=0.13U M=1
M9 NET120 WLI1 GTP VSS N W=1.61U L=0.13U M=1
.ENDS SPSRAM256X8WD
****
.SUBCKT SPSRAM256X8WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD1
****
.SUBCKT SPSRAM256X8ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER1: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD1
.ENDS SPSRAM256X8ROW_FILLER1
****
.SUBCKT SPSRAM256X8WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD2
****
.SUBCKT SPSRAM256X8ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER2: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD2
.ENDS SPSRAM256X8ROW_FILLER2
****
.SUBCKT SPSRAM256X8WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD3
****
.SUBCKT SPSRAM256X8ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP1 XP1F XP2_0 XP2_1
+  XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_FILLER3: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD3
.ENDS SPSRAM256X8ROW_FILLER3
****
.SUBCKT SPSRAM256X8WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD SPSRAM256X8WD
.ENDS SPSRAM256X8WD0
****
.SUBCKT SPSRAM256X8ROW_8 G0 G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP1F XP1F_0 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_8: 30 flat devices **
XI2_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD SPSRAM256X8WD0
.ENDS SPSRAM256X8ROW_8
****
.SUBCKT SPSRAM256X8FCMWDX MWL XP0 XP1 VSS VDD
** SPSRAM256X8FCMWDX: 2 flat devices **
D0 VSS XP1 DN 0.2116P 1.84U
D1 VSS XP0 DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCMWDX
****
.SUBCKT SPSRAM256X8FCMWD G0F G1F MWL XP0F XP1F VSS VDD
** SPSRAM256X8FCMWD: 2 flat devices **
D0 VSS XP1F DN 0.2116P 1.84U
D1 VSS XP0F DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCMWD
****
.SUBCKT SPSRAM256X8MWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7
+  MWG8 MWG9 MWG10 MWG11 MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** SPSRAM256X8MWD: 35 flat devices **
M0 MBL GTP VDD VDD P W=6.04U L=0.13U M=1
M1 MBL GTP MBL_ VDD P W=6.64U L=0.13U M=1
M10 MBL MWG9 VSS VSS N W=0.3U L=0.2U M=1
M11 MBL MWG7 VSS VSS N W=0.3U L=0.2U M=1
M12 MBL MWG7 VSS VSS N W=0.3U L=0.2U M=1
M13 MBL MWG5 VSS VSS N W=0.3U L=0.2U M=1
M14 MBL MWG5 VSS VSS N W=0.3U L=0.2U M=1
M15 MBL MWG10 VSS VSS N W=0.3U L=0.2U M=1
M16 MBL MWG10 VSS VSS N W=0.3U L=0.2U M=1
M17 MBL MWG8 VSS VSS N W=0.3U L=0.2U M=1
M18 MBL MWG3 VSS VSS N W=0.3U L=0.2U M=1
M19 MBL MWG8 VSS VSS N W=0.3U L=0.2U M=1
M2 MBL_ GTP VDD VDD P W=6.04U L=0.13U M=1
M20 MBL MWG6 VSS VSS N W=0.3U L=0.2U M=1
M21 MBL MWG6 VSS VSS N W=0.3U L=0.2U M=1
M22 MBL MWG4 VSS VSS N W=0.3U L=0.2U M=1
M23 MBL MWG4 VSS VSS N W=0.3U L=0.2U M=1
M24 MBL MWG2 VSS VSS N W=0.3U L=0.2U M=1
M25 MBL MWG2 VSS VSS N W=0.3U L=0.2U M=1
M26 MBL MWG0 VSS VSS N W=0.3U L=0.2U M=1
M27 MBL MWG0 VSS VSS N W=0.3U L=0.2U M=1
M28 MBL MWG11 VSS VSS N W=0.3U L=0.2U M=1
M29 MBL MWG3 VSS VSS N W=0.3U L=0.2U M=1
M3 NET41 VSS GTP VDD P W=1.61U L=0.13U M=1
M30 MBL MWG1 VSS VSS N W=0.3U L=0.2U M=1
M31 VDD NET41 NET120 VDD P W=11.43U L=0.13U M=1
M32 NET120 NET41 VSS VSS N W=7.26U L=0.13U M=1
M33 VDD NET120 MWL VDD P W=27.13U L=0.13U M=1
M34 MWL NET120 VSS VSS N W=16.68U L=0.13U M=1
M4 NET41 VDD GTP VSS N W=1.61U L=0.13U M=1
M5 MBL MWG1 VSS VSS N W=0.3U L=0.2U M=1
M6 MBL MWLD VSS VSS N W=0.3U L=0.2U M=1
M7 MBL MWLD VSS VSS N W=0.3U L=0.2U M=1
M8 MBL MWG11 VSS VSS N W=0.3U L=0.2U M=1
M9 MBL MWG9 VSS VSS N W=0.3U L=0.2U M=1
.ENDS SPSRAM256X8MWD
****
.SUBCKT SPSRAM256X8MWDX GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8MWDX: 35 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD MWLD MWLD MWLD VSS VSS VSS VSS VSS VSS VSS MWL
+  MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8MWD
.ENDS SPSRAM256X8MWDX
****
.SUBCKT SPSRAM256X8ROW_TOP G0F G1F GTP MBL MBL_ MWL MWLD XP0 XP0F XP1 XP1F
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8ROW_TOP: 39 flat devices **
XI0_0 MWL XP0 XP1 VSS VDD SPSRAM256X8FCMWDX
XI1_0 G0F G1F MWL XP0F XP1F VSS VDD SPSRAM256X8FCMWD
XI2_0 GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD SPSRAM256X8MWDX
.ENDS SPSRAM256X8ROW_TOP
****
.SUBCKT SPSRAM256X8WORD_ROWS G0 GTP MBL MBL_ MWL MWLD WL0 WL0_0 WL0_1 WL0_2
+  WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13
+  WL0_14 WL1 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9
+  WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** SPSRAM256X8WORD_ROWS: 519 flat devices **
XI0_0 G0 XP0_0 GTP WL0 WL1 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_BOTTOM
XI0_1 G0 XP0_0 GTP WL0_0 WL1_0 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_10 G0 XP0 GTP WL0_9 WL1_9 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_11 G0 XP0 GTP WL0_10 WL1_10 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_12 G0 XP1 XP0 GTP WL0_11 WL1_11 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_13 G0 XP1 GTP WL0_12 WL1_12 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_14 G0 XP1 GTP WL0_13 WL1_13 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_15 G0 XP1 GTP WL0_14 WL1_14 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_16 G0 XP1 GTP MBL MBL_ MWL MWLD XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_TOP
XI0_2 G0 XP0_0 GTP WL0_1 WL1_1 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_3 G0 XP0_0 GTP WL0_2 WL1_2 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_4 G0 XP1_0 XP0_0 GTP WL0_3 WL1_3 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_5 G0 XP1_0 GTP WL0_4 WL1_4 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
XI0_6 G0 XP1_0 GTP WL0_5 WL1_5 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER2
XI0_7 G0 XP1_0 GTP WL0_6 WL1_6 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER3
XI0_8 G0 XP0 XP1_0 GTP WL0_7 WL1_7 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_8
XI0_9 G0 XP0 GTP WL0_8 WL1_8 XP0 XP0_0 XP1 XP1_0 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD SPSRAM256X8ROW_FILLER1
.ENDS SPSRAM256X8WORD_ROWS
****
.SUBCKT SPSRAM256X8HCKA A0 A0_ AGTP CLKB GSRCN GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8HCKA: 4 flat devices **
M0 GTPN RST VDD VDD P W=12.2U L=0.13U M=1
M1 GTPN GSRCN CLKB VSS N W=26.73U L=0.13U M=1
M2 VDD GTPN AGTP VDD P W=36.46U L=0.13U M=1
M3 AGTP GTPN VSS VSS N W=17.82U L=0.13U M=1
.ENDS SPSRAM256X8HCKA
****
.SUBCKT SPSRAM256X8CK A0 A0_ CLKB GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CK: 4 flat devices **
M0 GTPN RST VDD VDD P W=12.2U L=0.13U M=1
M1 GTPN GSRCN CLKB VSS N W=26.73U L=0.13U M=1
M2 VDD GTPN GTP VDD P W=36.46U L=0.13U M=1
M3 GTP GTPN VSS VSS N W=17.82U L=0.13U M=1
.ENDS SPSRAM256X8CK
****
.SUBCKT SPSRAM256X8CLK_DRVS A0 A0_ AGTP CLKB GSRCN GTP GTPN GTP_0 GTP_1 GTP_2
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8CLK_DRVS: 20 flat devices **
XI0_0 A0 A0_ AGTP CLKB GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8HCKA
XI1_0 A0 A0_ CLKB GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8CK
XI2_0 A0 A0_ CLKB GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CK
XI3_0 A0 A0_ CLKB GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CK
XI4_0 A0 A0_ CLKB GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD SPSRAM256X8CK
.ENDS SPSRAM256X8CLK_DRVS
****
.SUBCKT SPSRAM256X8FCBWRO8 BWEN D Q VSS VDD
** SPSRAM256X8FCBWRO8: 2 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS Q DN 0.2116P 1.84U
.ENDS SPSRAM256X8FCBWRO8
****
.SUBCKT SPSRAM256X8MCOL_ODD_R8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0
+  VSS VDD
** SPSRAM256X8MCOL_ODD_R8: 1833 flat devices **
XI0_0 VSS D Q VSS VDD SPSRAM256X8FCBWRO8
XI0_1 BWE D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS STUBWEI VSS VSS WESA VSS VDD SPSRAM256X8IOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD SPSRAM256X8SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD SPSRAM256X8MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 VSS VDD SPSRAM256X8BIT_COL
.ENDS SPSRAM256X8MCOL_ODD_R8
****
.SUBCKT SPSRAM256X8WING_4_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11
+  BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21
+  BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D D_0 D_1
+  D_2 GTP GTP_0 GTP_1 Q Q_0 Q_1 Q_2 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1
+  YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** SPSRAM256X8WING_4_RIGHT: 7332 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 Q STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 D_0 GTP GTP_0 GTP_1 Q_0 STUBWE WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9
+  WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21
+  WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_ODD_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 D_1 GTP GTP_0 GTP_1 Q_1 STUBWE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_EVEN_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 D_2 GTP GTP_0 GTP_1 Q_2 STUBWE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7
+  WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  SPSRAM256X8MCOL_ODD_R8
.ENDS SPSRAM256X8WING_4_RIGHT
****
.SUBCKT SPSRAM256X8FLCIO A0 A0_ CLKB GSRCN GTP GTPN MBL MBL_ RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FLCIO: 11 flat devices **
D0 VSS YP1_0 DN 0.2116P 1.84U
D1 VSS YP1_1 DN 0.2116P 1.84U
D10 VSS A0 DN 0.2116P 1.84U
D2 VSS YP1_2 DN 0.2116P 1.84U
D3 VSS YP1_3 DN 0.2116P 1.84U
D4 VSS YP0_3 DN 0.2116P 1.84U
D5 VSS YP0_2 DN 0.2116P 1.84U
D6 VSS YP0_1 DN 0.2116P 1.84U
D7 VSS YP0_0 DN 0.2116P 1.84U
D8 VSS GTP DN 0.2116P 1.84U
D9 VSS A0_ DN 0.2116P 1.84U
.ENDS SPSRAM256X8FLCIO
****
.SUBCKT SPSRAM256X8FLCIOX A0 A0_ BL0 BL0_ CLKB GSRCN GTP GTPN RST YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** SPSRAM256X8FLCIOX: 11 flat devices **
XI0_0 A0 A0_ CLKB GSRCN GTP GTPN BL0_ BL0 RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8FLCIO
.ENDS SPSRAM256X8FLCIOX
****
.SUBCKT SPSRAM256X8RIGHT_CAP A0 A0_ DPU2 DW DW_ GTP GTP_0 GTP_1 WE WESA WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1
+  YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** SPSRAM256X8RIGHT_CAP: 3 flat devices **
XI0_0 DPU2 DW DW_ GTP WE WESA VSS VDD SPSRAM256X8FCIO8
XI0_1 GTP_0 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD SPSRAM256X8FCSA8
.ENDS SPSRAM256X8RIGHT_CAP
****
.SUBCKT SPSRAM256X8MBLBASE MBL MBL_ MWLD MWLS VSS VDD
** SPSRAM256X8MBLBASE: 1 flat devices **
M0 VDD VDD VDD VDD PCH_SRAM W=0.33U L=0.14U M=1
.ENDS SPSRAM256X8MBLBASE
****
.SUBCKT SPSRAM256X8MODEL_COL BL BL_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WP
+  WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13
+  WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25
+  WP_26 WP_27 WP_28 WP_29 WP_30 VSS VDD
** SPSRAM256X8MODEL_COL: 193 flat devices **
XI0_32 BL_ BL WL_32 WL_31 VSS VDD SPSRAM256X8MBLBASE
XI1_0 BL BL_ WL WP VSS VDD SPSRAM256X8CCP
XI1_1 BL_ BL WL_0 WP_0 VSS VDD SPSRAM256X8CCP
XI1_10 BL BL_ WL_9 WP_9 VSS VDD SPSRAM256X8CCP
XI1_11 BL_ BL WL_10 WP_10 VSS VDD SPSRAM256X8CCP
XI1_12 BL BL_ WL_11 WP_11 VSS VDD SPSRAM256X8CCP
XI1_13 BL_ BL WL_12 WP_12 VSS VDD SPSRAM256X8CCP
XI1_14 BL BL_ WL_13 WP_13 VSS VDD SPSRAM256X8CCP
XI1_15 BL_ BL WL_14 WP_14 VSS VDD SPSRAM256X8CCP
XI1_16 BL BL_ WL_15 WP_15 VSS VDD SPSRAM256X8CCP
XI1_17 BL_ BL WL_16 WP_16 VSS VDD SPSRAM256X8CCP
XI1_18 BL BL_ WL_17 WP_17 VSS VDD SPSRAM256X8CCP
XI1_19 BL_ BL WL_18 WP_18 VSS VDD SPSRAM256X8CCP
XI1_2 BL BL_ WL_1 WP_1 VSS VDD SPSRAM256X8CCP
XI1_20 BL BL_ WL_19 WP_19 VSS VDD SPSRAM256X8CCP
XI1_21 BL_ BL WL_20 WP_20 VSS VDD SPSRAM256X8CCP
XI1_22 BL BL_ WL_21 WP_21 VSS VDD SPSRAM256X8CCP
XI1_23 BL_ BL WL_22 WP_22 VSS VDD SPSRAM256X8CCP
XI1_24 BL BL_ WL_23 WP_23 VSS VDD SPSRAM256X8CCP
XI1_25 BL_ BL WL_24 WP_24 VSS VDD SPSRAM256X8CCP
XI1_26 BL BL_ WL_25 WP_25 VSS VDD SPSRAM256X8CCP
XI1_27 BL_ BL WL_26 WP_26 VSS VDD SPSRAM256X8CCP
XI1_28 BL BL_ WL_27 WP_27 VSS VDD SPSRAM256X8CCP
XI1_29 BL_ BL WL_28 WP_28 VSS VDD SPSRAM256X8CCP
XI1_3 BL_ BL WL_2 WP_2 VSS VDD SPSRAM256X8CCP
XI1_30 BL BL_ WL_29 WP_29 VSS VDD SPSRAM256X8CCP
XI1_31 BL_ BL WL_30 WP_30 VSS VDD SPSRAM256X8CCP
XI1_4 BL BL_ WL_3 WP_3 VSS VDD SPSRAM256X8CCP
XI1_5 BL_ BL WL_4 WP_4 VSS VDD SPSRAM256X8CCP
XI1_6 BL BL_ WL_5 WP_5 VSS VDD SPSRAM256X8CCP
XI1_7 BL_ BL WL_6 WP_6 VSS VDD SPSRAM256X8CCP
XI1_8 BL BL_ WL_7 WP_7 VSS VDD SPSRAM256X8CCP
XI1_9 BL_ BL WL_8 WP_8 VSS VDD SPSRAM256X8CCP
.ENDS SPSRAM256X8MODEL_COL
****
.SUBCKT SPSRAM256X8 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] CEN CLK D[0] D[1]
+  D[2] D[3] D[4] D[5] D[6] D[7] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] WEN
+  VSS VDD
** SPSRAM256X8: 16745 flat devices **
XI0_0 A0 A0_ VSS VSS VSS GTP_1 GTP_1 GTP_1 WE VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD
+  SPSRAM256X8LEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14
+  BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24
+  BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D[3] D[2] D[1] D[0] GTP_1 GTP_1
+  GTP_1 Q[3] Q[2] Q[1] Q[0] WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VDD SPSRAM256X8WING_4_LEFT
XI1_5 BL_ BL__15 BL_15 BL__16 BL_16 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__17 BL__18 BL__19
+  BL__20 BL__21 BL__22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_0
+  BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 MWLB VSS VSS MWLB MWLB VSS VDD
+  SPSRAM256X8MODEL_ROW_4
XI3_0 A[6] A[3] A[7] A[4] A[5] AGTPT AGTPT A0 A0_ VSS WE XP_0 XP_0_0 XP_1
+  XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3
+  VSS VSS VSS VSS VSS VDD SPSRAM256X8X_PRE_DECODE
XI3_3 VDD GTP_1 MBL MBL_ MWLB MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14
+  WL_15 WL_18 WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_0 WL_1 WL_4 WL_5 WL_8
+  WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24 WL_25 WL_28 WL_29 XP_2 XP_0
+  XP_3 XP_1 XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4 XP_5 XP_6 XP_7 VSS VDD
+  SPSRAM256X8WORD_ROWS
XI4_0 A[1] A[0] A[2] AGTPT A0 A0_ VSS CLKB GSRCN GTPN RST WE YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VDD SPSRAM256X8Y_DECODE
XI5_0 CEN CLK CLKB VSS VSS VSS VSS GSRCN GTP_1 GTPN MBL RST VSS WE WEN VSS VSS
+  VSS VSS VSS VSS VDD SPSRAM256X8HBFX
XI5_2 A0 A0_ AGTPT CLKB GSRCN GTP_1 GTPN GTP_1 GTP_1 GTP_1 RST YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD SPSRAM256X8CLK_DRVS
XI6_2 A0 A0_ MBL_ MBL CLKB GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 VSS
+  VSS VSS VSS VSS VDD SPSRAM256X8FLCIOX
XI6_4 MBL_ MBL WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 MWLB MWLB VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD SPSRAM256X8MODEL_COL
XI7_0 A0 A0_ BL_248 BL__250 BL_0_244 BL_1_240 BL_2_236 BL_3_232 BL_4_228
+  BL_5_224 BL_6_220 BL_7_218 BL_8_214 BL_9_210 BL_10_206 BL_11_202 BL_12_198
+  BL_13_194 BL_14_190 BL_15_184 BL_16_180 BL_17_176 BL_18_172 BL_19_168
+  BL_20_164 BL_21_160 BL_22_156 BL_23_154 BL_24_150 BL_25_146 BL_26_142
+  BL_27_138 BL_28_134 BL_29_130 BL_30_126 BL__0_246 BL__1_242 BL__2_238
+  BL__3_234 BL__4_230 BL__5_226 BL__6_222 BL__7_216 BL__8_212 BL__9_208
+  BL__10_204 BL__11_200 BL__12_196 BL__13_192 BL__14_188 BL__15_186
+  BL__16_182 BL__17_178 BL__18_174 BL__19_170 BL__20_166 BL__21_162
+  BL__22_158 BL__23_152 BL__24_148 BL__25_144 BL__26_140 BL__27_136
+  BL__28_132 BL__29_128 BL__30_124 D[4] D[5] D[6] D[7] GTP_1 GTP_1 GTP_1 Q[4]
+  Q[5] Q[6] Q[7] WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VDD SPSRAM256X8WING_4_RIGHT
XI7_5 BL__250 BL__15_186 BL_15_184 BL__16_182 BL_16_180 BL_248 BL__0_246
+  BL__1_242 BL__2_238 BL__3_234 BL__4_230 BL__5_226 BL__6_222 BL_7_218
+  BL_8_214 BL_9_210 BL_10_206 BL_11_202 BL_12_198 BL_13_194 BL_14_190
+  BL__17_178 BL__18_174 BL__19_170 BL__20_166 BL__21_162 BL__22_158 BL_23_154
+  BL_24_150 BL_25_146 BL_26_142 BL_27_138 BL_28_134 BL_29_130 BL_30_126
+  BL_0_244 BL_1_240 BL_2_236 BL_3_232 BL_4_228 BL_5_224 BL_6_220 BL__7_216
+  BL__8_212 BL__9_208 BL__10_204 BL__11_200 BL__12_196 BL__13_192 BL__14_188
+  BL_17_176 BL_18_172 BL_19_168 BL_20_164 BL_21_160 BL_22_156 BL__23_152
+  BL__24_148 BL__25_144 BL__26_140 BL__27_136 BL__28_132 BL__29_128
+  BL__30_124 MWLB VSS VSS MWLB MWLB VSS VDD SPSRAM256X8MODEL_ROW_4
XI8_0 A0 A0_ VSS VSS VSS GTP_1 GTP_1 GTP_1 WE VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD
+  SPSRAM256X8RIGHT_CAP
.ENDS SPSRAM256X8
