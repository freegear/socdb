library verilog;
use verilog.vl_types.all;
entity mt64ahb is
    generic(
        oe_active       : integer := 0;
        vendor_id       : integer := 43981;
        device_id       : integer := 25702;
        class_id        : integer := 425984;
        rev_id          : integer := 16;
        bar0_present    : integer := 1;
        bar0_dwidth     : integer := 22;
        bar1_present    : integer := 1;
        bar1_dwidth     : integer := 8;
        bar2_present    : integer := 0;
        bar2_map        : integer := 0;
        bar2_dwidth     : integer := 28;
        bar3_present    : integer := 0;
        bar3_map        : integer := 0;
        bar3_dwidth     : integer := 28;
        bar4_present    : integer := 0;
        bar4_map        : integer := 0;
        bar4_dwidth     : integer := 28;
        bar5_present    : integer := 0;
        bar5_map        : integer := 0;
        bar5_dwidth     : integer := 28;
        ebar_present    : integer := 0;
        ebar_map        : integer := 0;
        ebar_dwidth     : integer := 17;
        subvendor_id    : integer := 4334;
        subdevice_id    : integer := 256;
        cis_ptr         : integer := 0;
        cap_ptr         : integer := 0;
        max_lat         : integer := 32;
        min_gnt         : integer := 4;
        int_pin         : integer := 1;
        int_line        : integer := 0;
        command_init    : integer := 0;
        status_init     : integer := 544;
        clsize_init     : integer := 0;
        lattimer_init   : integer := 0;
        intline_init    : integer := 0;
        iack_code       : integer := 0;
        scyc_code       : integer := 1;
        iord_code       : integer := 2;
        iowr_code       : integer := 3;
        res4_code       : integer := 4;
        res5_code       : integer := 5;
        mrd_code        : integer := 6;
        mwr_code        : integer := 7;
        res8_code       : integer := 8;
        res9_code       : integer := 9;
        cfgrd_code      : integer := 10;
        cfgwr_code      : integer := 11;
        mrm_code        : integer := 12;
        dual_code       : integer := 13;
        mrl_code        : integer := 14;
        mwi_code        : integer := 15
    );
    port(
        rstpci          : in     vl_logic;
        clkpci          : in     vl_logic;
        pciaddr         : in     vl_logic_vector(31 downto 0);
        pcidin          : in     vl_logic_vector(63 downto 0);
        t_adr_valid     : in     vl_logic;
        t_width64       : in     vl_logic;
        t_barhit        : in     vl_logic_vector(5 downto 0);
        t_ebarhit       : in     vl_logic;
        t_ben           : in     vl_logic_vector(7 downto 0);
        t_cmd           : in     vl_logic_vector(3 downto 0);
        t_rd            : in     vl_logic;
        t_wr            : in     vl_logic;
        t_we            : in     vl_logic;
        t_nextd         : in     vl_logic;
        m_aack          : in     vl_logic;
        m_aack64        : in     vl_logic;
        m_otcmd         : in     vl_logic;
        m_otdata        : in     vl_logic;
        m_nextd         : in     vl_logic;
        m_wrejd         : in     vl_logic;
        m_mabort        : in     vl_logic;
        m_tabort        : in     vl_logic;
        m_tretry        : in     vl_logic;
        m_tdisc         : in     vl_logic;
        pcr_cmd         : in     vl_logic_vector(15 downto 0);
        pcr_stat        : in     vl_logic_vector(15 downto 0);
        pci_framenid    : in     vl_logic;
        pci_req64nid    : in     vl_logic;
        pci_irdynid     : in     vl_logic;
        pci_devselnid   : in     vl_logic;
        pci_ack64nid    : in     vl_logic;
        pci_trdynid     : in     vl_logic;
        pci_stopnid     : in     vl_logic;
        t_drdy          : out    vl_logic_vector(6 downto 0);
        t_abort         : out    vl_logic;
        t_term          : out    vl_logic;
        m_cbe           : out    vl_logic_vector(7 downto 0);
        m_areq          : out    vl_logic;
        m_areq64        : out    vl_logic;
        m_crw           : out    vl_logic;
        m_drdy          : out    vl_logic;
        m_lastd         : out    vl_logic;
        app_intn        : out    vl_logic;
        app_ado         : out    vl_logic_vector(63 downto 0);
        hclk            : in     vl_logic;
        hresetn         : in     vl_logic;
        mhaddr          : out    vl_logic_vector(31 downto 0);
        mhbusreq        : out    vl_logic;
        mhlock          : out    vl_logic;
        mhgrant         : in     vl_logic;
        mhwrite         : out    vl_logic;
        mhtrans         : out    vl_logic_vector(1 downto 0);
        mhsize          : out    vl_logic_vector(2 downto 0);
        mhprot          : out    vl_logic_vector(3 downto 0);
        mhburst         : out    vl_logic_vector(2 downto 0);
        mhready         : in     vl_logic;
        mhresp          : in     vl_logic_vector(1 downto 0);
        mhrdata         : in     vl_logic_vector(31 downto 0);
        mhwdata         : out    vl_logic_vector(31 downto 0);
        shsel           : in     vl_logic;
        shwrite         : in     vl_logic;
        shtrans         : in     vl_logic_vector(1 downto 0);
        shsize          : in     vl_logic_vector(2 downto 0);
        shburst         : in     vl_logic_vector(2 downto 0);
        shaddr          : in     vl_logic_vector(31 downto 0);
        shready         : out    vl_logic;
        shresp          : out    vl_logic_vector(1 downto 0);
        shrdata         : out    vl_logic_vector(31 downto 0);
        shwdata         : in     vl_logic_vector(31 downto 0);
        hint            : out    vl_logic
    );
end mt64ahb;
