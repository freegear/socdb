///////////////////////////////////////////////////////////////////////////
// This file includes explanation of MOON Test software
///////////////////////////////////////////////////////////////////////////

///////////////////////////////////////////////////////////////////////////
// Callback job scheduler
// GtxJobScheduler() is the scheduling task required to process accumulated
// interrupt information. If a user want to register callback function
// mapped to specific interrupt, use following schemes.
///////////////////////////////////////////////////////////////////////////

///////////////////////////////////////////////////////////////////////////
// To add callback function used for processing specific interrupt from LM
// (1) Edit your own callback function in isr.c
// (2) Add code for job registration into GtxIrqHdlr_Ext() in isr.c
// (3) Register your callback function using GtxRegCallBack() in main.c
// (1)~(3) are the all the things you should do for handling interrupt.
///////////////////////////////////////////////////////////////////////////

///////////////////////////////////////////////////////////////////////////
// USB Issue (010712)
// (1) Interrupt End Point Transmission Scheme Required (General Purpose)
///////////////////////////////////////////////////////////////////////////
