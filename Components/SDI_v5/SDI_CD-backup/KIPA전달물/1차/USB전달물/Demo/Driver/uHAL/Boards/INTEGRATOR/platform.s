;/***************************************************************************
; * Copyright © ARM Limited 1998.  All rights reserved.
; ***************************************************************************/
;************************************************************************
;
;  Integrator address map
;
;	NOTE: This is a multi-hosted header file for use with uHAL and
;	      supported debuggers.
;
;	$Id: platform.s,v 1.24.2.5 2000/01/21 18:55:07 asims Exp $
;
;***********************************************************************/

 IF :LNOT: :DEF: __address_h
__address_h			EQU	1

PLATFORM_ID			EQU	0x00000040

; Common modules for uHAL can be included or excluded by changing these
; definitions. These can be over-ridden by the makefile/ARM project file
; provided the .h file can is rebuilt.

 IF :LNOT: :DEF: USE_C_LIBRARY
USE_C_LIBRARY		EQU 0
 ENDIF
 IF :LNOT: :DEF: uHAL_BOOT
uHAL_BOOT			EQU	1
 ENDIF
 IF :LNOT: :DEF: uHAL_HEAP
uHAL_HEAP			EQU	1
 ENDIF
 IF :LNOT: :DEF: uHAL_TIMERS
uHAL_TIMERS			EQU	1
 ENDIF
 IF :LNOT: :DEF: uHAL_INTERRUPTS
uHAL_INTERRUPTS			EQU	1
 ENDIF
 IF :LNOT: :DEF: uHAL_COMPLEX_IRQ
uHAL_COMPLEX_IRQ		EQU	0
 ENDIF

 IF :LNOT: :DEF: uHAL_PCI
uHAL_PCI			EQU	1
 ENDIF


;===============================================================================
; Integrator definitions
;===============================================================================
;-------------------------------------------------------------------------------
; Memory definitions
;-------------------------------------------------------------------------------
; Integrator memory map
;
INTEGRATOR_BOOT_ROM_LO		EQU	0x00000000
INTEGRATOR_BOOT_ROM_HI		EQU	0x20000000
INTEGRATOR_BOOT_ROM_BASE	EQU	INTEGRATOR_BOOT_ROM_HI	; Normal position
INTEGRATOR_BOOT_ROM_SIZE	EQU	SZ_512K

;
; New Core Modules have different amounts of SSRAM, the amount of SSRAM fitted can
; be found in HDR_STAT.
;
; The symbol INTEGRATOR_SSRAM_SIZE is kept, however this now refers to the minimum
; amount of SSRAM fitted on any core module.
;
; New Core Modules also alias the SSRAM.
;
INTEGRATOR_SSRAM_BASE		EQU	0x00000000
INTEGRATOR_SSRAM_ALIAS_BASE	EQU	0x10800000
INTEGRATOR_SSRAM_SIZE		EQU	SZ_256K

INTEGRATOR_FLASH_BASE		EQU	0x24000000
INTEGRATOR_FLASH_SIZE		EQU	SZ_32M

INTEGRATOR_MBRD_SSRAM_BASE	EQU	0x28000000
INTEGRATOR_MBRD_SSRAM_SIZE	EQU	SZ_512K

;
; SDRAM is a SIMM therefore the size is not known.
;
INTEGRATOR_SDRAM_BASE		EQU	0x00040000

INTEGRATOR_SDRAM_ALIAS_BASE	EQU	0x80000000
INTEGRATOR_HDR0_SDRAM_BASE	EQU	0x80000000
INTEGRATOR_HDR1_SDRAM_BASE	EQU	0x90000000
INTEGRATOR_HDR2_SDRAM_BASE	EQU	0xA0000000
INTEGRATOR_HDR3_SDRAM_BASE	EQU	0xB0000000

;
; Logic expansion modules
;
INTEGRATOR_LOGIC_MODULES_BASE	EQU	0xC0000000
INTEGRATOR_LOGIC_MODULE0_BASE	EQU	0xC0000000
INTEGRATOR_LOGIC_MODULE1_BASE	EQU	0xD0000000
INTEGRATOR_LOGIC_MODULE2_BASE	EQU	0xE0000000
INTEGRATOR_LOGIC_MODULE3_BASE	EQU	0xF0000000

;-------------------------------------------------------------------------------
; Integrator header card registers
;-------------------------------------------------------------------------------
;
INTEGRATOR_HDR_ID_OFFSET	EQU	0x00
INTEGRATOR_HDR_PROC_OFFSET	EQU	0x04
INTEGRATOR_HDR_OSC_OFFSET	EQU	0x08
INTEGRATOR_HDR_CTRL_OFFSET	EQU	0x0C
INTEGRATOR_HDR_STAT_OFFSET	EQU	0x10
INTEGRATOR_HDR_LOCK_OFFSET	EQU	0x14
INTEGRATOR_HDR_SDRAM_OFFSET	EQU	0x20
INTEGRATOR_HDR_INIT_OFFSET	EQU	0x24	; CM9x6
INTEGRATOR_HDR_IC_OFFSET	EQU	0x40
INTEGRATOR_HDR_SPDBASE_OFFSET	EQU	0x100
INTEGRATOR_HDR_SPDTOP_OFFSET	EQU	0x200

INTEGRATOR_HDR_BASE	EQU	0x10000000
INTEGRATOR_HDR_ID	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_ID_OFFSET)
INTEGRATOR_HDR_PROC	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_PROC_OFFSET)
INTEGRATOR_HDR_OSC	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_OSC_OFFSET)
INTEGRATOR_HDR_CTRL	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_CTRL_OFFSET)
INTEGRATOR_HDR_STAT	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_STAT_OFFSET)
INTEGRATOR_HDR_LOCK	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_LOCK_OFFSET)
INTEGRATOR_HDR_SDRAM	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_SDRAM_OFFSET)
INTEGRATOR_HDR_INIT	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_INIT_OFFSET)
INTEGRATOR_HDR_IC	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_IC_OFFSET)
INTEGRATOR_HDR_SPDBASE	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_SPDBASE_OFFSET)
INTEGRATOR_HDR_SPDTOP	EQU	(INTEGRATOR_HDR_BASE + INTEGRATOR_HDR_SPDTOP_OFFSET)

INTEGRATOR_HDR_CTRL_LED		EQU	0x01
INTEGRATOR_HDR_CTRL_MBRD_DETECH	EQU	0x02
INTEGRATOR_HDR_CTRL_REMAP	EQU	0x04
INTEGRATOR_HDR_CTRL_RESET	EQU	0x08
INTEGRATOR_HDR_CTRL_HIGHVECTORS	EQU	0x10
INTEGRATOR_HDR_CTRL_BIG_ENDIAN	EQU	0x20
INTEGRATOR_HDR_CTRL_FASTBUS	EQU	0x40
INTEGRATOR_HDR_CTRL_SYNC	EQU	0x80

INTEGRATOR_HDR_OSC_CORE_10MHz	EQU	0x102
INTEGRATOR_HDR_OSC_CORE_15MHz	EQU	0x107
INTEGRATOR_HDR_OSC_CORE_20MHz	EQU	0x10C
INTEGRATOR_HDR_OSC_CORE_25MHz	EQU	0x111
INTEGRATOR_HDR_OSC_CORE_30MHz	EQU	0x116
INTEGRATOR_HDR_OSC_CORE_35MHz	EQU	0x11B
INTEGRATOR_HDR_OSC_CORE_40MHz	EQU	0x120
INTEGRATOR_HDR_OSC_CORE_45MHz	EQU	0x125
INTEGRATOR_HDR_OSC_CORE_50MHz	EQU	0x12A
INTEGRATOR_HDR_OSC_CORE_55MHz	EQU	0x12F
INTEGRATOR_HDR_OSC_CORE_60MHz	EQU	0x134
INTEGRATOR_HDR_OSC_CORE_65MHz	EQU	0x139
INTEGRATOR_HDR_OSC_CORE_70MHz	EQU	0x13E
INTEGRATOR_HDR_OSC_CORE_75MHz	EQU	0x143
INTEGRATOR_HDR_OSC_CORE_80MHz	EQU	0x148
INTEGRATOR_HDR_OSC_CORE_85MHz	EQU	0x14D
INTEGRATOR_HDR_OSC_CORE_90MHz	EQU	0x152
INTEGRATOR_HDR_OSC_CORE_95MHz	EQU	0x157
INTEGRATOR_HDR_OSC_CORE_100MHz	EQU	0x15C
INTEGRATOR_HDR_OSC_CORE_105MHz	EQU	0x161
INTEGRATOR_HDR_OSC_CORE_110MHz	EQU	0x166
INTEGRATOR_HDR_OSC_CORE_115MHz	EQU	0x16B
INTEGRATOR_HDR_OSC_CORE_120MHz	EQU	0x170
INTEGRATOR_HDR_OSC_CORE_125MHz	EQU	0x175
INTEGRATOR_HDR_OSC_CORE_130MHz	EQU	0x17A
INTEGRATOR_HDR_OSC_CORE_135MHz	EQU	0x17F
INTEGRATOR_HDR_OSC_CORE_140MHz	EQU	0x184
INTEGRATOR_HDR_OSC_CORE_145MHz	EQU	0x189
INTEGRATOR_HDR_OSC_CORE_150MHz	EQU	0x18E
INTEGRATOR_HDR_OSC_CORE_155MHz	EQU	0x193
INTEGRATOR_HDR_OSC_CORE_160MHz	EQU	0x198
INTEGRATOR_HDR_OSC_CORE_MASK		EQU	0x7FF

INTEGRATOR_HDR_OSC_MEM_10MHz		EQU	0x10C000
INTEGRATOR_HDR_OSC_MEM_15MHz		EQU	0x116000
INTEGRATOR_HDR_OSC_MEM_20MHz		EQU	0x120000
INTEGRATOR_HDR_OSC_MEM_25MHz		EQU	0x12A000
INTEGRATOR_HDR_OSC_MEM_30MHz		EQU	0x134000
INTEGRATOR_HDR_OSC_MEM_33MHz		EQU	0x13A000
INTEGRATOR_HDR_OSC_MEM_40MHz		EQU	0x148000
INTEGRATOR_HDR_OSC_MEM_50MHz		EQU	0x15C000
INTEGRATOR_HDR_OSC_MEM_60MHz		EQU	0x170000
INTEGRATOR_HDR_OSC_MEM_66MHz		EQU	0x17C000
INTEGRATOR_HDR_OSC_MEM_MASK		EQU	0x7FF000

INTEGRATOR_HDR_OSC_BUS_MODE_CM7x0	EQU	0x0
INTEGRATOR_HDR_OSC_BUS_MODE_CM9x0	EQU	0x0800000
INTEGRATOR_HDR_OSC_BUS_MODE_CM9x6	EQU	0x1000000
INTEGRATOR_HDR_OSC_BUS_MODE_CM10x00	EQU	0x1800000
INTEGRATOR_HDR_OSC_BUS_MODE_MASK	EQU	0x1800000

INTEGRATOR_HDR_SDRAM_SPD_OK	EQU	BIT5


;-------------------------------------------------------------------------------
; Integrator system registers
;-------------------------------------------------------------------------------
;

;
; System Controller
;
INTEGRATOR_SC_ID_OFFSET		EQU	0x00
INTEGRATOR_SC_OSC_OFFSET		EQU	0x04
INTEGRATOR_SC_CTRLS_OFFSET		EQU	0x08
INTEGRATOR_SC_CTRLC_OFFSET		EQU	0x0C
INTEGRATOR_SC_DEC_OFFSET		EQU	0x10
INTEGRATOR_SC_ARB_OFFSET		EQU	0x14
INTEGRATOR_SC_PCIENABLE_OFFSET	EQU	0x18
INTEGRATOR_SC_LOCK_OFFSET		EQU	0x1C

INTEGRATOR_SC_BASE		EQU	0x11000000
INTEGRATOR_SC_ID		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_ID_OFFSET)
INTEGRATOR_SC_OSC		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_OSC_OFFSET)
INTEGRATOR_SC_CTRLS		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_CTRLS_OFFSET)
INTEGRATOR_SC_CTRLC		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_CTRLC_OFFSET)
INTEGRATOR_SC_DEC		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_DEC_OFFSET)
INTEGRATOR_SC_ARB		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_ARB_OFFSET)
INTEGRATOR_SC_PCIENABLE	EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_PCIENABLE_OFFSET)
INTEGRATOR_SC_LOCK		EQU	(INTEGRATOR_SC_BASE + INTEGRATOR_SC_LOCK_OFFSET)

INTEGRATOR_SC_OSC_SYS_10MHz	EQU	0x20
INTEGRATOR_SC_OSC_SYS_15MHz	EQU	0x34
INTEGRATOR_SC_OSC_SYS_20MHz	EQU	0x48
INTEGRATOR_SC_OSC_SYS_25MHz	EQU	0x5C
INTEGRATOR_SC_OSC_SYS_33MHz	EQU	0x7C
INTEGRATOR_SC_OSC_SYS_MASK	EQU	0xFF

INTEGRATOR_SC_OSC_PCI_25MHz	EQU	0x100
INTEGRATOR_SC_OSC_PCI_33MHz	EQU	0x0
INTEGRATOR_SC_OSC_PCI_MASK	EQU	0x100

INTEGRATOR_SC_CTRL_SOFTRST	EQU	(1 << 0)
INTEGRATOR_SC_CTRL_nFLVPPEN	EQU	(1 << 1)
INTEGRATOR_SC_CTRL_nFLWP	EQU	(1 << 2)
INTEGRATOR_SC_CTRL_URTS0	EQU	(1 << 4)
INTEGRATOR_SC_CTRL_UDTR0	EQU	(1 << 5)
INTEGRATOR_SC_CTRL_URTS1	EQU	(1 << 6)
INTEGRATOR_SC_CTRL_UDTR1	EQU	(1 << 7)

;
; External Bus Interface
;
INTEGRATOR_EBI_BASE		EQU	0x12000000 

INTEGRATOR_EBI_CSR0_OFFSET	EQU	0x00
INTEGRATOR_EBI_CSR1_OFFSET	EQU	0x04
INTEGRATOR_EBI_CSR2_OFFSET	EQU	0x08
INTEGRATOR_EBI_CSR3_OFFSET	EQU	0x0C
INTEGRATOR_EBI_LOCK_OFFSET	EQU	0x20

INTEGRATOR_EBI_CSR0		EQU	(INTEGRATOR_EBI_BASE + INTEGRATOR_EBI_CSR0_OFFSET)
INTEGRATOR_EBI_CSR1		EQU	(INTEGRATOR_EBI_BASE + INTEGRATOR_EBI_CSR1_OFFSET)
INTEGRATOR_EBI_CSR2		EQU	(INTEGRATOR_EBI_BASE + INTEGRATOR_EBI_CSR2_OFFSET)
INTEGRATOR_EBI_CSR3		EQU	(INTEGRATOR_EBI_BASE + INTEGRATOR_EBI_CSR3_OFFSET)
INTEGRATOR_EBI_LOCK		EQU	(INTEGRATOR_EBI_BASE + INTEGRATOR_EBI_LOCK_OFFSET)

INTEGRATOR_EBI_8_BIT		EQU	0x00
INTEGRATOR_EBI_16_BIT		EQU	0x01
INTEGRATOR_EBI_32_BIT		EQU	0x02
INTEGRATOR_EBI_WRITE_ENABLE	EQU	0x04
INTEGRATOR_EBI_SYNC		EQU	0x08
INTEGRATOR_EBI_WS_2		EQU	0x00
INTEGRATOR_EBI_WS_3		EQU	0x10
INTEGRATOR_EBI_WS_4		EQU	0x20
INTEGRATOR_EBI_WS_5		EQU	0x30
INTEGRATOR_EBI_WS_6		EQU	0x40
INTEGRATOR_EBI_WS_7		EQU	0x50
INTEGRATOR_EBI_WS_8		EQU	0x60
INTEGRATOR_EBI_WS_9		EQU	0x70
INTEGRATOR_EBI_WS_10		EQU	0x80
INTEGRATOR_EBI_WS_11		EQU	0x90
INTEGRATOR_EBI_WS_12		EQU	0xA0
INTEGRATOR_EBI_WS_13		EQU	0xB0
INTEGRATOR_EBI_WS_14		EQU	0xC0
INTEGRATOR_EBI_WS_15		EQU	0xD0
INTEGRATOR_EBI_WS_16		EQU	0xE0
INTEGRATOR_EBI_WS_17		EQU	0xF0


INTEGRATOR_CT_BASE		EQU	0x13000000	; Counter/Timers
INTEGRATOR_IC_BASE		EQU	0x14000000	; Interrupt Controller
INTEGRATOR_RTC_BASE		EQU	0x15000000	; Real Time Clock
INTEGRATOR_UART0_BASE	EQU	0x16000000	; UART 0
INTEGRATOR_UART1_BASE	EQU	0x17000000	; UART 1
INTEGRATOR_KBD_BASE		EQU	0x18000000	; Keyboard
INTEGRATOR_MOUSE_BASE	EQU	0x19000000	; Mouse

;
; LED's & Switches
;
INTEGRATOR_DBG_ALPHA_OFFSET	EQU	0x00
INTEGRATOR_DBG_LEDS_OFFSET	EQU	0x04
INTEGRATOR_DBG_SWITCH_OFFSET	EQU	0x08

INTEGRATOR_DBG_BASE		EQU	0x1A000000
INTEGRATOR_DBG_ALPHA		EQU	(INTEGRATOR_DBG_BASE + INTEGRATOR_DBG_ALPHA_OFFSET)
INTEGRATOR_DBG_LEDS		EQU	(INTEGRATOR_DBG_BASE + INTEGRATOR_DBG_LEDS_OFFSET)
INTEGRATOR_DBG_SWITCH	EQU	(INTEGRATOR_DBG_BASE + INTEGRATOR_DBG_SWITCH_OFFSET)


INTEGRATOR_GPIO_BASE		EQU	0x1B000000	; GPIO

;-------------------------------------------------------------------------------
; KMI keyboard/mouse definitions
;-------------------------------------------------------------------------------
;/* PS2 Keyboard interface */

KMI0_BASE		EQU	INTEGRATOR_KBD_BASE		
KEYB_CR         	EQU	(INTEGRATOR_KBD_BASE)
KEYB_STAT       	EQU	(INTEGRATOR_KBD_BASE + 0x4)
KEYB_DATA       	EQU	(INTEGRATOR_KBD_BASE + 0x8)
KEYB_CLK        	EQU	(INTEGRATOR_KBD_BASE + 0xC)

;/* PS2 Mouse interface */
KMI1_BASE		EQU	INTEGRATOR_MOUSE_BASE
MOUSE_CR         	EQU	INTEGRATOR_MOUSE_BASE
MOUSE_STAT       	EQU	(INTEGRATOR_MOUSE_BASE+0x4)
MOUSE_DATA       	EQU	(INTEGRATOR_MOUSE_BASE+0x8)
MOUSE_CLK        	EQU	(INTEGRATOR_MOUSE_BASE+0xC)

;/* general KMI register macros */
;#define KMI_CR(b)	((volatile unsigned int *)b) 
;#define KMI_STAT(b)    ((volatile unsigned int *)(b+0x4))
;#define KMI_DATA(b)    ((volatile unsigned int *)(b+0x8))
;#define KMI_CLK(b)     ((volatile unsigned int *)(b+0xC))

;/* KMI constants */
KMI_TXEMPTY		EQU	0x40
KMI_TXBUSY		EQU	0x20
KMI_RXFULL		EQU	0x10
KMI_RXBUSY		EQU	0x08
KMI_PARITY		EQU	0x04

;-------------------------------------------------------------------------------
; V3 Local Bus to PCI Bridge definitions
;-------------------------------------------------------------------------------
; Registers (these are taken from page 129 of the EPC User's Manual Rev 1.04
; All V3 register names are prefaced by V3_ to avoid clashing with any other
; PCI definitions.  Their names match the user's manual.
;
; I'm assuming that I20 is disabled.
;
V3_PCI_VENDOR		EQU	0x00000000
V3_PCI_DEVICE		EQU	0x00000002
V3_PCI_CMD		EQU	0x00000004
V3_PCI_STAT		EQU	0x00000006
V3_PCI_CC_REV		EQU	0x00000008
V3_PCI_HDR_CFG		EQU	0x0000000C
V3_PCI_IO_BASE		EQU	0x00000010
V3_PCI_BASE0		EQU	0x00000014
V3_PCI_BASE1		EQU	0x00000018
V3_PCI_SUB_VENDOR	EQU	0x0000002C
V3_PCI_SUB_ID		EQU	0x0000002E
V3_PCI_ROM   		EQU	0x00000030
V3_PCI_BPARAM		EQU	0x0000003C
V3_PCI_MAP0  		EQU	0x00000040
V3_PCI_MAP1  		EQU	0x00000044
V3_PCI_INT_STAT		EQU	0x00000048
V3_PCI_INT_CFG		EQU	0x0000004C 
V3_LB_BASE0 		EQU	0x00000054
V3_LB_BASE1 		EQU	0x00000058
V3_LB_MAP0		EQU	0x0000005E
V3_LB_MAP1		EQU	0x00000062
V3_LB_BASE2  		EQU	0x00000064
V3_LB_MAP2   		EQU	0x00000066
V3_LB_SIZE   		EQU	0x00000068
V3_LB_IO_BASE		EQU	0x0000006E
V3_FIFO_CFG		EQU	0x00000070
V3_FIFO_PRIORITY	EQU	0x00000072
V3_FIFO_STAT		EQU	0x00000074
V3_LB_ISTAT		EQU	0x00000076
V3_LB_IMASK  		EQU	0x00000077
V3_SYSTEM    		EQU	0x00000078
V3_LB_CFG    		EQU	0x0000007A
V3_PCI_CFG		EQU	0x0000007C
V3_DMA_PCI_ADR0		EQU	0x00000080
V3_DMA_PCI_ADR1		EQU	0x00000090
V3_DMA_LOCAL_ADR0	EQU	0x00000084
V3_DMA_LOCAL_ADR1	EQU	0x00000094
V3_DMA_LENGTH0		EQU	0x00000088
V3_DMA_LENGTH1 		EQU	0x00000098
V3_DMA_CSR0		EQU	0x0000008B
V3_DMA_CSR1		EQU	0x0000009B
V3_DMA_CTLB_ADR0	EQU	0x0000008C
V3_DMA_CTLB_ADR1	EQU	0x0000009C
V3_DMA_DELAY		EQU	0x000000E0
V3_MAIL_DATA		EQU	0x000000C0
V3_PCI_MAIL_IEWR	EQU	0x000000D0
V3_PCI_MAIL_IERD	EQU	0x000000D2
V3_LB_MAIL_IEWR		EQU	0x000000D4
V3_LB_MAIL_IERD		EQU	0x000000D6
V3_MAIL_WR_STAT		EQU	0x000000D8
V3_MAIL_RD_STAT		EQU	0x000000DA
V3_QBA_MAP		EQU	0x000000DC

; PCI COMMAND REGISTER bits
V3_COMMAND_M_FBB_EN	EQU	BIT9
V3_COMMAND_M_SERR_EN	EQU	BIT8
V3_COMMAND_M_PAR_EN	EQU	BIT6
V3_COMMAND_M_MASTER_EN	EQU	BIT2
V3_COMMAND_M_MEM_EN	EQU	BIT1
V3_COMMAND_M_IO_EN	EQU	BIT0

; SYSTEM REGISTER bits
V3_SYSTEM_M_RST_OUT	EQU	BIT15
V3_SYSTEM_M_LOCK	EQU	BIT14 

; PCI_CFG bits
V3_PCI_CFG_M_RETRY_EN	EQU	BIT10
V3_PCI_CFG_M_AD_LOW1    EQU     BIT9
V3_PCI_CFG_M_AD_LOW0    EQU     BIT8

; PCI_BASE register bits (PCI -> Local Bus)
V3_PCI_BASE_M_ADR_BASE		EQU	0xFFF00000
V3_PCI_BASE_M_ADR_BASEL		EQU	0x000FFF00
V3_PCI_BASE_M_PREFETCH		EQU	BIT3
V3_PCI_BASE_M_TYPE		EQU	BIT2+BIT1
V3_PCI_BASE_M_IO		EQU	BIT0

; PCI MAP register bits (PCI -> Local bus)
V3_PCI_MAP_M_MAP_ADR		EQU	0xFFF00000
V3_PCI_MAP_M_RD_POST_INH	EQU	BIT15
V3_PCI_MAP_M_ROM_SIZE		EQU	BIT11+BIT10
V3_PCI_MAP_M_SWAP		EQU	BIT9+BIT8
V3_PCI_MAP_M_ADR_SIZE		EQU	0x000000F0
V3_PCI_MAP_M_REG_EN		EQU	BIT1	
V3_PCI_MAP_M_ENABLE		EQU	BIT0

; 9 => 512M window size
V3_PCI_MAP_M_ADR_SIZE_512M	EQU	0x00000090
; A => 1024M window size
V3_PCI_MAP_M_ADR_SIZE_1024M	EQU	0x000000A0      

; LB_BASE register bits (Local bus -> PCI)
V3_LB_BASE_M_MAP_ADR		EQU	0xFFF00000
V3_LB_BASE_M_SWAP		EQU	BIT9+BIT8
V3_LB_BASE_M_ADR_SIZE		EQU	0x000000F0
V3_LB_BASE_M_PREFETCH		EQU	BIT3
V3_LB_BASE_M_ENABLE		EQU	BIT0

; LB_MAP register bits (Local bus -> PCI)
V3_LB_MAP_M_MAP_ADR		EQU	0xFFF0
V3_LB_MAP_M_TYPE		EQU	0x000E
V3_LB_MAP_M_AD_LOW_EN		EQU	BIT0

;-------------------------------------------------------------------------------
; Where in the memory map does PCI live?
;-------------------------------------------------------------------------------
; This represents a fairly liberal usage of address space.  Even though the V3
; only has two windows (therefore we need to map stuff on the fly), we maintain
; the same addresses, even if they're not mapped.
;
PCI_MEM_BASE			EQU	0x40000000  ;512M to xxx
; unused 256M from A0000000-AFFFFFFF might be used for I2O ???
PCI_IO_BASE			EQU	0x60000000  ;16M to xxx
; unused (128-16)M from B1000000-B7FFFFFF
PCI_CONFIG_BASE			EQU	0x61000000  ;16M to xxx
; unused ((128-16)M - 64K) from XXX
PCI_V3_BASE			EQU	0x62000000

PCI_DRAMSIZE			EQU	INTEGRATOR_SSRAM_SIZE	

; /* 'export' these to UHAL */
UHAL_PCI_IO			EQU	PCI_IO_BASE
UHAL_PCI_MEM			EQU	PCI_MEM_BASE
UHAL_PCI_ALLOC_IO_BASE		EQU	0x00004000
UHAL_PCI_ALLOC_MEM_BASE		EQU	PCI_MEM_BASE
UHAL_PCI_MAX_SLOT		EQU	20
	
;-------------------------------------------------------------------------------
; From AMBA UART (PL010) Block Specification (ARM-0001-CUST-DSPC-A03)
;-------------------------------------------------------------------------------
; UART Register Offsets.
; 
AMBA_UARTDR	EQU	0x00	; Data read or written from the interface.
AMBA_UARTRSR	EQU	0x04	; Receive status register (Read).
AMBA_UARTECR	EQU	0x04	; Error clear register (Write).
AMBA_UARTLCR_H	EQU	0x08	; Line control register, high byte.
AMBA_UARTLCR_M	EQU	0x0C	; Line control register, middle byte.
AMBA_UARTLCR_L	EQU	0x10	; Line control register, low byte.
AMBA_UARTCR	EQU	0x14	; Control register.
AMBA_UARTFR	EQU	0x18	; Flag register (Read only).
AMBA_UARTIIR	EQU	0x1C	; Interrupt indentification register (Read).
AMBA_UARTICR	EQU	0x1C	; Interrupt clear register (Write).
AMBA_UARTILPR	EQU	0x20	; IrDA low power counter register.

AMBA_UARTRSR_OE		EQU	0x08
AMBA_UARTRSR_BE		EQU	0x04
AMBA_UARTRSR_PE		EQU	0x02
AMBA_UARTRSR_FE		EQU	0x01

AMBA_UARTFR_TXFF	EQU	0x20
AMBA_UARTFR_RXFE	EQU	0x10
AMBA_UARTFR_BUSY	EQU	0x08
AMBA_UARTFR_TMSK	EQU	(AMBA_UARTFR_TXFF + AMBA_UARTFR_BUSY)
 
AMBA_UARTCR_RTIE	EQU	0x40
AMBA_UARTCR_TIE		EQU	0x20
AMBA_UARTCR_RIE		EQU	0x10
AMBA_UARTCR_MSIE	EQU	0x08
AMBA_UARTCR_IIRLP	EQU	0x04
AMBA_UARTCR_SIREN	EQU	0x02
AMBA_UARTCR_UARTEN	EQU	0x01
 
AMBA_UARTLCR_H_WLEN_8	EQU	0x60
AMBA_UARTLCR_H_WLEN_7	EQU	0x40
AMBA_UARTLCR_H_WLEN_6	EQU	0x20
AMBA_UARTLCR_H_WLEN_5	EQU	0x00
AMBA_UARTLCR_H_FEN	EQU	0x10
AMBA_UARTLCR_H_STP2	EQU	0x08
AMBA_UARTLCR_H_EPS	EQU	0x04
AMBA_UARTLCR_H_PEN 	EQU	0x02
AMBA_UARTLCR_H_BRK	EQU	0x01

AMBA_UARTIIR_RTIS	EQU	0x08
AMBA_UARTIIR_TIS	EQU	0x04
AMBA_UARTIIR_RIS	EQU	0x02
AMBA_UARTIIR_MIS	EQU	0x01

ARM_BAUD_460800		EQU	1
ARM_BAUD_230400		EQU	3
ARM_BAUD_115200		EQU	7
ARM_BAUD_57600		EQU	15
ARM_BAUD_38400		EQU	23
ARM_BAUD_19200		EQU	47
ARM_BAUD_14400		EQU	63
ARM_BAUD_9600		EQU	95
ARM_BAUD_4800		EQU	191
ARM_BAUD_2400		EQU	383
ARM_BAUD_1200		EQU	767

;===============================================================================
; Start of uHAL definitions
;===============================================================================

;-------------------------------------------------------------------------------
; Integrator Interrupt Controllers
;-------------------------------------------------------------------------------
;
; Offsets from interrupt controller base 
;
; System Controller interrupt controller base is
;
;	INTEGRATOR_IC_BASE + (header_number << 6)
;
; Core Module interrupt controller base is
;
;	INTEGRATOR_HDR_IC 
;
IRQ_STATUS		EQU	0
IRQ_RAW_STATUS		EQU	0x04
IRQ_ENABLE		EQU	0x08
IRQ_ENABLE_SET		EQU	0x08
IRQ_ENABLE_CLEAR	EQU	0x0C
IRQ_SOFT_SET		EQU	0x10
IRQ_SOFT_CLEAR		EQU	0x14

FIQ_STATUS		EQU	0x20
FIQ_RAW_STATUS		EQU	0x24
FIQ_ENABLE		EQU	0x28
FIQ_ENABLE_SET		EQU	0x28
FIQ_ENABLE_CLEAR	EQU	0x2C


;-------------------------------------------------------------------------------
; Interrupts
;-------------------------------------------------------------------------------
;
; 
; Each Core Module has two interrupts controllers, one on the core module itself
; and one in the system controller on the motherboard.  The READ_INT macro in target.s
; reads both interrupt controllers and returns a 32 bit bitmask, bits 0 to 23 are
; interrupts from the system controller and bits 24 to 31 are from the core module.
; 
; The following definitions relate to the bitmask returned by READ_INT.
;

;
; As the interrupt bit definitions for FIQ/IRQ there is a common
; set of definitions prefixed INT/INTMASK.  The FIQ/IRQ definitions
; have been left to maintain backwards compatible.
;

;
; Interrupt numbers
;
INT_SOFTINT		EQU	0
INT_UARTINT0		EQU	1
INT_UARTINT1		EQU	2
INT_KMIINT0     	EQU	3
INT_KMIINT1     	EQU	4
INT_TIMERINT0   	EQU	5
INT_TIMERINT1   	EQU	6
INT_TIMERINT2   	EQU	7
INT_RTCINT      	EQU	8
INT_EXPINT0     	EQU	9
INT_EXPINT1     	EQU	10
INT_EXPINT2     	EQU	11
INT_EXPINT3     	EQU	12
INT_PCIINT0     	EQU	13
INT_PCIINT1		EQU	14
INT_PCIINT2     	EQU	15
INT_PCIINT3     	EQU	16
INT_V3INT		EQU	17
INT_CPINT0      	EQU	18
INT_CPINT1	     	EQU	19
INT_LBUSTIMEOUT		EQU	20
INT_APCINT     		EQU	21
INT_CM_SOFTINT		EQU	24
INT_CM_COMMRX		EQU	25
INT_CM_COMMTX		EQU	26

;
; Interrupt bit positions
;
INTMASK_SOFTINT		EQU	(1 << INT_SOFTINT)
INTMASK_UARTINT0	EQU	(1 << INT_UARTINT0)
INTMASK_UARTINT1	EQU	(1 << INT_UARTINT1)
INTMASK_KMIINT0		EQU	(1 << INT_KMIINT0)
INTMASK_KMIINT1		EQU	(1 << INT_KMIINT1)
INTMASK_TIMERINT0	EQU	(1 << INT_TIMERINT0)
INTMASK_TIMERINT1	EQU	(1 << INT_TIMERINT1)
INTMASK_TIMERINT2	EQU	(1 << INT_TIMERINT2)
INTMASK_RTCINT		EQU	(1 << INT_RTCINT)
INTMASK_EXPINT0		EQU	(1 << INT_EXPINT0)
INTMASK_EXPINT1		EQU	(1 << INT_EXPINT1)
INTMASK_EXPINT2		EQU	(1 << INT_EXPINT2)
INTMASK_EXPINT3		EQU	(1 << INT_EXPINT3)
INTMASK_PCIINT0		EQU	(1 << INT_PCIINT0)
INTMASK_PCIINT1		EQU	(1 << INT_PCIINT1)
INTMASK_PCIINT2		EQU	(1 << INT_PCIINT2)
INTMASK_PCIINT3		EQU	(1 << INT_PCIINT3)
INTMASK_V3INT		EQU	(1 << INT_V3INT)
INTMASK_CPINT0		EQU	(1 << INT_CPINT0)
INTMASK_CPINT1		EQU	(1 << INT_CPINT1)
INTMASK_LBUSTIMEOUT	EQU	(1 << INT_LBUSTIMEOUT)
INTMASK_APCINT		EQU	(1 << INT_APCINT)
INTMASK_CM_SOFTINT	EQU	(1 << INT_CM_SOFTINT)
INTMASK_CM_COMMRX	EQU	(1 << INT_CM_COMMRX)
INTMASK_CM_COMMTX	EQU	(1 << INT_CM_COMMTX)

;
; IRQ interrupts definitions are the same the INT definitions.
;
IRQ_SOFTINT		EQU	INT_SOFTINT
IRQ_UARTINT0		EQU	INT_UARTINT0
IRQ_UARTINT1		EQU	INT_UARTINT1
IRQ_KMIINT0		EQU	INT_KMIINT0
IRQ_KMIINT1		EQU	INT_KMIINT1
IRQ_TIMERINT0		EQU	INT_TIMERINT0
IRQ_TIMERINT1		EQU	INT_TIMERINT1
IRQ_TIMERINT2		EQU	INT_TIMERINT2
IRQ_RTCINT		EQU	INT_RTCINT
IRQ_EXPINT0		EQU	INT_EXPINT0
IRQ_EXPINT1		EQU	INT_EXPINT1
IRQ_EXPINT2		EQU	INT_EXPINT2
IRQ_EXPINT3		EQU	INT_EXPINT3
IRQ_PCIINT0		EQU	INT_PCIINT0
IRQ_PCIINT1		EQU	INT_PCIINT1
IRQ_PCIINT2		EQU	INT_PCIINT2
IRQ_PCIINT3		EQU	INT_PCIINT3
IRQ_V3INT		EQU	INT_V3INT
IRQ_CPINT0		EQU	INT_CPINT0
IRQ_CPINT1		EQU	INT_CPINT1
IRQ_LBUSTIMEOUT		EQU	INT_LBUSTIMEOUT
IRQ_APCINT		EQU	INT_APCINT

IRQMASK_SOFTINT		EQU	INTMASK_SOFTINT
IRQMASK_UARTINT0	EQU	INTMASK_UARTINT0
IRQMASK_UARTINT1	EQU	INTMASK_UARTINT1
IRQMASK_KMIINT0		EQU	INTMASK_KMIINT0
IRQMASK_KMIINT1		EQU	INTMASK_KMIINT1
IRQMASK_TIMERINT0	EQU	INTMASK_TIMERINT0
IRQMASK_TIMERINT1	EQU	INTMASK_TIMERINT1
IRQMASK_TIMERINT2	EQU	INTMASK_TIMERINT2
IRQMASK_RTCINT		EQU	INTMASK_RTCINT
IRQMASK_EXPINT0		EQU	INTMASK_EXPINT0
IRQMASK_EXPINT1		EQU	INTMASK_EXPINT1
IRQMASK_EXPINT2		EQU	INTMASK_EXPINT2
IRQMASK_EXPINT3		EQU	INTMASK_EXPINT3
IRQMASK_PCIINT0		EQU	INTMASK_PCIINT0
IRQMASK_PCIINT1		EQU	INTMASK_PCIINT1
IRQMASK_PCIINT2		EQU	INTMASK_PCIINT2
IRQMASK_PCIINT3		EQU	INTMASK_PCIINT3
IRQMASK_V3INT		EQU	INTMASK_V3INT
IRQMASK_CPINT0		EQU	INTMASK_CPINT0
IRQMASK_CPINT1		EQU	INTMASK_CPINT1
IRQMASK_LBUSTIMEOUT	EQU	INTMASK_LBUSTIMEOUT
IRQMASK_APCINT		EQU	INTMASK_APCINT

;
; FIQ interrupts definitions are the same the INT definitions.
;
FIQ_SOFTINT		EQU	INT_SOFTINT
FIQ_UARTINT0		EQU	INT_UARTINT0
FIQ_UARTINT1		EQU	INT_UARTINT1
FIQ_KMIINT0		EQU	INT_KMIINT0
FIQ_KMIINT1		EQU	INT_KMIINT1
FIQ_TIMERINT0		EQU	INT_TIMERINT0
FIQ_TIMERINT1		EQU	INT_TIMERINT1
FIQ_TIMERINT2		EQU	INT_TIMERINT2
FIQ_RTCINT		EQU	INT_RTCINT
FIQ_EXPINT0		EQU	INT_EXPINT0
FIQ_EXPINT1		EQU	INT_EXPINT1
FIQ_EXPINT2		EQU	INT_EXPINT2
FIQ_EXPINT3		EQU	INT_EXPINT3
FIQ_PCIINT0		EQU	INT_PCIINT0
FIQ_PCIINT1		EQU	INT_PCIINT1
FIQ_PCIINT2		EQU	INT_PCIINT2
FIQ_PCIINT3		EQU	INT_PCIINT3
FIQ_V3INT		EQU	INT_V3INT
FIQ_CPINT0		EQU	INT_CPINT0
FIQ_CPINT1		EQU	INT_CPINT1
FIQ_LBUSTIMEOUT		EQU	INT_LBUSTIMEOUT
FIQ_APCINT		EQU	INT_APCINT

FIQMASK_SOFTINT		EQU	INTMASK_SOFTINT
FIQMASK_UARTINT0	EQU	INTMASK_UARTINT0
FIQMASK_UARTINT1	EQU	INTMASK_UARTINT1
FIQMASK_KMIINT0		EQU	INTMASK_KMIINT0
FIQMASK_KMIINT1		EQU	INTMASK_KMIINT1
FIQMASK_TIMERINT0	EQU	INTMASK_TIMERINT0
FIQMASK_TIMERINT1	EQU	INTMASK_TIMERINT1
FIQMASK_TIMERINT2	EQU	INTMASK_TIMERINT2
FIQMASK_RTCINT		EQU	INTMASK_RTCINT
FIQMASK_EXPINT0		EQU	INTMASK_EXPINT0
FIQMASK_EXPINT1		EQU	INTMASK_EXPINT1
FIQMASK_EXPINT2		EQU	INTMASK_EXPINT2
FIQMASK_EXPINT3		EQU	INTMASK_EXPINT3
FIQMASK_PCIINT0		EQU	INTMASK_PCIINT0
FIQMASK_PCIINT1		EQU	INTMASK_PCIINT1
FIQMASK_PCIINT2		EQU	INTMASK_PCIINT2
FIQMASK_PCIINT3		EQU	INTMASK_PCIINT3
FIQMASK_V3INT		EQU	INTMASK_V3INT
FIQMASK_CPINT0		EQU	INTMASK_CPINT0
FIQMASK_CPINT1		EQU	INTMASK_CPINT1
FIQMASK_LBUSTIMEOUT	EQU	INTMASK_LBUSTIMEOUT
FIQMASK_APCINT		EQU	INTMASK_APCINT


;
; Misc. interrupt definitions
;
IRQ_KEYBDINT		EQU	INT_KMIINT0
IRQ_MOUSEINT    	EQU	INT_KMIINT1

IRQMASK_KEYBDINT	EQU	INTMASK_KMIINT0
IRQMASK_MOUSEINT    	EQU	INTMASK_KMIINT1

;
; INTEGRATOR_CM_INT0      - Interrupt number of first CM interrupt
; INTEGRATOR_SC_VALID_INT - Mask of valid system controller interrupts
;
INTEGRATOR_CM_INT0	EQU	INT_CM_SOFTINT
INTEGRATOR_SC_VALID_INT	EQU	0x003FFFFF

MAXIRQNUM		EQU	31
MAXFIQNUM		EQU	31
MAXSWINUM		EQU	31
 
NR_IRQS			EQU	(MAXIRQNUM + 1)

;-------------------------------------------------------------------------------
; LED's - The header LED is not accessable via the uHAL API
;-------------------------------------------------------------------------------
;
uHAL_LED_ON	EQU	1
uHAL_LED_OFF	EQU	0
uHAL_NUM_OF_LEDS	EQU	4

GREEN_LED	EQU	0x01
YELLOW_LED	EQU	0x02
RED_LED		EQU	0x04
GREEN_LED_2	EQU	0x08
ALL_LEDS	EQU	0x0F

LED_BANK	EQU	INTEGRATOR_DBG_LEDS

;#define uHAL_LED_MASKS	{0, GREEN_LED, YELLOW_LED, RED_LED, GREEN_LED_2}
;#define uHAL_LED_OFFSETS	{0, (void *)LED_BANK, (void *)LED_BANK, (void *)LED_BANK, (void *)LED_BANK}


;
; Memory definitions - run uHAL out of SSRAM.
;
uHAL_MEMORY_SIZE 	EQU	INTEGRATOR_SSRAM_SIZE

;
; Application Flash
;
FLASH_BASE		EQU	INTEGRATOR_FLASH_BASE
FLASH_SIZE		EQU	INTEGRATOR_FLASH_SIZE
FLASH_END		EQU	(FLASH_BASE + FLASH_SIZE - 1)
FLASH_BLOCK_SIZE	EQU	SZ_128K

;
; Boot Flash
;
EPROM_BASE		EQU	INTEGRATOR_BOOT_ROM_HI
EPROM_SIZE		EQU	INTEGRATOR_BOOT_ROM_SIZE
EPROM_END		EQU	(EPROM_BASE + EPROM_SIZE - 1)

;
; Clean base - dummy
;
CLEAN_BASE		EQU	EPROM_BASE

;
; UART definitions
;

;
; Which com port can the OS use?
;
; /* Default port to talk to host (via debugger) */
HOST_COMPORT		EQU	INTEGRATOR_UART0_BASE
HOST_IRQBIT_NUMBER	EQU	INT_UARTINT0
HOST_IRQBIT_MASK	EQU	INTMASK_UARTINT0
HOST_IRQBIT		EQU	HOST_IRQBIT_MASK

; /* Default port for use by Operating System or program */
OS_COMPORT		EQU	INTEGRATOR_UART0_BASE
OS_IRQBIT_NUMBER	EQU	INT_UARTINT0
OS_IRQBIT_MASK		EQU	INTMASK_UARTINT0
OS_IRQBIT		EQU	OS_IRQBIT_MASK

DEBUG_COMPORT		EQU	OS_COMPORT
DEBUG_IRQBIT		EQU	OS_IRQBIT

; /* Values to set given baud rates */
DEFAULT_HOST_BAUD	EQU	ARM_BAUD_9600
DEFAULT_OS_BAUD		EQU	ARM_BAUD_38400

;#define GET_STATUS(p)		(IO_READ((p) + AMBA_UARTFR) & 0xFF)
;#define GET_CHAR(p)		(IO_READ((p) + AMBA_UARTDR))
;#define PUT_CHAR(p, c)		(IO_WRITE(((p) + AMBA_UARTDR), (c)))
;#define IO_READ(p)             (*(volatile unsigned char *)(p))
;#define IO_WRITE(p, c)         (*(unsigned char *)(p) = (unsigned char)(c))
;#define RX_DATA(s)		(((s) & AMBA_UARTFR_RXFE) == 0)
;#define TX_READY(s)		(((s) & AMBA_UARTFR_TXFF) == 0)
;#define TX_EMPTY(p)		((GET_STATUS(p) & AMBA_UARTFR_TMSK) == 0)

;
; Timer definitions
;
; Only use timer 1 & 2
; (both run at 24MHz and will need the clock divider set to 16).
;
; Timer 0 runs at bus frequency and therefore could vary and currently
; uHAL can't handle that.
;

INTEGRATOR_TIMER0_BASE	EQU	INTEGRATOR_CT_BASE
INTEGRATOR_TIMER1_BASE	EQU	(INTEGRATOR_CT_BASE + 0x100)
INTEGRATOR_TIMER2_BASE	EQU	(INTEGRATOR_CT_BASE + 0x200)

MAX_TIMER	EQU	2
MAX_PERIOD	EQU	699050
TICKS_PER_uSEC	EQU	24

; /* Interrupt Flags */
SEMIHOSTED_INTS              EQU     0


;
; These are useconds NOT ticks.  
;
mSEC_1		EQU	1000
mSEC_5		EQU	(mSEC_1 * 5)
mSEC_10		EQU	(mSEC_1 * 10)
mSEC_25		EQU	(mSEC_1 * 25)
SEC_1		EQU	(mSEC_1 * 1000)

OS_TIMER	EQU	1
OS_TIMERINT	EQU	INT_TIMERINT1
HOST_TIMER	EQU	MAX_TIMER


; Timer definitions.		
; The irq numbers of the individual timers
;#define TIMER_VECTORS	{ 0, INT_TIMERINT1, INT_TIMERINT2}
; 

; Number of Level2 table entries in uHAL_AddressTable
L2_TABLE_ENTRIES	EQU	1


;macros to map from PCI memory/IO addresses to local bus addresses
;#define _MapAddress(a)		(a)
;#define _MapIOAddress(a)	((U32)UHAL_PCI_IO + (U32)(a))
;#define _MapMemAddress(a)	(a)


ALLBITS			EQU	0xffffffff


INTEGRATOR_CSR_BASE		EQU	0x10000000
INTEGRATOR_CSR_SIZE		EQU	0x10000000


; Purely for compatability with SEMIHOSTED (defined in uart.h in uHAL):
InterruptId			EQU	2
; Purely for compatability with uHAL (defined in superio_h.s in SEMIHOSTED):
EnableInt			EQU	0x04
CntlModem			EQU	0x10

 IF :DEF: uHAL_HEAP
   IF USE_C_LIBRARY <> 0
uHAL_HEAP_BASE		   	EQU	(INTEGRATOR_SSRAM_BASE + SZ_1M)
uHAL_HEAP_SIZE			EQU	(SZ_32M - SZ_1M - SZ_1M - 4)
uHAL_STACK_BASE			EQU	SZ_32M
uHAL_STACK_SIZE			EQU	SZ_1M
   ELSE
uHAL_HEAP_BASE			EQU	(INTEGRATOR_SSRAM_BASE + INTEGRATOR_SSRAM_SIZE - SZ_64K)
uHAL_HEAP_SIZE			EQU	SZ_16K
uHAL_STACK_SIZE			EQU	SZ_16K
uHAL_STACK_BASE		EQU	(uHAL_HEAP_BASE + SZ32K)
   ENDIF
 ENDIF

 ENDIF

	END
