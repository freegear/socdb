/***************************************************************************
 * Copyright © Intel Corporation, March 18th 1998.  All rights reserved.
 * Copyright © ARM Limited 1998.  All rights reserved.
 ***************************************************************************/
/* ======================================================================
 *
 * Abstract:	PCI address space access routines
 *
 * ====================================================================== */
 
#include "uhal.h"



