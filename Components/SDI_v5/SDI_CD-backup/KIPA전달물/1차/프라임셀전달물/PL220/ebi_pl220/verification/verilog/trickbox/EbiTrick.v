// --=========================================================================--
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from ARM Limited
//   (C) COPYRIGHT 2001-2002 ARM Limited
//       ALL RIGHTS RESERVED
// The entire notice above must be reproduced on all authorised
// copies and copies may only be made to the extent permitted
// by a licensing agreement from ARM Limited.
//
// -----------------------------------------------------------------------------
// Version and Release Control Information:
//
// File Name              : EbiTrick.v.rca
// File Revision          : 1.2
//
// Release Information    : PrimeCell(TM)-PL220-r0p0-00ltd0
//
// -----------------------------------------------------------------------------
// Purpose :
//           This block is the top level of the EBI Trickbox.
//
// --=========================================================================--

`timescale 1ns/1ps

// -----------------------------------------------------------------------------

module EbiTrick (
// Inputs
                 // AHB bus signals
                 HCLK,
                 HRESETn,
                 HADDR,
                 HTRANS,
                 HWRITE,
                 HSIZE,
                 HREADYIN,
                 HWDATA,
                 HSELEBITRICKBOX,
                 EBIGNT1,
                 EBIGNT2,
                 EBIGNT3,
                 EBIBACKOFF1,
                 EBIBACKOFF2,
                 EBIBACKOFF3,
                 nEBIEXTDATAEN,
                 EBIEXTADDROUT,
                 EBIEXTDATAOUT,
                 EBIDATAIN,

// Outputs
                 EBICLK,
                 EBIREQ1,
                 EBIREQ2,
                 EBIREQ3,
                 nPOR,
                 HREADYOUT,
                 HRESP,
                 HRDATA,
                 EBIADDR1,
                 EBIADDR2,
                 EBIADDR3,
                 EBIDATA1,
                 EBIDATA2,
                 EBIDATA3,
                 nEBIDATAEN1,
                 nEBIDATAEN2,
                 nEBIDATAEN3,
                 EBIEXTDATAIN,
                 EBITIMEOUTVALUE1,
                 EBITIMEOUTVALUE2,
                 EBITIMEOUTVALUE3
                );

parameter Tclkl  = 10; // HCLK low time
parameter Tclkh  = 10; // HCLK high time
parameter Tclks  = 10; // EBICLK start delay
// Inputs

// AHB bus signals
input         HCLK;             // AHB Bus Clock
input         HRESETn;          // Bus Reset
input  [11:2] HADDR;            // AHB Address Bus
input   [1:0] HTRANS;           // Transfer type AHB
input         HWRITE;           // AHB Peripheral Write
input   [2:0] HSIZE;            // Transfer size AHB
input         HREADYIN;         // Multiplexed version of HREADY
                                // outputs for AHB
input  [31:0] HWDATA;           // AHB Write Data bus
input         HSELEBITRICKBOX;  // AHB Peripheral (Trickbox) Select
input         EBIGNT1;          // Gnt signal generated by Ebi
input         EBIGNT2;          // Gnt signal generated by Ebi
input         EBIGNT3;          // Gnt signal generated by Ebi
input         EBIBACKOFF1;      // Backoff signal generated by Ebi
input         EBIBACKOFF2;      // Backoff signal generated by Ebi
input         EBIBACKOFF3;      // Backoff signal generated by Ebi
input   [3:0] nEBIEXTDATAEN;    // Data enable signal from Ebi
input  [31:0] EBIEXTADDROUT;    // Address out from Ebi
input  [31:0] EBIEXTDATAOUT;    // Data out from Ebi
input  [31:0] EBIDATAIN;        // Data in from Ebi

// Outputs
output        EBICLK;           // clock to the EBI
output        EBIREQ1;          // Ebi request from Port1
output        EBIREQ2;          // Ebi request from Port2
output        EBIREQ3;          // Ebi request from Port3
output        nPOR;             // Power on Reset
output        HREADYOUT;        // Slave HREADY output (AHB)
output  [1:0] HRESP;            // Slave response (AHB)
output [31:0] HRDATA;           // AHB Read Data bus
output [31:0] EBIADDR1;         // Address bus from Port1
output [31:0] EBIADDR2;         // Address bus from Port2
output [31:0] EBIADDR3;         // Address bus from Port3
output [31:0] EBIDATA1;         // Data bus from Port1
output [31:0] EBIDATA2;         // Data bus from Port2
output [31:0] EBIDATA3;         // Data bus from Port3
output  [3:0] nEBIDATAEN1;      // Data enable from Port1
output  [3:0] nEBIDATAEN2;      // Data enable from Port2
output  [3:0] nEBIDATAEN3;      // Data enable from Port3
output [31:0] EBIEXTDATAIN;     // Data from memory
output  [9:0] EBITIMEOUTVALUE1; // Gives the value to be loaded into
                                // timeout counter for port 1.
output  [9:0] EBITIMEOUTVALUE2; // Gives the value to be loaded into
                                // timeout counter for port 2.
output  [9:0] EBITIMEOUTVALUE3; // Gives the value to be loaded into
                                // timeout counter for port 3.

// Inputs

// AHB bus signals
wire        HCLK;             // AHB Bus Clock
wire        HRESETn;          // Bus Reset
wire [11:2] HADDR;            // AHB Address Bus
wire  [1:0] HTRANS;           // Transfer type AHB
wire        HWRITE;           // AHB Peripheral Write
wire  [2:0] HSIZE;            // Transfer size AHB
wire        HREADYIN;         // Multiplexed version of HREADY
                              // outputs for AHB
wire [31:0] HWDATA;           // AHB Write Data bus
wire        HSELEBITRICKBOX;  // AHB Peripheral (Trickbox) Select
wire        EBIGNT1;          // Gnt signal generated by Ebi
wire        EBIGNT2;          // Gnt signal generated by Ebi
wire        EBIGNT3;          // Gnt signal generated by Ebi
wire        EBIBACKOFF1;      // Backoff signal generated by Ebi
wire        EBIBACKOFF2;      // Backoff signal generated by Ebi
wire        EBIBACKOFF3;      // Backoff signal generated by Ebi
wire  [3:0] nEBIEXTDATAEN;    // Data enable signal from Ebi
wire [31:0] EBIEXTADDROUT;    // Address out from Ebi
wire [31:0] EBIEXTDATAOUT;    // Data out from Ebi
wire [31:0] EBIDATAIN;        // Data in from Ebi

// Outputs
wire        EBICLK;           // clock to the EBI
wire        EBIREQ1;          // Ebi request from Port1
wire        EBIREQ2;          // Ebi request from Port2
wire        EBIREQ3;          // Ebi request from Port3
wire        nPOR;             // Power on Reset
wire        HREADYOUT;        // Slave HREADY output (AHB)
wire  [1:0] HRESP;            // Slave response (AHB)
wire [31:0] HRDATA;           // AHB Read Data bus
wire [31:0] EBIADDR1;         // Address bus from Port1
wire [31:0] EBIADDR2;         // Address bus from Port2
wire [31:0] EBIADDR3;         // Address bus from Port3
wire [31:0] EBIDATA1;         // Data bus from Port1
wire [31:0] EBIDATA2;         // Data bus from Port2
wire [31:0] EBIDATA3;         // Data bus from Port3
wire  [3:0] nEBIDATAEN1;      // Data enable from Port1
wire  [3:0] nEBIDATAEN2;      // Data enable from Port2
wire  [3:0] nEBIDATAEN3;      // Data enable from Port3
wire [31:0] EBIEXTDATAIN;     // Data from memory
wire  [9:0] EBITIMEOUTVALUE1; // Gives the value to be loaded into
                              // timeout counter for port 1.
wire  [9:0] EBITIMEOUTVALUE2; // Gives the value to be loaded into
                              // timeout counter for port 2.
wire  [9:0] EBITIMEOUTVALUE3; // Gives the value to be loaded into
                              // timeout counter for port 3.


// -----------------------------------------------------------------------------
//
//                                  EbiTrick
//                                  =========
//
// -----------------------------------------------------------------------------
//
// Overview
// ========
//   This block is the top level of the Trickbox. This block instantiates the
// following functional sub-blocks in the trickbox.
//      - EbiTrAhbif
//      - EbiTrRegBlk
//      - EbiTrClkResGen
//      - EbiTrProChkr
//      - EbiTrMirEbi
//      - EbiTrComparator
//      - EbiTrReqIndctr
//
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// Constant declarations
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// Wire declarations
// -----------------------------------------------------------------------------
wire [7:0] EbiTrCntl;
// EbiTrCntl Register

wire [5:0] EbiTrStatus;
// EbiTrStatus Register

wire  [2:0] EbiTrClk;
//  Indicates speed of MEMCLK

wire [31:0] EbiTrAddr1;
// Indicates address on EBIADDR1

wire [31:0] EbiTrAddr2;
// Indicates address on EBIADDR1

wire [31:0] EbiTrAddr3;
// Indicates address on EBIADDR1

wire [31:0] EbiTrData1;
// Indicates data on EBIDATA1

wire [31:0] EbiTrData2;
// Indicates data on EBIDATA2

wire [31:0] EbiTrData3;
// Indicates data on EBIDATA3

wire  [3:0] nEbiTrDataEn1;
// Indicates data enable on nEBIDATAEN1

wire  [3:0] nEbiTrDataEn2;
// Indicates data enable on nEBIDATAEN2

wire  [3:0] nEbiTrDataEn3;
// Indicates data enable on nEBIDATAEN3

wire [31:0] EbiTrExtDataIn;
// Indicates data enable on EBIEXTDATAIN

wire  [9:0] EbiTrTimeOut1;
// Indicates EBITIMEOUTVALUE1

wire  [9:0] EbiTrTimeOut2;
// Indicates EBITIMEOUTVALUE2

wire  [9:0] EbiTrTimeOut3;
// Indicates EBITIMEOUTVALUE3

wire [31:0] WriteData;
// Write Data bus to the Register Block

wire        EbiTrCntlWr;
//  EbiTrCntl register write enable

wire        EbiTrClkWr;
//  EbiTrClk Register Write Enable

wire        EbiTrAddr1Wr;
//  EbiTrAddr1 Register Write

wire        EbiTrAddr2Wr;
//  EbiTrAddr2 Register Write

wire        EbiTrAddr3Wr;
//  EbiTrAddr3 Register Write

wire        EbiTrData1Wr;
//  EbiTrData1 Register Write

wire        EbiTrData2Wr;
//  EbiTrData2 Register Write

wire        EbiTrData3Wr;
//  EbiTrData3 Register Write

wire        nEbiTrDataEn1Wr;
//  nEbiTrDataEn1 Register Write

wire        nEbiTrDataEn2Wr;
//  nEbiTrDataEn2 Register Write

wire        nEbiTrDataEn3Wr;
//  nEbiTrDataEn3 Register Write

wire        EbiTrExtDataInWr;
//  EbiTrExtDataIn Register Write

wire        EbiTrTimeOut1Wr;
//  EbiTrTimeOut1 register write

wire        EbiTrTimeOut2Wr;
//  EbiTrTimeOut2 register write

wire        EbiTrTimeOut3Wr;
//  EbiTrTimeOut3 register write

wire        MEMCLK1;
//  Memory clock from Port1

wire        MEMCLK2;
//  Memory clock from Port2

wire        MEMCLK3;
//  Memory clock from Port3

wire        EbiTrGnt1;
//  Gnt signal generated by trickbox

wire        EbiTrGnt2;
//  Gnt signal generated by trickbox

wire        EbiTrGnt3;
//  Gnt signal generated by trickbox

wire        EbiTrBackoff1;
//  Backoff signal generated by trickbox

wire        EbiTrBackoff2;
//  Backoff signal generated by trickbox

wire        EbiTrBackoff3;
//  Backoff signal generated by trickbox

wire  [3:0] nEbiTrExtDataEn;
// Data enable signal from trickbox

wire [31:0] EbiTrExtAddrOut;
// Address out from trickbox

wire [31:0] EbiTrExtDataOut;
// Data out from trickbox

wire [31:0] EbiTrDataIn;
// Data in from trickbox

wire        ClkFlag;
//  Indicates whether Request comparison is clk by clk

wire        EventFlag;
//  Indicates whether Request comparison is on event basis

wire        iEBIREQ1;
wire        iEBIREQ2;
wire        iEBIREQ3;
wire [31:0] iEBIADDR1;
wire [31:0] iEBIADDR2;
wire [31:0] iEBIADDR3;
wire [31:0] iEBIDATA1;
wire [31:0] iEBIDATA2;
wire [31:0] iEBIDATA3;
wire  [3:0] inEBIDATAEN1;
wire  [3:0] inEBIDATAEN2;
wire  [3:0] inEBIDATAEN3;
wire [31:0] iEBIEXTDATAIN;
wire  [9:0] iEBITIMEOUTVAL1;
wire  [9:0] iEBITIMEOUTVAL2;
wire  [9:0] iEBITIMEOUTVAL3;
wire        inPOR;

// -----------------------------------------------------------------------------
// Register declarations
// ---------------------------------------------------------------------

// ---------------------------------------------------------------------
// Function declarations
// -----------------------------------------------------------------------------
// -----------------------------------------------------------------------------
//
// Main body of code
// =================
//
// -----------------------------------------------------------------------------

// -----------------------------------------------------------------------------
// Instantiation of EbiTrAhbif
// -----------------------------------------------------------------------------
EbiTrAhbif uEbiTrAhbif                (
                    .HCLK             (HCLK),
                    .HRESETn          (HRESETn),
                    .HADDR            (HADDR),
                    .HTRANS           (HTRANS),
                    .HWRITE           (HWRITE),
                    .HSIZE            (HSIZE),
                    .HREADYIN         (HREADYIN),
                    .HWDATA           (HWDATA),
                    .HSELEBITRICKBOX  (HSELEBITRICKBOX),
                    .EbiTrCntl        (EbiTrCntl),
                    .EbiTrStatus      (EbiTrStatus),
                    .EbiTrClk         (EbiTrClk),
                    .EbiTrAddr1       (EbiTrAddr1),
                    .EbiTrAddr2       (EbiTrAddr2),
                    .EbiTrAddr3       (EbiTrAddr3),
                    .EbiTrData1       (EbiTrData1),
                    .EbiTrData2       (EbiTrData2),
                    .EbiTrData3       (EbiTrData3),
                    .nEbiTrDataEn1    (nEbiTrDataEn1),
                    .nEbiTrDataEn2    (nEbiTrDataEn2),
                    .nEbiTrDataEn3    (nEbiTrDataEn3),
                    .EbiTrExtDataIn   (EbiTrExtDataIn),
                    .EbiTrTimeOut1    (EbiTrTimeOut1),
                    .EbiTrTimeOut2    (EbiTrTimeOut2),
                    .EbiTrTimeOut3    (EbiTrTimeOut3),
                    .HREADYOUT        (HREADYOUT),
                    .HRESP            (HRESP),
                    .HRDATA           (HRDATA),
                    .WriteData        (WriteData),
                    .EbiTrCntlWr      (EbiTrCntlWr),
                    .EbiTrClkWr       (EbiTrClkWr),
                    .EbiTrAddr1Wr     (EbiTrAddr1Wr),
                    .EbiTrAddr2Wr     (EbiTrAddr2Wr),
                    .EbiTrAddr3Wr     (EbiTrAddr3Wr),
                    .EbiTrData1Wr     (EbiTrData1Wr),
                    .EbiTrData2Wr     (EbiTrData2Wr),
                    .EbiTrData3Wr     (EbiTrData3Wr),
                    .nEbiTrDataEn1Wr  (nEbiTrDataEn1Wr),
                    .nEbiTrDataEn2Wr  (nEbiTrDataEn2Wr),
                    .nEbiTrDataEn3Wr  (nEbiTrDataEn3Wr),
                    .EbiTrExtDataInWr (EbiTrExtDataInWr),
                    .EbiTrTimeOut1Wr  (EbiTrTimeOut1Wr),
                    .EbiTrTimeOut2Wr  (EbiTrTimeOut2Wr),
                    .EbiTrTimeOut3Wr  (EbiTrTimeOut3Wr)
                    );

// -----------------------------------------------------------------------------
// Instantiation of EbiTrClkResGen
// -----------------------------------------------------------------------------
defparam uEbiTrClkResGen.Tclkl = Tclkl;
defparam uEbiTrClkResGen.Tclkh = Tclkh;
defparam uEbiTrClkResGen.Tclks = Tclks;

EbiTrClkResGen uEbiTrClkResGen        (
                    .HCLK             (HCLK),
                    .EbiTrClk         (EbiTrClk),
                    .HRESETn          (HRESETn),
                    .nPOR             (inPOR),
                    .MEMCLK1          (MEMCLK1),
                    .MEMCLK2          (MEMCLK2),
                    .MEMCLK3          (MEMCLK3),
                    .EBICLK           (EBICLK)
                   );

// -----------------------------------------------------------------------------
// Instantiation of EbiTrComparator
// -----------------------------------------------------------------------------
EbiTrComparator uEbiTrComparator      (
                    .EBICLK           (EBICLK),
                    .HRESETn          (HRESETn),
                    .EBIGNT1          (EBIGNT1),
                    .EBIGNT2          (EBIGNT2),
                    .EBIGNT3          (EBIGNT3),
                    .EBIBACKOFF1      (EBIBACKOFF1),
                    .EBIBACKOFF2      (EBIBACKOFF2),
                    .EBIBACKOFF3      (EBIBACKOFF3),
                    .nEBIEXTDATAEN    (nEBIEXTDATAEN),
                    .EBIEXTADDROUT    (EBIEXTADDROUT),
                    .EBIEXTDATAOUT    (EBIEXTDATAOUT),
                    .EBIDATAIN        (EBIDATAIN),
                    .EbiTrGnt1        (EbiTrGnt1),
                    .EbiTrGnt2        (EbiTrGnt2),
                    .EbiTrGnt3        (EbiTrGnt3),
                    .EbiTrBackoff1    (EbiTrBackoff1),
                    .EbiTrBackoff2    (EbiTrBackoff2),
                    .EbiTrBackoff3    (EbiTrBackoff3),
                    .nEbiTrExtDataEn  (nEbiTrExtDataEn),
                    .EbiTrExtAddrOut  (EbiTrExtAddrOut),
                    .EbiTrExtDataOut  (EbiTrExtDataOut),
                    .EbiTrDataIn      (EbiTrDataIn)
                   );


// -----------------------------------------------------------------------------
// Instantiation of EbiTrMirEbi
// -----------------------------------------------------------------------------
EbiTrMirEbi uEbiTrMirEbi              (
                    .EBICLK           (EBICLK),
                    .nPOR             (nPOR),
                    .EBIREQ1          (EBIREQ1),
                    .EBIADDR1         (EBIADDR1),
                    .EBIDATA1         (EBIDATA1),
                    .nEBIDATAEN1      (nEBIDATAEN1),
                    .EBITIMEOUTVALUE1 (EBITIMEOUTVALUE1),
                    .EBIREQ2          (EBIREQ2),
                    .EBIADDR2         (EBIADDR2),
                    .EBIDATA2         (EBIDATA2),
                    .nEBIDATAEN2      (nEBIDATAEN2),
                    .EBITIMEOUTVALUE2 (EBITIMEOUTVALUE2),
                    .EBIREQ3          (EBIREQ3),
                    .EBIADDR3         (EBIADDR3),
                    .EBIDATA3         (EBIDATA3),
                    .nEBIDATAEN3      (nEBIDATAEN3),
                    .EBITIMEOUTVALUE3 (EBITIMEOUTVALUE3),
                    .EBIEXTDATAIN     (EBIEXTDATAIN),
                    .EbiTrGnt1        (EbiTrGnt1),
                    .EbiTrBackoff1    (EbiTrBackoff1),
                    .EbiTrGnt2        (EbiTrGnt2),
                    .EbiTrBackoff2    (EbiTrBackoff2),
                    .EbiTrGnt3        (EbiTrGnt3),
                    .EbiTrBackoff3    (EbiTrBackoff3),
                    .EbiTrExtAddrOut  (EbiTrExtAddrOut),
                    .EbiTrExtDataOut  (EbiTrExtDataOut),
                    .nEbiTrExtDataEn  (nEbiTrExtDataEn),
                    .EbiTrDataIn      (EbiTrDataIn)
                   );

// -----------------------------------------------------------------------------
// Instantiation of EbiTrProChkr
// -----------------------------------------------------------------------------
EbiTrProChkr uEbiTrProChkr            (
                    .EBICLK           (EBICLK),
                    .HRESETn          (HRESETn),
                    .EBIGNT1          (EBIGNT1),
                    .EBIGNT2          (EBIGNT2),
                    .EBIGNT3          (EBIGNT3),
                    .EBIBACKOFF1      (EBIBACKOFF1),
                    .EBIBACKOFF2      (EBIBACKOFF2),
                    .EBIBACKOFF3      (EBIBACKOFF3),
                    .EBIDATAIN        (EBIDATAIN),
                    .EBIEXTADDROUT    (EBIEXTADDROUT),
                    .EBIEXTDATAOUT    (EBIEXTDATAOUT),
                    .nEBIEXTDATAEN    (nEBIEXTDATAEN)
                   );

// -----------------------------------------------------------------------------
// Instantiation of EbiTrRegBlk
// -----------------------------------------------------------------------------
EbiTrRegBlk uEbiTrRegBlk              (
                    .HCLK             (HCLK),
                    .MEMCLK1          (MEMCLK1),
                    .MEMCLK2          (MEMCLK2),
                    .MEMCLK3          (MEMCLK3),
                    .HRESETn          (HRESETn),
                    .HREADYIN         (HREADYIN),
                    .WriteData        (WriteData),
                    .EbiTrCntlWr      (EbiTrCntlWr),
                    .EbiTrClkWr       (EbiTrClkWr),
                    .EbiTrAddr1Wr     (EbiTrAddr1Wr),
                    .EbiTrAddr2Wr     (EbiTrAddr2Wr),
                    .EbiTrAddr3Wr     (EbiTrAddr3Wr),
                    .EbiTrData1Wr     (EbiTrData1Wr),
                    .EbiTrData2Wr     (EbiTrData2Wr),
                    .EbiTrData3Wr     (EbiTrData3Wr),
                    .nEbiTrDataEn1Wr  (nEbiTrDataEn1Wr),
                    .nEbiTrDataEn2Wr  (nEbiTrDataEn2Wr),
                    .nEbiTrDataEn3Wr  (nEbiTrDataEn3Wr),
                    .EbiTrExtDataInWr (EbiTrExtDataInWr),
                    .EbiTrTimeOut1Wr  (EbiTrTimeOut1Wr),
                    .EbiTrTimeOut2Wr  (EbiTrTimeOut2Wr),
                    .EbiTrTimeOut3Wr  (EbiTrTimeOut3Wr),
                    .EBIGNT1          (EBIGNT1),
                    .EBIGNT2          (EBIGNT2),
                    .EBIGNT3          (EBIGNT3),
                    .EBIBACKOFF1      (EBIBACKOFF1),
                    .EBIBACKOFF2      (EBIBACKOFF2),
                    .EBIBACKOFF3      (EBIBACKOFF3),
                    .EBIREQ1          (iEBIREQ1),
                    .EBIREQ2          (iEBIREQ2),
                    .EBIREQ3          (iEBIREQ3),
                    .ClkFlag          (ClkFlag),
                    .EventFlag        (EventFlag),
                    .EbiTrCntl        (EbiTrCntl),
                    .EbiTrStatus      (EbiTrStatus),
                    .EbiTrClk         (EbiTrClk),
                    .EbiTrAddr1       (EbiTrAddr1),
                    .EbiTrAddr2       (EbiTrAddr2),
                    .EbiTrAddr3       (EbiTrAddr3),
                    .EbiTrData1       (EbiTrData1),
                    .EbiTrData2       (EbiTrData2),
                    .EbiTrData3       (EbiTrData3),
                    .nEbiTrDataEn1    (nEbiTrDataEn1),
                    .nEbiTrDataEn2    (nEbiTrDataEn2),
                    .nEbiTrDataEn3    (nEbiTrDataEn3),
                    .EbiTrExtDataIn   (EbiTrExtDataIn),
                    .EbiTrTimeOut1    (EbiTrTimeOut1),
                    .EbiTrTimeOut2    (EbiTrTimeOut2),
                    .EbiTrTimeOut3    (EbiTrTimeOut3),
                    .EBIADDR1         (iEBIADDR1),
                    .EBIADDR2         (iEBIADDR2),
                    .EBIADDR3         (iEBIADDR3),
                    .EBIDATA1         (iEBIDATA1),
                    .EBIDATA2         (iEBIDATA2),
                    .EBIDATA3         (iEBIDATA3),
                    .nEBIDATAEN1      (inEBIDATAEN1),
                    .nEBIDATAEN2      (inEBIDATAEN2),
                    .nEBIDATAEN3      (inEBIDATAEN3),
                    .EBIEXTDATAIN     (iEBIEXTDATAIN),
                    .EBITIMEOUTVALUE1 (iEBITIMEOUTVAL1),
                    .EBITIMEOUTVALUE2 (iEBITIMEOUTVAL2),
                    .EBITIMEOUTVALUE3 (iEBITIMEOUTVAL3)
                   );

// -----------------------------------------------------------------------------
// Instantiation of EbiTrRegBlk
// -----------------------------------------------------------------------------
EbiTrReqIndctr uEbiTrReqIndctr        (
                    .EBICLK           (EBICLK),
                    .nPOR             (inPOR),
                    .ClkFlag          (ClkFlag),
                    .EventFlag        (EventFlag),
                    .EBIREQ1          (iEBIREQ1),
                    .EBIREQ2          (iEBIREQ2),
                    .EBIREQ3          (iEBIREQ3)
                   );

// -----------------------------------------------------------------------------
// Assign local copies of signals to the outputs
// -----------------------------------------------------------------------------
assign nPOR             = inPOR;
assign EBIREQ1          = iEBIREQ1;
assign EBIREQ2          = iEBIREQ2;
assign EBIREQ3          = iEBIREQ3;
assign EBIDATA1         = iEBIDATA1;
assign EBIDATA2         = iEBIDATA2;
assign EBIDATA3         = iEBIDATA3;
assign EBIADDR1         = iEBIADDR1;
assign EBIADDR2         = iEBIADDR2;
assign EBIADDR3         = iEBIADDR3;
assign nEBIDATAEN1      = inEBIDATAEN1;
assign nEBIDATAEN2      = inEBIDATAEN2;
assign nEBIDATAEN3      = inEBIDATAEN3;
assign EBIEXTDATAIN     = iEBIEXTDATAIN;
assign EBITIMEOUTVALUE1 = iEBITIMEOUTVAL1;
assign EBITIMEOUTVALUE2 = iEBITIMEOUTVAL2;
assign EBITIMEOUTVALUE3 = iEBITIMEOUTVAL3;

endmodule
// --================================== End ==================================--
