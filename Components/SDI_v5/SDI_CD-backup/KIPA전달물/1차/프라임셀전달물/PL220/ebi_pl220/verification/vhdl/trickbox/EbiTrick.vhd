-- --=========================================================================--
-- This confidential and proprietary software may be used only as
-- authorised by a licensing agreement from ARM Limited
--   (C) COPYRIGHT 2001-2002 ARM Limited
--       ALL RIGHTS RESERVED
-- The entire notice above must be reproduced on all authorised
-- copies and copies may only be made to the extent permitted
-- by a licensing agreement from ARM Limited.
--
-- -----------------------------------------------------------------------------
-- Version and Release Control Information:
--
-- File Name              : EbiTrick.vhd.rca
-- File Revision          : 1.2
--
-- Release Information    : PrimeCell(TM)-PL220-r0p0-00ltd0
--
-- -----------------------------------------------------------------------------
-- Purpose :
--           This block is the top level of the EBI Trickbox.
--
-- --=========================================================================--

library IEEE;
use IEEE.std_logic_1164.all;
use IEEE.std_logic_arith.all;

-- -----------------------------------------------------------------------------

entity EbiTrick is
  generic (
           Tclkl            : time := 10 ns; -- HCLK low time
           Tclkh            : time := 10 ns; -- HCLK high time
           Tclks            : time := 10 ns  -- EBICLK start delay
          );
  port (
-- Inputs
        -- AHB bus signals
        HCLK             : in    std_logic; -- AHB Bus Clock
        HRESETn          : in    std_logic; -- Bus Reset
        HADDR            : in    std_logic_vector(11 downto 2);
                                            -- AHB Address Bus
        HTRANS           : in    std_logic_vector(1 downto 0);
                                            -- Transfer type AHB
        HWRITE           : in    std_logic; -- AHB Peripheral Write
        HSIZE            : in    std_logic_vector(2 downto 0);
                                            -- Transfer size AHB
        HREADYIN         : in    std_logic; -- Multiplexed version of
                                            -- HREADY outputs for AHB
        HWDATA           : in    std_logic_vector(31 downto 0);
                                            -- AHB Write Data bus
        HSELEBITRICKBOX  : in    std_logic; -- AHB Peripheral (Trickbox)
                                            -- Select
        EBIGNT1          : in    std_logic; -- Gnt signal generated by Ebi
        EBIGNT2          : in    std_logic; -- Gnt signal generated by Ebi
        EBIGNT3          : in    std_logic; -- Gnt signal generated by Ebi
        EBIBACKOFF1      : in    std_logic; -- Backoff signal generated by Ebi
        EBIBACKOFF2      : in    std_logic; -- Backoff signal generated by Ebi
        EBIBACKOFF3      : in    std_logic; -- Backoff signal generated by Ebi
        nEBIEXTDATAEN    : in    std_logic_vector(3 downto 0);
                                            -- Data enable signal from Ebi
        EBIEXTADDROUT    : in    std_logic_vector(31 downto 0);
                                            -- Address out from Ebi
        EBIEXTDATAOUT    : in    std_logic_vector(31 downto 0);
                                            -- Data out from Ebi
        EBIDATAIN        : in    std_logic_vector(31 downto 0);
                                            -- Data in from Ebi

-- Outputs
        EBICLK           : out   std_logic; -- clock to the EBI
        EBIREQ1          : out   std_logic; -- Ebi request from Port1
        EBIREQ2          : out   std_logic; -- Ebi request from Port2
        EBIREQ3          : out   std_logic; -- Ebi request from Port3
        nPOR             : out   std_logic; -- Power on Reset
        HREADYOUT        : out   std_logic; -- Slave HREADY output (AHB)
        HRESP            : out   std_logic_vector(1 downto 0);
                                            -- Slave response (AHB)
        HRDATA           : out   std_logic_vector(31 downto 0);
                                            -- AHB Read Data bus
        EBIADDR1         : out   std_logic_vector(31 downto 0);
                                            -- Address bus from Port1
        EBIADDR2         : out   std_logic_vector(31 downto 0);
                                            -- Address bus from Port2
        EBIADDR3         : out   std_logic_vector(31 downto 0);
                                            -- Address bus from Port3
        EBIDATA1         : out   std_logic_vector(31 downto 0);
                                            -- Data bus from Port1
        EBIDATA2         : out   std_logic_vector(31 downto 0);
                                            -- Data bus from Port2
        EBIDATA3         : out   std_logic_vector(31 downto 0);
                                            -- Data bus from Port3
        nEBIDATAEN1      : out   std_logic_vector(3 downto 0);
                                            -- Data enable from Port1
        nEBIDATAEN2      : out   std_logic_vector(3 downto 0);
                                            -- Data enable from Port2
        nEBIDATAEN3      : out   std_logic_vector(3 downto 0);
                                            -- Data enable from Port3
        EBIEXTDATAIN     : out   std_logic_vector(31 downto 0);
                                               -- Data from memory
        EBITIMEOUTVALUE1 : out   std_logic_vector(9 downto 0);
                                            -- Gives the value to be loaded
                                            -- into timeout counter for port 1.
        EBITIMEOUTVALUE2 : out   std_logic_vector(9 downto 0);
                                            -- Gives the value to be loaded
                                            -- into timeout counter for port 2.
        EBITIMEOUTVALUE3 : out   std_logic_vector(9 downto 0)
                                            -- Gives the value to be loaded
                                            -- into timeout counter for port 3.
       );
end EbiTrick;

-- -----------------------------------------------------------------------------
--
--                                  EbiTrick
--                                  =========
--
-- -----------------------------------------------------------------------------
--
-- Overview
-- ========
--   This block is the top level of the Trickbox. This block instantiates the
-- following functional sub-blocks in the trickbox.
--      - EbiTrAhbif
--      - EbiTrRegBlk
--      - EbiTrClkResGen
--      - EbiTrProChkr
--      - EbiTrMirEbi
--      - EbiTrComparator.vhd
--      - EbiTrReqIndctr.vhd
--
-- -----------------------------------------------------------------------------


-- --=========================== ARCHITECTURE ================================--

architecture structural of EbiTrick is

-- -----------------------------------------------------------------------------
-- Component declarations
-- -----------------------------------------------------------------------------
component EbiTrAhbif
  port (
        HCLK             : in    std_logic; 
        HRESETn          : in    std_logic; 
        HADDR            : in    std_logic_vector(11 downto 2);
        HTRANS           : in    std_logic_vector(1 downto 0);
        HWRITE           : in    std_logic; 
        HSIZE            : in    std_logic_vector(2 downto 0);
        HREADYIN         : in    std_logic; 
        HWDATA           : in    std_logic_vector(31 downto 0);
        HSELEBITRICKBOX  : in    std_logic; 
        EbiTrCntl        : in    std_logic_vector(7 downto 0);
        EbiTrStatus      : in    std_logic_vector(5 downto 0);
        EbiTrClk         : in    std_logic_vector(2 downto 0); 
        EbiTrAddr1       : in    std_logic_vector(31 downto 0);
        EbiTrAddr2       : in    std_logic_vector(31 downto 0);
        EbiTrAddr3       : in    std_logic_vector(31 downto 0);
        EbiTrData1       : in    std_logic_vector(31 downto 0);
        EbiTrData2       : in    std_logic_vector(31 downto 0);
        EbiTrData3       : in    std_logic_vector(31 downto 0);
        nEbiTrDataEn1    : in    std_logic_vector(3 downto 0);
        nEbiTrDataEn2    : in    std_logic_vector(3 downto 0);
        nEbiTrDataEn3    : in    std_logic_vector(3 downto 0);
        EbiTrExtDataIn   : in    std_logic_vector(31 downto 0);
        EbiTrTimeOut1    : in    std_logic_vector(9 downto 0);
        EbiTrTimeOut2    : in    std_logic_vector(9 downto 0);
        EbiTrTimeOut3    : in    std_logic_vector(9 downto 0);
        HREADYOUT        : out   std_logic; 
        HRESP            : out   std_logic_vector(1 downto 0);
        HRDATA           : out   std_logic_vector(31 downto 0);
        WriteData        : out   std_logic_vector(31 downto 0);
        EbiTrCntlWr      : out   std_logic; 
        EbiTrClkWr       : out   std_logic; 
        EbiTrAddr1Wr     : out   std_logic; 
        EbiTrAddr2Wr     : out   std_logic; 
        EbiTrAddr3Wr     : out   std_logic; 
        EbiTrData1Wr     : out   std_logic; 
        EbiTrData2Wr     : out   std_logic; 
        EbiTrData3Wr     : out   std_logic; 
        nEbiTrDataEn1Wr  : out   std_logic; 
        nEbiTrDataEn2Wr  : out   std_logic; 
        nEbiTrDataEn3Wr  : out   std_logic; 
        EbiTrExtDataInWr : out   std_logic; 
        EbiTrTimeOut1Wr  : out   std_logic; 
        EbiTrTimeOut2Wr  : out   std_logic; 
        EbiTrTimeOut3Wr  : out   std_logic  
       );
end component;

component EbiTrClkResGen
  generic (
           Tclkl            : time; 
           Tclkh            : time; 
           Tclks            : time  
          );
  port (
        HCLK             : in    std_logic; 
        EbiTrClk         : in    std_logic_vector(2 downto 0); 
        HRESETn          : in    std_logic; 
        nPOR             : out   std_logic; 
        MEMCLK1          : out   std_logic; 
        MEMCLK2          : out   std_logic; 
        MEMCLK3          : out   std_logic; 
        EBICLK           : out   std_logic  
       );
end component;

component EbiTrComparator
  port (
        EBICLK           : in    std_logic; 
        HRESETn          : in    std_logic; 
        EBIGNT1          : in    std_logic; 
        EBIGNT2          : in    std_logic; 
        EBIGNT3          : in    std_logic; 
        EBIBACKOFF1      : in    std_logic; 
        EBIBACKOFF2      : in    std_logic; 
        EBIBACKOFF3      : in    std_logic; 
        nEBIEXTDATAEN    : in    std_logic_vector(3 downto 0);
        EBIEXTADDROUT    : in    std_logic_vector(31 downto 0);
        EBIEXTDATAOUT    : in    std_logic_vector(31 downto 0);
        EBIDATAIN        : in    std_logic_vector(31 downto 0);
        EbiTrGnt1        : in    std_logic; 
        EbiTrGnt2        : in    std_logic; 
        EbiTrGnt3        : in    std_logic; 
        EbiTrBackoff1    : in    std_logic; 
        EbiTrBackoff2    : in    std_logic; 
        EbiTrBackoff3    : in    std_logic; 
        nEbiTrExtDataEn  : in    std_logic_vector(3 downto 0);
        EbiTrExtAddrOut  : in    std_logic_vector(31 downto 0);
        EbiTrExtDataOut  : in    std_logic_vector(31 downto 0);
        EbiTrDataIn      : in    std_logic_vector(31 downto 0)
       );
end component;

component EbiTrMirEbi
  port (
        EBICLK           : in    std_logic; 
        nPOR             : in    std_logic; 
        EBIREQ1          : in    std_logic; 
        EBIADDR1         : in    std_logic_vector(31 downto 0);
        EBIDATA1         : in    std_logic_vector(31 downto 0);
        nEBIDATAEN1      : in    std_logic_vector(3 downto 0);
        EBITIMEOUTVALUE1 : in    std_logic_vector(9 downto 0);
        EBIREQ2          : in    std_logic; 
        EBIADDR2         : in    std_logic_vector(31 downto 0);
        EBIDATA2         : in    std_logic_vector(31 downto 0);
        nEBIDATAEN2      : in    std_logic_vector(3 downto 0);
        EBITIMEOUTVALUE2 : in    std_logic_vector(9 downto 0);
        EBIREQ3          : in    std_logic; 
        EBIADDR3         : in    std_logic_vector(31 downto 0);
        EBIDATA3         : in    std_logic_vector(31 downto 0);
        nEBIDATAEN3      : in    std_logic_vector(3 downto 0);
        EBITIMEOUTVALUE3 : in    std_logic_vector(9 downto 0);
        EBIEXTDATAIN     : in    std_logic_vector(31 downto 0);
        EbiTrGnt1        : out std_logic; 
        EbiTrBackoff1    : out std_logic; 
        EbiTrGnt2        : out std_logic; 
        EbiTrBackoff2    : out std_logic; 
        EbiTrGnt3        : out std_logic; 
        EbiTrBackoff3    : out std_logic; 
        EbiTrExtAddrOut  : out std_logic_vector(31 downto 0);
        EbiTrExtDataOut  : out std_logic_vector(31 downto 0);
        nEbiTrExtDataEn  : out std_logic_vector(3 downto 0);
        EbiTrDataIn      : out std_logic_vector(31 downto 0)
       );
end component;

component EbiTrProChkr
  port (
        EBICLK           : in    std_logic; 
        HRESETn          : in    std_logic; 
        EBIGNT1          : in    std_logic; 
        EBIGNT2          : in    std_logic; 
        EBIGNT3          : in    std_logic; 
        EBIBACKOFF1      : in    std_logic; 
        EBIBACKOFF2      : in    std_logic; 
        EBIBACKOFF3      : in    std_logic; 
        EBIDATAIN        : in    std_logic_vector(31 downto 0);
        EBIEXTADDROUT    : in    std_logic_vector(31 downto 0);
        EBIEXTDATAOUT    : in    std_logic_vector(31 downto 0);
        nEBIEXTDATAEN    : in    std_logic_vector(3 downto 0)
       );
end component;

component EbiTrRegBlk
  port (
        HCLK             : in    std_logic; 
        MEMCLK1          : in    std_logic; 
        MEMCLK2          : in    std_logic; 
        MEMCLK3          : in    std_logic; 
        HRESETn          : in    std_logic; 
        HREADYIN         : in    std_logic; 
        WriteData        : in    std_logic_vector(31 downto 0);
        EbiTrCntlWr      : in    std_logic; 
        EbiTrClkWr       : in    std_logic; 
        EbiTrAddr1Wr     : in    std_logic; 
        EbiTrAddr2Wr     : in    std_logic; 
        EbiTrAddr3Wr     : in    std_logic; 
        EbiTrData1Wr     : in    std_logic; 
        EbiTrData2Wr     : in    std_logic; 
        EbiTrData3Wr     : in    std_logic; 
        nEbiTrDataEn1Wr  : in    std_logic; 
        nEbiTrDataEn2Wr  : in    std_logic; 
        nEbiTrDataEn3Wr  : in    std_logic; 
        EbiTrExtDataInWr : in    std_logic; 
        EbiTrTimeOut1Wr  : in    std_logic; 
        EbiTrTimeOut2Wr  : in    std_logic; 
        EbiTrTimeOut3Wr  : in    std_logic; 
        EBIGNT1          : in    std_logic; 
        EBIGNT2          : in    std_logic; 
        EBIGNT3          : in    std_logic; 
        EBIBACKOFF1      : in    std_logic; 
        EBIBACKOFF2      : in    std_logic; 
        EBIBACKOFF3      : in    std_logic; 
        EBIREQ1          : out   std_logic; 
        EBIREQ2          : out   std_logic; 
        EBIREQ3          : out   std_logic; 
        ClkFlag          : out   std_logic; 
        EventFlag        : out   std_logic; 
        EbiTrCntl        : out   std_logic_vector(7 downto 0);
        EbiTrStatus      : out   std_logic_vector(5 downto 0);
        EbiTrClk         : out   std_logic_vector(2 downto 0); 
        EbiTrAddr1       : out   std_logic_vector(31 downto 0);
        EbiTrAddr2       : out   std_logic_vector(31 downto 0);
        EbiTrAddr3       : out   std_logic_vector(31 downto 0);
        EbiTrData1       : out   std_logic_vector(31 downto 0);
        EbiTrData2       : out   std_logic_vector(31 downto 0);
        EbiTrData3       : out   std_logic_vector(31 downto 0);
        nEbiTrDataEn1    : out   std_logic_vector(3 downto 0);
        nEbiTrDataEn2    : out   std_logic_vector(3 downto 0);
        nEbiTrDataEn3    : out   std_logic_vector(3 downto 0);
        EbiTrExtDataIn   : out   std_logic_vector(31 downto 0);
        EbiTrTimeOut1    : out   std_logic_vector(9 downto 0);
        EbiTrTimeOut2    : out   std_logic_vector(9 downto 0);
        EbiTrTimeOut3    : out   std_logic_vector(9 downto 0);
        EBIADDR1         : out   std_logic_vector(31 downto 0);
        EBIADDR2         : out   std_logic_vector(31 downto 0);
        EBIADDR3         : out   std_logic_vector(31 downto 0);
        EBIDATA1         : out   std_logic_vector(31 downto 0);
        EBIDATA2         : out   std_logic_vector(31 downto 0);
        EBIDATA3         : out   std_logic_vector(31 downto 0);
        nEBIDATAEN1      : out   std_logic_vector(3 downto 0);
        nEBIDATAEN2      : out   std_logic_vector(3 downto 0);
        nEBIDATAEN3      : out   std_logic_vector(3 downto 0);
        EBIEXTDATAIN     : out   std_logic_vector(31 downto 0);
        EBITIMEOUTVALUE1 : out   std_logic_vector(9 downto 0);
        EBITIMEOUTVALUE2 : out   std_logic_vector(9 downto 0);
        EBITIMEOUTVALUE3 : out   std_logic_vector(9 downto 0)
       );
end component;

component EbiTrReqIndctr
  port (
        EBICLK           : in    std_logic; 
        nPOR             : in    std_logic; 
        ClkFlag          : in    std_logic; 
        EventFlag        : in    std_logic; 
        EBIREQ1          : in    std_logic; 
        EBIREQ2          : in    std_logic; 
        EBIREQ3          : in    std_logic  
       );
end component;

-- -----------------------------------------------------------------------------
-- Constant declarations
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
-- Signal declarations
-- -----------------------------------------------------------------------------
signal EbiTrCntl        : std_logic_vector(7 downto 0);
-- EbiTrCntl Register 

signal EbiTrStatus      : std_logic_vector(5 downto 0);
-- EbiTrStatus Register 

signal EbiTrClk         : std_logic_vector(2 downto 0); 
--  Indicates MEMCLK  speed

signal EbiTrAddr1       : std_logic_vector(31 downto 0);
-- Indicates address on EBIADDR1 

signal EbiTrAddr2       : std_logic_vector(31 downto 0);
-- Indicates address on EBIADDR1 

signal EbiTrAddr3       : std_logic_vector(31 downto 0);
-- Indicates address on EBIADDR1 

signal EbiTrData1       : std_logic_vector(31 downto 0);
-- Indicates data on EBIDATA1 

signal EbiTrData2       : std_logic_vector(31 downto 0);
-- Indicates data on EBIDATA2 

signal EbiTrData3       : std_logic_vector(31 downto 0);
-- Indicates data on EBIDATA3 

signal nEbiTrDataEn1    : std_logic_vector(3 downto 0);
-- Indicates data enable on nEBIDATAEN1 

signal nEbiTrDataEn2    : std_logic_vector(3 downto 0);
-- Indicates data enable on nEBIDATAEN2 

signal nEbiTrDataEn3    : std_logic_vector(3 downto 0);
-- Indicates data enable on nEBIDATAEN3 

signal EbiTrExtDataIn   : std_logic_vector(31 downto 0);
-- Indicates data enable on EBIEXTDATAIN 

signal EbiTrTimeOut1    : std_logic_vector(9 downto 0);
-- Indicates EBITIMEOUTVALUE1 

signal EbiTrTimeOut2    : std_logic_vector(9 downto 0);
-- Indicates EBITIMEOUTVALUE2 

signal EbiTrTimeOut3    : std_logic_vector(9 downto 0);
-- Indicates EBITIMEOUTVALUE3 

signal WriteData        : std_logic_vector(31 downto 0);
-- Write Data bus to the Register Block 

signal EbiTrCntlWr      : std_logic; 
--  EbiTrCntl register write enable 

signal EbiTrClkWr       : std_logic; 
--  EbiTrClk Register Write Enable 

signal EbiTrAddr1Wr     : std_logic; 
--  EbiTrAddr1 Register Write 

signal EbiTrAddr2Wr     : std_logic; 
--  EbiTrAddr2 Register Write 

signal EbiTrAddr3Wr     : std_logic; 
--  EbiTrAddr3 Register Write 

signal EbiTrData1Wr     : std_logic; 
--  EbiTrData1 Register Write 

signal EbiTrData2Wr     : std_logic; 
--  EbiTrData2 Register Write 

signal EbiTrData3Wr     : std_logic; 
--  EbiTrData3 Register Write 

signal nEbiTrDataEn1Wr  : std_logic; 
--  nEbiTrDataEn1 Register Write 

signal nEbiTrDataEn2Wr  : std_logic; 
--  nEbiTrDataEn2 Register Write 

signal nEbiTrDataEn3Wr  : std_logic; 
--  nEbiTrDataEn3 Register Write 

signal EbiTrExtDataInWr : std_logic; 
--  EbiTrExtDataIn Register Write 

signal EbiTrTimeOut1Wr  : std_logic; 
--  EbiTrTimeOut1 register write 

signal EbiTrTimeOut2Wr  : std_logic; 
--  EbiTrTimeOut2 register write 

signal EbiTrTimeOut3Wr  : std_logic  ;
--  EbiTrTimeOut3 register write   generic ( 

signal MEMCLK1          : std_logic; 
--  Memory clock from Port1 

signal MEMCLK2          : std_logic; 
--  Memory clock from Port2 

signal MEMCLK3          : std_logic; 
--  Memory clock from Port3 

signal EbiTrGnt1        : std_logic; 
--  Gnt signal generated by trickbox 

signal EbiTrGnt2        : std_logic; 
--  Gnt signal generated by trickbox 

signal EbiTrGnt3        : std_logic; 
--  Gnt signal generated by trickbox 

signal EbiTrBackoff1    : std_logic; 
--  Backoff signal generated by trickbox 

signal EbiTrBackoff2    : std_logic; 
--  Backoff signal generated by trickbox 

signal EbiTrBackoff3    : std_logic; 
--  Backoff signal generated by trickbox 

signal nEbiTrExtDataEn  : std_logic_vector(3 downto 0);
-- Data enable signal from trickbox 

signal EbiTrExtAddrOut  : std_logic_vector(31 downto 0);
-- Address out from trickbox 

signal EbiTrExtDataOut  : std_logic_vector(31 downto 0);
-- Data out from trickbox 

signal EbiTrDataIn      : std_logic_vector(31 downto 0);
-- Data in from trickbox  

signal ClkFlag          : std_logic; 
-- Indicates whether Request comparison is clk by clk  

signal EventFlag        : std_logic; 
-- Indicates whether Request comparison is on event basis  

signal iEBICLK          : std_logic;
-- Internal version of the EBICLK

signal inPOR            : std_logic;
-- Internal version of the nEBIDATAEN3 signal

signal iEBIREQ1         : std_logic;
-- Internal version of the EBIREQ1 signal

signal iEBIREQ2         : std_logic;
-- Internal version of the EBIREQ2 signal

signal iEBIREQ3         : std_logic;
-- Internal version of the EBIREQ3 signal

signal iEBIADDR1        : std_logic_vector(31 downto 0);
-- Internal version of the EBIADDR1 signal

signal iEBIADDR2        : std_logic_vector(31 downto 0);
-- Internal version of the EBIADDR2 signal

signal iEBIADDR3        : std_logic_vector(31 downto 0);
-- Internal version of the EBIADDR3 signal

signal iEBIDATA1        : std_logic_vector(31 downto 0);
-- Internal version of the EBIDATA1 signal

signal iEBIDATA2        : std_logic_vector(31 downto 0);
-- Internal version of the EBIDATA2 signal

signal iEBIDATA3        : std_logic_vector(31 downto 0);
-- Internal version of the EBIDATA3 signal

signal inEBIDATAEN1     : std_logic_vector(3 downto 0);
-- Internal version of the nEBIDATAEN1 signal

signal inEBIDATAEN2     : std_logic_vector(3 downto 0);
-- Internal version of the nEBIDATAEN2 signal

signal inEBIDATAEN3     : std_logic_vector(3 downto 0);
-- Internal version of the nEBIDATAEN3 signal

signal iEBIEXTDATAIN    : std_logic_vector(31 downto 0);
-- Internal version of the EBIEXTDATAIN signal

signal iEBITIMEOUTVAL1  : std_logic_vector(9 downto 0);
-- Internal version of the EBITIMEOUTVALUE1 signal

signal iEBITIMEOUTVAL2  : std_logic_vector(9 downto 0);
-- Internal version of the EBITIMEOUTVALUE2 signal

signal iEBITIMEOUTVAL3  : std_logic_vector(9 downto 0);
-- Internal version of the EBITIMEOUTVALUE3 signal

-- -----------------------------------------------------------------------------
-- Function declarations
-- -----------------------------------------------------------------------------

-- -----------------------------------------------------------------------------
--
-- Main body of code
-- =================
--
-- -----------------------------------------------------------------------------

begin

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrAhbif
-- -----------------------------------------------------------------------------
uEbiTrAhbif : EbiTrAhbif
  port map (
        HCLK              => HCLK,
        HRESETn           => HRESETn,
        HADDR             => HADDR,
        HTRANS            => HTRANS,
        HWRITE            => HWRITE,
        HSIZE             => HSIZE,
        HREADYIN          => HREADYIN,
        HWDATA            => HWDATA,
        HSELEBITRICKBOX   => HSELEBITRICKBOX,
        EbiTrCntl         => EbiTrCntl,
        EbiTrStatus       => EbiTrStatus,
        EbiTrClk          => EbiTrClk,
        EbiTrAddr1        => EbiTrAddr1,
        EbiTrAddr2        => EbiTrAddr2,
        EbiTrAddr3        => EbiTrAddr3,
        EbiTrData1        => EbiTrData1,
        EbiTrData2        => EbiTrData2,
        EbiTrData3        => EbiTrData3,
        nEbiTrDataEn1     => nEbiTrDataEn1,
        nEbiTrDataEn2     => nEbiTrDataEn2,
        nEbiTrDataEn3     => nEbiTrDataEn3,
        EbiTrExtDataIn    => EbiTrExtDataIn,
        EbiTrTimeOut1     => EbiTrTimeOut1,
        EbiTrTimeOut2     => EbiTrTimeOut2,
        EbiTrTimeOut3     => EbiTrTimeOut3,
        HREADYOUT         => HREADYOUT,
        HRESP             => HRESP,
        HRDATA            => HRDATA,
        WriteData         => WriteData,
        EbiTrCntlWr       => EbiTrCntlWr,
        EbiTrClkWr        => EbiTrClkWr,
        EbiTrAddr1Wr      => EbiTrAddr1Wr,
        EbiTrAddr2Wr      => EbiTrAddr2Wr,
        EbiTrAddr3Wr      => EbiTrAddr3Wr,
        EbiTrData1Wr      => EbiTrData1Wr,
        EbiTrData2Wr      => EbiTrData2Wr,
        EbiTrData3Wr      => EbiTrData3Wr,
        nEbiTrDataEn1Wr   => nEbiTrDataEn1Wr,
        nEbiTrDataEn2Wr   => nEbiTrDataEn2Wr,
        nEbiTrDataEn3Wr   => nEbiTrDataEn3Wr,
        EbiTrExtDataInWr  => EbiTrExtDataInWr,
        EbiTrTimeOut1Wr   => EbiTrTimeOut1Wr,
        EbiTrTimeOut2Wr   => EbiTrTimeOut2Wr,
        EbiTrTimeOut3Wr   => EbiTrTimeOut3Wr
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrClkResGen
-- -----------------------------------------------------------------------------
uEbiTrClkResGen : EbiTrClkResGen
  generic map (
           Tclkl             => Tclkl,
           Tclkh             => Tclkh,
           Tclks             => Tclks
          )
  port map (
        HCLK              => HCLK,
        EbiTrClk          => EbiTrClk,
        HRESETn           => HRESETn,
        nPOR              => inPOR,
        MEMCLK1           => MEMCLK1,
        MEMCLK2           => MEMCLK2,
        MEMCLK3           => MEMCLK3,
        EBICLK            => iEBICLK
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrComparator
-- -----------------------------------------------------------------------------
uEbiTrComparator : EbiTrComparator
  port map (
        EBICLK            => iEBICLK,
        HRESETn           => HRESETn,
        EBIGNT1           => EBIGNT1,
        EBIGNT2           => EBIGNT2,
        EBIGNT3           => EBIGNT3,
        EBIBACKOFF1       => EBIBACKOFF1,
        EBIBACKOFF2       => EBIBACKOFF2,
        EBIBACKOFF3       => EBIBACKOFF3,
        nEBIEXTDATAEN     => nEBIEXTDATAEN,
        EBIEXTADDROUT     => EBIEXTADDROUT,
        EBIEXTDATAOUT     => EBIEXTDATAOUT,
        EBIDATAIN         => EBIDATAIN,
        EbiTrGnt1         => EbiTrGnt1,
        EbiTrGnt2         => EbiTrGnt2,
        EbiTrGnt3         => EbiTrGnt3,
        EbiTrBackoff1     => EbiTrBackoff1,
        EbiTrBackoff2     => EbiTrBackoff2,
        EbiTrBackoff3     => EbiTrBackoff3,
        nEbiTrExtDataEn   => nEbiTrExtDataEn,
        EbiTrExtAddrOut   => EbiTrExtAddrOut,
        EbiTrExtDataOut   => EbiTrExtDataOut,
        EbiTrDataIn       => EbiTrDataIn
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrMirEbi
-- -----------------------------------------------------------------------------
uEbiTrMirEbi : EbiTrMirEbi
  port map (
        EBICLK            => iEBICLK,
        nPOR              => inPOR,
        EBIREQ1           => iEBIREQ1,
        EBIADDR1          => iEBIADDR1,
        EBIDATA1          => iEBIDATA1,
        nEBIDATAEN1       => inEBIDATAEN1,
        EBITIMEOUTVALUE1  => iEBITIMEOUTVAL1,
        EBIREQ2           => iEBIREQ2,
        EBIADDR2          => iEBIADDR2,
        EBIDATA2          => iEBIDATA2,
        nEBIDATAEN2       => inEBIDATAEN2,
        EBITIMEOUTVALUE2  => iEBITIMEOUTVAL2,
        EBIREQ3           => iEBIREQ3,
        EBIADDR3          => iEBIADDR3,
        EBIDATA3          => iEBIDATA3,
        nEBIDATAEN3       => inEBIDATAEN3,
        EBITIMEOUTVALUE3  => iEBITIMEOUTVAL3,
        EBIEXTDATAIN      => iEBIEXTDATAIN,
        EbiTrGnt1         => EbiTrGnt1,
        EbiTrBackoff1     => EbiTrBackoff1,
        EbiTrGnt2         => EbiTrGnt2,
        EbiTrBackoff2     => EbiTrBackoff2,
        EbiTrGnt3         => EbiTrGnt3,
        EbiTrBackoff3     => EbiTrBackoff3,
        EbiTrExtAddrOut   => EbiTrExtAddrOut,
        EbiTrExtDataOut   => EbiTrExtDataOut,
        nEbiTrExtDataEn   => nEbiTrExtDataEn,
        EbiTrDataIn       => EbiTrDataIn
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrProChkr
-- -----------------------------------------------------------------------------
uEbiTrProChkr : EbiTrProChkr
  port map (
        EBICLK            => iEBICLK,
        HRESETn           => HRESETn,
        EBIGNT1           => EBIGNT1,
        EBIGNT2           => EBIGNT2,
        EBIGNT3           => EBIGNT3,
        EBIBACKOFF1       => EBIBACKOFF1,
        EBIBACKOFF2       => EBIBACKOFF2,
        EBIBACKOFF3       => EBIBACKOFF3,
        EBIDATAIN         => EBIDATAIN,
        EBIEXTADDROUT     => EBIEXTADDROUT,
        EBIEXTDATAOUT     => EBIEXTDATAOUT,
        nEBIEXTDATAEN     => nEBIEXTDATAEN
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrRegBlk
-- -----------------------------------------------------------------------------
uEbiTrRegBlk : EbiTrRegBlk
  port map (
        HCLK              => HCLK,
        MEMCLK1           => MEMCLK1,
        MEMCLK2           => MEMCLK2,
        MEMCLK3           => MEMCLK3,
        HRESETn           => HRESETn,
        HREADYIN          => HREADYIN,
        WriteData         => WriteData,
        EbiTrCntlWr       => EbiTrCntlWr,
        EbiTrClkWr        => EbiTrClkWr,
        EbiTrAddr1Wr      => EbiTrAddr1Wr,
        EbiTrAddr2Wr      => EbiTrAddr2Wr,
        EbiTrAddr3Wr      => EbiTrAddr3Wr,
        EbiTrData1Wr      => EbiTrData1Wr,
        EbiTrData2Wr      => EbiTrData2Wr,
        EbiTrData3Wr      => EbiTrData3Wr,
        nEbiTrDataEn1Wr   => nEbiTrDataEn1Wr,
        nEbiTrDataEn2Wr   => nEbiTrDataEn2Wr,
        nEbiTrDataEn3Wr   => nEbiTrDataEn3Wr,
        EbiTrExtDataInWr  => EbiTrExtDataInWr,
        EbiTrTimeOut1Wr   => EbiTrTimeOut1Wr,
        EbiTrTimeOut2Wr   => EbiTrTimeOut2Wr,
        EbiTrTimeOut3Wr   => EbiTrTimeOut3Wr,
        EBIGNT1           => EBIGNT1,
        EBIGNT2           => EBIGNT2,
        EBIGNT3           => EBIGNT3,
        EBIBACKOFF1       => EBIBACKOFF1,
        EBIBACKOFF2       => EBIBACKOFF2,
        EBIBACKOFF3       => EBIBACKOFF3,
        EBIREQ1           => iEBIREQ1,
        EBIREQ2           => iEBIREQ2,
        EBIREQ3           => iEBIREQ3,
        ClkFlag           => ClkFlag,
        EventFlag         => EventFlag,
        EbiTrCntl         => EbiTrCntl,
        EbiTrStatus       => EbiTrStatus,
        EbiTrClk          => EbiTrClk,
        EbiTrAddr1        => EbiTrAddr1,
        EbiTrAddr2        => EbiTrAddr2,
        EbiTrAddr3        => EbiTrAddr3,
        EbiTrData1        => EbiTrData1,
        EbiTrData2        => EbiTrData2,
        EbiTrData3        => EbiTrData3,
        nEbiTrDataEn1     => nEbiTrDataEn1,
        nEbiTrDataEn2     => nEbiTrDataEn2,
        nEbiTrDataEn3     => nEbiTrDataEn3,
        EbiTrExtDataIn    => EbiTrExtDataIn,
        EbiTrTimeOut1     => EbiTrTimeOut1,
        EbiTrTimeOut2     => EbiTrTimeOut2,
        EbiTrTimeOut3     => EbiTrTimeOut3,
        EBIADDR1          => iEBIADDR1,
        EBIADDR2          => iEBIADDR2,
        EBIADDR3          => iEBIADDR3,
        EBIDATA1          => iEBIDATA1,
        EBIDATA2          => iEBIDATA2,
        EBIDATA3          => iEBIDATA3,
        nEBIDATAEN1       => inEBIDATAEN1,
        nEBIDATAEN2       => inEBIDATAEN2,
        nEBIDATAEN3       => inEBIDATAEN3,
        EBIEXTDATAIN      => iEBIEXTDATAIN,
        EBITIMEOUTVALUE1  => iEBITIMEOUTVAL1,
        EBITIMEOUTVALUE2  => iEBITIMEOUTVAL2,
        EBITIMEOUTVALUE3  => iEBITIMEOUTVAL3
       );

-- -----------------------------------------------------------------------------
-- Instantiation of EbiTrRegBlk
-- -----------------------------------------------------------------------------
uEbiTrReqIndctr : EbiTrReqIndctr
  port map (
        EBICLK            => iEBICLK,
        nPOR              => inPOR,
        ClkFlag           => ClkFlag,
        EventFlag         => EventFlag,
        EBIREQ1           => iEBIREQ1,
        EBIREQ2           => iEBIREQ2,
        EBIREQ3           => iEBIREQ3
       );

-- -----------------------------------------------------------------------------
-- Assign local copies of signals to the outputs
-- -----------------------------------------------------------------------------
nPOR             <= inPOR;
EBICLK           <= iEBICLK;
EBIREQ1          <= iEBIREQ1;
EBIREQ2          <= iEBIREQ2;
EBIREQ3          <= iEBIREQ3;
EBIDATA1         <= iEBIDATA1;
EBIDATA2         <= iEBIDATA2;
EBIDATA3         <= iEBIDATA3;
EBIADDR1         <= iEBIADDR1;
EBIADDR2         <= iEBIADDR2;
EBIADDR3         <= iEBIADDR3;
nEBIDATAEN1      <= inEBIDATAEN1;
nEBIDATAEN2      <= inEBIDATAEN2;
nEBIDATAEN3      <= inEBIDATAEN3;
EBIEXTDATAIN     <= iEBIEXTDATAIN;
EBITIMEOUTVALUE1 <= iEBITIMEOUTVAL1;
EBITIMEOUTVALUE2 <= iEBITIMEOUTVAL2;
EBITIMEOUTVALUE3 <= iEBITIMEOUTVAL3;

end structural;

-- --================================== End ==================================--
