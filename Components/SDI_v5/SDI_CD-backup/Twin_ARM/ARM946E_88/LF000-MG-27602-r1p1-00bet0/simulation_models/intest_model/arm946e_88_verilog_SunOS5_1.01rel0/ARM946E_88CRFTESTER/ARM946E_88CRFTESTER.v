// ARM946E_88CRFTESTER.v
//
// Verilog implementation of ARM946E_88CRFTESTER, generated by ModelGen

// Elements of the code in this file are
// Copyright 1993, 94-99, 2000 ARM Ltd,
// All rights reserved.

`timescale 1 ps / 1 ps

// Inout shell

module ARM946E_88CRFTESTER_inout (HBUSREQ,
  HLOCK,
  HADDR,
  HTRANS,
  HWRITE,
  HSIZE,
  HBURST,
  HPROT,
  HWDATA,
  CPINSTR,
  CPDOUT,
  CPPASS,
  CPLATECANCEL,
  CPTBIT,
  nCPMREQ,
  nCPTRANS,
  CPCLKEN,
  COMMRX,
  COMMTX,
  DBGACK,
  DBGRQI,
  DBGINSTREXEC,
  DBGRNG,
  DBGTDO,
  DBGIR,
  DBGSCREG,
  DBGTAPSM,
  DBGnTDOEN,
  DBGSDIN,
  BIGENDOUT,
  ETMBIGEND,
  ETMHIVECS,
  ETMIA,
  ETMInMREQ,
  ETMISEQ,
  ETMITBIT,
  ETMIABORT,
  ETMDA,
  ETMDMAS,
  ETMDMORE,
  ETMDnMREQ,
  ETMDnRW,
  ETMDSEQ,
  ETMRDATA,
  ETMDABORT,
  ETMCHSD,
  ETMCHSE,
  ETMnWAIT,
  ETMID31To25,
  ETMID15To11,
  ETMWDATA,
  ETMLATECANCEL,
  ETMPASS,
  ETMDBGACK,
  ETMINSTREXEC,
  ETMRNGOUT,
  ETMPROCID,
  ETMPROCIDWR,
  ETMINSTRVALID,
  GateTheCLK,
  ITCMWData,
  ITCMWEn,
  ITCMEn,
  ITCMAdrs,
  DTCMWData,
  DTCMWEn,
  DTCMEn,
  DTCMAdrs,
  SCANOUT1,
  SCANOUT2,
  SCANOUT3,
  SCANOUT4,
  HRESETn,
  HCLKEN,
  CLK,
  HGRANT,
  HRDATA,
  HREADY,
  HRESP,
  CPDIN,
  CHSDE,
  CHSEX,
  DBGEN,
  EDBGRQ,
  DBGEXT,
  DBGIEBKPT,
  DBGDEWPT,
  DBGnTRST,
  DBGTCKEN,
  DBGTDI,
  DBGTMS,
  DBGSDOUT,
  nFIQ,
  nIRQ,
  VINITHI,
  INITRAM,
  TAPID,
  DCacheSize,
  ICacheSize,
  ETMEN,
  SCANEN,
  TESTMODE,
  SCANIN1,
  SCANIN2,
  SCANIN3,
  SCANIN4,
  ETMFIFOFULL,
  UnGatedCLK,
  ITCMRData,
  DTCMRData,
  PhyDTCMSize,
  PhyITCMSize,
  CRFHBUSREQ,
  CRFHLOCK,
  CRFHADDR,
  CRFHTRANS,
  CRFHWRITE,
  CRFHSIZE,
  CRFHBURST,
  CRFHPROT,
  CRFHWDATA,
  CRFCPINSTR,
  CRFCPDOUT,
  CRFCPPASS,
  CRFCPLATECANCEL,
  CRFCPTBIT,
  CRFnCPMREQ,
  CRFnCPTRANS,
  CRFCPCLKEN,
  CRFCOMMRX,
  CRFCOMMTX,
  CRFDBGACK,
  CRFDBGRQI,
  CRFDBGINSTREXEC,
  CRFDBGRNG,
  CRFDBGTDO,
  CRFDBGIR,
  CRFDBGSCREG,
  CRFDBGTAPSM,
  CRFDBGnTDOEN,
  CRFDBGSDIN,
  CRFBIGENDOUT,
  CRFETMBIGEND,
  CRFETMHIVECS,
  CRFETMIA,
  CRFETMInMREQ,
  CRFETMISEQ,
  CRFETMITBIT,
  CRFETMIABORT,
  CRFETMDA,
  CRFETMDMAS,
  CRFETMDMORE,
  CRFETMDnMREQ,
  CRFETMDnRW,
  CRFETMDSEQ,
  CRFETMRDATA,
  CRFETMDABORT,
  CRFETMCHSD,
  CRFETMCHSE,
  CRFETMnWAIT,
  CRFETMID31To25,
  CRFETMID15To11,
  CRFETMWDATA,
  CRFETMLATECANCEL,
  CRFETMPASS,
  CRFETMDBGACK,
  CRFETMINSTREXEC,
  CRFETMRNGOUT,
  CRFETMPROCID,
  CRFETMPROCIDWR,
  CRFETMINSTRVALID,
  CRFGateTheCLK,
  CRFITCMWData,
  CRFITCMWEn,
  CRFITCMEn,
  CRFITCMAdrs,
  CRFDTCMWData,
  CRFDTCMWEn,
  CRFDTCMEn,
  CRFDTCMAdrs,
  CRFSCANOUT1,
  CRFSCANOUT2,
  CRFSCANOUT3,
  CRFSCANOUT4,
  CRFHRESETn,
  CRFHCLKEN,
  CRFCLK,
  CRFHGRANT,
  CRFHRDATA,
  CRFHREADY,
  CRFHRESP,
  CRFCPDIN,
  CRFCHSDE,
  CRFCHSEX,
  CRFDBGEN,
  CRFEDBGRQ,
  CRFDBGEXT,
  CRFDBGIEBKPT,
  CRFDBGDEWPT,
  CRFDBGnTRST,
  CRFDBGTCKEN,
  CRFDBGTDI,
  CRFDBGTMS,
  CRFDBGSDOUT,
  CRFnFIQ,
  CRFnIRQ,
  CRFVINITHI,
  CRFINITRAM,
  CRFTAPID,
  CRFDCacheSize,
  CRFICacheSize,
  CRFETMEN,
  CRFSCANEN,
  CRFTESTMODE,
  CRFSCANIN1,
  CRFSCANIN2,
  CRFSCANIN3,
  CRFSCANIN4,
  CRFETMFIFOFULL,
  CRFUnGatedCLK,
  CRFITCMRData,
  CRFDTCMRData,
  CRFPhyDTCMSize,
  CRFPhyITCMSize,
  CRFstrobe);

input HBUSREQ;
input HLOCK;
input [31:0] HADDR;
input [1:0] HTRANS;
input HWRITE;
input [2:0] HSIZE;
input [2:0] HBURST;
input [3:0] HPROT;
input [31:0] HWDATA;
input [31:0] CPINSTR;
input [31:0] CPDOUT;
input CPPASS;
input CPLATECANCEL;
input CPTBIT;
input nCPMREQ;
input nCPTRANS;
input CPCLKEN;
input COMMRX;
input COMMTX;
input DBGACK;
input DBGRQI;
input DBGINSTREXEC;
input [1:0] DBGRNG;
input DBGTDO;
input [3:0] DBGIR;
input [4:0] DBGSCREG;
input [3:0] DBGTAPSM;
input DBGnTDOEN;
input DBGSDIN;
input BIGENDOUT;
input ETMBIGEND;
input ETMHIVECS;
input [31:1] ETMIA;
input ETMInMREQ;
input ETMISEQ;
input ETMITBIT;
input ETMIABORT;
input [31:0] ETMDA;
input [1:0] ETMDMAS;
input ETMDMORE;
input ETMDnMREQ;
input ETMDnRW;
input ETMDSEQ;
input [31:0] ETMRDATA;
input ETMDABORT;
input [1:0] ETMCHSD;
input [1:0] ETMCHSE;
input ETMnWAIT;
input [31:25] ETMID31To25;
input [15:11] ETMID15To11;
input [31:0] ETMWDATA;
input ETMLATECANCEL;
input ETMPASS;
input ETMDBGACK;
input ETMINSTREXEC;
input [1:0] ETMRNGOUT;
input [31:0] ETMPROCID;
input ETMPROCIDWR;
input ETMINSTRVALID;
input GateTheCLK;
input [31:0] ITCMWData;
input [3:0] ITCMWEn;
input ITCMEn;
input [17:0] ITCMAdrs;
input [31:0] DTCMWData;
input [3:0] DTCMWEn;
input DTCMEn;
input [17:0] DTCMAdrs;
input SCANOUT1;
input SCANOUT2;
input SCANOUT3;
input SCANOUT4;
output HRESETn;
output HCLKEN;
output CLK;
output HGRANT;
output [31:0] HRDATA;
output HREADY;
output [1:0] HRESP;
output [31:0] CPDIN;
output [1:0] CHSDE;
output [1:0] CHSEX;
output DBGEN;
output EDBGRQ;
output [1:0] DBGEXT;
output DBGIEBKPT;
output DBGDEWPT;
output DBGnTRST;
output DBGTCKEN;
output DBGTDI;
output DBGTMS;
output DBGSDOUT;
output nFIQ;
output nIRQ;
output VINITHI;
output INITRAM;
output [31:0] TAPID;
output [3:0] DCacheSize;
output [3:0] ICacheSize;
output ETMEN;
output SCANEN;
output TESTMODE;
output SCANIN1;
output SCANIN2;
output SCANIN3;
output SCANIN4;
output ETMFIFOFULL;
output UnGatedCLK;
output [31:0] ITCMRData;
output [31:0] DTCMRData;
output [3:0] PhyDTCMSize;
output [3:0] PhyITCMSize;
output CRFHBUSREQ;
output CRFHLOCK;
output CRFHADDR;
output CRFHTRANS;
output CRFHWRITE;
output CRFHSIZE;
output CRFHBURST;
output CRFHPROT;
output CRFHWDATA;
output CRFCPINSTR;
output CRFCPDOUT;
output CRFCPPASS;
output CRFCPLATECANCEL;
output CRFCPTBIT;
output CRFnCPMREQ;
output CRFnCPTRANS;
output CRFCPCLKEN;
output CRFCOMMRX;
output CRFCOMMTX;
output CRFDBGACK;
output CRFDBGRQI;
output CRFDBGINSTREXEC;
output CRFDBGRNG;
output CRFDBGTDO;
output CRFDBGIR;
output CRFDBGSCREG;
output CRFDBGTAPSM;
output CRFDBGnTDOEN;
output CRFDBGSDIN;
output CRFBIGENDOUT;
output CRFETMBIGEND;
output CRFETMHIVECS;
output CRFETMIA;
output CRFETMInMREQ;
output CRFETMISEQ;
output CRFETMITBIT;
output CRFETMIABORT;
output CRFETMDA;
output CRFETMDMAS;
output CRFETMDMORE;
output CRFETMDnMREQ;
output CRFETMDnRW;
output CRFETMDSEQ;
output CRFETMRDATA;
output CRFETMDABORT;
output CRFETMCHSD;
output CRFETMCHSE;
output CRFETMnWAIT;
output CRFETMID31To25;
output CRFETMID15To11;
output CRFETMWDATA;
output CRFETMLATECANCEL;
output CRFETMPASS;
output CRFETMDBGACK;
output CRFETMINSTREXEC;
output CRFETMRNGOUT;
output CRFETMPROCID;
output CRFETMPROCIDWR;
output CRFETMINSTRVALID;
output CRFGateTheCLK;
output CRFITCMWData;
output CRFITCMWEn;
output CRFITCMEn;
output CRFITCMAdrs;
output CRFDTCMWData;
output CRFDTCMWEn;
output CRFDTCMEn;
output CRFDTCMAdrs;
output CRFSCANOUT1;
output CRFSCANOUT2;
output CRFSCANOUT3;
output CRFSCANOUT4;
output CRFHRESETn;
output CRFHCLKEN;
output CRFCLK;
output CRFHGRANT;
output CRFHRDATA;
output CRFHREADY;
output CRFHRESP;
output CRFCPDIN;
output CRFCHSDE;
output CRFCHSEX;
output CRFDBGEN;
output CRFEDBGRQ;
output CRFDBGEXT;
output CRFDBGIEBKPT;
output CRFDBGDEWPT;
output CRFDBGnTRST;
output CRFDBGTCKEN;
output CRFDBGTDI;
output CRFDBGTMS;
output CRFDBGSDOUT;
output CRFnFIQ;
output CRFnIRQ;
output CRFVINITHI;
output CRFINITRAM;
output CRFTAPID;
output CRFDCacheSize;
output CRFICacheSize;
output CRFETMEN;
output CRFSCANEN;
output CRFTESTMODE;
output CRFSCANIN1;
output CRFSCANIN2;
output CRFSCANIN3;
output CRFSCANIN4;
output CRFETMFIFOFULL;
output CRFUnGatedCLK;
output CRFITCMRData;
output CRFDTCMRData;
output CRFPhyDTCMSize;
output CRFPhyITCMSize;
output CRFstrobe;

reg CRFHBUSREQ;
reg CRFHLOCK;
reg CRFHADDR;
reg CRFHTRANS;
reg CRFHWRITE;
reg CRFHSIZE;
reg CRFHBURST;
reg CRFHPROT;
reg CRFHWDATA;
reg CRFCPINSTR;
reg CRFCPDOUT;
reg CRFCPPASS;
reg CRFCPLATECANCEL;
reg CRFCPTBIT;
reg CRFnCPMREQ;
reg CRFnCPTRANS;
reg CRFCPCLKEN;
reg CRFCOMMRX;
reg CRFCOMMTX;
reg CRFDBGACK;
reg CRFDBGRQI;
reg CRFDBGINSTREXEC;
reg CRFDBGRNG;
reg CRFDBGTDO;
reg CRFDBGIR;
reg CRFDBGSCREG;
reg CRFDBGTAPSM;
reg CRFDBGnTDOEN;
reg CRFDBGSDIN;
reg CRFBIGENDOUT;
reg CRFETMBIGEND;
reg CRFETMHIVECS;
reg CRFETMIA;
reg CRFETMInMREQ;
reg CRFETMISEQ;
reg CRFETMITBIT;
reg CRFETMIABORT;
reg CRFETMDA;
reg CRFETMDMAS;
reg CRFETMDMORE;
reg CRFETMDnMREQ;
reg CRFETMDnRW;
reg CRFETMDSEQ;
reg CRFETMRDATA;
reg CRFETMDABORT;
reg CRFETMCHSD;
reg CRFETMCHSE;
reg CRFETMnWAIT;
reg CRFETMID31To25;
reg CRFETMID15To11;
reg CRFETMWDATA;
reg CRFETMLATECANCEL;
reg CRFETMPASS;
reg CRFETMDBGACK;
reg CRFETMINSTREXEC;
reg CRFETMRNGOUT;
reg CRFETMPROCID;
reg CRFETMPROCIDWR;
reg CRFETMINSTRVALID;
reg CRFGateTheCLK;
reg CRFITCMWData;
reg CRFITCMWEn;
reg CRFITCMEn;
reg CRFITCMAdrs;
reg CRFDTCMWData;
reg CRFDTCMWEn;
reg CRFDTCMEn;
reg CRFDTCMAdrs;
reg CRFSCANOUT1;
reg CRFSCANOUT2;
reg CRFSCANOUT3;
reg CRFSCANOUT4;
reg HRESETn;
reg CRFHRESETn;
reg HCLKEN;
reg CRFHCLKEN;
reg CLK;
reg CRFCLK;
reg HGRANT;
reg CRFHGRANT;
reg [31:0] HRDATA;
reg CRFHRDATA;
reg HREADY;
reg CRFHREADY;
reg [1:0] HRESP;
reg CRFHRESP;
reg [31:0] CPDIN;
reg CRFCPDIN;
reg [1:0] CHSDE;
reg CRFCHSDE;
reg [1:0] CHSEX;
reg CRFCHSEX;
reg DBGEN;
reg CRFDBGEN;
reg EDBGRQ;
reg CRFEDBGRQ;
reg [1:0] DBGEXT;
reg CRFDBGEXT;
reg DBGIEBKPT;
reg CRFDBGIEBKPT;
reg DBGDEWPT;
reg CRFDBGDEWPT;
reg DBGnTRST;
reg CRFDBGnTRST;
reg DBGTCKEN;
reg CRFDBGTCKEN;
reg DBGTDI;
reg CRFDBGTDI;
reg DBGTMS;
reg CRFDBGTMS;
reg DBGSDOUT;
reg CRFDBGSDOUT;
reg nFIQ;
reg CRFnFIQ;
reg nIRQ;
reg CRFnIRQ;
reg VINITHI;
reg CRFVINITHI;
reg INITRAM;
reg CRFINITRAM;
reg [31:0] TAPID;
reg CRFTAPID;
reg [3:0] DCacheSize;
reg CRFDCacheSize;
reg [3:0] ICacheSize;
reg CRFICacheSize;
reg ETMEN;
reg CRFETMEN;
reg SCANEN;
reg CRFSCANEN;
reg TESTMODE;
reg CRFTESTMODE;
reg SCANIN1;
reg CRFSCANIN1;
reg SCANIN2;
reg CRFSCANIN2;
reg SCANIN3;
reg CRFSCANIN3;
reg SCANIN4;
reg CRFSCANIN4;
reg ETMFIFOFULL;
reg CRFETMFIFOFULL;
reg UnGatedCLK;
reg CRFUnGatedCLK;
reg [31:0] ITCMRData;
reg CRFITCMRData;
reg [31:0] DTCMRData;
reg CRFDTCMRData;
reg [3:0] PhyDTCMSize;
reg CRFPhyDTCMSize;
reg [3:0] PhyITCMSize;
reg CRFPhyITCMSize;
reg CRFstrobe;
initial
  begin
    $mm("ARM946E_88CRFTESTER?rev=r1_crftester",HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize,
    CRFHBUSREQ, CRFHBUSREQ,
    CRFHLOCK, CRFHLOCK,
    CRFHADDR, CRFHADDR,
    CRFHTRANS, CRFHTRANS,
    CRFHWRITE, CRFHWRITE,
    CRFHSIZE, CRFHSIZE,
    CRFHBURST, CRFHBURST,
    CRFHPROT, CRFHPROT,
    CRFHWDATA, CRFHWDATA,
    CRFCPINSTR, CRFCPINSTR,
    CRFCPDOUT, CRFCPDOUT,
    CRFCPPASS, CRFCPPASS,
    CRFCPLATECANCEL, CRFCPLATECANCEL,
    CRFCPTBIT, CRFCPTBIT,
    CRFnCPMREQ, CRFnCPMREQ,
    CRFnCPTRANS, CRFnCPTRANS,
    CRFCPCLKEN, CRFCPCLKEN,
    CRFCOMMRX, CRFCOMMRX,
    CRFCOMMTX, CRFCOMMTX,
    CRFDBGACK, CRFDBGACK,
    CRFDBGRQI, CRFDBGRQI,
    CRFDBGINSTREXEC, CRFDBGINSTREXEC,
    CRFDBGRNG, CRFDBGRNG,
    CRFDBGTDO, CRFDBGTDO,
    CRFDBGIR, CRFDBGIR,
    CRFDBGSCREG, CRFDBGSCREG,
    CRFDBGTAPSM, CRFDBGTAPSM,
    CRFDBGnTDOEN, CRFDBGnTDOEN,
    CRFDBGSDIN, CRFDBGSDIN,
    CRFBIGENDOUT, CRFBIGENDOUT,
    CRFETMBIGEND, CRFETMBIGEND,
    CRFETMHIVECS, CRFETMHIVECS,
    CRFETMIA, CRFETMIA,
    CRFETMInMREQ, CRFETMInMREQ,
    CRFETMISEQ, CRFETMISEQ,
    CRFETMITBIT, CRFETMITBIT,
    CRFETMIABORT, CRFETMIABORT,
    CRFETMDA, CRFETMDA,
    CRFETMDMAS, CRFETMDMAS,
    CRFETMDMORE, CRFETMDMORE,
    CRFETMDnMREQ, CRFETMDnMREQ,
    CRFETMDnRW, CRFETMDnRW,
    CRFETMDSEQ, CRFETMDSEQ,
    CRFETMRDATA, CRFETMRDATA,
    CRFETMDABORT, CRFETMDABORT,
    CRFETMCHSD, CRFETMCHSD,
    CRFETMCHSE, CRFETMCHSE,
    CRFETMnWAIT, CRFETMnWAIT,
    CRFETMID31To25, CRFETMID31To25,
    CRFETMID15To11, CRFETMID15To11,
    CRFETMWDATA, CRFETMWDATA,
    CRFETMLATECANCEL, CRFETMLATECANCEL,
    CRFETMPASS, CRFETMPASS,
    CRFETMDBGACK, CRFETMDBGACK,
    CRFETMINSTREXEC, CRFETMINSTREXEC,
    CRFETMRNGOUT, CRFETMRNGOUT,
    CRFETMPROCID, CRFETMPROCID,
    CRFETMPROCIDWR, CRFETMPROCIDWR,
    CRFETMINSTRVALID, CRFETMINSTRVALID,
    CRFGateTheCLK, CRFGateTheCLK,
    CRFITCMWData, CRFITCMWData,
    CRFITCMWEn, CRFITCMWEn,
    CRFITCMEn, CRFITCMEn,
    CRFITCMAdrs, CRFITCMAdrs,
    CRFDTCMWData, CRFDTCMWData,
    CRFDTCMWEn, CRFDTCMWEn,
    CRFDTCMEn, CRFDTCMEn,
    CRFDTCMAdrs, CRFDTCMAdrs,
    CRFSCANOUT1, CRFSCANOUT1,
    CRFSCANOUT2, CRFSCANOUT2,
    CRFSCANOUT3, CRFSCANOUT3,
    CRFSCANOUT4, CRFSCANOUT4,
    CRFHRESETn, CRFHRESETn,
    CRFHCLKEN, CRFHCLKEN,
    CRFCLK, CRFCLK,
    CRFHGRANT, CRFHGRANT,
    CRFHRDATA, CRFHRDATA,
    CRFHREADY, CRFHREADY,
    CRFHRESP, CRFHRESP,
    CRFCPDIN, CRFCPDIN,
    CRFCHSDE, CRFCHSDE,
    CRFCHSEX, CRFCHSEX,
    CRFDBGEN, CRFDBGEN,
    CRFEDBGRQ, CRFEDBGRQ,
    CRFDBGEXT, CRFDBGEXT,
    CRFDBGIEBKPT, CRFDBGIEBKPT,
    CRFDBGDEWPT, CRFDBGDEWPT,
    CRFDBGnTRST, CRFDBGnTRST,
    CRFDBGTCKEN, CRFDBGTCKEN,
    CRFDBGTDI, CRFDBGTDI,
    CRFDBGTMS, CRFDBGTMS,
    CRFDBGSDOUT, CRFDBGSDOUT,
    CRFnFIQ, CRFnFIQ,
    CRFnIRQ, CRFnIRQ,
    CRFVINITHI, CRFVINITHI,
    CRFINITRAM, CRFINITRAM,
    CRFTAPID, CRFTAPID,
    CRFDCacheSize, CRFDCacheSize,
    CRFICacheSize, CRFICacheSize,
    CRFETMEN, CRFETMEN,
    CRFSCANEN, CRFSCANEN,
    CRFTESTMODE, CRFTESTMODE,
    CRFSCANIN1, CRFSCANIN1,
    CRFSCANIN2, CRFSCANIN2,
    CRFSCANIN3, CRFSCANIN3,
    CRFSCANIN4, CRFSCANIN4,
    CRFETMFIFOFULL, CRFETMFIFOFULL,
    CRFUnGatedCLK, CRFUnGatedCLK,
    CRFITCMRData, CRFITCMRData,
    CRFDTCMRData, CRFDTCMRData,
    CRFPhyDTCMSize, CRFPhyDTCMSize,
    CRFPhyITCMSize, CRFPhyITCMSize,
    CRFstrobe, CRFstrobe);
  end

endmodule

// Timing shell

module ARM946E_88CRFTESTER_timing (HBUSREQ,
  HLOCK,
  HADDR,
  HTRANS,
  HWRITE,
  HSIZE,
  HBURST,
  HPROT,
  HWDATA,
  CPINSTR,
  CPDOUT,
  CPPASS,
  CPLATECANCEL,
  CPTBIT,
  nCPMREQ,
  nCPTRANS,
  CPCLKEN,
  COMMRX,
  COMMTX,
  DBGACK,
  DBGRQI,
  DBGINSTREXEC,
  DBGRNG,
  DBGTDO,
  DBGIR,
  DBGSCREG,
  DBGTAPSM,
  DBGnTDOEN,
  DBGSDIN,
  BIGENDOUT,
  ETMBIGEND,
  ETMHIVECS,
  ETMIA,
  ETMInMREQ,
  ETMISEQ,
  ETMITBIT,
  ETMIABORT,
  ETMDA,
  ETMDMAS,
  ETMDMORE,
  ETMDnMREQ,
  ETMDnRW,
  ETMDSEQ,
  ETMRDATA,
  ETMDABORT,
  ETMCHSD,
  ETMCHSE,
  ETMnWAIT,
  ETMID31To25,
  ETMID15To11,
  ETMWDATA,
  ETMLATECANCEL,
  ETMPASS,
  ETMDBGACK,
  ETMINSTREXEC,
  ETMRNGOUT,
  ETMPROCID,
  ETMPROCIDWR,
  ETMINSTRVALID,
  GateTheCLK,
  ITCMWData,
  ITCMWEn,
  ITCMEn,
  ITCMAdrs,
  DTCMWData,
  DTCMWEn,
  DTCMEn,
  DTCMAdrs,
  SCANOUT1,
  SCANOUT2,
  SCANOUT3,
  SCANOUT4,
  HRESETn,
  HCLKEN,
  CLK,
  HGRANT,
  HRDATA,
  HREADY,
  HRESP,
  CPDIN,
  CHSDE,
  CHSEX,
  DBGEN,
  EDBGRQ,
  DBGEXT,
  DBGIEBKPT,
  DBGDEWPT,
  DBGnTRST,
  DBGTCKEN,
  DBGTDI,
  DBGTMS,
  DBGSDOUT,
  nFIQ,
  nIRQ,
  VINITHI,
  INITRAM,
  TAPID,
  DCacheSize,
  ICacheSize,
  ETMEN,
  SCANEN,
  TESTMODE,
  SCANIN1,
  SCANIN2,
  SCANIN3,
  SCANIN4,
  ETMFIFOFULL,
  UnGatedCLK,
  ITCMRData,
  DTCMRData,
  PhyDTCMSize,
  PhyITCMSize,
  CRFHBUSREQ, CRFHBUSREQXMGXOUT,
  CRFHLOCK, CRFHLOCKXMGXOUT,
  CRFHADDR, CRFHADDRXMGXOUT,
  CRFHTRANS, CRFHTRANSXMGXOUT,
  CRFHWRITE, CRFHWRITEXMGXOUT,
  CRFHSIZE, CRFHSIZEXMGXOUT,
  CRFHBURST, CRFHBURSTXMGXOUT,
  CRFHPROT, CRFHPROTXMGXOUT,
  CRFHWDATA, CRFHWDATAXMGXOUT,
  CRFCPINSTR, CRFCPINSTRXMGXOUT,
  CRFCPDOUT, CRFCPDOUTXMGXOUT,
  CRFCPPASS, CRFCPPASSXMGXOUT,
  CRFCPLATECANCEL, CRFCPLATECANCELXMGXOUT,
  CRFCPTBIT, CRFCPTBITXMGXOUT,
  CRFnCPMREQ, CRFnCPMREQXMGXOUT,
  CRFnCPTRANS, CRFnCPTRANSXMGXOUT,
  CRFCPCLKEN, CRFCPCLKENXMGXOUT,
  CRFCOMMRX, CRFCOMMRXXMGXOUT,
  CRFCOMMTX, CRFCOMMTXXMGXOUT,
  CRFDBGACK, CRFDBGACKXMGXOUT,
  CRFDBGRQI, CRFDBGRQIXMGXOUT,
  CRFDBGINSTREXEC, CRFDBGINSTREXECXMGXOUT,
  CRFDBGRNG, CRFDBGRNGXMGXOUT,
  CRFDBGTDO, CRFDBGTDOXMGXOUT,
  CRFDBGIR, CRFDBGIRXMGXOUT,
  CRFDBGSCREG, CRFDBGSCREGXMGXOUT,
  CRFDBGTAPSM, CRFDBGTAPSMXMGXOUT,
  CRFDBGnTDOEN, CRFDBGnTDOENXMGXOUT,
  CRFDBGSDIN, CRFDBGSDINXMGXOUT,
  CRFBIGENDOUT, CRFBIGENDOUTXMGXOUT,
  CRFETMBIGEND, CRFETMBIGENDXMGXOUT,
  CRFETMHIVECS, CRFETMHIVECSXMGXOUT,
  CRFETMIA, CRFETMIAXMGXOUT,
  CRFETMInMREQ, CRFETMInMREQXMGXOUT,
  CRFETMISEQ, CRFETMISEQXMGXOUT,
  CRFETMITBIT, CRFETMITBITXMGXOUT,
  CRFETMIABORT, CRFETMIABORTXMGXOUT,
  CRFETMDA, CRFETMDAXMGXOUT,
  CRFETMDMAS, CRFETMDMASXMGXOUT,
  CRFETMDMORE, CRFETMDMOREXMGXOUT,
  CRFETMDnMREQ, CRFETMDnMREQXMGXOUT,
  CRFETMDnRW, CRFETMDnRWXMGXOUT,
  CRFETMDSEQ, CRFETMDSEQXMGXOUT,
  CRFETMRDATA, CRFETMRDATAXMGXOUT,
  CRFETMDABORT, CRFETMDABORTXMGXOUT,
  CRFETMCHSD, CRFETMCHSDXMGXOUT,
  CRFETMCHSE, CRFETMCHSEXMGXOUT,
  CRFETMnWAIT, CRFETMnWAITXMGXOUT,
  CRFETMID31To25, CRFETMID31To25XMGXOUT,
  CRFETMID15To11, CRFETMID15To11XMGXOUT,
  CRFETMWDATA, CRFETMWDATAXMGXOUT,
  CRFETMLATECANCEL, CRFETMLATECANCELXMGXOUT,
  CRFETMPASS, CRFETMPASSXMGXOUT,
  CRFETMDBGACK, CRFETMDBGACKXMGXOUT,
  CRFETMINSTREXEC, CRFETMINSTREXECXMGXOUT,
  CRFETMRNGOUT, CRFETMRNGOUTXMGXOUT,
  CRFETMPROCID, CRFETMPROCIDXMGXOUT,
  CRFETMPROCIDWR, CRFETMPROCIDWRXMGXOUT,
  CRFETMINSTRVALID, CRFETMINSTRVALIDXMGXOUT,
  CRFGateTheCLK, CRFGateTheCLKXMGXOUT,
  CRFITCMWData, CRFITCMWDataXMGXOUT,
  CRFITCMWEn, CRFITCMWEnXMGXOUT,
  CRFITCMEn, CRFITCMEnXMGXOUT,
  CRFITCMAdrs, CRFITCMAdrsXMGXOUT,
  CRFDTCMWData, CRFDTCMWDataXMGXOUT,
  CRFDTCMWEn, CRFDTCMWEnXMGXOUT,
  CRFDTCMEn, CRFDTCMEnXMGXOUT,
  CRFDTCMAdrs, CRFDTCMAdrsXMGXOUT,
  CRFSCANOUT1, CRFSCANOUT1XMGXOUT,
  CRFSCANOUT2, CRFSCANOUT2XMGXOUT,
  CRFSCANOUT3, CRFSCANOUT3XMGXOUT,
  CRFSCANOUT4, CRFSCANOUT4XMGXOUT,
  CRFHRESETn, CRFHRESETnXMGXOUT,
  CRFHCLKEN, CRFHCLKENXMGXOUT,
  CRFCLK, CRFCLKXMGXOUT,
  CRFHGRANT, CRFHGRANTXMGXOUT,
  CRFHRDATA, CRFHRDATAXMGXOUT,
  CRFHREADY, CRFHREADYXMGXOUT,
  CRFHRESP, CRFHRESPXMGXOUT,
  CRFCPDIN, CRFCPDINXMGXOUT,
  CRFCHSDE, CRFCHSDEXMGXOUT,
  CRFCHSEX, CRFCHSEXXMGXOUT,
  CRFDBGEN, CRFDBGENXMGXOUT,
  CRFEDBGRQ, CRFEDBGRQXMGXOUT,
  CRFDBGEXT, CRFDBGEXTXMGXOUT,
  CRFDBGIEBKPT, CRFDBGIEBKPTXMGXOUT,
  CRFDBGDEWPT, CRFDBGDEWPTXMGXOUT,
  CRFDBGnTRST, CRFDBGnTRSTXMGXOUT,
  CRFDBGTCKEN, CRFDBGTCKENXMGXOUT,
  CRFDBGTDI, CRFDBGTDIXMGXOUT,
  CRFDBGTMS, CRFDBGTMSXMGXOUT,
  CRFDBGSDOUT, CRFDBGSDOUTXMGXOUT,
  CRFnFIQ, CRFnFIQXMGXOUT,
  CRFnIRQ, CRFnIRQXMGXOUT,
  CRFVINITHI, CRFVINITHIXMGXOUT,
  CRFINITRAM, CRFINITRAMXMGXOUT,
  CRFTAPID, CRFTAPIDXMGXOUT,
  CRFDCacheSize, CRFDCacheSizeXMGXOUT,
  CRFICacheSize, CRFICacheSizeXMGXOUT,
  CRFETMEN, CRFETMENXMGXOUT,
  CRFSCANEN, CRFSCANENXMGXOUT,
  CRFTESTMODE, CRFTESTMODEXMGXOUT,
  CRFSCANIN1, CRFSCANIN1XMGXOUT,
  CRFSCANIN2, CRFSCANIN2XMGXOUT,
  CRFSCANIN3, CRFSCANIN3XMGXOUT,
  CRFSCANIN4, CRFSCANIN4XMGXOUT,
  CRFETMFIFOFULL, CRFETMFIFOFULLXMGXOUT,
  CRFUnGatedCLK, CRFUnGatedCLKXMGXOUT,
  CRFITCMRData, CRFITCMRDataXMGXOUT,
  CRFDTCMRData, CRFDTCMRDataXMGXOUT,
  CRFPhyDTCMSize, CRFPhyDTCMSizeXMGXOUT,
  CRFPhyITCMSize, CRFPhyITCMSizeXMGXOUT,
  CRFstrobe, CRFstrobeXMGXOUT);

input HBUSREQ;
input HLOCK;
input [31:0] HADDR;
input [1:0] HTRANS;
input HWRITE;
input [2:0] HSIZE;
input [2:0] HBURST;
input [3:0] HPROT;
input [31:0] HWDATA;
input [31:0] CPINSTR;
input [31:0] CPDOUT;
input CPPASS;
input CPLATECANCEL;
input CPTBIT;
input nCPMREQ;
input nCPTRANS;
input CPCLKEN;
input COMMRX;
input COMMTX;
input DBGACK;
input DBGRQI;
input DBGINSTREXEC;
input [1:0] DBGRNG;
input DBGTDO;
input [3:0] DBGIR;
input [4:0] DBGSCREG;
input [3:0] DBGTAPSM;
input DBGnTDOEN;
input DBGSDIN;
input BIGENDOUT;
input ETMBIGEND;
input ETMHIVECS;
input [31:1] ETMIA;
input ETMInMREQ;
input ETMISEQ;
input ETMITBIT;
input ETMIABORT;
input [31:0] ETMDA;
input [1:0] ETMDMAS;
input ETMDMORE;
input ETMDnMREQ;
input ETMDnRW;
input ETMDSEQ;
input [31:0] ETMRDATA;
input ETMDABORT;
input [1:0] ETMCHSD;
input [1:0] ETMCHSE;
input ETMnWAIT;
input [31:25] ETMID31To25;
input [15:11] ETMID15To11;
input [31:0] ETMWDATA;
input ETMLATECANCEL;
input ETMPASS;
input ETMDBGACK;
input ETMINSTREXEC;
input [1:0] ETMRNGOUT;
input [31:0] ETMPROCID;
input ETMPROCIDWR;
input ETMINSTRVALID;
input GateTheCLK;
input [31:0] ITCMWData;
input [3:0] ITCMWEn;
input ITCMEn;
input [17:0] ITCMAdrs;
input [31:0] DTCMWData;
input [3:0] DTCMWEn;
input DTCMEn;
input [17:0] DTCMAdrs;
input SCANOUT1;
input SCANOUT2;
input SCANOUT3;
input SCANOUT4;
output HRESETn;
output HCLKEN;
output CLK;
output HGRANT;
output [31:0] HRDATA;
output HREADY;
output [1:0] HRESP;
output [31:0] CPDIN;
output [1:0] CHSDE;
output [1:0] CHSEX;
output DBGEN;
output EDBGRQ;
output [1:0] DBGEXT;
output DBGIEBKPT;
output DBGDEWPT;
output DBGnTRST;
output DBGTCKEN;
output DBGTDI;
output DBGTMS;
output DBGSDOUT;
output nFIQ;
output nIRQ;
output VINITHI;
output INITRAM;
output [31:0] TAPID;
output [3:0] DCacheSize;
output [3:0] ICacheSize;
output ETMEN;
output SCANEN;
output TESTMODE;
output SCANIN1;
output SCANIN2;
output SCANIN3;
output SCANIN4;
output ETMFIFOFULL;
output UnGatedCLK;
output [31:0] ITCMRData;
output [31:0] DTCMRData;
output [3:0] PhyDTCMSize;
output [3:0] PhyITCMSize;
input CRFHBUSREQ;
output CRFHBUSREQXMGXOUT;
input CRFHLOCK;
output CRFHLOCKXMGXOUT;
input CRFHADDR;
output CRFHADDRXMGXOUT;
input CRFHTRANS;
output CRFHTRANSXMGXOUT;
input CRFHWRITE;
output CRFHWRITEXMGXOUT;
input CRFHSIZE;
output CRFHSIZEXMGXOUT;
input CRFHBURST;
output CRFHBURSTXMGXOUT;
input CRFHPROT;
output CRFHPROTXMGXOUT;
input CRFHWDATA;
output CRFHWDATAXMGXOUT;
input CRFCPINSTR;
output CRFCPINSTRXMGXOUT;
input CRFCPDOUT;
output CRFCPDOUTXMGXOUT;
input CRFCPPASS;
output CRFCPPASSXMGXOUT;
input CRFCPLATECANCEL;
output CRFCPLATECANCELXMGXOUT;
input CRFCPTBIT;
output CRFCPTBITXMGXOUT;
input CRFnCPMREQ;
output CRFnCPMREQXMGXOUT;
input CRFnCPTRANS;
output CRFnCPTRANSXMGXOUT;
input CRFCPCLKEN;
output CRFCPCLKENXMGXOUT;
input CRFCOMMRX;
output CRFCOMMRXXMGXOUT;
input CRFCOMMTX;
output CRFCOMMTXXMGXOUT;
input CRFDBGACK;
output CRFDBGACKXMGXOUT;
input CRFDBGRQI;
output CRFDBGRQIXMGXOUT;
input CRFDBGINSTREXEC;
output CRFDBGINSTREXECXMGXOUT;
input CRFDBGRNG;
output CRFDBGRNGXMGXOUT;
input CRFDBGTDO;
output CRFDBGTDOXMGXOUT;
input CRFDBGIR;
output CRFDBGIRXMGXOUT;
input CRFDBGSCREG;
output CRFDBGSCREGXMGXOUT;
input CRFDBGTAPSM;
output CRFDBGTAPSMXMGXOUT;
input CRFDBGnTDOEN;
output CRFDBGnTDOENXMGXOUT;
input CRFDBGSDIN;
output CRFDBGSDINXMGXOUT;
input CRFBIGENDOUT;
output CRFBIGENDOUTXMGXOUT;
input CRFETMBIGEND;
output CRFETMBIGENDXMGXOUT;
input CRFETMHIVECS;
output CRFETMHIVECSXMGXOUT;
input CRFETMIA;
output CRFETMIAXMGXOUT;
input CRFETMInMREQ;
output CRFETMInMREQXMGXOUT;
input CRFETMISEQ;
output CRFETMISEQXMGXOUT;
input CRFETMITBIT;
output CRFETMITBITXMGXOUT;
input CRFETMIABORT;
output CRFETMIABORTXMGXOUT;
input CRFETMDA;
output CRFETMDAXMGXOUT;
input CRFETMDMAS;
output CRFETMDMASXMGXOUT;
input CRFETMDMORE;
output CRFETMDMOREXMGXOUT;
input CRFETMDnMREQ;
output CRFETMDnMREQXMGXOUT;
input CRFETMDnRW;
output CRFETMDnRWXMGXOUT;
input CRFETMDSEQ;
output CRFETMDSEQXMGXOUT;
input CRFETMRDATA;
output CRFETMRDATAXMGXOUT;
input CRFETMDABORT;
output CRFETMDABORTXMGXOUT;
input CRFETMCHSD;
output CRFETMCHSDXMGXOUT;
input CRFETMCHSE;
output CRFETMCHSEXMGXOUT;
input CRFETMnWAIT;
output CRFETMnWAITXMGXOUT;
input CRFETMID31To25;
output CRFETMID31To25XMGXOUT;
input CRFETMID15To11;
output CRFETMID15To11XMGXOUT;
input CRFETMWDATA;
output CRFETMWDATAXMGXOUT;
input CRFETMLATECANCEL;
output CRFETMLATECANCELXMGXOUT;
input CRFETMPASS;
output CRFETMPASSXMGXOUT;
input CRFETMDBGACK;
output CRFETMDBGACKXMGXOUT;
input CRFETMINSTREXEC;
output CRFETMINSTREXECXMGXOUT;
input CRFETMRNGOUT;
output CRFETMRNGOUTXMGXOUT;
input CRFETMPROCID;
output CRFETMPROCIDXMGXOUT;
input CRFETMPROCIDWR;
output CRFETMPROCIDWRXMGXOUT;
input CRFETMINSTRVALID;
output CRFETMINSTRVALIDXMGXOUT;
input CRFGateTheCLK;
output CRFGateTheCLKXMGXOUT;
input CRFITCMWData;
output CRFITCMWDataXMGXOUT;
input CRFITCMWEn;
output CRFITCMWEnXMGXOUT;
input CRFITCMEn;
output CRFITCMEnXMGXOUT;
input CRFITCMAdrs;
output CRFITCMAdrsXMGXOUT;
input CRFDTCMWData;
output CRFDTCMWDataXMGXOUT;
input CRFDTCMWEn;
output CRFDTCMWEnXMGXOUT;
input CRFDTCMEn;
output CRFDTCMEnXMGXOUT;
input CRFDTCMAdrs;
output CRFDTCMAdrsXMGXOUT;
input CRFSCANOUT1;
output CRFSCANOUT1XMGXOUT;
input CRFSCANOUT2;
output CRFSCANOUT2XMGXOUT;
input CRFSCANOUT3;
output CRFSCANOUT3XMGXOUT;
input CRFSCANOUT4;
output CRFSCANOUT4XMGXOUT;
input CRFHRESETn;
output CRFHRESETnXMGXOUT;
input CRFHCLKEN;
output CRFHCLKENXMGXOUT;
input CRFCLK;
output CRFCLKXMGXOUT;
input CRFHGRANT;
output CRFHGRANTXMGXOUT;
input CRFHRDATA;
output CRFHRDATAXMGXOUT;
input CRFHREADY;
output CRFHREADYXMGXOUT;
input CRFHRESP;
output CRFHRESPXMGXOUT;
input CRFCPDIN;
output CRFCPDINXMGXOUT;
input CRFCHSDE;
output CRFCHSDEXMGXOUT;
input CRFCHSEX;
output CRFCHSEXXMGXOUT;
input CRFDBGEN;
output CRFDBGENXMGXOUT;
input CRFEDBGRQ;
output CRFEDBGRQXMGXOUT;
input CRFDBGEXT;
output CRFDBGEXTXMGXOUT;
input CRFDBGIEBKPT;
output CRFDBGIEBKPTXMGXOUT;
input CRFDBGDEWPT;
output CRFDBGDEWPTXMGXOUT;
input CRFDBGnTRST;
output CRFDBGnTRSTXMGXOUT;
input CRFDBGTCKEN;
output CRFDBGTCKENXMGXOUT;
input CRFDBGTDI;
output CRFDBGTDIXMGXOUT;
input CRFDBGTMS;
output CRFDBGTMSXMGXOUT;
input CRFDBGSDOUT;
output CRFDBGSDOUTXMGXOUT;
input CRFnFIQ;
output CRFnFIQXMGXOUT;
input CRFnIRQ;
output CRFnIRQXMGXOUT;
input CRFVINITHI;
output CRFVINITHIXMGXOUT;
input CRFINITRAM;
output CRFINITRAMXMGXOUT;
input CRFTAPID;
output CRFTAPIDXMGXOUT;
input CRFDCacheSize;
output CRFDCacheSizeXMGXOUT;
input CRFICacheSize;
output CRFICacheSizeXMGXOUT;
input CRFETMEN;
output CRFETMENXMGXOUT;
input CRFSCANEN;
output CRFSCANENXMGXOUT;
input CRFTESTMODE;
output CRFTESTMODEXMGXOUT;
input CRFSCANIN1;
output CRFSCANIN1XMGXOUT;
input CRFSCANIN2;
output CRFSCANIN2XMGXOUT;
input CRFSCANIN3;
output CRFSCANIN3XMGXOUT;
input CRFSCANIN4;
output CRFSCANIN4XMGXOUT;
input CRFETMFIFOFULL;
output CRFETMFIFOFULLXMGXOUT;
input CRFUnGatedCLK;
output CRFUnGatedCLKXMGXOUT;
input CRFITCMRData;
output CRFITCMRDataXMGXOUT;
input CRFDTCMRData;
output CRFDTCMRDataXMGXOUT;
input CRFPhyDTCMSize;
output CRFPhyDTCMSizeXMGXOUT;
input CRFPhyITCMSize;
output CRFPhyITCMSizeXMGXOUT;
input CRFstrobe;
output CRFstrobeXMGXOUT;


ARM946E_88CRFTESTER_inout theinout (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize,
    CRFHBUSREQXMGXOUT,
    CRFHLOCKXMGXOUT,
    CRFHADDRXMGXOUT,
    CRFHTRANSXMGXOUT,
    CRFHWRITEXMGXOUT,
    CRFHSIZEXMGXOUT,
    CRFHBURSTXMGXOUT,
    CRFHPROTXMGXOUT,
    CRFHWDATAXMGXOUT,
    CRFCPINSTRXMGXOUT,
    CRFCPDOUTXMGXOUT,
    CRFCPPASSXMGXOUT,
    CRFCPLATECANCELXMGXOUT,
    CRFCPTBITXMGXOUT,
    CRFnCPMREQXMGXOUT,
    CRFnCPTRANSXMGXOUT,
    CRFCPCLKENXMGXOUT,
    CRFCOMMRXXMGXOUT,
    CRFCOMMTXXMGXOUT,
    CRFDBGACKXMGXOUT,
    CRFDBGRQIXMGXOUT,
    CRFDBGINSTREXECXMGXOUT,
    CRFDBGRNGXMGXOUT,
    CRFDBGTDOXMGXOUT,
    CRFDBGIRXMGXOUT,
    CRFDBGSCREGXMGXOUT,
    CRFDBGTAPSMXMGXOUT,
    CRFDBGnTDOENXMGXOUT,
    CRFDBGSDINXMGXOUT,
    CRFBIGENDOUTXMGXOUT,
    CRFETMBIGENDXMGXOUT,
    CRFETMHIVECSXMGXOUT,
    CRFETMIAXMGXOUT,
    CRFETMInMREQXMGXOUT,
    CRFETMISEQXMGXOUT,
    CRFETMITBITXMGXOUT,
    CRFETMIABORTXMGXOUT,
    CRFETMDAXMGXOUT,
    CRFETMDMASXMGXOUT,
    CRFETMDMOREXMGXOUT,
    CRFETMDnMREQXMGXOUT,
    CRFETMDnRWXMGXOUT,
    CRFETMDSEQXMGXOUT,
    CRFETMRDATAXMGXOUT,
    CRFETMDABORTXMGXOUT,
    CRFETMCHSDXMGXOUT,
    CRFETMCHSEXMGXOUT,
    CRFETMnWAITXMGXOUT,
    CRFETMID31To25XMGXOUT,
    CRFETMID15To11XMGXOUT,
    CRFETMWDATAXMGXOUT,
    CRFETMLATECANCELXMGXOUT,
    CRFETMPASSXMGXOUT,
    CRFETMDBGACKXMGXOUT,
    CRFETMINSTREXECXMGXOUT,
    CRFETMRNGOUTXMGXOUT,
    CRFETMPROCIDXMGXOUT,
    CRFETMPROCIDWRXMGXOUT,
    CRFETMINSTRVALIDXMGXOUT,
    CRFGateTheCLKXMGXOUT,
    CRFITCMWDataXMGXOUT,
    CRFITCMWEnXMGXOUT,
    CRFITCMEnXMGXOUT,
    CRFITCMAdrsXMGXOUT,
    CRFDTCMWDataXMGXOUT,
    CRFDTCMWEnXMGXOUT,
    CRFDTCMEnXMGXOUT,
    CRFDTCMAdrsXMGXOUT,
    CRFSCANOUT1XMGXOUT,
    CRFSCANOUT2XMGXOUT,
    CRFSCANOUT3XMGXOUT,
    CRFSCANOUT4XMGXOUT,
    CRFHRESETnXMGXOUT,
    CRFHCLKENXMGXOUT,
    CRFCLKXMGXOUT,
    CRFHGRANTXMGXOUT,
    CRFHRDATAXMGXOUT,
    CRFHREADYXMGXOUT,
    CRFHRESPXMGXOUT,
    CRFCPDINXMGXOUT,
    CRFCHSDEXMGXOUT,
    CRFCHSEXXMGXOUT,
    CRFDBGENXMGXOUT,
    CRFEDBGRQXMGXOUT,
    CRFDBGEXTXMGXOUT,
    CRFDBGIEBKPTXMGXOUT,
    CRFDBGDEWPTXMGXOUT,
    CRFDBGnTRSTXMGXOUT,
    CRFDBGTCKENXMGXOUT,
    CRFDBGTDIXMGXOUT,
    CRFDBGTMSXMGXOUT,
    CRFDBGSDOUTXMGXOUT,
    CRFnFIQXMGXOUT,
    CRFnIRQXMGXOUT,
    CRFVINITHIXMGXOUT,
    CRFINITRAMXMGXOUT,
    CRFTAPIDXMGXOUT,
    CRFDCacheSizeXMGXOUT,
    CRFICacheSizeXMGXOUT,
    CRFETMENXMGXOUT,
    CRFSCANENXMGXOUT,
    CRFTESTMODEXMGXOUT,
    CRFSCANIN1XMGXOUT,
    CRFSCANIN2XMGXOUT,
    CRFSCANIN3XMGXOUT,
    CRFSCANIN4XMGXOUT,
    CRFETMFIFOFULLXMGXOUT,
    CRFUnGatedCLKXMGXOUT,
    CRFITCMRDataXMGXOUT,
    CRFDTCMRDataXMGXOUT,
    CRFPhyDTCMSizeXMGXOUT,
    CRFPhyITCMSizeXMGXOUT,
    CRFstrobeXMGXOUT);

endmodule

// Debug shell

module ARM946E_88CRFTESTER (HBUSREQ,
  HLOCK,
  HADDR,
  HTRANS,
  HWRITE,
  HSIZE,
  HBURST,
  HPROT,
  HWDATA,
  CPINSTR,
  CPDOUT,
  CPPASS,
  CPLATECANCEL,
  CPTBIT,
  nCPMREQ,
  nCPTRANS,
  CPCLKEN,
  COMMRX,
  COMMTX,
  DBGACK,
  DBGRQI,
  DBGINSTREXEC,
  DBGRNG,
  DBGTDO,
  DBGIR,
  DBGSCREG,
  DBGTAPSM,
  DBGnTDOEN,
  DBGSDIN,
  BIGENDOUT,
  ETMBIGEND,
  ETMHIVECS,
  ETMIA,
  ETMInMREQ,
  ETMISEQ,
  ETMITBIT,
  ETMIABORT,
  ETMDA,
  ETMDMAS,
  ETMDMORE,
  ETMDnMREQ,
  ETMDnRW,
  ETMDSEQ,
  ETMRDATA,
  ETMDABORT,
  ETMCHSD,
  ETMCHSE,
  ETMnWAIT,
  ETMID31To25,
  ETMID15To11,
  ETMWDATA,
  ETMLATECANCEL,
  ETMPASS,
  ETMDBGACK,
  ETMINSTREXEC,
  ETMRNGOUT,
  ETMPROCID,
  ETMPROCIDWR,
  ETMINSTRVALID,
  GateTheCLK,
  ITCMWData,
  ITCMWEn,
  ITCMEn,
  ITCMAdrs,
  DTCMWData,
  DTCMWEn,
  DTCMEn,
  DTCMAdrs,
  SCANOUT1,
  SCANOUT2,
  SCANOUT3,
  SCANOUT4,
  HRESETn,
  HCLKEN,
  CLK,
  HGRANT,
  HRDATA,
  HREADY,
  HRESP,
  CPDIN,
  CHSDE,
  CHSEX,
  DBGEN,
  EDBGRQ,
  DBGEXT,
  DBGIEBKPT,
  DBGDEWPT,
  DBGnTRST,
  DBGTCKEN,
  DBGTDI,
  DBGTMS,
  DBGSDOUT,
  nFIQ,
  nIRQ,
  VINITHI,
  INITRAM,
  TAPID,
  DCacheSize,
  ICacheSize,
  ETMEN,
  SCANEN,
  TESTMODE,
  SCANIN1,
  SCANIN2,
  SCANIN3,
  SCANIN4,
  ETMFIFOFULL,
  UnGatedCLK,
  ITCMRData,
  DTCMRData,
  PhyDTCMSize,
  PhyITCMSize);

input HBUSREQ;
input HLOCK;
input [31:0] HADDR;
input [1:0] HTRANS;
input HWRITE;
input [2:0] HSIZE;
input [2:0] HBURST;
input [3:0] HPROT;
input [31:0] HWDATA;
input [31:0] CPINSTR;
input [31:0] CPDOUT;
input CPPASS;
input CPLATECANCEL;
input CPTBIT;
input nCPMREQ;
input nCPTRANS;
input CPCLKEN;
input COMMRX;
input COMMTX;
input DBGACK;
input DBGRQI;
input DBGINSTREXEC;
input [1:0] DBGRNG;
input DBGTDO;
input [3:0] DBGIR;
input [4:0] DBGSCREG;
input [3:0] DBGTAPSM;
input DBGnTDOEN;
input DBGSDIN;
input BIGENDOUT;
input ETMBIGEND;
input ETMHIVECS;
input [31:1] ETMIA;
input ETMInMREQ;
input ETMISEQ;
input ETMITBIT;
input ETMIABORT;
input [31:0] ETMDA;
input [1:0] ETMDMAS;
input ETMDMORE;
input ETMDnMREQ;
input ETMDnRW;
input ETMDSEQ;
input [31:0] ETMRDATA;
input ETMDABORT;
input [1:0] ETMCHSD;
input [1:0] ETMCHSE;
input ETMnWAIT;
input [31:25] ETMID31To25;
input [15:11] ETMID15To11;
input [31:0] ETMWDATA;
input ETMLATECANCEL;
input ETMPASS;
input ETMDBGACK;
input ETMINSTREXEC;
input [1:0] ETMRNGOUT;
input [31:0] ETMPROCID;
input ETMPROCIDWR;
input ETMINSTRVALID;
input GateTheCLK;
input [31:0] ITCMWData;
input [3:0] ITCMWEn;
input ITCMEn;
input [17:0] ITCMAdrs;
input [31:0] DTCMWData;
input [3:0] DTCMWEn;
input DTCMEn;
input [17:0] DTCMAdrs;
input SCANOUT1;
input SCANOUT2;
input SCANOUT3;
input SCANOUT4;
output HRESETn;
output HCLKEN;
output CLK;
output HGRANT;
output [31:0] HRDATA;
output HREADY;
output [1:0] HRESP;
output [31:0] CPDIN;
output [1:0] CHSDE;
output [1:0] CHSEX;
output DBGEN;
output EDBGRQ;
output [1:0] DBGEXT;
output DBGIEBKPT;
output DBGDEWPT;
output DBGnTRST;
output DBGTCKEN;
output DBGTDI;
output DBGTMS;
output DBGSDOUT;
output nFIQ;
output nIRQ;
output VINITHI;
output INITRAM;
output [31:0] TAPID;
output [3:0] DCacheSize;
output [3:0] ICacheSize;
output ETMEN;
output SCANEN;
output TESTMODE;
output SCANIN1;
output SCANIN2;
output SCANIN3;
output SCANIN4;
output ETMFIFOFULL;
output UnGatedCLK;
output [31:0] ITCMRData;
output [31:0] DTCMRData;
output [3:0] PhyDTCMSize;
output [3:0] PhyITCMSize;

// Connectors for LOOPBACKs:

wire CRFHBUSREQ;
wire CRFHLOCK;
wire CRFHADDR;
wire CRFHTRANS;
wire CRFHWRITE;
wire CRFHSIZE;
wire CRFHBURST;
wire CRFHPROT;
wire CRFHWDATA;
wire CRFCPINSTR;
wire CRFCPDOUT;
wire CRFCPPASS;
wire CRFCPLATECANCEL;
wire CRFCPTBIT;
wire CRFnCPMREQ;
wire CRFnCPTRANS;
wire CRFCPCLKEN;
wire CRFCOMMRX;
wire CRFCOMMTX;
wire CRFDBGACK;
wire CRFDBGRQI;
wire CRFDBGINSTREXEC;
wire CRFDBGRNG;
wire CRFDBGTDO;
wire CRFDBGIR;
wire CRFDBGSCREG;
wire CRFDBGTAPSM;
wire CRFDBGnTDOEN;
wire CRFDBGSDIN;
wire CRFBIGENDOUT;
wire CRFETMBIGEND;
wire CRFETMHIVECS;
wire CRFETMIA;
wire CRFETMInMREQ;
wire CRFETMISEQ;
wire CRFETMITBIT;
wire CRFETMIABORT;
wire CRFETMDA;
wire CRFETMDMAS;
wire CRFETMDMORE;
wire CRFETMDnMREQ;
wire CRFETMDnRW;
wire CRFETMDSEQ;
wire CRFETMRDATA;
wire CRFETMDABORT;
wire CRFETMCHSD;
wire CRFETMCHSE;
wire CRFETMnWAIT;
wire CRFETMID31To25;
wire CRFETMID15To11;
wire CRFETMWDATA;
wire CRFETMLATECANCEL;
wire CRFETMPASS;
wire CRFETMDBGACK;
wire CRFETMINSTREXEC;
wire CRFETMRNGOUT;
wire CRFETMPROCID;
wire CRFETMPROCIDWR;
wire CRFETMINSTRVALID;
wire CRFGateTheCLK;
wire CRFITCMWData;
wire CRFITCMWEn;
wire CRFITCMEn;
wire CRFITCMAdrs;
wire CRFDTCMWData;
wire CRFDTCMWEn;
wire CRFDTCMEn;
wire CRFDTCMAdrs;
wire CRFSCANOUT1;
wire CRFSCANOUT2;
wire CRFSCANOUT3;
wire CRFSCANOUT4;
wire CRFHRESETn;
wire CRFHCLKEN;
wire CRFCLK;
wire CRFHGRANT;
wire CRFHRDATA;
wire CRFHREADY;
wire CRFHRESP;
wire CRFCPDIN;
wire CRFCHSDE;
wire CRFCHSEX;
wire CRFDBGEN;
wire CRFEDBGRQ;
wire CRFDBGEXT;
wire CRFDBGIEBKPT;
wire CRFDBGDEWPT;
wire CRFDBGnTRST;
wire CRFDBGTCKEN;
wire CRFDBGTDI;
wire CRFDBGTMS;
wire CRFDBGSDOUT;
wire CRFnFIQ;
wire CRFnIRQ;
wire CRFVINITHI;
wire CRFINITRAM;
wire CRFTAPID;
wire CRFDCacheSize;
wire CRFICacheSize;
wire CRFETMEN;
wire CRFSCANEN;
wire CRFTESTMODE;
wire CRFSCANIN1;
wire CRFSCANIN2;
wire CRFSCANIN3;
wire CRFSCANIN4;
wire CRFETMFIFOFULL;
wire CRFUnGatedCLK;
wire CRFITCMRData;
wire CRFDTCMRData;
wire CRFPhyDTCMSize;
wire CRFPhyITCMSize;
wire CRFstrobe;


parameter
  MG_LOGFILE_NAME = "",
  MG_FORCED_DELAY = 0;

ARM946E_88CRFTESTER_timing thetiming (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize,
    CRFHBUSREQ, CRFHBUSREQ,
    CRFHLOCK, CRFHLOCK,
    CRFHADDR, CRFHADDR,
    CRFHTRANS, CRFHTRANS,
    CRFHWRITE, CRFHWRITE,
    CRFHSIZE, CRFHSIZE,
    CRFHBURST, CRFHBURST,
    CRFHPROT, CRFHPROT,
    CRFHWDATA, CRFHWDATA,
    CRFCPINSTR, CRFCPINSTR,
    CRFCPDOUT, CRFCPDOUT,
    CRFCPPASS, CRFCPPASS,
    CRFCPLATECANCEL, CRFCPLATECANCEL,
    CRFCPTBIT, CRFCPTBIT,
    CRFnCPMREQ, CRFnCPMREQ,
    CRFnCPTRANS, CRFnCPTRANS,
    CRFCPCLKEN, CRFCPCLKEN,
    CRFCOMMRX, CRFCOMMRX,
    CRFCOMMTX, CRFCOMMTX,
    CRFDBGACK, CRFDBGACK,
    CRFDBGRQI, CRFDBGRQI,
    CRFDBGINSTREXEC, CRFDBGINSTREXEC,
    CRFDBGRNG, CRFDBGRNG,
    CRFDBGTDO, CRFDBGTDO,
    CRFDBGIR, CRFDBGIR,
    CRFDBGSCREG, CRFDBGSCREG,
    CRFDBGTAPSM, CRFDBGTAPSM,
    CRFDBGnTDOEN, CRFDBGnTDOEN,
    CRFDBGSDIN, CRFDBGSDIN,
    CRFBIGENDOUT, CRFBIGENDOUT,
    CRFETMBIGEND, CRFETMBIGEND,
    CRFETMHIVECS, CRFETMHIVECS,
    CRFETMIA, CRFETMIA,
    CRFETMInMREQ, CRFETMInMREQ,
    CRFETMISEQ, CRFETMISEQ,
    CRFETMITBIT, CRFETMITBIT,
    CRFETMIABORT, CRFETMIABORT,
    CRFETMDA, CRFETMDA,
    CRFETMDMAS, CRFETMDMAS,
    CRFETMDMORE, CRFETMDMORE,
    CRFETMDnMREQ, CRFETMDnMREQ,
    CRFETMDnRW, CRFETMDnRW,
    CRFETMDSEQ, CRFETMDSEQ,
    CRFETMRDATA, CRFETMRDATA,
    CRFETMDABORT, CRFETMDABORT,
    CRFETMCHSD, CRFETMCHSD,
    CRFETMCHSE, CRFETMCHSE,
    CRFETMnWAIT, CRFETMnWAIT,
    CRFETMID31To25, CRFETMID31To25,
    CRFETMID15To11, CRFETMID15To11,
    CRFETMWDATA, CRFETMWDATA,
    CRFETMLATECANCEL, CRFETMLATECANCEL,
    CRFETMPASS, CRFETMPASS,
    CRFETMDBGACK, CRFETMDBGACK,
    CRFETMINSTREXEC, CRFETMINSTREXEC,
    CRFETMRNGOUT, CRFETMRNGOUT,
    CRFETMPROCID, CRFETMPROCID,
    CRFETMPROCIDWR, CRFETMPROCIDWR,
    CRFETMINSTRVALID, CRFETMINSTRVALID,
    CRFGateTheCLK, CRFGateTheCLK,
    CRFITCMWData, CRFITCMWData,
    CRFITCMWEn, CRFITCMWEn,
    CRFITCMEn, CRFITCMEn,
    CRFITCMAdrs, CRFITCMAdrs,
    CRFDTCMWData, CRFDTCMWData,
    CRFDTCMWEn, CRFDTCMWEn,
    CRFDTCMEn, CRFDTCMEn,
    CRFDTCMAdrs, CRFDTCMAdrs,
    CRFSCANOUT1, CRFSCANOUT1,
    CRFSCANOUT2, CRFSCANOUT2,
    CRFSCANOUT3, CRFSCANOUT3,
    CRFSCANOUT4, CRFSCANOUT4,
    CRFHRESETn, CRFHRESETn,
    CRFHCLKEN, CRFHCLKEN,
    CRFCLK, CRFCLK,
    CRFHGRANT, CRFHGRANT,
    CRFHRDATA, CRFHRDATA,
    CRFHREADY, CRFHREADY,
    CRFHRESP, CRFHRESP,
    CRFCPDIN, CRFCPDIN,
    CRFCHSDE, CRFCHSDE,
    CRFCHSEX, CRFCHSEX,
    CRFDBGEN, CRFDBGEN,
    CRFEDBGRQ, CRFEDBGRQ,
    CRFDBGEXT, CRFDBGEXT,
    CRFDBGIEBKPT, CRFDBGIEBKPT,
    CRFDBGDEWPT, CRFDBGDEWPT,
    CRFDBGnTRST, CRFDBGnTRST,
    CRFDBGTCKEN, CRFDBGTCKEN,
    CRFDBGTDI, CRFDBGTDI,
    CRFDBGTMS, CRFDBGTMS,
    CRFDBGSDOUT, CRFDBGSDOUT,
    CRFnFIQ, CRFnFIQ,
    CRFnIRQ, CRFnIRQ,
    CRFVINITHI, CRFVINITHI,
    CRFINITRAM, CRFINITRAM,
    CRFTAPID, CRFTAPID,
    CRFDCacheSize, CRFDCacheSize,
    CRFICacheSize, CRFICacheSize,
    CRFETMEN, CRFETMEN,
    CRFSCANEN, CRFSCANEN,
    CRFTESTMODE, CRFTESTMODE,
    CRFSCANIN1, CRFSCANIN1,
    CRFSCANIN2, CRFSCANIN2,
    CRFSCANIN3, CRFSCANIN3,
    CRFSCANIN4, CRFSCANIN4,
    CRFETMFIFOFULL, CRFETMFIFOFULL,
    CRFUnGatedCLK, CRFUnGatedCLK,
    CRFITCMRData, CRFITCMRData,
    CRFDTCMRData, CRFDTCMRData,
    CRFPhyDTCMSize, CRFPhyDTCMSize,
    CRFPhyITCMSize, CRFPhyITCMSize,
    CRFstrobe, CRFstrobe);

endmodule

// Model with socket

module ARM946E_88CRFTESTERTOP ();

  wire HBUSREQ;
  wire HLOCK;
  wire [31:0] HADDR;
  wire [1:0] HTRANS;
  wire HWRITE;
  wire [2:0] HSIZE;
  wire [2:0] HBURST;
  wire [3:0] HPROT;
  wire [31:0] HWDATA;
  wire [31:0] CPINSTR;
  wire [31:0] CPDOUT;
  wire CPPASS;
  wire CPLATECANCEL;
  wire CPTBIT;
  wire nCPMREQ;
  wire nCPTRANS;
  wire CPCLKEN;
  wire COMMRX;
  wire COMMTX;
  wire DBGACK;
  wire DBGRQI;
  wire DBGINSTREXEC;
  wire [1:0] DBGRNG;
  wire DBGTDO;
  wire [3:0] DBGIR;
  wire [4:0] DBGSCREG;
  wire [3:0] DBGTAPSM;
  wire DBGnTDOEN;
  wire DBGSDIN;
  wire BIGENDOUT;
  wire ETMBIGEND;
  wire ETMHIVECS;
  wire [31:1] ETMIA;
  wire ETMInMREQ;
  wire ETMISEQ;
  wire ETMITBIT;
  wire ETMIABORT;
  wire [31:0] ETMDA;
  wire [1:0] ETMDMAS;
  wire ETMDMORE;
  wire ETMDnMREQ;
  wire ETMDnRW;
  wire ETMDSEQ;
  wire [31:0] ETMRDATA;
  wire ETMDABORT;
  wire [1:0] ETMCHSD;
  wire [1:0] ETMCHSE;
  wire ETMnWAIT;
  wire [31:25] ETMID31To25;
  wire [15:11] ETMID15To11;
  wire [31:0] ETMWDATA;
  wire ETMLATECANCEL;
  wire ETMPASS;
  wire ETMDBGACK;
  wire ETMINSTREXEC;
  wire [1:0] ETMRNGOUT;
  wire [31:0] ETMPROCID;
  wire ETMPROCIDWR;
  wire ETMINSTRVALID;
  wire GateTheCLK;
  wire [31:0] ITCMWData;
  wire [3:0] ITCMWEn;
  wire ITCMEn;
  wire [17:0] ITCMAdrs;
  wire [31:0] DTCMWData;
  wire [3:0] DTCMWEn;
  wire DTCMEn;
  wire [17:0] DTCMAdrs;
  wire SCANOUT1;
  wire SCANOUT2;
  wire SCANOUT3;
  wire SCANOUT4;
  wire HRESETn;
  wire HCLKEN;
  wire CLK;
  wire HGRANT;
  wire [31:0] HRDATA;
  wire HREADY;
  wire [1:0] HRESP;
  wire [31:0] CPDIN;
  wire [1:0] CHSDE;
  wire [1:0] CHSEX;
  wire DBGEN;
  wire EDBGRQ;
  wire [1:0] DBGEXT;
  wire DBGIEBKPT;
  wire DBGDEWPT;
  wire DBGnTRST;
  wire DBGTCKEN;
  wire DBGTDI;
  wire DBGTMS;
  wire DBGSDOUT;
  wire nFIQ;
  wire nIRQ;
  wire VINITHI;
  wire INITRAM;
  wire [31:0] TAPID;
  wire [3:0] DCacheSize;
  wire [3:0] ICacheSize;
  wire ETMEN;
  wire SCANEN;
  wire TESTMODE;
  wire SCANIN1;
  wire SCANIN2;
  wire SCANIN3;
  wire SCANIN4;
  wire ETMFIFOFULL;
  wire UnGatedCLK;
  wire [31:0] ITCMRData;
  wire [31:0] DTCMRData;
  wire [3:0] PhyDTCMSize;
  wire [3:0] PhyITCMSize;

  ARM946E_88CRFTESTER theARM946E_88CRFTESTER (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize);

  ARM946E_88 theARM946E_88 (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize);

initial begin
        $shm_open("sim_ARM946E_88CRFTESTER");
        $shm_probe("AC");
end

endmodule
