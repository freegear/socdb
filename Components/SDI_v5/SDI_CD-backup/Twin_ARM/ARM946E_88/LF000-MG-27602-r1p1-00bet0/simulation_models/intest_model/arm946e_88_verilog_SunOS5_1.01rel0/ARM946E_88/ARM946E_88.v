// ARM946E_88.v shipped with DSM LF000-MG-22602-1.01rel0
//
// Verilog implementation of ARM946E_88, generated by ModelGen

// Elements of the code in this file are
// Copyright 1993, 94-99, 2000 ARM Ltd,
// All rights reserved.

`timescale 1 ps / 1 ps

// Inout shell

module ARM946E_88_inout (HBUSREQ,
  HLOCK,
  HADDR,
  HTRANS,
  HWRITE,
  HSIZE,
  HBURST,
  HPROT,
  HWDATA,
  CPINSTR,
  CPDOUT,
  CPPASS,
  CPLATECANCEL,
  CPTBIT,
  nCPMREQ,
  nCPTRANS,
  CPCLKEN,
  COMMRX,
  COMMTX,
  DBGACK,
  DBGRQI,
  DBGINSTREXEC,
  DBGRNG,
  DBGTDO,
  DBGIR,
  DBGSCREG,
  DBGTAPSM,
  DBGnTDOEN,
  DBGSDIN,
  BIGENDOUT,
  ETMBIGEND,
  ETMHIVECS,
  ETMIA,
  ETMInMREQ,
  ETMISEQ,
  ETMITBIT,
  ETMIABORT,
  ETMDA,
  ETMDMAS,
  ETMDMORE,
  ETMDnMREQ,
  ETMDnRW,
  ETMDSEQ,
  ETMRDATA,
  ETMDABORT,
  ETMCHSD,
  ETMCHSE,
  ETMnWAIT,
  ETMID31To25,
  ETMID15To11,
  ETMWDATA,
  ETMLATECANCEL,
  ETMPASS,
  ETMDBGACK,
  ETMINSTREXEC,
  ETMRNGOUT,
  ETMPROCID,
  ETMPROCIDWR,
  ETMINSTRVALID,
  GateTheCLK,
  ITCMWData,
  ITCMWEn,
  ITCMEn,
  ITCMAdrs,
  DTCMWData,
  DTCMWEn,
  DTCMEn,
  DTCMAdrs,
  SCANOUT1,
  SCANOUT2,
  SCANOUT3,
  SCANOUT4,
  HRESETn,
  HCLKEN,
  CLK,
  HGRANT,
  HRDATA,
  HREADY,
  HRESP,
  CPDIN,
  CHSDE,
  CHSEX,
  DBGEN,
  EDBGRQ,
  DBGEXT,
  DBGIEBKPT,
  DBGDEWPT,
  DBGnTRST,
  DBGTCKEN,
  DBGTDI,
  DBGTMS,
  DBGSDOUT,
  nFIQ,
  nIRQ,
  VINITHI,
  INITRAM,
  TAPID,
  DCacheSize,
  ICacheSize,
  ETMEN,
  SCANEN,
  TESTMODE,
  SCANIN1,
  SCANIN2,
  SCANIN3,
  SCANIN4,
  ETMFIFOFULL,
  UnGatedCLK,
  ITCMRData,
  DTCMRData,
  PhyDTCMSize,
  PhyITCMSize);

output HBUSREQ;
output HLOCK;
output [31:0] HADDR;
output [1:0] HTRANS;
output HWRITE;
output [2:0] HSIZE;
output [2:0] HBURST;
output [3:0] HPROT;
output [31:0] HWDATA;
output [31:0] CPINSTR;
output [31:0] CPDOUT;
output CPPASS;
output CPLATECANCEL;
output CPTBIT;
output nCPMREQ;
output nCPTRANS;
output CPCLKEN;
output COMMRX;
output COMMTX;
output DBGACK;
output DBGRQI;
output DBGINSTREXEC;
output [1:0] DBGRNG;
output DBGTDO;
output [3:0] DBGIR;
output [4:0] DBGSCREG;
output [3:0] DBGTAPSM;
output DBGnTDOEN;
output DBGSDIN;
output BIGENDOUT;
output ETMBIGEND;
output ETMHIVECS;
output [31:1] ETMIA;
output ETMInMREQ;
output ETMISEQ;
output ETMITBIT;
output ETMIABORT;
output [31:0] ETMDA;
output [1:0] ETMDMAS;
output ETMDMORE;
output ETMDnMREQ;
output ETMDnRW;
output ETMDSEQ;
output [31:0] ETMRDATA;
output ETMDABORT;
output [1:0] ETMCHSD;
output [1:0] ETMCHSE;
output ETMnWAIT;
output [31:25] ETMID31To25;
output [15:11] ETMID15To11;
output [31:0] ETMWDATA;
output ETMLATECANCEL;
output ETMPASS;
output ETMDBGACK;
output ETMINSTREXEC;
output [1:0] ETMRNGOUT;
output [31:0] ETMPROCID;
output ETMPROCIDWR;
output ETMINSTRVALID;
output GateTheCLK;
output [31:0] ITCMWData;
output [3:0] ITCMWEn;
output ITCMEn;
output [17:0] ITCMAdrs;
output [31:0] DTCMWData;
output [3:0] DTCMWEn;
output DTCMEn;
output [17:0] DTCMAdrs;
output SCANOUT1;
output SCANOUT2;
output SCANOUT3;
output SCANOUT4;
input HRESETn;
input HCLKEN;
input CLK;
input HGRANT;
input [31:0] HRDATA;
input HREADY;
input [1:0] HRESP;
input [31:0] CPDIN;
input [1:0] CHSDE;
input [1:0] CHSEX;
input DBGEN;
input EDBGRQ;
input [1:0] DBGEXT;
input DBGIEBKPT;
input DBGDEWPT;
input DBGnTRST;
input DBGTCKEN;
input DBGTDI;
input DBGTMS;
input DBGSDOUT;
input nFIQ;
input nIRQ;
input VINITHI;
input INITRAM;
input [31:0] TAPID;
input [3:0] DCacheSize;
input [3:0] ICacheSize;
input ETMEN;
input SCANEN;
input TESTMODE;
input SCANIN1;
input SCANIN2;
input SCANIN3;
input SCANIN4;
input ETMFIFOFULL;
input UnGatedCLK;
input [31:0] ITCMRData;
input [31:0] DTCMRData;
input [3:0] PhyDTCMSize;
input [3:0] PhyITCMSize;

reg HBUSREQ;
reg HLOCK;
reg [31:0] HADDR;
reg [1:0] HTRANS;
reg HWRITE;
reg [2:0] HSIZE;
reg [2:0] HBURST;
reg [3:0] HPROT;
reg [31:0] HWDATA;
reg [31:0] CPINSTR;
reg [31:0] CPDOUT;
reg CPPASS;
reg CPLATECANCEL;
reg CPTBIT;
reg nCPMREQ;
reg nCPTRANS;
reg CPCLKEN;
reg COMMRX;
reg COMMTX;
reg DBGACK;
reg DBGRQI;
reg DBGINSTREXEC;
reg [1:0] DBGRNG;
reg DBGTDO;
reg [3:0] DBGIR;
reg [4:0] DBGSCREG;
reg [3:0] DBGTAPSM;
reg DBGnTDOEN;
reg DBGSDIN;
reg BIGENDOUT;
reg ETMBIGEND;
reg ETMHIVECS;
reg [31:1] ETMIA;
reg ETMInMREQ;
reg ETMISEQ;
reg ETMITBIT;
reg ETMIABORT;
reg [31:0] ETMDA;
reg [1:0] ETMDMAS;
reg ETMDMORE;
reg ETMDnMREQ;
reg ETMDnRW;
reg ETMDSEQ;
reg [31:0] ETMRDATA;
reg ETMDABORT;
reg [1:0] ETMCHSD;
reg [1:0] ETMCHSE;
reg ETMnWAIT;
reg [31:25] ETMID31To25;
reg [15:11] ETMID15To11;
reg [31:0] ETMWDATA;
reg ETMLATECANCEL;
reg ETMPASS;
reg ETMDBGACK;
reg ETMINSTREXEC;
reg [1:0] ETMRNGOUT;
reg [31:0] ETMPROCID;
reg ETMPROCIDWR;
reg ETMINSTRVALID;
reg GateTheCLK;
reg [31:0] ITCMWData;
reg [3:0] ITCMWEn;
reg ITCMEn;
reg [17:0] ITCMAdrs;
reg [31:0] DTCMWData;
reg [3:0] DTCMWEn;
reg DTCMEn;
reg [17:0] DTCMAdrs;
reg SCANOUT1;
reg SCANOUT2;
reg SCANOUT3;
reg SCANOUT4;
initial
  begin
    $mm("ARM946E_88?rev=r1",HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize);
  end

endmodule

// Timing shell

`celldefine
`delay_mode_path

module ARM946E_88_timing (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize);

output HBUSREQ;
output HLOCK;
output [31:0] HADDR;
output [1:0] HTRANS;
output HWRITE;
output [2:0] HSIZE;
output [2:0] HBURST;
output [3:0] HPROT;
output [31:0] HWDATA;
output [31:0] CPINSTR;
output [31:0] CPDOUT;
output CPPASS;
output CPLATECANCEL;
output CPTBIT;
output nCPMREQ;
output nCPTRANS;
output CPCLKEN;
output COMMRX;
output COMMTX;
output DBGACK;
output DBGRQI;
output DBGINSTREXEC;
output [1:0] DBGRNG;
output DBGTDO;
output [3:0] DBGIR;
output [4:0] DBGSCREG;
output [3:0] DBGTAPSM;
output DBGnTDOEN;
output DBGSDIN;
output BIGENDOUT;
output ETMBIGEND;
output ETMHIVECS;
output [31:1] ETMIA;
output ETMInMREQ;
output ETMISEQ;
output ETMITBIT;
output ETMIABORT;
output [31:0] ETMDA;
output [1:0] ETMDMAS;
output ETMDMORE;
output ETMDnMREQ;
output ETMDnRW;
output ETMDSEQ;
output [31:0] ETMRDATA;
output ETMDABORT;
output [1:0] ETMCHSD;
output [1:0] ETMCHSE;
output ETMnWAIT;
output [31:25] ETMID31To25;
output [15:11] ETMID15To11;
output [31:0] ETMWDATA;
output ETMLATECANCEL;
output ETMPASS;
output ETMDBGACK;
output ETMINSTREXEC;
output [1:0] ETMRNGOUT;
output [31:0] ETMPROCID;
output ETMPROCIDWR;
output ETMINSTRVALID;
output GateTheCLK;
output [31:0] ITCMWData;
output [3:0] ITCMWEn;
output ITCMEn;
output [17:0] ITCMAdrs;
output [31:0] DTCMWData;
output [3:0] DTCMWEn;
output DTCMEn;
output [17:0] DTCMAdrs;
output SCANOUT1;
output SCANOUT2;
output SCANOUT3;
output SCANOUT4;
input HRESETn;
input HCLKEN;
input CLK;
input HGRANT;
input [31:0] HRDATA;
input HREADY;
input [1:0] HRESP;
input [31:0] CPDIN;
input [1:0] CHSDE;
input [1:0] CHSEX;
input DBGEN;
input EDBGRQ;
input [1:0] DBGEXT;
input DBGIEBKPT;
input DBGDEWPT;
input DBGnTRST;
input DBGTCKEN;
input DBGTDI;
input DBGTMS;
input DBGSDOUT;
input nFIQ;
input nIRQ;
input VINITHI;
input INITRAM;
input [31:0] TAPID;
input [3:0] DCacheSize;
input [3:0] ICacheSize;
input ETMEN;
input SCANEN;
input TESTMODE;
input SCANIN1;
input SCANIN2;
input SCANIN3;
input SCANIN4;
input ETMFIFOFULL;
input UnGatedCLK;
input [31:0] ITCMRData;
input [31:0] DTCMRData;
input [3:0] PhyDTCMSize;
input [3:0] PhyITCMSize;


// Delayed signal defs:

wire CLK_xmgxnegd;
wire UnGatedCLK_xmgxnegd;
wire nFIQ_xmgxnegd;
wire nIRQ_xmgxnegd;
wire VINITHI_xmgxnegd;
wire INITRAM_xmgxnegd;
wire HCLKEN_xmgxnegd;
wire [31:0] TAPID_xmgxnegd;
wire [31:0] CPDIN_xmgxnegd;
wire [1:0] CHSDE_xmgxnegd;
wire [1:0] CHSEX_xmgxnegd;
wire DBGEN_xmgxnegd;
wire EDBGRQ_xmgxnegd;
wire DBGIEBKPT_xmgxnegd;
wire DBGDEWPT_xmgxnegd;
wire [1:0] DBGEXT_xmgxnegd;
wire DBGTDI_xmgxnegd;
wire DBGTMS_xmgxnegd;
wire DBGTCKEN_xmgxnegd;
wire DBGSDOUT_xmgxnegd;
wire DBGnTRST_xmgxnegd;
wire ETMEN_xmgxnegd;
wire HREADY_xmgxnegd;
wire [1:0] HRESP_xmgxnegd;
wire [31:0] HRDATA_xmgxnegd;
wire HGRANT_xmgxnegd;
wire HRESETn_xmgxnegd;
wire SCANEN_xmgxnegd;
wire TESTMODE_xmgxnegd;
wire SCANIN1_xmgxnegd;
wire SCANIN2_xmgxnegd;
wire SCANIN3_xmgxnegd;
wire SCANIN4_xmgxnegd;
wire ETMFIFOFULL_xmgxnegd;
wire [31:0] ITCMRData_xmgxnegd;
wire [31:0] DTCMRData_xmgxnegd;
wire [3:0] PhyDTCMSize_xmgxnegd;
wire [3:0] PhyITCMSize_xmgxnegd;
wire [3:0] DCacheSize_xmgxnegd;
wire [3:0] ICacheSize_xmgxnegd;

// Buffering for backannotation

pmos(HBUSREQ, HBUSREQ_xmgxi, 0);
pmos(HLOCK, HLOCK_xmgxi, 0);
wire [31:0] HADDR_xmgxi;
pmos(HADDR[0], HADDR_xmgxi[0], 0);
pmos(HADDR[1], HADDR_xmgxi[1], 0);
pmos(HADDR[2], HADDR_xmgxi[2], 0);
pmos(HADDR[3], HADDR_xmgxi[3], 0);
pmos(HADDR[4], HADDR_xmgxi[4], 0);
pmos(HADDR[5], HADDR_xmgxi[5], 0);
pmos(HADDR[6], HADDR_xmgxi[6], 0);
pmos(HADDR[7], HADDR_xmgxi[7], 0);
pmos(HADDR[8], HADDR_xmgxi[8], 0);
pmos(HADDR[9], HADDR_xmgxi[9], 0);
pmos(HADDR[10], HADDR_xmgxi[10], 0);
pmos(HADDR[11], HADDR_xmgxi[11], 0);
pmos(HADDR[12], HADDR_xmgxi[12], 0);
pmos(HADDR[13], HADDR_xmgxi[13], 0);
pmos(HADDR[14], HADDR_xmgxi[14], 0);
pmos(HADDR[15], HADDR_xmgxi[15], 0);
pmos(HADDR[16], HADDR_xmgxi[16], 0);
pmos(HADDR[17], HADDR_xmgxi[17], 0);
pmos(HADDR[18], HADDR_xmgxi[18], 0);
pmos(HADDR[19], HADDR_xmgxi[19], 0);
pmos(HADDR[20], HADDR_xmgxi[20], 0);
pmos(HADDR[21], HADDR_xmgxi[21], 0);
pmos(HADDR[22], HADDR_xmgxi[22], 0);
pmos(HADDR[23], HADDR_xmgxi[23], 0);
pmos(HADDR[24], HADDR_xmgxi[24], 0);
pmos(HADDR[25], HADDR_xmgxi[25], 0);
pmos(HADDR[26], HADDR_xmgxi[26], 0);
pmos(HADDR[27], HADDR_xmgxi[27], 0);
pmos(HADDR[28], HADDR_xmgxi[28], 0);
pmos(HADDR[29], HADDR_xmgxi[29], 0);
pmos(HADDR[30], HADDR_xmgxi[30], 0);
pmos(HADDR[31], HADDR_xmgxi[31], 0);
wire [1:0] HTRANS_xmgxi;
pmos(HTRANS[0], HTRANS_xmgxi[0], 0);
pmos(HTRANS[1], HTRANS_xmgxi[1], 0);
pmos(HWRITE, HWRITE_xmgxi, 0);
wire [2:0] HSIZE_xmgxi;
pmos(HSIZE[0], HSIZE_xmgxi[0], 0);
pmos(HSIZE[1], HSIZE_xmgxi[1], 0);
pmos(HSIZE[2], HSIZE_xmgxi[2], 0);
wire [2:0] HBURST_xmgxi;
pmos(HBURST[0], HBURST_xmgxi[0], 0);
pmos(HBURST[1], HBURST_xmgxi[1], 0);
pmos(HBURST[2], HBURST_xmgxi[2], 0);
wire [3:0] HPROT_xmgxi;
pmos(HPROT[0], HPROT_xmgxi[0], 0);
pmos(HPROT[1], HPROT_xmgxi[1], 0);
pmos(HPROT[2], HPROT_xmgxi[2], 0);
pmos(HPROT[3], HPROT_xmgxi[3], 0);
wire [31:0] HWDATA_xmgxi;
pmos(HWDATA[0], HWDATA_xmgxi[0], 0);
pmos(HWDATA[1], HWDATA_xmgxi[1], 0);
pmos(HWDATA[2], HWDATA_xmgxi[2], 0);
pmos(HWDATA[3], HWDATA_xmgxi[3], 0);
pmos(HWDATA[4], HWDATA_xmgxi[4], 0);
pmos(HWDATA[5], HWDATA_xmgxi[5], 0);
pmos(HWDATA[6], HWDATA_xmgxi[6], 0);
pmos(HWDATA[7], HWDATA_xmgxi[7], 0);
pmos(HWDATA[8], HWDATA_xmgxi[8], 0);
pmos(HWDATA[9], HWDATA_xmgxi[9], 0);
pmos(HWDATA[10], HWDATA_xmgxi[10], 0);
pmos(HWDATA[11], HWDATA_xmgxi[11], 0);
pmos(HWDATA[12], HWDATA_xmgxi[12], 0);
pmos(HWDATA[13], HWDATA_xmgxi[13], 0);
pmos(HWDATA[14], HWDATA_xmgxi[14], 0);
pmos(HWDATA[15], HWDATA_xmgxi[15], 0);
pmos(HWDATA[16], HWDATA_xmgxi[16], 0);
pmos(HWDATA[17], HWDATA_xmgxi[17], 0);
pmos(HWDATA[18], HWDATA_xmgxi[18], 0);
pmos(HWDATA[19], HWDATA_xmgxi[19], 0);
pmos(HWDATA[20], HWDATA_xmgxi[20], 0);
pmos(HWDATA[21], HWDATA_xmgxi[21], 0);
pmos(HWDATA[22], HWDATA_xmgxi[22], 0);
pmos(HWDATA[23], HWDATA_xmgxi[23], 0);
pmos(HWDATA[24], HWDATA_xmgxi[24], 0);
pmos(HWDATA[25], HWDATA_xmgxi[25], 0);
pmos(HWDATA[26], HWDATA_xmgxi[26], 0);
pmos(HWDATA[27], HWDATA_xmgxi[27], 0);
pmos(HWDATA[28], HWDATA_xmgxi[28], 0);
pmos(HWDATA[29], HWDATA_xmgxi[29], 0);
pmos(HWDATA[30], HWDATA_xmgxi[30], 0);
pmos(HWDATA[31], HWDATA_xmgxi[31], 0);
wire [31:0] CPINSTR_xmgxi;
pmos(CPINSTR[0], CPINSTR_xmgxi[0], 0);
pmos(CPINSTR[1], CPINSTR_xmgxi[1], 0);
pmos(CPINSTR[2], CPINSTR_xmgxi[2], 0);
pmos(CPINSTR[3], CPINSTR_xmgxi[3], 0);
pmos(CPINSTR[4], CPINSTR_xmgxi[4], 0);
pmos(CPINSTR[5], CPINSTR_xmgxi[5], 0);
pmos(CPINSTR[6], CPINSTR_xmgxi[6], 0);
pmos(CPINSTR[7], CPINSTR_xmgxi[7], 0);
pmos(CPINSTR[8], CPINSTR_xmgxi[8], 0);
pmos(CPINSTR[9], CPINSTR_xmgxi[9], 0);
pmos(CPINSTR[10], CPINSTR_xmgxi[10], 0);
pmos(CPINSTR[11], CPINSTR_xmgxi[11], 0);
pmos(CPINSTR[12], CPINSTR_xmgxi[12], 0);
pmos(CPINSTR[13], CPINSTR_xmgxi[13], 0);
pmos(CPINSTR[14], CPINSTR_xmgxi[14], 0);
pmos(CPINSTR[15], CPINSTR_xmgxi[15], 0);
pmos(CPINSTR[16], CPINSTR_xmgxi[16], 0);
pmos(CPINSTR[17], CPINSTR_xmgxi[17], 0);
pmos(CPINSTR[18], CPINSTR_xmgxi[18], 0);
pmos(CPINSTR[19], CPINSTR_xmgxi[19], 0);
pmos(CPINSTR[20], CPINSTR_xmgxi[20], 0);
pmos(CPINSTR[21], CPINSTR_xmgxi[21], 0);
pmos(CPINSTR[22], CPINSTR_xmgxi[22], 0);
pmos(CPINSTR[23], CPINSTR_xmgxi[23], 0);
pmos(CPINSTR[24], CPINSTR_xmgxi[24], 0);
pmos(CPINSTR[25], CPINSTR_xmgxi[25], 0);
pmos(CPINSTR[26], CPINSTR_xmgxi[26], 0);
pmos(CPINSTR[27], CPINSTR_xmgxi[27], 0);
pmos(CPINSTR[28], CPINSTR_xmgxi[28], 0);
pmos(CPINSTR[29], CPINSTR_xmgxi[29], 0);
pmos(CPINSTR[30], CPINSTR_xmgxi[30], 0);
pmos(CPINSTR[31], CPINSTR_xmgxi[31], 0);
wire [31:0] CPDOUT_xmgxi;
pmos(CPDOUT[0], CPDOUT_xmgxi[0], 0);
pmos(CPDOUT[1], CPDOUT_xmgxi[1], 0);
pmos(CPDOUT[2], CPDOUT_xmgxi[2], 0);
pmos(CPDOUT[3], CPDOUT_xmgxi[3], 0);
pmos(CPDOUT[4], CPDOUT_xmgxi[4], 0);
pmos(CPDOUT[5], CPDOUT_xmgxi[5], 0);
pmos(CPDOUT[6], CPDOUT_xmgxi[6], 0);
pmos(CPDOUT[7], CPDOUT_xmgxi[7], 0);
pmos(CPDOUT[8], CPDOUT_xmgxi[8], 0);
pmos(CPDOUT[9], CPDOUT_xmgxi[9], 0);
pmos(CPDOUT[10], CPDOUT_xmgxi[10], 0);
pmos(CPDOUT[11], CPDOUT_xmgxi[11], 0);
pmos(CPDOUT[12], CPDOUT_xmgxi[12], 0);
pmos(CPDOUT[13], CPDOUT_xmgxi[13], 0);
pmos(CPDOUT[14], CPDOUT_xmgxi[14], 0);
pmos(CPDOUT[15], CPDOUT_xmgxi[15], 0);
pmos(CPDOUT[16], CPDOUT_xmgxi[16], 0);
pmos(CPDOUT[17], CPDOUT_xmgxi[17], 0);
pmos(CPDOUT[18], CPDOUT_xmgxi[18], 0);
pmos(CPDOUT[19], CPDOUT_xmgxi[19], 0);
pmos(CPDOUT[20], CPDOUT_xmgxi[20], 0);
pmos(CPDOUT[21], CPDOUT_xmgxi[21], 0);
pmos(CPDOUT[22], CPDOUT_xmgxi[22], 0);
pmos(CPDOUT[23], CPDOUT_xmgxi[23], 0);
pmos(CPDOUT[24], CPDOUT_xmgxi[24], 0);
pmos(CPDOUT[25], CPDOUT_xmgxi[25], 0);
pmos(CPDOUT[26], CPDOUT_xmgxi[26], 0);
pmos(CPDOUT[27], CPDOUT_xmgxi[27], 0);
pmos(CPDOUT[28], CPDOUT_xmgxi[28], 0);
pmos(CPDOUT[29], CPDOUT_xmgxi[29], 0);
pmos(CPDOUT[30], CPDOUT_xmgxi[30], 0);
pmos(CPDOUT[31], CPDOUT_xmgxi[31], 0);
pmos(CPPASS, CPPASS_xmgxi, 0);
pmos(CPLATECANCEL, CPLATECANCEL_xmgxi, 0);
pmos(CPTBIT, CPTBIT_xmgxi, 0);
pmos(nCPMREQ, nCPMREQ_xmgxi, 0);
pmos(nCPTRANS, nCPTRANS_xmgxi, 0);
pmos(CPCLKEN, CPCLKEN_xmgxi, 0);
pmos(COMMRX, COMMRX_xmgxi, 0);
pmos(COMMTX, COMMTX_xmgxi, 0);
pmos(DBGACK, DBGACK_xmgxi, 0);
pmos(DBGRQI, DBGRQI_xmgxi, 0);
pmos(DBGINSTREXEC, DBGINSTREXEC_xmgxi, 0);
wire [1:0] DBGRNG_xmgxi;
pmos(DBGRNG[0], DBGRNG_xmgxi[0], 0);
pmos(DBGRNG[1], DBGRNG_xmgxi[1], 0);
pmos(DBGTDO, DBGTDO_xmgxi, 0);
wire [3:0] DBGIR_xmgxi;
pmos(DBGIR[0], DBGIR_xmgxi[0], 0);
pmos(DBGIR[1], DBGIR_xmgxi[1], 0);
pmos(DBGIR[2], DBGIR_xmgxi[2], 0);
pmos(DBGIR[3], DBGIR_xmgxi[3], 0);
wire [4:0] DBGSCREG_xmgxi;
pmos(DBGSCREG[0], DBGSCREG_xmgxi[0], 0);
pmos(DBGSCREG[1], DBGSCREG_xmgxi[1], 0);
pmos(DBGSCREG[2], DBGSCREG_xmgxi[2], 0);
pmos(DBGSCREG[3], DBGSCREG_xmgxi[3], 0);
pmos(DBGSCREG[4], DBGSCREG_xmgxi[4], 0);
wire [3:0] DBGTAPSM_xmgxi;
pmos(DBGTAPSM[0], DBGTAPSM_xmgxi[0], 0);
pmos(DBGTAPSM[1], DBGTAPSM_xmgxi[1], 0);
pmos(DBGTAPSM[2], DBGTAPSM_xmgxi[2], 0);
pmos(DBGTAPSM[3], DBGTAPSM_xmgxi[3], 0);
pmos(DBGnTDOEN, DBGnTDOEN_xmgxi, 0);
pmos(DBGSDIN, DBGSDIN_xmgxi, 0);
pmos(BIGENDOUT, BIGENDOUT_xmgxi, 0);
pmos(ETMBIGEND, ETMBIGEND_xmgxi, 0);
pmos(ETMHIVECS, ETMHIVECS_xmgxi, 0);
wire [31:1] ETMIA_xmgxi;
pmos(ETMIA[1], ETMIA_xmgxi[1], 0);
pmos(ETMIA[2], ETMIA_xmgxi[2], 0);
pmos(ETMIA[3], ETMIA_xmgxi[3], 0);
pmos(ETMIA[4], ETMIA_xmgxi[4], 0);
pmos(ETMIA[5], ETMIA_xmgxi[5], 0);
pmos(ETMIA[6], ETMIA_xmgxi[6], 0);
pmos(ETMIA[7], ETMIA_xmgxi[7], 0);
pmos(ETMIA[8], ETMIA_xmgxi[8], 0);
pmos(ETMIA[9], ETMIA_xmgxi[9], 0);
pmos(ETMIA[10], ETMIA_xmgxi[10], 0);
pmos(ETMIA[11], ETMIA_xmgxi[11], 0);
pmos(ETMIA[12], ETMIA_xmgxi[12], 0);
pmos(ETMIA[13], ETMIA_xmgxi[13], 0);
pmos(ETMIA[14], ETMIA_xmgxi[14], 0);
pmos(ETMIA[15], ETMIA_xmgxi[15], 0);
pmos(ETMIA[16], ETMIA_xmgxi[16], 0);
pmos(ETMIA[17], ETMIA_xmgxi[17], 0);
pmos(ETMIA[18], ETMIA_xmgxi[18], 0);
pmos(ETMIA[19], ETMIA_xmgxi[19], 0);
pmos(ETMIA[20], ETMIA_xmgxi[20], 0);
pmos(ETMIA[21], ETMIA_xmgxi[21], 0);
pmos(ETMIA[22], ETMIA_xmgxi[22], 0);
pmos(ETMIA[23], ETMIA_xmgxi[23], 0);
pmos(ETMIA[24], ETMIA_xmgxi[24], 0);
pmos(ETMIA[25], ETMIA_xmgxi[25], 0);
pmos(ETMIA[26], ETMIA_xmgxi[26], 0);
pmos(ETMIA[27], ETMIA_xmgxi[27], 0);
pmos(ETMIA[28], ETMIA_xmgxi[28], 0);
pmos(ETMIA[29], ETMIA_xmgxi[29], 0);
pmos(ETMIA[30], ETMIA_xmgxi[30], 0);
pmos(ETMIA[31], ETMIA_xmgxi[31], 0);
pmos(ETMInMREQ, ETMInMREQ_xmgxi, 0);
pmos(ETMISEQ, ETMISEQ_xmgxi, 0);
pmos(ETMITBIT, ETMITBIT_xmgxi, 0);
pmos(ETMIABORT, ETMIABORT_xmgxi, 0);
wire [31:0] ETMDA_xmgxi;
pmos(ETMDA[0], ETMDA_xmgxi[0], 0);
pmos(ETMDA[1], ETMDA_xmgxi[1], 0);
pmos(ETMDA[2], ETMDA_xmgxi[2], 0);
pmos(ETMDA[3], ETMDA_xmgxi[3], 0);
pmos(ETMDA[4], ETMDA_xmgxi[4], 0);
pmos(ETMDA[5], ETMDA_xmgxi[5], 0);
pmos(ETMDA[6], ETMDA_xmgxi[6], 0);
pmos(ETMDA[7], ETMDA_xmgxi[7], 0);
pmos(ETMDA[8], ETMDA_xmgxi[8], 0);
pmos(ETMDA[9], ETMDA_xmgxi[9], 0);
pmos(ETMDA[10], ETMDA_xmgxi[10], 0);
pmos(ETMDA[11], ETMDA_xmgxi[11], 0);
pmos(ETMDA[12], ETMDA_xmgxi[12], 0);
pmos(ETMDA[13], ETMDA_xmgxi[13], 0);
pmos(ETMDA[14], ETMDA_xmgxi[14], 0);
pmos(ETMDA[15], ETMDA_xmgxi[15], 0);
pmos(ETMDA[16], ETMDA_xmgxi[16], 0);
pmos(ETMDA[17], ETMDA_xmgxi[17], 0);
pmos(ETMDA[18], ETMDA_xmgxi[18], 0);
pmos(ETMDA[19], ETMDA_xmgxi[19], 0);
pmos(ETMDA[20], ETMDA_xmgxi[20], 0);
pmos(ETMDA[21], ETMDA_xmgxi[21], 0);
pmos(ETMDA[22], ETMDA_xmgxi[22], 0);
pmos(ETMDA[23], ETMDA_xmgxi[23], 0);
pmos(ETMDA[24], ETMDA_xmgxi[24], 0);
pmos(ETMDA[25], ETMDA_xmgxi[25], 0);
pmos(ETMDA[26], ETMDA_xmgxi[26], 0);
pmos(ETMDA[27], ETMDA_xmgxi[27], 0);
pmos(ETMDA[28], ETMDA_xmgxi[28], 0);
pmos(ETMDA[29], ETMDA_xmgxi[29], 0);
pmos(ETMDA[30], ETMDA_xmgxi[30], 0);
pmos(ETMDA[31], ETMDA_xmgxi[31], 0);
wire [1:0] ETMDMAS_xmgxi;
pmos(ETMDMAS[0], ETMDMAS_xmgxi[0], 0);
pmos(ETMDMAS[1], ETMDMAS_xmgxi[1], 0);
pmos(ETMDMORE, ETMDMORE_xmgxi, 0);
pmos(ETMDnMREQ, ETMDnMREQ_xmgxi, 0);
pmos(ETMDnRW, ETMDnRW_xmgxi, 0);
pmos(ETMDSEQ, ETMDSEQ_xmgxi, 0);
wire [31:0] ETMRDATA_xmgxi;
pmos(ETMRDATA[0], ETMRDATA_xmgxi[0], 0);
pmos(ETMRDATA[1], ETMRDATA_xmgxi[1], 0);
pmos(ETMRDATA[2], ETMRDATA_xmgxi[2], 0);
pmos(ETMRDATA[3], ETMRDATA_xmgxi[3], 0);
pmos(ETMRDATA[4], ETMRDATA_xmgxi[4], 0);
pmos(ETMRDATA[5], ETMRDATA_xmgxi[5], 0);
pmos(ETMRDATA[6], ETMRDATA_xmgxi[6], 0);
pmos(ETMRDATA[7], ETMRDATA_xmgxi[7], 0);
pmos(ETMRDATA[8], ETMRDATA_xmgxi[8], 0);
pmos(ETMRDATA[9], ETMRDATA_xmgxi[9], 0);
pmos(ETMRDATA[10], ETMRDATA_xmgxi[10], 0);
pmos(ETMRDATA[11], ETMRDATA_xmgxi[11], 0);
pmos(ETMRDATA[12], ETMRDATA_xmgxi[12], 0);
pmos(ETMRDATA[13], ETMRDATA_xmgxi[13], 0);
pmos(ETMRDATA[14], ETMRDATA_xmgxi[14], 0);
pmos(ETMRDATA[15], ETMRDATA_xmgxi[15], 0);
pmos(ETMRDATA[16], ETMRDATA_xmgxi[16], 0);
pmos(ETMRDATA[17], ETMRDATA_xmgxi[17], 0);
pmos(ETMRDATA[18], ETMRDATA_xmgxi[18], 0);
pmos(ETMRDATA[19], ETMRDATA_xmgxi[19], 0);
pmos(ETMRDATA[20], ETMRDATA_xmgxi[20], 0);
pmos(ETMRDATA[21], ETMRDATA_xmgxi[21], 0);
pmos(ETMRDATA[22], ETMRDATA_xmgxi[22], 0);
pmos(ETMRDATA[23], ETMRDATA_xmgxi[23], 0);
pmos(ETMRDATA[24], ETMRDATA_xmgxi[24], 0);
pmos(ETMRDATA[25], ETMRDATA_xmgxi[25], 0);
pmos(ETMRDATA[26], ETMRDATA_xmgxi[26], 0);
pmos(ETMRDATA[27], ETMRDATA_xmgxi[27], 0);
pmos(ETMRDATA[28], ETMRDATA_xmgxi[28], 0);
pmos(ETMRDATA[29], ETMRDATA_xmgxi[29], 0);
pmos(ETMRDATA[30], ETMRDATA_xmgxi[30], 0);
pmos(ETMRDATA[31], ETMRDATA_xmgxi[31], 0);
pmos(ETMDABORT, ETMDABORT_xmgxi, 0);
wire [1:0] ETMCHSD_xmgxi;
pmos(ETMCHSD[0], ETMCHSD_xmgxi[0], 0);
pmos(ETMCHSD[1], ETMCHSD_xmgxi[1], 0);
wire [1:0] ETMCHSE_xmgxi;
pmos(ETMCHSE[0], ETMCHSE_xmgxi[0], 0);
pmos(ETMCHSE[1], ETMCHSE_xmgxi[1], 0);
pmos(ETMnWAIT, ETMnWAIT_xmgxi, 0);
wire [31:25] ETMID31To25_xmgxi;
pmos(ETMID31To25[25], ETMID31To25_xmgxi[25], 0);
pmos(ETMID31To25[26], ETMID31To25_xmgxi[26], 0);
pmos(ETMID31To25[27], ETMID31To25_xmgxi[27], 0);
pmos(ETMID31To25[28], ETMID31To25_xmgxi[28], 0);
pmos(ETMID31To25[29], ETMID31To25_xmgxi[29], 0);
pmos(ETMID31To25[30], ETMID31To25_xmgxi[30], 0);
pmos(ETMID31To25[31], ETMID31To25_xmgxi[31], 0);
wire [15:11] ETMID15To11_xmgxi;
pmos(ETMID15To11[11], ETMID15To11_xmgxi[11], 0);
pmos(ETMID15To11[12], ETMID15To11_xmgxi[12], 0);
pmos(ETMID15To11[13], ETMID15To11_xmgxi[13], 0);
pmos(ETMID15To11[14], ETMID15To11_xmgxi[14], 0);
pmos(ETMID15To11[15], ETMID15To11_xmgxi[15], 0);
wire [31:0] ETMWDATA_xmgxi;
pmos(ETMWDATA[0], ETMWDATA_xmgxi[0], 0);
pmos(ETMWDATA[1], ETMWDATA_xmgxi[1], 0);
pmos(ETMWDATA[2], ETMWDATA_xmgxi[2], 0);
pmos(ETMWDATA[3], ETMWDATA_xmgxi[3], 0);
pmos(ETMWDATA[4], ETMWDATA_xmgxi[4], 0);
pmos(ETMWDATA[5], ETMWDATA_xmgxi[5], 0);
pmos(ETMWDATA[6], ETMWDATA_xmgxi[6], 0);
pmos(ETMWDATA[7], ETMWDATA_xmgxi[7], 0);
pmos(ETMWDATA[8], ETMWDATA_xmgxi[8], 0);
pmos(ETMWDATA[9], ETMWDATA_xmgxi[9], 0);
pmos(ETMWDATA[10], ETMWDATA_xmgxi[10], 0);
pmos(ETMWDATA[11], ETMWDATA_xmgxi[11], 0);
pmos(ETMWDATA[12], ETMWDATA_xmgxi[12], 0);
pmos(ETMWDATA[13], ETMWDATA_xmgxi[13], 0);
pmos(ETMWDATA[14], ETMWDATA_xmgxi[14], 0);
pmos(ETMWDATA[15], ETMWDATA_xmgxi[15], 0);
pmos(ETMWDATA[16], ETMWDATA_xmgxi[16], 0);
pmos(ETMWDATA[17], ETMWDATA_xmgxi[17], 0);
pmos(ETMWDATA[18], ETMWDATA_xmgxi[18], 0);
pmos(ETMWDATA[19], ETMWDATA_xmgxi[19], 0);
pmos(ETMWDATA[20], ETMWDATA_xmgxi[20], 0);
pmos(ETMWDATA[21], ETMWDATA_xmgxi[21], 0);
pmos(ETMWDATA[22], ETMWDATA_xmgxi[22], 0);
pmos(ETMWDATA[23], ETMWDATA_xmgxi[23], 0);
pmos(ETMWDATA[24], ETMWDATA_xmgxi[24], 0);
pmos(ETMWDATA[25], ETMWDATA_xmgxi[25], 0);
pmos(ETMWDATA[26], ETMWDATA_xmgxi[26], 0);
pmos(ETMWDATA[27], ETMWDATA_xmgxi[27], 0);
pmos(ETMWDATA[28], ETMWDATA_xmgxi[28], 0);
pmos(ETMWDATA[29], ETMWDATA_xmgxi[29], 0);
pmos(ETMWDATA[30], ETMWDATA_xmgxi[30], 0);
pmos(ETMWDATA[31], ETMWDATA_xmgxi[31], 0);
pmos(ETMLATECANCEL, ETMLATECANCEL_xmgxi, 0);
pmos(ETMPASS, ETMPASS_xmgxi, 0);
pmos(ETMDBGACK, ETMDBGACK_xmgxi, 0);
pmos(ETMINSTREXEC, ETMINSTREXEC_xmgxi, 0);
wire [1:0] ETMRNGOUT_xmgxi;
pmos(ETMRNGOUT[0], ETMRNGOUT_xmgxi[0], 0);
pmos(ETMRNGOUT[1], ETMRNGOUT_xmgxi[1], 0);
wire [31:0] ETMPROCID_xmgxi;
pmos(ETMPROCID[0], ETMPROCID_xmgxi[0], 0);
pmos(ETMPROCID[1], ETMPROCID_xmgxi[1], 0);
pmos(ETMPROCID[2], ETMPROCID_xmgxi[2], 0);
pmos(ETMPROCID[3], ETMPROCID_xmgxi[3], 0);
pmos(ETMPROCID[4], ETMPROCID_xmgxi[4], 0);
pmos(ETMPROCID[5], ETMPROCID_xmgxi[5], 0);
pmos(ETMPROCID[6], ETMPROCID_xmgxi[6], 0);
pmos(ETMPROCID[7], ETMPROCID_xmgxi[7], 0);
pmos(ETMPROCID[8], ETMPROCID_xmgxi[8], 0);
pmos(ETMPROCID[9], ETMPROCID_xmgxi[9], 0);
pmos(ETMPROCID[10], ETMPROCID_xmgxi[10], 0);
pmos(ETMPROCID[11], ETMPROCID_xmgxi[11], 0);
pmos(ETMPROCID[12], ETMPROCID_xmgxi[12], 0);
pmos(ETMPROCID[13], ETMPROCID_xmgxi[13], 0);
pmos(ETMPROCID[14], ETMPROCID_xmgxi[14], 0);
pmos(ETMPROCID[15], ETMPROCID_xmgxi[15], 0);
pmos(ETMPROCID[16], ETMPROCID_xmgxi[16], 0);
pmos(ETMPROCID[17], ETMPROCID_xmgxi[17], 0);
pmos(ETMPROCID[18], ETMPROCID_xmgxi[18], 0);
pmos(ETMPROCID[19], ETMPROCID_xmgxi[19], 0);
pmos(ETMPROCID[20], ETMPROCID_xmgxi[20], 0);
pmos(ETMPROCID[21], ETMPROCID_xmgxi[21], 0);
pmos(ETMPROCID[22], ETMPROCID_xmgxi[22], 0);
pmos(ETMPROCID[23], ETMPROCID_xmgxi[23], 0);
pmos(ETMPROCID[24], ETMPROCID_xmgxi[24], 0);
pmos(ETMPROCID[25], ETMPROCID_xmgxi[25], 0);
pmos(ETMPROCID[26], ETMPROCID_xmgxi[26], 0);
pmos(ETMPROCID[27], ETMPROCID_xmgxi[27], 0);
pmos(ETMPROCID[28], ETMPROCID_xmgxi[28], 0);
pmos(ETMPROCID[29], ETMPROCID_xmgxi[29], 0);
pmos(ETMPROCID[30], ETMPROCID_xmgxi[30], 0);
pmos(ETMPROCID[31], ETMPROCID_xmgxi[31], 0);
pmos(ETMPROCIDWR, ETMPROCIDWR_xmgxi, 0);
pmos(ETMINSTRVALID, ETMINSTRVALID_xmgxi, 0);
pmos(GateTheCLK, GateTheCLK_xmgxi, 0);
wire [31:0] ITCMWData_xmgxi;
pmos(ITCMWData[0], ITCMWData_xmgxi[0], 0);
pmos(ITCMWData[1], ITCMWData_xmgxi[1], 0);
pmos(ITCMWData[2], ITCMWData_xmgxi[2], 0);
pmos(ITCMWData[3], ITCMWData_xmgxi[3], 0);
pmos(ITCMWData[4], ITCMWData_xmgxi[4], 0);
pmos(ITCMWData[5], ITCMWData_xmgxi[5], 0);
pmos(ITCMWData[6], ITCMWData_xmgxi[6], 0);
pmos(ITCMWData[7], ITCMWData_xmgxi[7], 0);
pmos(ITCMWData[8], ITCMWData_xmgxi[8], 0);
pmos(ITCMWData[9], ITCMWData_xmgxi[9], 0);
pmos(ITCMWData[10], ITCMWData_xmgxi[10], 0);
pmos(ITCMWData[11], ITCMWData_xmgxi[11], 0);
pmos(ITCMWData[12], ITCMWData_xmgxi[12], 0);
pmos(ITCMWData[13], ITCMWData_xmgxi[13], 0);
pmos(ITCMWData[14], ITCMWData_xmgxi[14], 0);
pmos(ITCMWData[15], ITCMWData_xmgxi[15], 0);
pmos(ITCMWData[16], ITCMWData_xmgxi[16], 0);
pmos(ITCMWData[17], ITCMWData_xmgxi[17], 0);
pmos(ITCMWData[18], ITCMWData_xmgxi[18], 0);
pmos(ITCMWData[19], ITCMWData_xmgxi[19], 0);
pmos(ITCMWData[20], ITCMWData_xmgxi[20], 0);
pmos(ITCMWData[21], ITCMWData_xmgxi[21], 0);
pmos(ITCMWData[22], ITCMWData_xmgxi[22], 0);
pmos(ITCMWData[23], ITCMWData_xmgxi[23], 0);
pmos(ITCMWData[24], ITCMWData_xmgxi[24], 0);
pmos(ITCMWData[25], ITCMWData_xmgxi[25], 0);
pmos(ITCMWData[26], ITCMWData_xmgxi[26], 0);
pmos(ITCMWData[27], ITCMWData_xmgxi[27], 0);
pmos(ITCMWData[28], ITCMWData_xmgxi[28], 0);
pmos(ITCMWData[29], ITCMWData_xmgxi[29], 0);
pmos(ITCMWData[30], ITCMWData_xmgxi[30], 0);
pmos(ITCMWData[31], ITCMWData_xmgxi[31], 0);
wire [3:0] ITCMWEn_xmgxi;
pmos(ITCMWEn[0], ITCMWEn_xmgxi[0], 0);
pmos(ITCMWEn[1], ITCMWEn_xmgxi[1], 0);
pmos(ITCMWEn[2], ITCMWEn_xmgxi[2], 0);
pmos(ITCMWEn[3], ITCMWEn_xmgxi[3], 0);
pmos(ITCMEn, ITCMEn_xmgxi, 0);
wire [17:0] ITCMAdrs_xmgxi;
pmos(ITCMAdrs[0], ITCMAdrs_xmgxi[0], 0);
pmos(ITCMAdrs[1], ITCMAdrs_xmgxi[1], 0);
pmos(ITCMAdrs[2], ITCMAdrs_xmgxi[2], 0);
pmos(ITCMAdrs[3], ITCMAdrs_xmgxi[3], 0);
pmos(ITCMAdrs[4], ITCMAdrs_xmgxi[4], 0);
pmos(ITCMAdrs[5], ITCMAdrs_xmgxi[5], 0);
pmos(ITCMAdrs[6], ITCMAdrs_xmgxi[6], 0);
pmos(ITCMAdrs[7], ITCMAdrs_xmgxi[7], 0);
pmos(ITCMAdrs[8], ITCMAdrs_xmgxi[8], 0);
pmos(ITCMAdrs[9], ITCMAdrs_xmgxi[9], 0);
pmos(ITCMAdrs[10], ITCMAdrs_xmgxi[10], 0);
pmos(ITCMAdrs[11], ITCMAdrs_xmgxi[11], 0);
pmos(ITCMAdrs[12], ITCMAdrs_xmgxi[12], 0);
pmos(ITCMAdrs[13], ITCMAdrs_xmgxi[13], 0);
pmos(ITCMAdrs[14], ITCMAdrs_xmgxi[14], 0);
pmos(ITCMAdrs[15], ITCMAdrs_xmgxi[15], 0);
pmos(ITCMAdrs[16], ITCMAdrs_xmgxi[16], 0);
pmos(ITCMAdrs[17], ITCMAdrs_xmgxi[17], 0);
wire [31:0] DTCMWData_xmgxi;
pmos(DTCMWData[0], DTCMWData_xmgxi[0], 0);
pmos(DTCMWData[1], DTCMWData_xmgxi[1], 0);
pmos(DTCMWData[2], DTCMWData_xmgxi[2], 0);
pmos(DTCMWData[3], DTCMWData_xmgxi[3], 0);
pmos(DTCMWData[4], DTCMWData_xmgxi[4], 0);
pmos(DTCMWData[5], DTCMWData_xmgxi[5], 0);
pmos(DTCMWData[6], DTCMWData_xmgxi[6], 0);
pmos(DTCMWData[7], DTCMWData_xmgxi[7], 0);
pmos(DTCMWData[8], DTCMWData_xmgxi[8], 0);
pmos(DTCMWData[9], DTCMWData_xmgxi[9], 0);
pmos(DTCMWData[10], DTCMWData_xmgxi[10], 0);
pmos(DTCMWData[11], DTCMWData_xmgxi[11], 0);
pmos(DTCMWData[12], DTCMWData_xmgxi[12], 0);
pmos(DTCMWData[13], DTCMWData_xmgxi[13], 0);
pmos(DTCMWData[14], DTCMWData_xmgxi[14], 0);
pmos(DTCMWData[15], DTCMWData_xmgxi[15], 0);
pmos(DTCMWData[16], DTCMWData_xmgxi[16], 0);
pmos(DTCMWData[17], DTCMWData_xmgxi[17], 0);
pmos(DTCMWData[18], DTCMWData_xmgxi[18], 0);
pmos(DTCMWData[19], DTCMWData_xmgxi[19], 0);
pmos(DTCMWData[20], DTCMWData_xmgxi[20], 0);
pmos(DTCMWData[21], DTCMWData_xmgxi[21], 0);
pmos(DTCMWData[22], DTCMWData_xmgxi[22], 0);
pmos(DTCMWData[23], DTCMWData_xmgxi[23], 0);
pmos(DTCMWData[24], DTCMWData_xmgxi[24], 0);
pmos(DTCMWData[25], DTCMWData_xmgxi[25], 0);
pmos(DTCMWData[26], DTCMWData_xmgxi[26], 0);
pmos(DTCMWData[27], DTCMWData_xmgxi[27], 0);
pmos(DTCMWData[28], DTCMWData_xmgxi[28], 0);
pmos(DTCMWData[29], DTCMWData_xmgxi[29], 0);
pmos(DTCMWData[30], DTCMWData_xmgxi[30], 0);
pmos(DTCMWData[31], DTCMWData_xmgxi[31], 0);
wire [3:0] DTCMWEn_xmgxi;
pmos(DTCMWEn[0], DTCMWEn_xmgxi[0], 0);
pmos(DTCMWEn[1], DTCMWEn_xmgxi[1], 0);
pmos(DTCMWEn[2], DTCMWEn_xmgxi[2], 0);
pmos(DTCMWEn[3], DTCMWEn_xmgxi[3], 0);
pmos(DTCMEn, DTCMEn_xmgxi, 0);
wire [17:0] DTCMAdrs_xmgxi;
pmos(DTCMAdrs[0], DTCMAdrs_xmgxi[0], 0);
pmos(DTCMAdrs[1], DTCMAdrs_xmgxi[1], 0);
pmos(DTCMAdrs[2], DTCMAdrs_xmgxi[2], 0);
pmos(DTCMAdrs[3], DTCMAdrs_xmgxi[3], 0);
pmos(DTCMAdrs[4], DTCMAdrs_xmgxi[4], 0);
pmos(DTCMAdrs[5], DTCMAdrs_xmgxi[5], 0);
pmos(DTCMAdrs[6], DTCMAdrs_xmgxi[6], 0);
pmos(DTCMAdrs[7], DTCMAdrs_xmgxi[7], 0);
pmos(DTCMAdrs[8], DTCMAdrs_xmgxi[8], 0);
pmos(DTCMAdrs[9], DTCMAdrs_xmgxi[9], 0);
pmos(DTCMAdrs[10], DTCMAdrs_xmgxi[10], 0);
pmos(DTCMAdrs[11], DTCMAdrs_xmgxi[11], 0);
pmos(DTCMAdrs[12], DTCMAdrs_xmgxi[12], 0);
pmos(DTCMAdrs[13], DTCMAdrs_xmgxi[13], 0);
pmos(DTCMAdrs[14], DTCMAdrs_xmgxi[14], 0);
pmos(DTCMAdrs[15], DTCMAdrs_xmgxi[15], 0);
pmos(DTCMAdrs[16], DTCMAdrs_xmgxi[16], 0);
pmos(DTCMAdrs[17], DTCMAdrs_xmgxi[17], 0);
pmos(SCANOUT1, SCANOUT1_xmgxi, 0);
pmos(SCANOUT2, SCANOUT2_xmgxi, 0);
pmos(SCANOUT3, SCANOUT3_xmgxi, 0);
pmos(SCANOUT4, SCANOUT4_xmgxi, 0);
pmos(HRESETn_xmgxi, HRESETn, 0);
pmos(HCLKEN_xmgxi, HCLKEN, 0);
pmos(CLK_xmgxi, CLK, 0);
pmos(HGRANT_xmgxi, HGRANT, 0);
wire [31:0] HRDATA_xmgxi;
pmos(HRDATA_xmgxi[0], HRDATA[0], 0);
pmos(HRDATA_xmgxi[1], HRDATA[1], 0);
pmos(HRDATA_xmgxi[2], HRDATA[2], 0);
pmos(HRDATA_xmgxi[3], HRDATA[3], 0);
pmos(HRDATA_xmgxi[4], HRDATA[4], 0);
pmos(HRDATA_xmgxi[5], HRDATA[5], 0);
pmos(HRDATA_xmgxi[6], HRDATA[6], 0);
pmos(HRDATA_xmgxi[7], HRDATA[7], 0);
pmos(HRDATA_xmgxi[8], HRDATA[8], 0);
pmos(HRDATA_xmgxi[9], HRDATA[9], 0);
pmos(HRDATA_xmgxi[10], HRDATA[10], 0);
pmos(HRDATA_xmgxi[11], HRDATA[11], 0);
pmos(HRDATA_xmgxi[12], HRDATA[12], 0);
pmos(HRDATA_xmgxi[13], HRDATA[13], 0);
pmos(HRDATA_xmgxi[14], HRDATA[14], 0);
pmos(HRDATA_xmgxi[15], HRDATA[15], 0);
pmos(HRDATA_xmgxi[16], HRDATA[16], 0);
pmos(HRDATA_xmgxi[17], HRDATA[17], 0);
pmos(HRDATA_xmgxi[18], HRDATA[18], 0);
pmos(HRDATA_xmgxi[19], HRDATA[19], 0);
pmos(HRDATA_xmgxi[20], HRDATA[20], 0);
pmos(HRDATA_xmgxi[21], HRDATA[21], 0);
pmos(HRDATA_xmgxi[22], HRDATA[22], 0);
pmos(HRDATA_xmgxi[23], HRDATA[23], 0);
pmos(HRDATA_xmgxi[24], HRDATA[24], 0);
pmos(HRDATA_xmgxi[25], HRDATA[25], 0);
pmos(HRDATA_xmgxi[26], HRDATA[26], 0);
pmos(HRDATA_xmgxi[27], HRDATA[27], 0);
pmos(HRDATA_xmgxi[28], HRDATA[28], 0);
pmos(HRDATA_xmgxi[29], HRDATA[29], 0);
pmos(HRDATA_xmgxi[30], HRDATA[30], 0);
pmos(HRDATA_xmgxi[31], HRDATA[31], 0);
pmos(HREADY_xmgxi, HREADY, 0);
wire [1:0] HRESP_xmgxi;
pmos(HRESP_xmgxi[0], HRESP[0], 0);
pmos(HRESP_xmgxi[1], HRESP[1], 0);
wire [31:0] CPDIN_xmgxi;
pmos(CPDIN_xmgxi[0], CPDIN[0], 0);
pmos(CPDIN_xmgxi[1], CPDIN[1], 0);
pmos(CPDIN_xmgxi[2], CPDIN[2], 0);
pmos(CPDIN_xmgxi[3], CPDIN[3], 0);
pmos(CPDIN_xmgxi[4], CPDIN[4], 0);
pmos(CPDIN_xmgxi[5], CPDIN[5], 0);
pmos(CPDIN_xmgxi[6], CPDIN[6], 0);
pmos(CPDIN_xmgxi[7], CPDIN[7], 0);
pmos(CPDIN_xmgxi[8], CPDIN[8], 0);
pmos(CPDIN_xmgxi[9], CPDIN[9], 0);
pmos(CPDIN_xmgxi[10], CPDIN[10], 0);
pmos(CPDIN_xmgxi[11], CPDIN[11], 0);
pmos(CPDIN_xmgxi[12], CPDIN[12], 0);
pmos(CPDIN_xmgxi[13], CPDIN[13], 0);
pmos(CPDIN_xmgxi[14], CPDIN[14], 0);
pmos(CPDIN_xmgxi[15], CPDIN[15], 0);
pmos(CPDIN_xmgxi[16], CPDIN[16], 0);
pmos(CPDIN_xmgxi[17], CPDIN[17], 0);
pmos(CPDIN_xmgxi[18], CPDIN[18], 0);
pmos(CPDIN_xmgxi[19], CPDIN[19], 0);
pmos(CPDIN_xmgxi[20], CPDIN[20], 0);
pmos(CPDIN_xmgxi[21], CPDIN[21], 0);
pmos(CPDIN_xmgxi[22], CPDIN[22], 0);
pmos(CPDIN_xmgxi[23], CPDIN[23], 0);
pmos(CPDIN_xmgxi[24], CPDIN[24], 0);
pmos(CPDIN_xmgxi[25], CPDIN[25], 0);
pmos(CPDIN_xmgxi[26], CPDIN[26], 0);
pmos(CPDIN_xmgxi[27], CPDIN[27], 0);
pmos(CPDIN_xmgxi[28], CPDIN[28], 0);
pmos(CPDIN_xmgxi[29], CPDIN[29], 0);
pmos(CPDIN_xmgxi[30], CPDIN[30], 0);
pmos(CPDIN_xmgxi[31], CPDIN[31], 0);
wire [1:0] CHSDE_xmgxi;
pmos(CHSDE_xmgxi[0], CHSDE[0], 0);
pmos(CHSDE_xmgxi[1], CHSDE[1], 0);
wire [1:0] CHSEX_xmgxi;
pmos(CHSEX_xmgxi[0], CHSEX[0], 0);
pmos(CHSEX_xmgxi[1], CHSEX[1], 0);
pmos(DBGEN_xmgxi, DBGEN, 0);
pmos(EDBGRQ_xmgxi, EDBGRQ, 0);
wire [1:0] DBGEXT_xmgxi;
pmos(DBGEXT_xmgxi[0], DBGEXT[0], 0);
pmos(DBGEXT_xmgxi[1], DBGEXT[1], 0);
pmos(DBGIEBKPT_xmgxi, DBGIEBKPT, 0);
pmos(DBGDEWPT_xmgxi, DBGDEWPT, 0);
pmos(DBGnTRST_xmgxi, DBGnTRST, 0);
pmos(DBGTCKEN_xmgxi, DBGTCKEN, 0);
pmos(DBGTDI_xmgxi, DBGTDI, 0);
pmos(DBGTMS_xmgxi, DBGTMS, 0);
pmos(DBGSDOUT_xmgxi, DBGSDOUT, 0);
pmos(nFIQ_xmgxi, nFIQ, 0);
pmos(nIRQ_xmgxi, nIRQ, 0);
pmos(VINITHI_xmgxi, VINITHI, 0);
pmos(INITRAM_xmgxi, INITRAM, 0);
wire [31:0] TAPID_xmgxi;
pmos(TAPID_xmgxi[0], TAPID[0], 0);
pmos(TAPID_xmgxi[1], TAPID[1], 0);
pmos(TAPID_xmgxi[2], TAPID[2], 0);
pmos(TAPID_xmgxi[3], TAPID[3], 0);
pmos(TAPID_xmgxi[4], TAPID[4], 0);
pmos(TAPID_xmgxi[5], TAPID[5], 0);
pmos(TAPID_xmgxi[6], TAPID[6], 0);
pmos(TAPID_xmgxi[7], TAPID[7], 0);
pmos(TAPID_xmgxi[8], TAPID[8], 0);
pmos(TAPID_xmgxi[9], TAPID[9], 0);
pmos(TAPID_xmgxi[10], TAPID[10], 0);
pmos(TAPID_xmgxi[11], TAPID[11], 0);
pmos(TAPID_xmgxi[12], TAPID[12], 0);
pmos(TAPID_xmgxi[13], TAPID[13], 0);
pmos(TAPID_xmgxi[14], TAPID[14], 0);
pmos(TAPID_xmgxi[15], TAPID[15], 0);
pmos(TAPID_xmgxi[16], TAPID[16], 0);
pmos(TAPID_xmgxi[17], TAPID[17], 0);
pmos(TAPID_xmgxi[18], TAPID[18], 0);
pmos(TAPID_xmgxi[19], TAPID[19], 0);
pmos(TAPID_xmgxi[20], TAPID[20], 0);
pmos(TAPID_xmgxi[21], TAPID[21], 0);
pmos(TAPID_xmgxi[22], TAPID[22], 0);
pmos(TAPID_xmgxi[23], TAPID[23], 0);
pmos(TAPID_xmgxi[24], TAPID[24], 0);
pmos(TAPID_xmgxi[25], TAPID[25], 0);
pmos(TAPID_xmgxi[26], TAPID[26], 0);
pmos(TAPID_xmgxi[27], TAPID[27], 0);
pmos(TAPID_xmgxi[28], TAPID[28], 0);
pmos(TAPID_xmgxi[29], TAPID[29], 0);
pmos(TAPID_xmgxi[30], TAPID[30], 0);
pmos(TAPID_xmgxi[31], TAPID[31], 0);
wire [3:0] DCacheSize_xmgxi;
pmos(DCacheSize_xmgxi[0], DCacheSize[0], 0);
pmos(DCacheSize_xmgxi[1], DCacheSize[1], 0);
pmos(DCacheSize_xmgxi[2], DCacheSize[2], 0);
pmos(DCacheSize_xmgxi[3], DCacheSize[3], 0);
wire [3:0] ICacheSize_xmgxi;
pmos(ICacheSize_xmgxi[0], ICacheSize[0], 0);
pmos(ICacheSize_xmgxi[1], ICacheSize[1], 0);
pmos(ICacheSize_xmgxi[2], ICacheSize[2], 0);
pmos(ICacheSize_xmgxi[3], ICacheSize[3], 0);
pmos(ETMEN_xmgxi, ETMEN, 0);
pmos(SCANEN_xmgxi, SCANEN, 0);
pmos(TESTMODE_xmgxi, TESTMODE, 0);
pmos(SCANIN1_xmgxi, SCANIN1, 0);
pmos(SCANIN2_xmgxi, SCANIN2, 0);
pmos(SCANIN3_xmgxi, SCANIN3, 0);
pmos(SCANIN4_xmgxi, SCANIN4, 0);
pmos(ETMFIFOFULL_xmgxi, ETMFIFOFULL, 0);
pmos(UnGatedCLK_xmgxi, UnGatedCLK, 0);
wire [31:0] ITCMRData_xmgxi;
pmos(ITCMRData_xmgxi[0], ITCMRData[0], 0);
pmos(ITCMRData_xmgxi[1], ITCMRData[1], 0);
pmos(ITCMRData_xmgxi[2], ITCMRData[2], 0);
pmos(ITCMRData_xmgxi[3], ITCMRData[3], 0);
pmos(ITCMRData_xmgxi[4], ITCMRData[4], 0);
pmos(ITCMRData_xmgxi[5], ITCMRData[5], 0);
pmos(ITCMRData_xmgxi[6], ITCMRData[6], 0);
pmos(ITCMRData_xmgxi[7], ITCMRData[7], 0);
pmos(ITCMRData_xmgxi[8], ITCMRData[8], 0);
pmos(ITCMRData_xmgxi[9], ITCMRData[9], 0);
pmos(ITCMRData_xmgxi[10], ITCMRData[10], 0);
pmos(ITCMRData_xmgxi[11], ITCMRData[11], 0);
pmos(ITCMRData_xmgxi[12], ITCMRData[12], 0);
pmos(ITCMRData_xmgxi[13], ITCMRData[13], 0);
pmos(ITCMRData_xmgxi[14], ITCMRData[14], 0);
pmos(ITCMRData_xmgxi[15], ITCMRData[15], 0);
pmos(ITCMRData_xmgxi[16], ITCMRData[16], 0);
pmos(ITCMRData_xmgxi[17], ITCMRData[17], 0);
pmos(ITCMRData_xmgxi[18], ITCMRData[18], 0);
pmos(ITCMRData_xmgxi[19], ITCMRData[19], 0);
pmos(ITCMRData_xmgxi[20], ITCMRData[20], 0);
pmos(ITCMRData_xmgxi[21], ITCMRData[21], 0);
pmos(ITCMRData_xmgxi[22], ITCMRData[22], 0);
pmos(ITCMRData_xmgxi[23], ITCMRData[23], 0);
pmos(ITCMRData_xmgxi[24], ITCMRData[24], 0);
pmos(ITCMRData_xmgxi[25], ITCMRData[25], 0);
pmos(ITCMRData_xmgxi[26], ITCMRData[26], 0);
pmos(ITCMRData_xmgxi[27], ITCMRData[27], 0);
pmos(ITCMRData_xmgxi[28], ITCMRData[28], 0);
pmos(ITCMRData_xmgxi[29], ITCMRData[29], 0);
pmos(ITCMRData_xmgxi[30], ITCMRData[30], 0);
pmos(ITCMRData_xmgxi[31], ITCMRData[31], 0);
wire [31:0] DTCMRData_xmgxi;
pmos(DTCMRData_xmgxi[0], DTCMRData[0], 0);
pmos(DTCMRData_xmgxi[1], DTCMRData[1], 0);
pmos(DTCMRData_xmgxi[2], DTCMRData[2], 0);
pmos(DTCMRData_xmgxi[3], DTCMRData[3], 0);
pmos(DTCMRData_xmgxi[4], DTCMRData[4], 0);
pmos(DTCMRData_xmgxi[5], DTCMRData[5], 0);
pmos(DTCMRData_xmgxi[6], DTCMRData[6], 0);
pmos(DTCMRData_xmgxi[7], DTCMRData[7], 0);
pmos(DTCMRData_xmgxi[8], DTCMRData[8], 0);
pmos(DTCMRData_xmgxi[9], DTCMRData[9], 0);
pmos(DTCMRData_xmgxi[10], DTCMRData[10], 0);
pmos(DTCMRData_xmgxi[11], DTCMRData[11], 0);
pmos(DTCMRData_xmgxi[12], DTCMRData[12], 0);
pmos(DTCMRData_xmgxi[13], DTCMRData[13], 0);
pmos(DTCMRData_xmgxi[14], DTCMRData[14], 0);
pmos(DTCMRData_xmgxi[15], DTCMRData[15], 0);
pmos(DTCMRData_xmgxi[16], DTCMRData[16], 0);
pmos(DTCMRData_xmgxi[17], DTCMRData[17], 0);
pmos(DTCMRData_xmgxi[18], DTCMRData[18], 0);
pmos(DTCMRData_xmgxi[19], DTCMRData[19], 0);
pmos(DTCMRData_xmgxi[20], DTCMRData[20], 0);
pmos(DTCMRData_xmgxi[21], DTCMRData[21], 0);
pmos(DTCMRData_xmgxi[22], DTCMRData[22], 0);
pmos(DTCMRData_xmgxi[23], DTCMRData[23], 0);
pmos(DTCMRData_xmgxi[24], DTCMRData[24], 0);
pmos(DTCMRData_xmgxi[25], DTCMRData[25], 0);
pmos(DTCMRData_xmgxi[26], DTCMRData[26], 0);
pmos(DTCMRData_xmgxi[27], DTCMRData[27], 0);
pmos(DTCMRData_xmgxi[28], DTCMRData[28], 0);
pmos(DTCMRData_xmgxi[29], DTCMRData[29], 0);
pmos(DTCMRData_xmgxi[30], DTCMRData[30], 0);
pmos(DTCMRData_xmgxi[31], DTCMRData[31], 0);
wire [3:0] PhyDTCMSize_xmgxi;
pmos(PhyDTCMSize_xmgxi[0], PhyDTCMSize[0], 0);
pmos(PhyDTCMSize_xmgxi[1], PhyDTCMSize[1], 0);
pmos(PhyDTCMSize_xmgxi[2], PhyDTCMSize[2], 0);
pmos(PhyDTCMSize_xmgxi[3], PhyDTCMSize[3], 0);
wire [3:0] PhyITCMSize_xmgxi;
pmos(PhyITCMSize_xmgxi[0], PhyITCMSize[0], 0);
pmos(PhyITCMSize_xmgxi[1], PhyITCMSize[1], 0);
pmos(PhyITCMSize_xmgxi[2], PhyITCMSize[2], 0);
pmos(PhyITCMSize_xmgxi[3], PhyITCMSize[3], 0);

reg CLK_xmgxcopy;

always @(CLK_xmgxi)
begin
  CLK_xmgxcopy <= #1 CLK_xmgxi;
end

reg UnGatedCLK_xmgxcopy;

always @(UnGatedCLK_xmgxi)
begin
  UnGatedCLK_xmgxcopy <= #1 UnGatedCLK_xmgxi;
end

reg notifierxmgx0;

always @(notifierxmgx0)
begin
  $display("Setup/hold violation on signal nFIQ, reference rising UnGatedCLK (Tungatednfiqs/Tungatednfiqh)");
end
reg notifierxmgx1;

always @(notifierxmgx1)
begin
  $display("Setup/hold violation on signal nFIQ, reference rising CLK (Tints/Tinth)");
end
reg notifierxmgx2;

always @(notifierxmgx2)
begin
  $display("Setup/hold violation on signal nIRQ, reference rising UnGatedCLK (Tungatednirqs/Tungatednirqh)");
end
reg notifierxmgx3;

always @(notifierxmgx3)
begin
  $display("Setup/hold violation on signal nIRQ, reference rising CLK (Tints/Tinth)");
end
reg notifierxmgx4;

always @(notifierxmgx4)
begin
  $display("Setup/hold violation on signal VINITHI, reference rising CLK (Tithis/Tithih)");
end
reg notifierxmgx5;

always @(notifierxmgx5)
begin
  $display("Setup/hold violation on signal INITRAM, reference rising CLK (Tinitrams/Tinitramh)");
end
reg notifierxmgx6;

always @(notifierxmgx6)
begin
  $display("Setup/hold violation on signal HCLKEN, reference rising CLK (Thclkens/Thclkenh)");
end
reg notifierxmgx7;

always @(notifierxmgx7)
begin
  $display("Setup/hold violation on signal TAPID, reference rising CLK (Ttapids/Ttapidh)");
end
reg notifierxmgx8;

always @(notifierxmgx8)
begin
  $display("Setup/hold violation on signal CPDIN, reference rising CLK (Tcpdins/Tcpdinh)");
end
reg notifierxmgx9;

always @(notifierxmgx9)
begin
  $display("Setup/hold violation on signal CHSDE, reference rising CLK (Tchss/Tchsh)");
end
reg notifierxmgx10;

always @(notifierxmgx10)
begin
  $display("Setup/hold violation on signal CHSEX, reference rising CLK (Tchss/Tchsh)");
end
reg notifierxmgx11;

always @(notifierxmgx11)
begin
  $display("Setup/hold violation on signal DBGEN, reference rising UnGatedCLK (Tungateddbgens/Tungateddbgenh)");
end
reg notifierxmgx12;

always @(notifierxmgx12)
begin
  $display("Setup/hold violation on signal DBGEN, reference rising CLK (Tdbgens/Tdbgenh)");
end
reg notifierxmgx13;

always @(notifierxmgx13)
begin
  $display("Setup/hold violation on signal EDBGRQ, reference rising UnGatedCLK (Tungatededbgrqs/Tungatededbgrgh)");
end
reg notifierxmgx14;

always @(notifierxmgx14)
begin
  $display("Setup/hold violation on signal EDBGRQ, reference rising CLK (Tedbgrqs/Tedbgrgh)");
end
reg notifierxmgx15;

always @(notifierxmgx15)
begin
  $display("Setup/hold violation on signal DBGIEBKPT, reference rising CLK (Tbrkpts/Tbrkpth)");
end
reg notifierxmgx16;

always @(notifierxmgx16)
begin
  $display("Setup/hold violation on signal DBGDEWPT, reference rising CLK (Twpts/Twpth)");
end
reg notifierxmgx17;

always @(notifierxmgx17)
begin
  $display("Setup/hold violation on signal DBGEXT, reference rising CLK (Tbgexts/Tbgexth)");
end
reg notifierxmgx18;

always @(notifierxmgx18)
begin
  $display("Setup/hold violation on signal DBGTDI, reference rising CLK (Ttdis/Tdhih)");
end
reg notifierxmgx19;

always @(notifierxmgx19)
begin
  $display("Setup/hold violation on signal DBGTMS, reference rising CLK (Ttdis/Tdhih)");
end
reg notifierxmgx20;

always @(notifierxmgx20)
begin
  $display("Setup/hold violation on signal DBGTCKEN, reference rising CLK (Tbgtckens/Tbgtckenh)");
end
reg notifierxmgx21;

always @(notifierxmgx21)
begin
  $display("Setup/hold violation on signal DBGSDOUT, reference rising CLK (Tbgsdouts/Tbgsdouth)");
end
reg notifierxmgx22;

always @(notifierxmgx22)
begin
  $display("Setup/hold violation on signal DBGnTRST, reference rising CLK (Ttdis/Tdhih)");
end
reg notifierxmgx23;

always @(notifierxmgx23)
begin
  $display("Setup/hold violation on signal ETMEN, reference rising CLK (Tetmens/Tetmenh)");
end
reg notifierxmgx24;

always @(notifierxmgx24)
begin
  $display("Setup/hold violation on signal HREADY, reference rising CLK (Tisrdy/Tihrdy)");
end
reg notifierxmgx25;

always @(notifierxmgx25)
begin
  $display("Setup/hold violation on signal HRESP, reference rising CLK (Tisrsp/Tihrsp)");
end
reg notifierxmgx26;

always @(notifierxmgx26)
begin
  $display("Setup/hold violation on signal HRDATA, reference rising CLK (Tisrd/Tihrd)");
end
reg notifierxmgx27;

always @(notifierxmgx27)
begin
  $display("Setup/hold violation on signal HGRANT, reference rising CLK (Tisgnt/Tihgnt)");
end
reg notifierxmgx28;

always @(notifierxmgx28)
begin
  $display("Setup/hold violation on signal HRESETn, reference rising CLK (Tisrst/Tihrst)");
end
reg notifierxmgx29;

always @(notifierxmgx29)
begin
  $display("Setup/hold violation on signal SCANEN, reference rising UnGatedCLK (Tungatedscans/Tungatedscanh)");
end
reg notifierxmgx30;

always @(notifierxmgx30)
begin
  $display("Setup/hold violation on signal SCANEN, reference rising CLK (Tscans/Tscanh)");
end
reg notifierxmgx31;

always @(notifierxmgx31)
begin
  $display("Setup/hold violation on signal TESTMODE, reference rising CLK (Ttestmodes/Ttestmodeh)");
end
reg notifierxmgx32;

always @(notifierxmgx32)
begin
  $display("Setup/hold violation on signal SCANIN1, reference rising UnGatedCLK (Tungatedscanin1s/Tungatedscanin1h)");
end
reg notifierxmgx33;

always @(notifierxmgx33)
begin
  $display("Setup/hold violation on signal SCANIN1, reference rising CLK (Tscanin1s/Tscanin1h)");
end
reg notifierxmgx34;

always @(notifierxmgx34)
begin
  $display("Setup/hold violation on signal SCANIN2, reference rising UnGatedCLK (Tungatedscanin2s/Tungatedscanin2h)");
end
reg notifierxmgx35;

always @(notifierxmgx35)
begin
  $display("Setup/hold violation on signal SCANIN2, reference rising CLK (Tscanin2s/Tscanin2h)");
end
reg notifierxmgx36;

always @(notifierxmgx36)
begin
  $display("Setup/hold violation on signal SCANIN3, reference rising UnGatedCLK (Tungatedscanin3s/Tungatedscanin3h)");
end
reg notifierxmgx37;

always @(notifierxmgx37)
begin
  $display("Setup/hold violation on signal SCANIN3, reference rising CLK (Tscanin3s/Tscanin3h)");
end
reg notifierxmgx38;

always @(notifierxmgx38)
begin
  $display("Setup/hold violation on signal SCANIN4, reference rising UnGatedCLK (Tungatedscanin4s/Tungatedscanin4h)");
end
reg notifierxmgx39;

always @(notifierxmgx39)
begin
  $display("Setup/hold violation on signal SCANIN4, reference rising CLK (Tscanin4s/Tscanin4h)");
end
reg notifierxmgx40;

always @(notifierxmgx40)
begin
  $display("Setup/hold violation on signal ETMFIFOFULL, reference rising CLK (Tetmfifofulls/Tetmfifofullh)");
end
reg notifierxmgx41;

always @(notifierxmgx41)
begin
  $display("Setup/hold violation on signal ITCMRData, reference rising CLK (Titcmrdatas/Titcmrdatah)");
end
reg notifierxmgx42;

always @(notifierxmgx42)
begin
  $display("Setup/hold violation on signal DTCMRData, reference rising CLK (Tdtcmrdatas/Tdtcmrdatah)");
end
reg notifierxmgx43;

always @(notifierxmgx43)
begin
  $display("Setup/hold violation on signal PhyDTCMSize, reference rising CLK (Tphydtcmsizes/Tphydtcmsizeh)");
end
reg notifierxmgx44;

always @(notifierxmgx44)
begin
  $display("Setup/hold violation on signal PhyITCMSize, reference rising CLK (Tphyitcmsizes/Tphyitcmsizeh)");
end
reg notifierxmgx45;

always @(notifierxmgx45)
begin
  $display("Setup/hold violation on signal DCacheSize, reference rising CLK (Tcachesizeh/Tcachesizev)");
end
reg notifierxmgx46;

always @(notifierxmgx46)
begin
  $display("Setup/hold violation on signal ICacheSize, reference rising CLK (Tcachesizeh/Tcachesizev)");
end
reg notifierxmgx47;

always @(notifierxmgx47)
begin
  $display("Period violation (Ttclkph) on signal CLK");
end
reg notifierxmgx48;

always @(notifierxmgx48)
begin
  $display("Width low violation (Ttclkwh) on signal CLK");
end
reg notifierxmgx49;

always @(notifierxmgx49)
begin
  $display("Width high violation (Ttclkws) on signal CLK");
end
reg notifierxmgx50;

always @(notifierxmgx50)
begin
  $display("Period violation (Ttunclkph) on signal UnGatedCLK");
end
reg notifierxmgx51;

always @(notifierxmgx51)
begin
  $display("Width low violation (Tungatedclkh) on signal UnGatedCLK");
end
reg notifierxmgx52;

always @(notifierxmgx52)
begin
  $display("Width high violation (Tungatedclks) on signal UnGatedCLK");
end
specify

// Input checks

$setuphold(posedge UnGatedCLK, nFIQ, 0, 0, notifierxmgx0,,,UnGatedCLK_xmgxnegd, nFIQ_xmgxnegd); // rising
$setuphold(posedge CLK, nFIQ, 0, 0, notifierxmgx1,,,CLK_xmgxnegd, nFIQ_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, nIRQ, 0, 0, notifierxmgx2,,,UnGatedCLK_xmgxnegd, nIRQ_xmgxnegd); // rising
$setuphold(posedge CLK, nIRQ, 0, 0, notifierxmgx3,,,CLK_xmgxnegd, nIRQ_xmgxnegd); // rising
$setuphold(posedge CLK, VINITHI, 0, 0, notifierxmgx4,,,CLK_xmgxnegd, VINITHI_xmgxnegd); // rising
$setuphold(posedge CLK, INITRAM, 0, 0, notifierxmgx5,,,CLK_xmgxnegd, INITRAM_xmgxnegd); // rising
$setuphold(posedge CLK, HCLKEN, 0, 0, notifierxmgx6,,,CLK_xmgxnegd, HCLKEN_xmgxnegd); // rising
$setuphold(posedge CLK, TAPID[0], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[0]); // rising
$setuphold(posedge CLK, TAPID[1], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[1]); // rising
$setuphold(posedge CLK, TAPID[2], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[2]); // rising
$setuphold(posedge CLK, TAPID[3], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[3]); // rising
$setuphold(posedge CLK, TAPID[4], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[4]); // rising
$setuphold(posedge CLK, TAPID[5], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[5]); // rising
$setuphold(posedge CLK, TAPID[6], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[6]); // rising
$setuphold(posedge CLK, TAPID[7], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[7]); // rising
$setuphold(posedge CLK, TAPID[8], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[8]); // rising
$setuphold(posedge CLK, TAPID[9], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[9]); // rising
$setuphold(posedge CLK, TAPID[10], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[10]); // rising
$setuphold(posedge CLK, TAPID[11], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[11]); // rising
$setuphold(posedge CLK, TAPID[12], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[12]); // rising
$setuphold(posedge CLK, TAPID[13], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[13]); // rising
$setuphold(posedge CLK, TAPID[14], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[14]); // rising
$setuphold(posedge CLK, TAPID[15], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[15]); // rising
$setuphold(posedge CLK, TAPID[16], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[16]); // rising
$setuphold(posedge CLK, TAPID[17], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[17]); // rising
$setuphold(posedge CLK, TAPID[18], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[18]); // rising
$setuphold(posedge CLK, TAPID[19], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[19]); // rising
$setuphold(posedge CLK, TAPID[20], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[20]); // rising
$setuphold(posedge CLK, TAPID[21], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[21]); // rising
$setuphold(posedge CLK, TAPID[22], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[22]); // rising
$setuphold(posedge CLK, TAPID[23], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[23]); // rising
$setuphold(posedge CLK, TAPID[24], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[24]); // rising
$setuphold(posedge CLK, TAPID[25], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[25]); // rising
$setuphold(posedge CLK, TAPID[26], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[26]); // rising
$setuphold(posedge CLK, TAPID[27], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[27]); // rising
$setuphold(posedge CLK, TAPID[28], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[28]); // rising
$setuphold(posedge CLK, TAPID[29], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[29]); // rising
$setuphold(posedge CLK, TAPID[30], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[30]); // rising
$setuphold(posedge CLK, TAPID[31], 0, 0, notifierxmgx7,,,CLK_xmgxnegd, TAPID_xmgxnegd[31]); // rising
$setuphold(posedge CLK, CPDIN[0], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[0]); // rising
$setuphold(posedge CLK, CPDIN[1], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[1]); // rising
$setuphold(posedge CLK, CPDIN[2], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[2]); // rising
$setuphold(posedge CLK, CPDIN[3], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[3]); // rising
$setuphold(posedge CLK, CPDIN[4], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[4]); // rising
$setuphold(posedge CLK, CPDIN[5], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[5]); // rising
$setuphold(posedge CLK, CPDIN[6], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[6]); // rising
$setuphold(posedge CLK, CPDIN[7], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[7]); // rising
$setuphold(posedge CLK, CPDIN[8], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[8]); // rising
$setuphold(posedge CLK, CPDIN[9], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[9]); // rising
$setuphold(posedge CLK, CPDIN[10], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[10]); // rising
$setuphold(posedge CLK, CPDIN[11], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[11]); // rising
$setuphold(posedge CLK, CPDIN[12], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[12]); // rising
$setuphold(posedge CLK, CPDIN[13], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[13]); // rising
$setuphold(posedge CLK, CPDIN[14], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[14]); // rising
$setuphold(posedge CLK, CPDIN[15], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[15]); // rising
$setuphold(posedge CLK, CPDIN[16], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[16]); // rising
$setuphold(posedge CLK, CPDIN[17], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[17]); // rising
$setuphold(posedge CLK, CPDIN[18], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[18]); // rising
$setuphold(posedge CLK, CPDIN[19], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[19]); // rising
$setuphold(posedge CLK, CPDIN[20], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[20]); // rising
$setuphold(posedge CLK, CPDIN[21], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[21]); // rising
$setuphold(posedge CLK, CPDIN[22], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[22]); // rising
$setuphold(posedge CLK, CPDIN[23], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[23]); // rising
$setuphold(posedge CLK, CPDIN[24], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[24]); // rising
$setuphold(posedge CLK, CPDIN[25], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[25]); // rising
$setuphold(posedge CLK, CPDIN[26], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[26]); // rising
$setuphold(posedge CLK, CPDIN[27], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[27]); // rising
$setuphold(posedge CLK, CPDIN[28], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[28]); // rising
$setuphold(posedge CLK, CPDIN[29], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[29]); // rising
$setuphold(posedge CLK, CPDIN[30], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[30]); // rising
$setuphold(posedge CLK, CPDIN[31], 0, 0, notifierxmgx8,,,CLK_xmgxnegd, CPDIN_xmgxnegd[31]); // rising
$setuphold(posedge CLK, CHSDE[0], 0, 0, notifierxmgx9,,,CLK_xmgxnegd, CHSDE_xmgxnegd[0]); // rising
$setuphold(posedge CLK, CHSDE[1], 0, 0, notifierxmgx9,,,CLK_xmgxnegd, CHSDE_xmgxnegd[1]); // rising
$setuphold(posedge CLK, CHSEX[0], 0, 0, notifierxmgx10,,,CLK_xmgxnegd, CHSEX_xmgxnegd[0]); // rising
$setuphold(posedge CLK, CHSEX[1], 0, 0, notifierxmgx10,,,CLK_xmgxnegd, CHSEX_xmgxnegd[1]); // rising
$setuphold(posedge UnGatedCLK, DBGEN, 0, 0, notifierxmgx11,,,UnGatedCLK_xmgxnegd, DBGEN_xmgxnegd); // rising
$setuphold(posedge CLK, DBGEN, 0, 0, notifierxmgx12,,,CLK_xmgxnegd, DBGEN_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, EDBGRQ, 0, 0, notifierxmgx13,,,UnGatedCLK_xmgxnegd, EDBGRQ_xmgxnegd); // rising
$setuphold(posedge CLK, EDBGRQ, 0, 0, notifierxmgx14,,,CLK_xmgxnegd, EDBGRQ_xmgxnegd); // rising
$setuphold(posedge CLK, DBGIEBKPT, 0, 0, notifierxmgx15,,,CLK_xmgxnegd, DBGIEBKPT_xmgxnegd); // rising
$setuphold(posedge CLK, DBGDEWPT, 0, 0, notifierxmgx16,,,CLK_xmgxnegd, DBGDEWPT_xmgxnegd); // rising
$setuphold(posedge CLK, DBGEXT[0], 0, 0, notifierxmgx17,,,CLK_xmgxnegd, DBGEXT_xmgxnegd[0]); // rising
$setuphold(posedge CLK, DBGEXT[1], 0, 0, notifierxmgx17,,,CLK_xmgxnegd, DBGEXT_xmgxnegd[1]); // rising
$setuphold(posedge CLK, DBGTDI, 0, 0, notifierxmgx18,,,CLK_xmgxnegd, DBGTDI_xmgxnegd); // rising
$setuphold(posedge CLK, DBGTMS, 0, 0, notifierxmgx19,,,CLK_xmgxnegd, DBGTMS_xmgxnegd); // rising
$setuphold(posedge CLK, DBGTCKEN, 0, 0, notifierxmgx20,,,CLK_xmgxnegd, DBGTCKEN_xmgxnegd); // rising
$setuphold(posedge CLK, DBGSDOUT, 0, 0, notifierxmgx21,,,CLK_xmgxnegd, DBGSDOUT_xmgxnegd); // rising
$setuphold(posedge CLK, DBGnTRST, 0, 0, notifierxmgx22,,,CLK_xmgxnegd, DBGnTRST_xmgxnegd); // rising
$setuphold(posedge CLK, ETMEN, 0, 0, notifierxmgx23,,,CLK_xmgxnegd, ETMEN_xmgxnegd); // rising
$setuphold(posedge CLK, HREADY, 0, 0, notifierxmgx24,,,CLK_xmgxnegd, HREADY_xmgxnegd); // rising
$setuphold(posedge CLK, HRESP[0], 0, 0, notifierxmgx25,,,CLK_xmgxnegd, HRESP_xmgxnegd[0]); // rising
$setuphold(posedge CLK, HRESP[1], 0, 0, notifierxmgx25,,,CLK_xmgxnegd, HRESP_xmgxnegd[1]); // rising
$setuphold(posedge CLK, HRDATA[0], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[0]); // rising
$setuphold(posedge CLK, HRDATA[1], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[1]); // rising
$setuphold(posedge CLK, HRDATA[2], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[2]); // rising
$setuphold(posedge CLK, HRDATA[3], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[3]); // rising
$setuphold(posedge CLK, HRDATA[4], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[4]); // rising
$setuphold(posedge CLK, HRDATA[5], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[5]); // rising
$setuphold(posedge CLK, HRDATA[6], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[6]); // rising
$setuphold(posedge CLK, HRDATA[7], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[7]); // rising
$setuphold(posedge CLK, HRDATA[8], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[8]); // rising
$setuphold(posedge CLK, HRDATA[9], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[9]); // rising
$setuphold(posedge CLK, HRDATA[10], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[10]); // rising
$setuphold(posedge CLK, HRDATA[11], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[11]); // rising
$setuphold(posedge CLK, HRDATA[12], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[12]); // rising
$setuphold(posedge CLK, HRDATA[13], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[13]); // rising
$setuphold(posedge CLK, HRDATA[14], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[14]); // rising
$setuphold(posedge CLK, HRDATA[15], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[15]); // rising
$setuphold(posedge CLK, HRDATA[16], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[16]); // rising
$setuphold(posedge CLK, HRDATA[17], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[17]); // rising
$setuphold(posedge CLK, HRDATA[18], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[18]); // rising
$setuphold(posedge CLK, HRDATA[19], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[19]); // rising
$setuphold(posedge CLK, HRDATA[20], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[20]); // rising
$setuphold(posedge CLK, HRDATA[21], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[21]); // rising
$setuphold(posedge CLK, HRDATA[22], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[22]); // rising
$setuphold(posedge CLK, HRDATA[23], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[23]); // rising
$setuphold(posedge CLK, HRDATA[24], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[24]); // rising
$setuphold(posedge CLK, HRDATA[25], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[25]); // rising
$setuphold(posedge CLK, HRDATA[26], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[26]); // rising
$setuphold(posedge CLK, HRDATA[27], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[27]); // rising
$setuphold(posedge CLK, HRDATA[28], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[28]); // rising
$setuphold(posedge CLK, HRDATA[29], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[29]); // rising
$setuphold(posedge CLK, HRDATA[30], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[30]); // rising
$setuphold(posedge CLK, HRDATA[31], 0, 0, notifierxmgx26,,,CLK_xmgxnegd, HRDATA_xmgxnegd[31]); // rising
$setuphold(posedge CLK, HGRANT, 0, 0, notifierxmgx27,,,CLK_xmgxnegd, HGRANT_xmgxnegd); // rising
$setuphold(posedge CLK, HRESETn, 0, 0, notifierxmgx28,,,CLK_xmgxnegd, HRESETn_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, SCANEN, 0, 0, notifierxmgx29,,,UnGatedCLK_xmgxnegd, SCANEN_xmgxnegd); // rising
$setuphold(posedge CLK, SCANEN, 0, 0, notifierxmgx30,,,CLK_xmgxnegd, SCANEN_xmgxnegd); // rising
$setuphold(posedge CLK, TESTMODE, 0, 0, notifierxmgx31,,,CLK_xmgxnegd, TESTMODE_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, SCANIN1, 0, 0, notifierxmgx32,,,UnGatedCLK_xmgxnegd, SCANIN1_xmgxnegd); // rising
$setuphold(posedge CLK, SCANIN1, 0, 0, notifierxmgx33,,,CLK_xmgxnegd, SCANIN1_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, SCANIN2, 0, 0, notifierxmgx34,,,UnGatedCLK_xmgxnegd, SCANIN2_xmgxnegd); // rising
$setuphold(posedge CLK, SCANIN2, 0, 0, notifierxmgx35,,,CLK_xmgxnegd, SCANIN2_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, SCANIN3, 0, 0, notifierxmgx36,,,UnGatedCLK_xmgxnegd, SCANIN3_xmgxnegd); // rising
$setuphold(posedge CLK, SCANIN3, 0, 0, notifierxmgx37,,,CLK_xmgxnegd, SCANIN3_xmgxnegd); // rising
$setuphold(posedge UnGatedCLK, SCANIN4, 0, 0, notifierxmgx38,,,UnGatedCLK_xmgxnegd, SCANIN4_xmgxnegd); // rising
$setuphold(posedge CLK, SCANIN4, 0, 0, notifierxmgx39,,,CLK_xmgxnegd, SCANIN4_xmgxnegd); // rising
$setuphold(posedge CLK, ETMFIFOFULL, 0, 0, notifierxmgx40,,,CLK_xmgxnegd, ETMFIFOFULL_xmgxnegd); // rising
$setuphold(posedge CLK, ITCMRData[0], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[0]); // rising
$setuphold(posedge CLK, ITCMRData[1], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[1]); // rising
$setuphold(posedge CLK, ITCMRData[2], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[2]); // rising
$setuphold(posedge CLK, ITCMRData[3], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[3]); // rising
$setuphold(posedge CLK, ITCMRData[4], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[4]); // rising
$setuphold(posedge CLK, ITCMRData[5], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[5]); // rising
$setuphold(posedge CLK, ITCMRData[6], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[6]); // rising
$setuphold(posedge CLK, ITCMRData[7], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[7]); // rising
$setuphold(posedge CLK, ITCMRData[8], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[8]); // rising
$setuphold(posedge CLK, ITCMRData[9], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[9]); // rising
$setuphold(posedge CLK, ITCMRData[10], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[10]); // rising
$setuphold(posedge CLK, ITCMRData[11], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[11]); // rising
$setuphold(posedge CLK, ITCMRData[12], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[12]); // rising
$setuphold(posedge CLK, ITCMRData[13], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[13]); // rising
$setuphold(posedge CLK, ITCMRData[14], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[14]); // rising
$setuphold(posedge CLK, ITCMRData[15], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[15]); // rising
$setuphold(posedge CLK, ITCMRData[16], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[16]); // rising
$setuphold(posedge CLK, ITCMRData[17], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[17]); // rising
$setuphold(posedge CLK, ITCMRData[18], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[18]); // rising
$setuphold(posedge CLK, ITCMRData[19], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[19]); // rising
$setuphold(posedge CLK, ITCMRData[20], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[20]); // rising
$setuphold(posedge CLK, ITCMRData[21], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[21]); // rising
$setuphold(posedge CLK, ITCMRData[22], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[22]); // rising
$setuphold(posedge CLK, ITCMRData[23], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[23]); // rising
$setuphold(posedge CLK, ITCMRData[24], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[24]); // rising
$setuphold(posedge CLK, ITCMRData[25], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[25]); // rising
$setuphold(posedge CLK, ITCMRData[26], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[26]); // rising
$setuphold(posedge CLK, ITCMRData[27], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[27]); // rising
$setuphold(posedge CLK, ITCMRData[28], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[28]); // rising
$setuphold(posedge CLK, ITCMRData[29], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[29]); // rising
$setuphold(posedge CLK, ITCMRData[30], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[30]); // rising
$setuphold(posedge CLK, ITCMRData[31], 0, 0, notifierxmgx41,,,CLK_xmgxnegd, ITCMRData_xmgxnegd[31]); // rising
$setuphold(posedge CLK, DTCMRData[0], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[0]); // rising
$setuphold(posedge CLK, DTCMRData[1], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[1]); // rising
$setuphold(posedge CLK, DTCMRData[2], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[2]); // rising
$setuphold(posedge CLK, DTCMRData[3], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[3]); // rising
$setuphold(posedge CLK, DTCMRData[4], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[4]); // rising
$setuphold(posedge CLK, DTCMRData[5], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[5]); // rising
$setuphold(posedge CLK, DTCMRData[6], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[6]); // rising
$setuphold(posedge CLK, DTCMRData[7], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[7]); // rising
$setuphold(posedge CLK, DTCMRData[8], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[8]); // rising
$setuphold(posedge CLK, DTCMRData[9], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[9]); // rising
$setuphold(posedge CLK, DTCMRData[10], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[10]); // rising
$setuphold(posedge CLK, DTCMRData[11], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[11]); // rising
$setuphold(posedge CLK, DTCMRData[12], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[12]); // rising
$setuphold(posedge CLK, DTCMRData[13], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[13]); // rising
$setuphold(posedge CLK, DTCMRData[14], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[14]); // rising
$setuphold(posedge CLK, DTCMRData[15], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[15]); // rising
$setuphold(posedge CLK, DTCMRData[16], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[16]); // rising
$setuphold(posedge CLK, DTCMRData[17], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[17]); // rising
$setuphold(posedge CLK, DTCMRData[18], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[18]); // rising
$setuphold(posedge CLK, DTCMRData[19], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[19]); // rising
$setuphold(posedge CLK, DTCMRData[20], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[20]); // rising
$setuphold(posedge CLK, DTCMRData[21], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[21]); // rising
$setuphold(posedge CLK, DTCMRData[22], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[22]); // rising
$setuphold(posedge CLK, DTCMRData[23], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[23]); // rising
$setuphold(posedge CLK, DTCMRData[24], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[24]); // rising
$setuphold(posedge CLK, DTCMRData[25], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[25]); // rising
$setuphold(posedge CLK, DTCMRData[26], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[26]); // rising
$setuphold(posedge CLK, DTCMRData[27], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[27]); // rising
$setuphold(posedge CLK, DTCMRData[28], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[28]); // rising
$setuphold(posedge CLK, DTCMRData[29], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[29]); // rising
$setuphold(posedge CLK, DTCMRData[30], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[30]); // rising
$setuphold(posedge CLK, DTCMRData[31], 0, 0, notifierxmgx42,,,CLK_xmgxnegd, DTCMRData_xmgxnegd[31]); // rising
$setuphold(posedge CLK, PhyDTCMSize[0], 0, 0, notifierxmgx43,,,CLK_xmgxnegd, PhyDTCMSize_xmgxnegd[0]); // rising
$setuphold(posedge CLK, PhyDTCMSize[1], 0, 0, notifierxmgx43,,,CLK_xmgxnegd, PhyDTCMSize_xmgxnegd[1]); // rising
$setuphold(posedge CLK, PhyDTCMSize[2], 0, 0, notifierxmgx43,,,CLK_xmgxnegd, PhyDTCMSize_xmgxnegd[2]); // rising
$setuphold(posedge CLK, PhyDTCMSize[3], 0, 0, notifierxmgx43,,,CLK_xmgxnegd, PhyDTCMSize_xmgxnegd[3]); // rising
$setuphold(posedge CLK, PhyITCMSize[0], 0, 0, notifierxmgx44,,,CLK_xmgxnegd, PhyITCMSize_xmgxnegd[0]); // rising
$setuphold(posedge CLK, PhyITCMSize[1], 0, 0, notifierxmgx44,,,CLK_xmgxnegd, PhyITCMSize_xmgxnegd[1]); // rising
$setuphold(posedge CLK, PhyITCMSize[2], 0, 0, notifierxmgx44,,,CLK_xmgxnegd, PhyITCMSize_xmgxnegd[2]); // rising
$setuphold(posedge CLK, PhyITCMSize[3], 0, 0, notifierxmgx44,,,CLK_xmgxnegd, PhyITCMSize_xmgxnegd[3]); // rising
$setuphold(posedge CLK, DCacheSize[0], 0, 0, notifierxmgx45,,,CLK_xmgxnegd, DCacheSize_xmgxnegd[0]); // rising
$setuphold(posedge CLK, DCacheSize[1], 0, 0, notifierxmgx45,,,CLK_xmgxnegd, DCacheSize_xmgxnegd[1]); // rising
$setuphold(posedge CLK, DCacheSize[2], 0, 0, notifierxmgx45,,,CLK_xmgxnegd, DCacheSize_xmgxnegd[2]); // rising
$setuphold(posedge CLK, DCacheSize[3], 0, 0, notifierxmgx45,,,CLK_xmgxnegd, DCacheSize_xmgxnegd[3]); // rising
$setuphold(posedge CLK, ICacheSize[0], 0, 0, notifierxmgx46,,,CLK_xmgxnegd, ICacheSize_xmgxnegd[0]); // rising
$setuphold(posedge CLK, ICacheSize[1], 0, 0, notifierxmgx46,,,CLK_xmgxnegd, ICacheSize_xmgxnegd[1]); // rising
$setuphold(posedge CLK, ICacheSize[2], 0, 0, notifierxmgx46,,,CLK_xmgxnegd, ICacheSize_xmgxnegd[2]); // rising
$setuphold(posedge CLK, ICacheSize[3], 0, 0, notifierxmgx46,,,CLK_xmgxnegd, ICacheSize_xmgxnegd[3]); // rising

// Width checks

$period(posedge CLK, 0, notifierxmgx47);
$period(negedge CLK, 0, notifierxmgx47);
$width(negedge CLK, 0, 0, notifierxmgx48);
$width(posedge CLK, 0, 0, notifierxmgx49);
$period(posedge UnGatedCLK, 0, notifierxmgx50);
$period(negedge UnGatedCLK, 0, notifierxmgx50);
$width(negedge UnGatedCLK, 0, 0, notifierxmgx51);
$width(posedge UnGatedCLK, 0, 0, notifierxmgx52);

// Output delays

if (~HRESETn) (negedge HRESETn *> (HADDR[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HADDR[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HADDR[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HADDR[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HTRANS[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HTRANS[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HTRANS[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HTRANS[1] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HBURST[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HBURST[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HBURST[2] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HBURST[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HBURST[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HBURST[2] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWRITE +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HWRITE +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HSIZE[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HSIZE[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HSIZE[2] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HSIZE[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HSIZE[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HSIZE[2] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HPROT[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HPROT[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HPROT[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HPROT[3] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HPROT[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HPROT[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HPROT[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HPROT[3] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (HWDATA[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HWDATA[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (HWDATA[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HBUSREQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HBUSREQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (HLOCK +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (HLOCK +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPCLKEN +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPCLKEN +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPINSTR[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPINSTR[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPDOUT[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (CPDOUT[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPPASS +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPPASS +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPLATECANCEL +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPLATECANCEL +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (CPTBIT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (CPTBIT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (nCPMREQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (nCPMREQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (nCPTRANS +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (nCPTRANS +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (COMMRX +: DBGnTRST)) = 0;
if (CLK) (posedge CLK *> (COMMRX +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (COMMTX +: DBGnTRST)) = 0;
if (CLK) (posedge CLK *> (COMMTX +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGACK +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGACK +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGACK +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGRQI +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGRQI +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGRQI +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGINSTREXEC +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGINSTREXEC +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGINSTREXEC +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGRNG[0] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGRNG[1] +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGRNG[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGRNG[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGRNG[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGRNG[1] +: CLK)) = 0;
(DBGSDOUT *> DBGTDO) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGTDO +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGTDO +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGTDO +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGIR[0] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGIR[1] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGIR[2] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGIR[3] +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGIR[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGIR[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGIR[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGIR[3] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGIR[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGIR[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGIR[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGIR[3] +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSCREG[0] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSCREG[1] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSCREG[2] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSCREG[3] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSCREG[4] +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSCREG[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSCREG[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSCREG[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSCREG[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSCREG[4] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGSCREG[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGSCREG[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGSCREG[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGSCREG[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGSCREG[4] +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGTAPSM[0] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGTAPSM[1] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGTAPSM[2] +: DBGnTRST)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGTAPSM[3] +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGTAPSM[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGTAPSM[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGTAPSM[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGTAPSM[3] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGTAPSM[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGTAPSM[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGTAPSM[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DBGTAPSM[3] +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGnTDOEN +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGnTDOEN +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGnTDOEN +: CLK)) = 0;
if (~DBGnTRST) (negedge DBGnTRST *> (DBGSDIN +: DBGnTRST)) = 0;
if (~HRESETn) (negedge HRESETn *> (DBGSDIN +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DBGSDIN +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (BIGENDOUT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (BIGENDOUT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMBIGEND +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMBIGEND +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMHIVECS +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMHIVECS +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIA[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMIA[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMIA[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMInMREQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMInMREQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMISEQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMISEQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMITBIT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMITBIT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMIABORT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMIABORT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDA[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDA[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDA[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDMAS[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDMAS[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDMAS[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMDMAS[1] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDMORE +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDMORE +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDnMREQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDnMREQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDnRW +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDnRW +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDSEQ +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDSEQ +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRDATA[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRDATA[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDABORT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDABORT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMWDATA[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMWDATA[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMnWAIT +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMnWAIT +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMDBGACK +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMDBGACK +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCID[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMPROCID[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPROCIDWR +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMPROCIDWR +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMINSTREXEC +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMINSTREXEC +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRNGOUT[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMRNGOUT[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMRNGOUT[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMRNGOUT[1] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID31To25[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID31To25[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID15To11[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID15To11[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID15To11[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID15To11[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMID15To11[15] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMID15To11[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID15To11[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID15To11[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID15To11[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMID15To11[15] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMCHSD[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMCHSD[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMCHSD[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMCHSD[1] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMCHSE[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMCHSE[1] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMCHSE[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ETMCHSE[1] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMPASS +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMPASS +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMLATECANCEL +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMLATECANCEL +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ETMINSTRVALID +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ETMINSTRVALID +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (GateTheCLK +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (GateTheCLK +: UnGatedCLK)) = 0;
(CPDIN *> ITCMWData[0]) = 0;
(CPDIN *> ITCMWData[1]) = 0;
(CPDIN *> ITCMWData[2]) = 0;
(CPDIN *> ITCMWData[3]) = 0;
(CPDIN *> ITCMWData[4]) = 0;
(CPDIN *> ITCMWData[5]) = 0;
(CPDIN *> ITCMWData[6]) = 0;
(CPDIN *> ITCMWData[7]) = 0;
(CPDIN *> ITCMWData[8]) = 0;
(CPDIN *> ITCMWData[9]) = 0;
(CPDIN *> ITCMWData[10]) = 0;
(CPDIN *> ITCMWData[11]) = 0;
(CPDIN *> ITCMWData[12]) = 0;
(CPDIN *> ITCMWData[13]) = 0;
(CPDIN *> ITCMWData[14]) = 0;
(CPDIN *> ITCMWData[15]) = 0;
(CPDIN *> ITCMWData[16]) = 0;
(CPDIN *> ITCMWData[17]) = 0;
(CPDIN *> ITCMWData[18]) = 0;
(CPDIN *> ITCMWData[19]) = 0;
(CPDIN *> ITCMWData[20]) = 0;
(CPDIN *> ITCMWData[21]) = 0;
(CPDIN *> ITCMWData[22]) = 0;
(CPDIN *> ITCMWData[23]) = 0;
(CPDIN *> ITCMWData[24]) = 0;
(CPDIN *> ITCMWData[25]) = 0;
(CPDIN *> ITCMWData[26]) = 0;
(CPDIN *> ITCMWData[27]) = 0;
(CPDIN *> ITCMWData[28]) = 0;
(CPDIN *> ITCMWData[29]) = 0;
(CPDIN *> ITCMWData[30]) = 0;
(CPDIN *> ITCMWData[31]) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWData[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWData[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWEn[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWEn[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWEn[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMWEn[3] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ITCMWEn[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWEn[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWEn[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMWEn[3] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMEn +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (ITCMEn +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (ITCMEn +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (ITCMAdrs[17] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (ITCMAdrs[17] +: CLK)) = 0;
(CPDIN *> DTCMWData[0]) = 0;
(CPDIN *> DTCMWData[1]) = 0;
(CPDIN *> DTCMWData[2]) = 0;
(CPDIN *> DTCMWData[3]) = 0;
(CPDIN *> DTCMWData[4]) = 0;
(CPDIN *> DTCMWData[5]) = 0;
(CPDIN *> DTCMWData[6]) = 0;
(CPDIN *> DTCMWData[7]) = 0;
(CPDIN *> DTCMWData[8]) = 0;
(CPDIN *> DTCMWData[9]) = 0;
(CPDIN *> DTCMWData[10]) = 0;
(CPDIN *> DTCMWData[11]) = 0;
(CPDIN *> DTCMWData[12]) = 0;
(CPDIN *> DTCMWData[13]) = 0;
(CPDIN *> DTCMWData[14]) = 0;
(CPDIN *> DTCMWData[15]) = 0;
(CPDIN *> DTCMWData[16]) = 0;
(CPDIN *> DTCMWData[17]) = 0;
(CPDIN *> DTCMWData[18]) = 0;
(CPDIN *> DTCMWData[19]) = 0;
(CPDIN *> DTCMWData[20]) = 0;
(CPDIN *> DTCMWData[21]) = 0;
(CPDIN *> DTCMWData[22]) = 0;
(CPDIN *> DTCMWData[23]) = 0;
(CPDIN *> DTCMWData[24]) = 0;
(CPDIN *> DTCMWData[25]) = 0;
(CPDIN *> DTCMWData[26]) = 0;
(CPDIN *> DTCMWData[27]) = 0;
(CPDIN *> DTCMWData[28]) = 0;
(CPDIN *> DTCMWData[29]) = 0;
(CPDIN *> DTCMWData[30]) = 0;
(CPDIN *> DTCMWData[31]) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[17] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[18] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[19] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[20] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[21] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[22] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[23] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[24] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[25] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[26] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[27] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[28] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[29] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[30] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWData[31] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[17] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[18] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[19] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[20] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[21] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[22] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[23] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[24] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[25] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[26] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[27] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[28] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[29] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[30] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWData[31] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWEn[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWEn[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWEn[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMWEn[3] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DTCMWEn[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWEn[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWEn[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMWEn[3] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMEn +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (DTCMEn +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (DTCMEn +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[0] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[1] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[2] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[3] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[4] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[5] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[6] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[7] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[8] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[9] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[10] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[11] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[12] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[13] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[14] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[15] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[16] +: HRESETn)) = 0;
if (~HRESETn) (negedge HRESETn *> (DTCMAdrs[17] +: HRESETn)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[0] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[1] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[2] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[3] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[4] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[5] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[6] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[7] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[8] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[9] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[10] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[11] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[12] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[13] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[14] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[15] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[16] +: CLK)) = 0;
if (CLK) (posedge CLK *> (DTCMAdrs[17] +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (SCANOUT1 +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (SCANOUT1 +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (SCANOUT1 +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (SCANOUT2 +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (SCANOUT2 +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (SCANOUT2 +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (SCANOUT3 +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (SCANOUT3 +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (SCANOUT3 +: CLK)) = 0;
if (~HRESETn) (negedge HRESETn *> (SCANOUT4 +: HRESETn)) = 0;
if (UnGatedCLK) (posedge UnGatedCLK *> (SCANOUT4 +: UnGatedCLK)) = 0;
if (CLK) (posedge CLK *> (SCANOUT4 +: CLK)) = 0;
    
endspecify


// The next layer down...

ARM946E_88_inout theinout (HBUSREQ_xmgxi,
  HLOCK_xmgxi,
  HADDR_xmgxi,
  HTRANS_xmgxi,
  HWRITE_xmgxi,
  HSIZE_xmgxi,
  HBURST_xmgxi,
  HPROT_xmgxi,
  HWDATA_xmgxi,
  CPINSTR_xmgxi,
  CPDOUT_xmgxi,
  CPPASS_xmgxi,
  CPLATECANCEL_xmgxi,
  CPTBIT_xmgxi,
  nCPMREQ_xmgxi,
  nCPTRANS_xmgxi,
  CPCLKEN_xmgxi,
  COMMRX_xmgxi,
  COMMTX_xmgxi,
  DBGACK_xmgxi,
  DBGRQI_xmgxi,
  DBGINSTREXEC_xmgxi,
  DBGRNG_xmgxi,
  DBGTDO_xmgxi,
  DBGIR_xmgxi,
  DBGSCREG_xmgxi,
  DBGTAPSM_xmgxi,
  DBGnTDOEN_xmgxi,
  DBGSDIN_xmgxi,
  BIGENDOUT_xmgxi,
  ETMBIGEND_xmgxi,
  ETMHIVECS_xmgxi,
  ETMIA_xmgxi,
  ETMInMREQ_xmgxi,
  ETMISEQ_xmgxi,
  ETMITBIT_xmgxi,
  ETMIABORT_xmgxi,
  ETMDA_xmgxi,
  ETMDMAS_xmgxi,
  ETMDMORE_xmgxi,
  ETMDnMREQ_xmgxi,
  ETMDnRW_xmgxi,
  ETMDSEQ_xmgxi,
  ETMRDATA_xmgxi,
  ETMDABORT_xmgxi,
  ETMCHSD_xmgxi,
  ETMCHSE_xmgxi,
  ETMnWAIT_xmgxi,
  ETMID31To25_xmgxi,
  ETMID15To11_xmgxi,
  ETMWDATA_xmgxi,
  ETMLATECANCEL_xmgxi,
  ETMPASS_xmgxi,
  ETMDBGACK_xmgxi,
  ETMINSTREXEC_xmgxi,
  ETMRNGOUT_xmgxi,
  ETMPROCID_xmgxi,
  ETMPROCIDWR_xmgxi,
  ETMINSTRVALID_xmgxi,
  GateTheCLK_xmgxi,
  ITCMWData_xmgxi,
  ITCMWEn_xmgxi,
  ITCMEn_xmgxi,
  ITCMAdrs_xmgxi,
  DTCMWData_xmgxi,
  DTCMWEn_xmgxi,
  DTCMEn_xmgxi,
  DTCMAdrs_xmgxi,
  SCANOUT1_xmgxi,
  SCANOUT2_xmgxi,
  SCANOUT3_xmgxi,
  SCANOUT4_xmgxi,
  HRESETn_xmgxnegd,
  HCLKEN_xmgxnegd,
  CLK_xmgxnegd,
  HGRANT_xmgxnegd,
  HRDATA_xmgxnegd,
  HREADY_xmgxnegd,
  HRESP_xmgxnegd,
  CPDIN_xmgxnegd,
  CHSDE_xmgxnegd,
  CHSEX_xmgxnegd,
  DBGEN_xmgxnegd,
  EDBGRQ_xmgxnegd,
  DBGEXT_xmgxnegd,
  DBGIEBKPT_xmgxnegd,
  DBGDEWPT_xmgxnegd,
  DBGnTRST_xmgxnegd,
  DBGTCKEN_xmgxnegd,
  DBGTDI_xmgxnegd,
  DBGTMS_xmgxnegd,
  DBGSDOUT_xmgxnegd,
  nFIQ_xmgxnegd,
  nIRQ_xmgxnegd,
  VINITHI_xmgxnegd,
  INITRAM_xmgxnegd,
  TAPID_xmgxnegd,
  DCacheSize_xmgxnegd,
  ICacheSize_xmgxnegd,
  ETMEN_xmgxnegd,
  SCANEN_xmgxnegd,
  TESTMODE_xmgxnegd,
  SCANIN1_xmgxnegd,
  SCANIN2_xmgxnegd,
  SCANIN3_xmgxnegd,
  SCANIN4_xmgxnegd,
  ETMFIFOFULL_xmgxnegd,
  UnGatedCLK_xmgxnegd,
  ITCMRData_xmgxnegd,
  DTCMRData_xmgxnegd,
  PhyDTCMSize_xmgxnegd,
  PhyITCMSize_xmgxnegd);

endmodule

`endcelldefine

// Debug shell

module ARM946E_88 (HBUSREQ,
  HLOCK,
  HADDR,
  HTRANS,
  HWRITE,
  HSIZE,
  HBURST,
  HPROT,
  HWDATA,
  CPINSTR,
  CPDOUT,
  CPPASS,
  CPLATECANCEL,
  CPTBIT,
  nCPMREQ,
  nCPTRANS,
  CPCLKEN,
  COMMRX,
  COMMTX,
  DBGACK,
  DBGRQI,
  DBGINSTREXEC,
  DBGRNG,
  DBGTDO,
  DBGIR,
  DBGSCREG,
  DBGTAPSM,
  DBGnTDOEN,
  DBGSDIN,
  BIGENDOUT,
  ETMBIGEND,
  ETMHIVECS,
  ETMIA,
  ETMInMREQ,
  ETMISEQ,
  ETMITBIT,
  ETMIABORT,
  ETMDA,
  ETMDMAS,
  ETMDMORE,
  ETMDnMREQ,
  ETMDnRW,
  ETMDSEQ,
  ETMRDATA,
  ETMDABORT,
  ETMCHSD,
  ETMCHSE,
  ETMnWAIT,
  ETMID31To25,
  ETMID15To11,
  ETMWDATA,
  ETMLATECANCEL,
  ETMPASS,
  ETMDBGACK,
  ETMINSTREXEC,
  ETMRNGOUT,
  ETMPROCID,
  ETMPROCIDWR,
  ETMINSTRVALID,
  GateTheCLK,
  ITCMWData,
  ITCMWEn,
  ITCMEn,
  ITCMAdrs,
  DTCMWData,
  DTCMWEn,
  DTCMEn,
  DTCMAdrs,
  SCANOUT1,
  SCANOUT2,
  SCANOUT3,
  SCANOUT4,
  HRESETn,
  HCLKEN,
  CLK,
  HGRANT,
  HRDATA,
  HREADY,
  HRESP,
  CPDIN,
  CHSDE,
  CHSEX,
  DBGEN,
  EDBGRQ,
  DBGEXT,
  DBGIEBKPT,
  DBGDEWPT,
  DBGnTRST,
  DBGTCKEN,
  DBGTDI,
  DBGTMS,
  DBGSDOUT,
  nFIQ,
  nIRQ,
  VINITHI,
  INITRAM,
  TAPID,
  DCacheSize,
  ICacheSize,
  ETMEN,
  SCANEN,
  TESTMODE,
  SCANIN1,
  SCANIN2,
  SCANIN3,
  SCANIN4,
  ETMFIFOFULL,
  UnGatedCLK,
  ITCMRData,
  DTCMRData,
  PhyDTCMSize,
  PhyITCMSize);

output HBUSREQ;
output HLOCK;
output [31:0] HADDR;
output [1:0] HTRANS;
output HWRITE;
output [2:0] HSIZE;
output [2:0] HBURST;
output [3:0] HPROT;
output [31:0] HWDATA;
output [31:0] CPINSTR;
output [31:0] CPDOUT;
output CPPASS;
output CPLATECANCEL;
output CPTBIT;
output nCPMREQ;
output nCPTRANS;
output CPCLKEN;
output COMMRX;
output COMMTX;
output DBGACK;
output DBGRQI;
output DBGINSTREXEC;
output [1:0] DBGRNG;
output DBGTDO;
output [3:0] DBGIR;
output [4:0] DBGSCREG;
output [3:0] DBGTAPSM;
output DBGnTDOEN;
output DBGSDIN;
output BIGENDOUT;
output ETMBIGEND;
output ETMHIVECS;
output [31:1] ETMIA;
output ETMInMREQ;
output ETMISEQ;
output ETMITBIT;
output ETMIABORT;
output [31:0] ETMDA;
output [1:0] ETMDMAS;
output ETMDMORE;
output ETMDnMREQ;
output ETMDnRW;
output ETMDSEQ;
output [31:0] ETMRDATA;
output ETMDABORT;
output [1:0] ETMCHSD;
output [1:0] ETMCHSE;
output ETMnWAIT;
output [31:25] ETMID31To25;
output [15:11] ETMID15To11;
output [31:0] ETMWDATA;
output ETMLATECANCEL;
output ETMPASS;
output ETMDBGACK;
output ETMINSTREXEC;
output [1:0] ETMRNGOUT;
output [31:0] ETMPROCID;
output ETMPROCIDWR;
output ETMINSTRVALID;
output GateTheCLK;
output [31:0] ITCMWData;
output [3:0] ITCMWEn;
output ITCMEn;
output [17:0] ITCMAdrs;
output [31:0] DTCMWData;
output [3:0] DTCMWEn;
output DTCMEn;
output [17:0] DTCMAdrs;
output SCANOUT1;
output SCANOUT2;
output SCANOUT3;
output SCANOUT4;
input HRESETn;
input HCLKEN;
input CLK;
input HGRANT;
input [31:0] HRDATA;
input HREADY;
input [1:0] HRESP;
input [31:0] CPDIN;
input [1:0] CHSDE;
input [1:0] CHSEX;
input DBGEN;
input EDBGRQ;
input [1:0] DBGEXT;
input DBGIEBKPT;
input DBGDEWPT;
input DBGnTRST;
input DBGTCKEN;
input DBGTDI;
input DBGTMS;
input DBGSDOUT;
input nFIQ;
input nIRQ;
input VINITHI;
input INITRAM;
input [31:0] TAPID;
input [3:0] DCacheSize;
input [3:0] ICacheSize;
input ETMEN;
input SCANEN;
input TESTMODE;
input SCANIN1;
input SCANIN2;
input SCANIN3;
input SCANIN4;
input ETMFIFOFULL;
input UnGatedCLK;
input [31:0] ITCMRData;
input [31:0] DTCMRData;
input [3:0] PhyDTCMSize;
input [3:0] PhyITCMSize;



parameter
  MG_LOGFILE_NAME = "",
  MG_BUILTIN_TIMING_MESSAGES = 1,
  ARM946E_88_TimingFile = "./ARM946E_88.tdef",
  MG_ENABLE_BUILTIN_TIMING = 0,
  MG_FORCED_DELAY = 0;

ARM946E_88_timing thetiming (HBUSREQ,
    HLOCK,
    HADDR,
    HTRANS,
    HWRITE,
    HSIZE,
    HBURST,
    HPROT,
    HWDATA,
    CPINSTR,
    CPDOUT,
    CPPASS,
    CPLATECANCEL,
    CPTBIT,
    nCPMREQ,
    nCPTRANS,
    CPCLKEN,
    COMMRX,
    COMMTX,
    DBGACK,
    DBGRQI,
    DBGINSTREXEC,
    DBGRNG,
    DBGTDO,
    DBGIR,
    DBGSCREG,
    DBGTAPSM,
    DBGnTDOEN,
    DBGSDIN,
    BIGENDOUT,
    ETMBIGEND,
    ETMHIVECS,
    ETMIA,
    ETMInMREQ,
    ETMISEQ,
    ETMITBIT,
    ETMIABORT,
    ETMDA,
    ETMDMAS,
    ETMDMORE,
    ETMDnMREQ,
    ETMDnRW,
    ETMDSEQ,
    ETMRDATA,
    ETMDABORT,
    ETMCHSD,
    ETMCHSE,
    ETMnWAIT,
    ETMID31To25,
    ETMID15To11,
    ETMWDATA,
    ETMLATECANCEL,
    ETMPASS,
    ETMDBGACK,
    ETMINSTREXEC,
    ETMRNGOUT,
    ETMPROCID,
    ETMPROCIDWR,
    ETMINSTRVALID,
    GateTheCLK,
    ITCMWData,
    ITCMWEn,
    ITCMEn,
    ITCMAdrs,
    DTCMWData,
    DTCMWEn,
    DTCMEn,
    DTCMAdrs,
    SCANOUT1,
    SCANOUT2,
    SCANOUT3,
    SCANOUT4,
    HRESETn,
    HCLKEN,
    CLK,
    HGRANT,
    HRDATA,
    HREADY,
    HRESP,
    CPDIN,
    CHSDE,
    CHSEX,
    DBGEN,
    EDBGRQ,
    DBGEXT,
    DBGIEBKPT,
    DBGDEWPT,
    DBGnTRST,
    DBGTCKEN,
    DBGTDI,
    DBGTMS,
    DBGSDOUT,
    nFIQ,
    nIRQ,
    VINITHI,
    INITRAM,
    TAPID,
    DCacheSize,
    ICacheSize,
    ETMEN,
    SCANEN,
    TESTMODE,
    SCANIN1,
    SCANIN2,
    SCANIN3,
    SCANIN4,
    ETMFIFOFULL,
    UnGatedCLK,
    ITCMRData,
    DTCMRData,
    PhyDTCMSize,
    PhyITCMSize);

endmodule

