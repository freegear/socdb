//===========================================================================--
//  This confidential and proprietary software may be used only as
//  authorised by a licensing agreement from ARM Limited
//    (C) COPYRIGHT 2001 ARM Limited
//        ALL RIGHTS RESERVED
//  The entire notice above must be reproduced on all authorised
//  copies and copies may only be made to the extent permitted
//  by a licensing agreement from ARM Limited.
//  
//
//-----------------------------------------------------------------------------
//  Version and Release Control Information:
//  
//  File Name           : BusMatrix.v,v
//  File Revision       : 1.2
//  
//  Release Information : BusMatrix-REL1v0
//  
//-----------------------------------------------------------------------------
//  Purpose             : BusMatrix is the top-level which connects together
//                        the required Input Stages, MatrixDecodes, Output 
//                        Stages and Output Arbitration blocks.
//                        
//===========================================================================--
`timescale 1ns/1ps

module BusMatrix `protected
k<VjhSQV5DT^<J2lUPOkF2N<2aWSSlHJe=5da2Wo`]UKgS92KAnDj4<V>`0IC\AF
H=^`qSO[@@D<ko]Hbc^hJ]JjCk`[c@LKIp2P8TN>0ncY@95YY8<;b0LN^S`:Ek\C
^FAnlCA<OGdafbl?7oWEamp24D?N@KpeQM9?>qc:]QJ:pc_dX7\dID6ljCOqgGIL
eN`B\h7lk^jS0lk:q<FWLFK[>T>d3@ESDU0pld;63Qp;6UDFR2cO1jb7TRd3`q]Q
Lcn0ka6GW99d5V3mpbV^Y7<n^CmT;o8D@inga:;VV=LKQl[0SdoK?GOBBRDhF:I8
a^^2QgDojT5117o<_UGMo^XCpg^\Kdk;[?2NRQ;>9Mm2qme:[>[48_FXhBbUNNmQ
q1WGDoM3=fFjaAf4bI9p_a;:Jc:TI_aPa4cKeYapG[h>;8BoJFR`bkpY[5M[KF5<
n?FBOTdP:qOnXKgl0M`B:Jo=3YTNCqDV5eol]1kZNbTKTC8_OVS0;q_2B_nDYT1T
b:]abPD5dq2Z:7\8`kI8mhMKl?RM`pJ3^U1bjS0NY]UF?P];?Z<AWqX5OF=4:[1h
bil:Q[1aqT::::Ud6XZ7[h?iYC;=_W22]]<F[H8X@lHJiMCXA15S]3;4G1j2XRi1
LVQWql`dZV[pjn@9d[qb<;^54K\L13?RGLopo7CoiOYige@I729]T^q1>;jP0fgc
5TME5e?Wk=q;h44Gom]n\:LSKQ^L<cpnUf?Eo?SGSSJ_YFYoAp2]M@[h\97:E76A
X>A64qKk`Fhg4o@B0FFAKcTIpgb]e9PTo:knTn4m^[<dA`f[2@[cA9PHUiRQVajV
`HgX8]MaKlOnJB:DfhGV662qn`YFmg7aW^]\UQ7V^1GpLCMgK<l_=;6;X8k_EnCD
3C^q2=i9df6TgDRhoATJ<jmqSN`XclFV3MdmW6C<5<XpFG6`202ZZ4I\TEc8KelB
iEUqo@9T=`nHkK=f_Xi5^5pGicB;`_9>Mk>5?lDWgS;7B4k\P_D]6SOUR69JD2MB
k1>PNFY4=S<fUi_[UUk:O5plWBNZmqKA8S^XpIgg=Coe9\Ojmd\F:q1[kTT@DCVW
GmGHO]o=qGh]VR:H7im5D9`Ub613bPU[U`IgSQP\\qJmCaZM>QD9k5XPU0I]np\f
n\e;LVC__3Me<UjcZq0YY43hh1WhIGUinAbOp]N[R_]?<D3G0SI>;=^?p?JVFm;[
m50Am:0c3<<p7oLje=22>kVVXRDi=UQqS1[^0cGC6ioH>UCVF7@W3EgpScLn[=V:
[2K4Ch0W`:EqB=Qd33S_nYRF]bHQ?_0p0fo`?iTh10JOaJL2HUQ3c>oHRcl?dWqT
fNXK4I8WX2bCHG3hE\iPC_q3CllQTd`:?JQ[T6lLXpHmKC64qOJ[Nd4qQ9ZXfS8h
\<RXe4KbqCO<1f\CdEO]KdH=d0<qjJ39K;`@1a]mjBjSISYq9:W32nRSoMVM0jop
LBcK9j<KBjFiH12o?4^p\4c7=5^T;:=bKPkcGiqTkTUm_`WQI@KUkE=bNSq0@gV7
[L=l?P=d6bQLhq5=XZohOLJXR>LXhXdc=qLeWHk3a>`F:4ad^E9_4jBMWpNBjAUU
e9eXMImo43h<gqVhe:NIJVChm^g<99e:V[`gAB\U5S0V`IMop3^lMoiA[m6TDUP>
mE0=pY7H9gZJD]@>?N1:UleC_TWTp6mnQ2mhjOn]XeCmMV2q96EP:EplPiY;B>fB
Mc3;@=;oNZ71J97dDQEcaTikIdCASXq\[Oe]Ap?>Rgdb6ZX^^OAZ2FpU[=3eSCoF
=T]LQ9d;Jpe98EU:_mhDecUC6B\k>pHd9bOA\bCo<<e6PX=E0pVe]La75Xi^bh;S
A4`Dq0NmPaVZ<EgNYi@@N0ol_V9coD;Z@hN7oP0G`<_UJ@beBTGdUDCJBOk9K16_
U7DQ_gR;q>cY0K>2_GkGTdmMh@LMp6nOF9ehXA1MCiX3RTmp6h1\N?lGRBO\HUi;
]k9p9JS:\=NmF_X;23g[TcHgbK>paZin_\MYgRLOdgl?=QRBF`acQ`qS^fN8=g^R
8mWFKm72Zbqo<^LNZUiWDN]`3]4LjQpeMn_:?:9_ji1Z\2b7RRJEEXp5n2`1ncoG
_bAj1lHbkq[Zg_Ghbd58X1VXc:6a931Q;TK9N][Zg9><B;d^_Q[?8Q33C=]ZF<0Q
kX;9a9:F\`SjFVqC9Z3Gdqc`A;J2qlg\Sd6Z456a6=[64m[Qj<lqB3CnN8GIQd9Z
NC>Uc81?9bpUXVIK>]E>;CgcC7PLFFQ4`q63cHbd@4q@Ui6?cqLZcC8DG5Sc4=BP
DYp=lZR1bUP2nW5BUabH?a@pg0WGkagaf65@^GAfdiN1XeImXBlIpacN]@BRNNN@
Q^EdBkckpoDhM?:FB90KcE5mR4PD?HB31f[1f?Oc=bB6qc6ZBCX4Yhl5B0H:5Le3
IkVfM2C^lmRV??EMp1HgL9C`1SA9Xd]W[j4[hbbq;C69@MWT<GC7A20JE\=RK`bK
FglS47Uk2AqTZi44l`>3lM5^^EK[CK5Jg4Zl6_<S3U[\a1q<VX0_IP?5F5Kb6lkU
TkELl`4b2R=CEelNJp6;g@iWbPGNfdjbIKH>1G<]8K^OR<EhL<`lBQq7NBni2LFN
1?hTj0KOgDi;h]:A@ThV<bH[H\Dfkf6Eo0LGG]HQ1QpTFhehKicN?ZAD88]hT\_F
K>SG7p8Z[MA4mnGic7?_lH[>7VDOp3FHDgmAg;HL<VRUd0H\pdlHO04\>m8HaT2k
@^55W30:^g?@dXgN:0fDn9`j3@`\>EgU`VXbpcaVFJG@OPT0]Y]9;FiYnVFj0b`b
<dRRnedjqfKVTZ5a^1KWTQNlR3a1k=lb5AlGe9oaPn6SpCVA32kakLN@_oO_USW;
Om9pbkYGZdDA]gBl@?hGGnMi3ZnI`k4b@0D]6Wq1f5n]Mk<lL1\T6A?\PAje^gdk
V<[bDM^NZ=q`I<T\alfjcgkgm;MHdWC]=B`6D2>9Uee\5pUOVZW57B;7M9ca_Qn`
W?SmikgObLQefgHoK>SiDhNXMb:P4oUakTa_bF<hHo4Y:T4RB;qYM\kl[[Y6akf@
M3@_^^XeHiAJ9XfIa^BjI5Xp]B:nOgWCWO59`\;Pfa@bFRSDdXqhZVJ]TQ?LPV@2
D2Z@:F7gap9JPfV[pN>SHH`e`T\Fmmh8a=hF>W[LnknNSYK<9]B4npC>6S@X1ILE
F3Nh>:1@k_Bb1fFjp=]ZUS?N:Yi>YB<KN97UEm9ecP@1[n:El=XqM[5[[MT`2jh7
Q@=_<K==M9WYR[6S<E_l00B^po7HVb:f5fU[A40O>:jDg\O5B`Wqmblli2>o88gJ
c8fM;ebq`no]:]GYhP\c\PIh6F@K^?>i=NM7WGA4g]qkbg:5E_L^`5OSc=7[DBhH
1aWMa[JZZHiToaGqH>OhMR6?G6K@Q0\On@TWV1Sa?0qZO[Da>3h@NBN2YZ2_`9jC
S8X[NK3[ia6Edhq?E90HO_[c=^;_gf`MAn;UlEG]0NJoP;HbMqJ><=[L758CTjUH
nWUa?ZKJ_EqkMHZnCDLIJ6F8UVjYdgl231dpT\TJ_MpAE2S?Go5F?;Z\QnYDP75e
V_KGgIJWXAU>G7Oq]2Ll@aI2AnM[eKj>Nghb2DP8qj=C<h==Ym96:_`Ql]_@Lc3C
@N1pEmm>AI=n``=3nX_S5CBZ0PJON\VcY8>LWTpC>o4Ko:XUM@N;Tlf8cKAA\@:n
oN0MgPb`8e3qjlD20HR@TiTAW_^gP8jR0WNC]cp[76E>KPMlR=6m=0]6I5TAA4a2
?NJNaMH4gl<mXO@ZSHEo4nEE<df@_Hi@N;MDmm;9geSgY78pUcU7@1C0>anM7ThM
:;EJKl;\ad<>Q^LLO<pWofjJ2qZo7920W0Mg9m<0O6_Q;p]P4Pe7j;Zd2O?S@0fj
B4aSa8TOQD6hJZ4^Bq_DaM40PDf>0<4KoVOK_?Kg`U8OcBoj3XdA:m6X4pfkNT\:
QGfNM5VKnMOieE8jd>E1GOLI1MkImpQUKH]P5fD:0HHo>LQNfkDTpJZ^kb8@`n[P
oAWnXI=bN>QnKSZD^[mnokhqK7\m9RFMS9:m<BcDGOm[ih[Nglf0bjS5e^__R`\:
D9]5pmJ72<gYm\e0jkXL`^0;C5^2aRW_YB_He1ibqgkk2U]ALe?e]6af:`GdFU64
>8P0;bDb>5]qb5^JhZFN^jkmYBkDQXYkAdanI7_GbmQ7^dUNpeS5UPThS?Tlcmc>
UhXAYUM\8dMpPUJSTCEYa06MI>YH<Ngbl0p417lc>mJieHDNJUEn<Wpb@fPjV_hE
Y]O\jnU:9<ho36YM2_OTWGT9IJ=F1Q4plPf`@62mV__[BZP\H^_OU:P\FFGnA0QH
>:Rp5[NaMmD9Qe8Ub6WXHWE6cCS:X_7NbLc=l:Jql:JVZNgBflGBBZ82Znd>W8pc
ASJDF4Nn?NSYUUUVEYYl1ZFW587SPDaSop]Y0BO[L`MnOD9aKFDX\hJ3n@Yg1DPg
p2N`dH<N4=SN;5?6dj3\J1;ecm_`i5GRBZkWp2hRhSU?E=<]BWdYaJ_PSAK2J03C
7ScQZAep@LNJU:;C:Xh4KJAedPFNAige[HMYfPkiVhGOp4g433Z>Wf[1@M1o\@1M
Qb8GnA^qXPG7H3EU58PSAohP7^kP:7q_\3]_WL1c?ZXeXBOBYGqQ80ga4Ofg8Tjh
fB<IB9L3GI4Q;`o_m?@<Bbp2m4U>6ZSia^kMP?4[K8<8U5V47Hekl94bhQpXmPcd
bb=PG?\W^3kMTKNb<b0SoE<I;I0I<>1]KBUcM?Dg?WY`Y@L@>4RqI]0DJJ4\?7M6
7e_VHchTFYp8[>Z]h;c8m_:h>4llO3O=6hGc8P7cHbk^[pa3b4PPjbFZg_:T3M4D
HBeJR1U<KRfa9KPP6q?><lRCc[o@g]EoLYq<mdAS^48jV^ZbdZ7jL9;^8cW6AEhA
W]BbNpB9YSk_cb5W[\jgb<6f_GCQ71<J;I5=P:EkEGqSQ6R\ggV<NQYg>TESSISH
dIWG^qHhFS`iegR`Gm:n9UG[MSkaq9NJYFYpagYkB5?:b7bd[>YaiY=nm\2C?apF
5]VhJ;ZgIYWLfIE_G_lL<JIlJ?Fp^hCWc>qJoa^B>pn;RlTI@[n2nAUm[Vpc<D`=
DSglkNeIdXinFYaq`1>_N7hE:Pi>I]T5;@Epm;:1`G=o4cNCFo_C4i]dhKmFgQc5
ealV<j@p?_oAfK@5joAgS\^47H<Wf@\kRTZcJ:80=amq[Jk?^eZT2D[h<UISG9GK
cHZBM]a7YmT<Yo02cB?eN?AHbYC=ajHI;:gX=NKgG:q]56OWngLT2=719hR?hO?0
OpOCHBi3=Pl81R:POZFRiUTH99Ql1k0@c[h6q\o4EXVE66@VkS8EQaAA]BY==oT7
ogU8E5Y6q]LDG9PX2hlFIFV_:?UKmJin2F;R]S]l;gdMj`4pc0kFMMjNc\@2OXVG
M:j6W9AMQ;2>Z@]>\5q=UX:\0g^WM00cd:_0ecTK0^33NaD3\cNa=UOp5D:@oOD\
Z92aOG6@?eQa6VRDG`p6`N:<EK:aC\]AK=4b9bK7lqGeXTbiD_J@6<g3TRiMZ1\`
ZBBZ;oQTU]iiQap=[m2B9;[N^H9c:Ticeg\`a848>?phY_e\aTgBCJAV3<EFA70;
:4Hj4pTOR2VHb;>o?1P97iKJhkghcVXem^34U\?1qic<aL`BNE3YAcBHhJ31pe43
MFRH6:o7e2ahk7N4gkN5O2R^R\Y6aG:gp><DCEJ1Jl2TGUb9AP?0>c^O4k7HAIV\
U7:QqZob>>RM=:OIU]4B6jiIW4PkbZBc?dapkgY_N@anbRX@1@bL=2^N:RpO1Fk=
@lMCE]nKIJGghR:3RBid_Z4_5J^G?pPY0EV9KKfJWS;F7L283WEeM5;<fXf5>nbW
1pLkWAoaK@bB8]K_S`]<SYFbHhdf@9BU=YmoqXTe8QRM]G4:TGTX:`IFFm9;65g5
pEUg_ZS<TfRB`LfNZFPMAkTY7fFA`8;BR:6[:qg?_?RbkRZW`;W3cmON^D0dQeI=
p7>F[mji]O_@`]_8b;gBm1mpJZSXcFJRgQ\;XM_8FA81LMe;h@Fda]RWjW:MpcRR
g1dCLdD8E\I9fQNgNXF[=^=q^[SleFFZUc1bKUEo35;U`Z:M_BX1YWhB=9q7H:3c
A8Qo90MUDkek<>q<HcAYB86gXQk2eZHUD=qBVdlRZMW>0oID_3=H4dOcc>YCM^L5
HB8Oh1qc6@jjSSmhSOJf>V=5VbVGF1aY3jIkKf9\HCqJoj>WYXNhQ\GoUKW@XeaQ
mp4h2P1]n5P25g6>70h`AQ^dPP>QOMKO;nanq:i9jG\W3jf1lb=Gci9J5ZeqWVMA
>:N@I@0EmW9XF9>PC53T9L0_N_PY2g8q@6T7Q_8?AYbAb2`<Hb\oN:YRSo6_cEc2
U>pUDa8Q1hT66`ECSA1iT<:32mM5c];9=>];Ab4q`kXRIZFZ6<A1JJ33VB\6k8O0
h6qoZI\RTRX5MLHL`lfRd3OYAqRXUB[OKNXN?A>b7gI[eLfk`Le@P:eX[?^\g9p\
VJYh`W?jcn>i5?EbBI?i`j`\^qZKM]_iY8RmifFcGS2N553NeO<Uk4=AjmBEAknM
3dFbQ^YPNC@\KW]8Uq[Ml_?eoI5;gT\?1@gc\Vkf1Kf>CN5S[KF2q7XH;3?UNQi]
ScjnQnlPqld;cPOIaiEQXFV53R9YDVBb2<]5kiO\5_b8q4d1MhB<_:CV=nT\aT2g
]Z?<[1BO432m;ZOB4C>le<oO5L^^FXdYYfYmgZ]`ql1k[W7Z7ZE_9_`m`_d20RB>
YZ5PRlgZ9GahqSiK;:Pl6DM=ZhXAYeM1:ClqkUAN`10EDn^>B3D^dfd@MHK`<hk4
if4lM=qH]nKO[Zf0nf]e6PXJ0WkK_j9LXF9M1[4QbcpOY<[j_[=43Me4P2<a9WH1
i=0C?53aDkQS=q\fUURBD786lmF?Ib1V6IP7d=0^G;bKj<GLYlpB]KImJ2F2L4fl
WZl\jmlAJ;XgUqeCk<H=PWB>CIMNP=hN5i8kqCo_QIdg?J]cCWdd4@@NR_P>79N5
H`mZ@`KoNpL>UiT0]54_k<a]mnJ=:RiKaYkZboJ\n=IN>WPK99T=nM4WEbl?7oW;
3Tp6GXlZQI<:gP`0P`3IY[goHVAC[p7HLXiDVAHTT2@5iQE<B1[c\HZ17b<6b[TS
pJ=]YcF>KZaFaRJQm;`=p]TBE_9=8;:B:RE3HcbgFD[cm4U?[0`1nU5np15f]ibl
<lmZ\^WLH7[7KeGH4gAXj1a1B`b`p=bcNU;<^1c<\KUB_Bba^?Iqc^3leB3e8O:_
WN5IW6XMb\oAmG4n=ejRkgpTG>Q]?KRWDfmM\MZAXj6CC`0iVUg]NQb29np5OB7I
0S4o\2]XVU;G]f?jg;eadbf@20O^cZhL]KkGEJfMhT2SMODokQSaeia=oSaI@U8q
gaRT0W`lee@\R?Yn9S;gG=U=8kC<DK2b6VqHo_O`0HVfb]>:ZITdJ:6^>eY^YOVa
ic;lH6]qNM\Um:56ieV9Z14ZBW1lan5O2Hp?EOg:XQK_fL^eIK[`X=POHp_M3800
IC>@Hm[UBR_RPka^A5hO1_MA<a6iYBqKm]fJQg2a55VNmm=TbdjY3Y?XBpVcoP;J
P`8DKQ=[:KaM[nlbMF2XenidM8g6\LMbq2G<RfAVoPg6GnD_95=lEQD1Z?f48AmZ
[9lpJ=>P9mp7R7[PKCEZ`JEeLUcpF>DGPC8^ok1T2kFbWUe^=@:7GIFlA=[epgSG
=_SYMi1MbRE8om0;h4KkEokJe58Dkq8bTCJcd9ZABW6EP?cb9qP:Wj`lfYo_XAKg
S1n3=a]YnhI=gC=BJca`=GQ50qDkEdF`fUbH?FTEGB^8[6g6E2\a4HVoopPcU]4d
<a9eSGl7hOP5T_b^__fIHX\RgPpE1MEU6\Q]?VeHj4]iF66k2Id=;c49eeqKPVo;
A7aAYk@[cRgmL[7Z^8qEk1FRTk\[e@bP0?D=0bmqlJ8D=X1eH2VQSQSSgKQ`=_hp
0:Q]BUmK[8;gW\G1gO5XPdcq_a]mERS4HbG8@Pfk3nQU\U5WhKTONk`qN[^23Iab
N0bEiKiUjg1ZjmLf21:TN8<PFk@L\P52@S3CL9LUX6;F?D;pc6jVdoBM:N>no69E
pbc`?kmf57n@e]cCeINkaVbk1FZ=9;FhWqm[b69JikbD;5io>]NhC3]4UQR[mKLS
GFq8k42?4O32ZZXaPMF?L2pOn:Bn?:<k?VCnQ:]G]@U39jD5aHPW6Wp4_0OYhne7
56T@<nYLb[YXQF;d;=LcRagq7PP\13JWQM7TZVbWgO=:5Ngbf60LI85W=bUGeULE
kdp`OUA0C;ADoYFa3g3[5fnN:5?OHc<j44qOcY6Q2F9hf<H5iQIbGJCSFnplk1P:
?;WcCFZAT:@[X`JqY^dh@=d>]QDE3BVo3mPkkY?q:1MDD\OEL5NPOI755hP]gTQp
d`CL>I6C_5jK`HMk>cllXkU71oaXG]QpDn1iD=q[GO0M1=`ZA>kL1H\jRM9q9]l7
ED5mgdDnU^UkOnI9]6W7qQaC3k4oj`13Q][GElRA8Cg]38UKcE;GNij]XnP?V`@e
hY4L[hBJ?T<5U7ZkcY=YWPABYIe;q:5hAocO833M@khY3]en?q?=lQlK6eZb0;aj
Qik9Fa7H0LpB`<I`:qPRL8UAEQUOBXboSYjg:hpEC;CR6LB5BgJUlZVk^JRoXPTq
P67Wcj<7<f0`^@`=U<PeZS7cobdDQ^D1n:Ahj_ZY]ULIZP<p4c<=WVMlOJ^:Q6[@
JMD=pogigj2]WD1KSi8fLkH4ga0O4p`:fBncp9LZeWg3eU57?TYL30J0Fp\:eY]a
JeRL:E2WmqhajAVj>oH7lP]WV<MXddN<CJq5G<oC<mM4c_A3[HO\0RNpdU\Sb[L4
1o882I3JkSRI^oUoq\>W_;2q]Z7dngqdQWY[Ak2IEQ8DMXccn<bkYYGb<Bhp:34Z
V4qaVbhgnq5l2lRR3Edg@WKk]E=[T7o9P:Z=A5P1FU[l:50ePpj5Pl`[[RFViQBM
Vl868dKl71gcEiScBq_H31gaYqH43;i`E3J]QeR6@`A;[<W1Gb]1qN\fgB3ZM0Th
KYY3T<[6H^8Q@8bUPH=>KgdpGVC]BGplZgg=7jQg3o>9[m_;0@^F5dT9TiY8mqR2
iBFca<CH\Gb=Dg8XhS5oNE<;\_enQcp[Yl13k;?W:>UO>h[5h\@A\2GP<@@W=eKi
FFpekRLE\=B0ga@Ob\oTF14g2fI60^BC8C721;pbXFT`8:=7KbT@]DcHKJni_lG[
`Ud5H0IqiIbeJ9HVLJ54U;GBXF[YJ4?R5hACD;q_N:87=n@@lRJR^SP0a\4R2aVW
=JMIZmSH`>qlQDZRnJ;ZQkEanZ\gAjJI:m8ZP>1;0cdqe;JK5\1;?2CIco9YI5J3
M@dN<l?6oWim^?Wkle`7m=Vp3i>3AcLECe\Yf[OQ=:39\id1ofhOmCeA_^ApTVX@
a1p2bLga[4<XDY2>0UbQA?JVG@nILNoFJN5_I<a]4O6YI`q1@\?fY1:2KkUU4^pF
ZY6kVgHWRfm@JE@l2j;5UoooVe2l6lAqV_ckYSpJchL;Cj[j4;EjdM=mFbV76USq
5\bAe;N@3GCOD;H90HeML2@3gQ6pf0kbZ_o;bAajn9i?`Z8dhQ^N>8YhcWqhYIRm
3?[[3`cThaCj:[<JRi=>HECj<pahSN`I^]S`RPMKaT2V=DR3=imIKp<Pk\0gIIUJ
idDEeOHoddfB;Q4TGeRbkVTI?b[oi<Rg0DL[9?Ubm`_o\3E:LoqjP=4he_ncJIWm
]33U0_G[m:XAjF3f7qK8?d<<GGVAKIalBZ2LNKRo=]G`UqTO3WFHO3c<f[2IVYBF
OjDMDc;Km[G2K3@3VS0@pl`V[`fmBLGfCEPBVlHZPS3QeeNI8IIk6L\HGJWpUcC=
BGqH0@^gEFEMTB8NZD2EmNgUQd^:6E^O2;?pG\mbb27HaBlONO;AbHAJ^Ehg760V
ORV7=b^4F1p<QD@0iJiQ>]Uc6ONB^I\_`^37=q8EEfbj5EqKI4XM;8UQIIcd5G3G
=AZPAZ?8I\ZbbAjDel[KZ>MobBQQo@C]GFI_JIM`:RAKP`O;4pX]9^:Dq^\U6Nbo
]g1M^?g]87jTYkRAW[n;PZd1_\F@m<Y4pA;R0@<1pG`cWK5RMn83NTZK>4Zm?J62
NB4qKR^L\XPD\CV66^<RnnP8752AkC]8SPST_9pm43IO^59b:QKQih7I\Q<7WaT8
`[mGLM3^f>HaJ@nbCd6piN8M3Xp`UWbFFjhEemiH;mWYjCDS1@SZMCUJgq31J`_O
RI8NdefVB^fedBUmMcZd4P_@31q2XfS@CMcRHM7mb^?GK1RY\D`j9W7^W\_Ra<p[
Yi`P?>D:fQ445Qh`WOTh\_X9Yk2c6h0WNWqf;j74NbNQY51;<23kSidFoffH9UYe
gLep5l5c=]XJ\hXFei0l]nmMVUVc[CgeJ=ENl[iLKbXaGlF]1GYLb1\U`[YS@6IO
^6q\haML6fefX@DmTWXi]dd8WC\JKb72O9\IFIq7UJg=k[O\;l`hW]=]_W:hViDD
mckNB5ApM@`NIK5kN\=2dW@iTGR\m67knC6JI7JIUUVQjZoGKO2qQ\2j=OCON4Jb
VVN]2La^gX9?G?=_<BBIK^Bp;FBO_Wpge8:6_bGbURcNo2ogLKC5=1Hi?cnKi[oA
YG>WHUQK5=p3kW5M=V1Of]Zn5hYC?eeVdDS1A>J<^deplk4OFbpIn\K1F;Yk\i3E
3D7ORNKhZElpLagIabRX4>[JKDF406VUXL>cKQbOZ4BG>g[Pp14f9?<cbXV_eBYR
Mb[E?G>6YAPAqYm5l=0kBhg`SKRig[KfV;JioT61gcOp@<SVjLTD^^6ZKi4F;cAe
0^kegk@Sbbp32XiJZlBm5bSh=mDR\7\KRPlb9HjY^JdbYQ>K]XG=<D`dYB<BCXeY
G=]iIp>lWGZFNF=_m6afmcH3<GgP8_`_WqlnF=S9AbDo1baBD;am<Xc5>d=A>o\I
qAO:HjnR``<[j9Q[oV\2DJdM?VO0pnjc@nR\ah=lZoR;\R\gm0?SLa:0167fl9FC
J>Cpo[<VG8VH4H[EWYHKN`9XQUHU[GDknRQQ\Xo;o6q]KCLSiq[KV=0a=aDfeLnV
Cn]X7[L[HiWE4>7GNZa<7ZJZ8cjamid@>g==gfJGqd1Jl8dCh0FaIl;lWlL?J^MO
4QJ23C`MPpFHdU><I_CmZG?_nAc_cg4d^XS2:TGkY8VDQH86pQ]4Ln]B6]0YXX:D
4ZUH^=EGVESpg1@>o`:ZpZKFlWjCiVmlQ;^jVbEkQHeoJf0i]`EiC4eO=Pn8GD=U
UpQ<_kJ\Gpd=cDmRQB5_bNZYAWHYPOL\n:S<p2DfZf=a3KiQ=H6N:JG70O1T0l1T
6IWdj9Wq<?dE2IZh40bCDCYcUE^\4VE\jFA0c:_UU3Jpj?E@]WCQN0Wg4?CcPeX0
;g>0p<ZZj?LEYgidXTWA2Z]fCPSL9p<3lM[Cg?jA=Y=lB1OIh?W6ek>X_q3X<81^
2`NGVFO1`]@BL4\Za_3MEG>^qQgcBQU5<hIKgP5O63W]X4L?F5315fZF4_aGZM4q
bRIj]:;LU\:DaY?0lFOIS7BFcA4O\X2>7T<IC3e6UYqZ8GELSb0NB\:gDcQIcZV6
=aQXbdLC@YpVeOCQ7W]OlU2HjoDaLSGZoBECM:LSXIn6bqgJ^=O2X@VVO]abT0=Z
dG<=]f`iIPq@`mffT<C@a;Vo3nAUNB?6J>[d[cV<9q0Zl0[@;IP6VTAo=7M`3_9k
JUQ@^Pi5Bg:Q4N:TqABgY[lm7j3lR^>MSFjd]LnM:_?ooBQf7]7nTi>TK3hqhjUL
l3=VfJgTA3gG2_c<aRZ7kddPXamq8MDPXBjIPGSm:RR]S5?ooo;lL7`510_aAkqQ
k=Ro1:23@^j6SHeWRFBAU8G^8W=d`q6=NY:OXG2nQ?;eLJZ\83QO<3]U?Whl5C2l
jBM4q3bFa]Do8@o>OIF:mCJm:[Njc`^mc=^MQA`0Aca2h>eqkL:YJhUJl9I>QnZ6
6VULI[EffBf@A?_M9cmKS?^WRkhOOi9die9GZRYTXI07UE8QpgYU6=OE=g5=Q@l?
TV=jZenna15\k6gPp^\=^;X@VX_8k:]k?<_82AH94kNXiVebAn^p[nEiYZT2^k:>
d8XI;n;i=KVd6kl=L[Ujpb<R7GmLaG_4cB>i1[J1VdUfdMaT1h]VK=NYY39mJplR
_3Ma2C10fKDdI?T[B`3>V1R5F>aSpB7J^l<XPHRk4l3Y^4O]58LH2nILlk=j:ebp
Ed<O9P`0hDm1BSY^BmqgWJc=oO@qnL7:?6pH_7c__JAe2860U9gl]98;gkQ^OQRS
^TdV;S0j>2k3EMbq2BSHlY`q\mg[4>`d<@WO<ieIkm[VMTh]R<qOn>Kl?_^W;6Co
=oY<E_E4<NEo;2l=1@lg7pBM<2RGfGDFjbbm;f5;Ib<oC2TV6FSNMibBVpTWP3e\
0E\HH]CNY]9;T3URXc?9O5p`:Pe3QAY8WFYSjLgP>B4jB7;pd90Y91cg_>Oc>e:e
_::1VZS2;dOq`NKZ^>1HnN;7KnGI8HfEObWl5eb26WqO3h8lF[NhMD9?e=PW0h6c
hWJWld::c^>GBTAUJp6eg1=O3?0GQ]J^RgL6NMLUW_l\nQk6NJVAaQ=9kn_mq02R
c?QTl`:?kk[Ld?cdmSKC1c99TnbVq=A3K:f5keF4d_8p0fJYK9hY[hi^af^_739g
ZgbEX__Nfh8GbnqGE_g3PnFCCZL=5cWGR`Z1:Vi:K_3T=pL=[5^U0^[\Z3<oD3FZ
aT@SadBd>8<i=TeUa90mqY[i6ak=@]ABHfDU8RH<b_D\GFg1JST3n?;PHRVTS5hq
?\X<J0hfEA0=@PG4:1]eO2?mcj>hacOpbk`dX0GAa@oR]\fbmO;QYAo^ShHQNDXd
h6qBK<\d?BHTf[gk[QT\F6W;\21;:d6LBp4?05O7HfgWfY[GE=]7ec3cd1;i9Wo0
;aMK1L>8qE?f6W0N<7j^bn<:cHB9\K:AV:f\9VIJ8[6dBMT3Kikq3AR^TiEG@CcV
VD6:kHGD>V75FmWiETaiQGK_B\PR`gD4]0qdee?o0bZ[YFEC_;VhR:<a_2VaS7LH
c1qeh78<EZCg`Qmn_ZK=lT5;@;iJ9^;ikV<;mqT><3]KVkZ;l2F0V]JLJPFCHYcF
La^=ABql\g74R>dg>24b_PEWafnn:Uo`]=^8S]V67cDBQI^qNEDYdo1>cOH7=S^0
ojGF^kNB_Jk4@YqbQfa>WSRW^CT3XMFBf6AI;6ZafRjg@E7Ljq0=Y@L>6Cp6SDC\
6qS;8a=@4lDjEfP`E1E?a;F2BM51mmc1ZN\?`<_CZnYDqo[4o@SoO0VnE9a9[JLP
P[ap2_?`ACMp^=GiDLQVI0]<XL>NH=Nb4o5HnBph33RiDD;lTYBm6hQPeb^FiJ41
<GYBEBQlPqYb4hAJqX\F?fn^CYn0cS36L\EK49knV;d[0h1qjTKSlJ?7^eM?Xfah
aKEDF4JDGbYZqZFfiP8UTa5Z2>dG14k9M45a^`^>80LAqYO4[\0MN;Y5oFDA5]?7
Elc<=habA1=4qLf>BnmKlWfF>mK]9Qg]<Fj4A9USXeVefSHih=WQmF;<=JK0:Rlp
Le=TEh_ncSAXCo=?`J`3B<b@CQHjqXWKFF8n:QV[Z2C4[350_`IH;WjO`4aTp17V
OJFBJJ?BmMZBKV]CTSZE=4WGIp<U`]hLNHGk4d>_^gCC36[oTLY3DIGXSL0Bm9G6
[p8Qf45@2YECS3SY:hod2h\\6I1]bUgiMZmkq_=^B7F<@koIX?5aW>W==O`ij5Y<
MLm\MQ5\oHSLp3eAa@G090ZL1o96Y20:V0=IE3n]1Fd@\g]bJ]bpmgL\`?qBIPb7
?qGhcM>YhdnWT1i6:;cHdFAaQAcj3>]WUG;00l@jJNTGU\M^o]]XQSi;C7l2O[Ij
nqfYUNGMo9[1AfMN0L2@g[afdB@nDob`p3:TJ5UomVg:Q^=\XODZF6HhS81LKp[5
8>i?P?M<gNU0\<O2=U_eM7PJXHf__pjCOQ8>A<gM6jOihocKG:I5Hj1<Ie;@Dp5;
<`g^]Q]EWm3^Z@cod=MFYnKF]5qWc1@5J4d<l=]Fk]MSC5Lo;bgZG]^YnZp@HdHU
b?k9X9CZRDHm?`UlJH[`h3eP0NH1RD:1_HG;?NqFZY6>_Ag?WKbGf\m2o;PnY:;^
MMIq\HV9ZP]VBY@\ZX5R^[j0>_g@h^dMYI9E@jDoPe0qP>^\^hEgTGDG=8FSgm:^
GKXoiiO4cZQ4>bqGh`kZHKG=SITT^Z[6d8Ek^9R=ij>ijaQCl?kcSaqY66GMB^17
T79Z4YXFDk1]IG>`SE\aibZIgDB@mqV]a1]BqL@7hj03YaiLOdE5>R4`VbDWa;S3
08^Wq2EBaCCpgfU`nKfJ1^W]j9HJcHW:4]KXm3>@`hpm]eeKOQ_`77Fg@\Gkk3CC
FQhHAd`WUB`p^GD3HSh0`EEo@8UdQd]@lbP]DhekeJI_U;Gq_F\5YBNmJ>2]iT2K
7WeX;AGGe^f82@^E?]1qbMiJcJ8VlHM^;2;gU4H_L<ViVI?k2B3980?q>S`5411Z
Qk4ODnHPfCjbLm:JfE1eCQ_Jp6DE;n`k>78FhbFP^8@d<:BC;`[h13W1h30`pF^?
@7\Pk51kk@9O;Jj0HhiWd@VEPEV9Hqm1E_iE^2cTN3Y>gJT\lV:SP3MBN?l\^e[C
2DKbQ7@]gq5D`VTVfOa25CAiSdZPB3VGk>_TVVP<@_iWhpThkKSV3og3Ro`dbbSO
6]I@hpElR?S?:mfcWdB]QR52CCW=EMDEd8UZS21\fp_O?07Xpm3=iR`q`n\h`k`P
g2<i=bgAf1M=S2N87>Yj7iCoZ1ma_JUNmHq=FebM@S[qKIH8bT:mD>CdB0>@9?B9
[6f]2nl\iXS1AB5g2\:Bn`B=;;ScgeS1WgYhpRf7F[JqY\>liAfik^K[El6Z]MRV
`@l:G^W8=N033]6c7S@8:2qcJo5iAJp8_cJR`\OHmZB4kIf8jS\So]N?2pm<g`[Y
\@3d]JQ6liNWZ`M>DP=K1RnK]Gd7qoOKN5PqDaW\<1i?HP7bIf@<Xn2jU@L7S>V_
I:pc>SIEVcgH0@N6Z9G`NILWUkVP>4apoF9>h@G?Ic7?ejB5[cAPiZFNBFPaaVap
nflhUV0iBFWm\Yi^^ZBI0mMnk3Pn7?5WVPJBThaD>cGTo1miCko5>2:Lbc<p7c`^
LWg@;H3dTOHGmMk^lC?<45NAQPdpbMfGLDfO_860Hd[`bGKTHeIIckbRq1NnJVL4
I06BdYbV:CiM^mf\^cK92[I:qY37H`k>P?Ihk\\8>Tbde?JAnk0T;p2m3OR2haUj
j[TN`jN?Gh8XoF\WM=;^=7]Uo>Jnmp78iX0`]W7oaadH_Uh<9O`[dkg>ne8kMjNJ
qf16[8Z>B]J<2;^:]e1BHO;EP\92?QjajDGHQ]MN\?CkLZ<o;KA:`OfiZIX<pO6U
4im;@01U]_TPoLhabDbcSALj^U6LOn:^9k:\pei<AB8?::@2jgB[HLaMc7<Z7NS0
e=o46JQQ0IWqXlX\]OqB@@_IOqPE:iC]Rolmnc=<l5H@SQR]oS9Oa;alqZ0G;4Bf
D5Q>2\g_3<]jW>=S?S_Z@pbEOPHDoDDkS]X]g;=f`;V:hA3cJ:^Jaq>cJUa3[5GO
6YMKDKnl7^2=cK<BNTZcTqHNYBR<7Z:JT6P2C=NT]U=69]C@GHpk^23W6kIBC[LZ
63^V_n^D8CWk?ap?>FiXY<gg[YNBCV^g9B;JlT2M[04Tn;qBl;W`YVoKg?<W7DA6
mbRo_A\b=8ipgCGWo4<j;f_Pm`_QSXSQd6aX[SF51fk<g7>Nl0ap]Ib2<lIJoWRN
m?IJ4dK\c]Vb]^jGlR5Q:cp4BZHdVMo7RGVa7Y=JX1=n<7Fn2h^\fGDjaN36jnqD
f1K`F;T>FYALigKeVGn6^LQW?cFhA49gd5J1mp;cWM^[p^^4KcdS_To7<iVnha_7
F5P=TTAk2[aXNVlk?c=Tmj?Hga8BQRQVN=C5]JC1RSOjlg>j<:<pFA;F5VpgdEUA
4GX7m;afJ3R:7nZed]5ZCF0IYqaLKlB3_?iCc0ZNPoXY\UmH0bXY:3\VCJpG0cXM
JY\JVAT<BJ1c4MPj@RdmNK\]W?4^O[p]hOo:6Yfl\nDHf9GH@X[hfPORNRg:05lR
DZNNVmFGKEYV2qd7mhlSSX_n2f^e\kW4Xi]4Wo9eCROFS_SgAqmh?Ck_ND?`I4OA
[E;]NidGa2@`DWKfc1q17VOeDRGWGV4n=jg^[XbL]hc7RE2Y>6BmEVp^KJh]=eQM
\g]J`[f2OP^V>XhU?<Q5>IkpAP2fP1NdcYk<3R3jKmS]iKJKceBSMAGYJh`<eWV]
65`piiLYn:_h\<kXMU6f1>jT1`4LkgQN]jGOdo=p0:VD2@8>1L@F1`NO=>@X`a9>
?K`U1cio1RJfOompachj4EK[U`DX3i6_L6noD_6L^@YH@b47_FAq5mfh`CpH8?kn
kp<7o0Ni8o^Yh2h9;7aBd\QSM=Ef3OHWdYN_4l90l5o4qcQXB_dYZqgkC9LBp?\n
6^Idj?^0?oMDNV\c3h8V1`<TEJkad=i=P>3M^>IgP@@TUlOQFMf3PMN5^Rac];Hm
35\Kpcl7U\:6;^lc5_mgY28J<0Q0\0WbT?Emh7]@?am`VE=q1@LVhgdq5REN5<WY
ZEeB@K9Y<7K>lShOA>q:KX`T<45Q]mXQ>4Oh8R^_>fMVBPg5^4>>>pAAgI]>p=RO
VdKSZb0KjBk5>4A5YSV85@7]`QIpTS<_DJF<hSi1PM6LQDB:Vn<82OGUqOVP@jK>
k6\B>Q\\cWiicBD^_;?kCZ:Fp[M]C36;kkn23eCKgn_fmA@@8b?4lJa5YX1SBnQV
QmnDHAckERKpggH5E`SY?DaB5M?nEBdRdSaZP?@caMRqH9QNCf2\O3g<G^>;lOJ<
ifDX`YdFqc?iYg<7YZ_QD]23mY8c^1\O7:V20hL[qg:@J:]j4]jaMo6@SmgA;:b_
cc1lmB<^ZI5f;X1jfX`SlBJNH\7=<qVeR7<YSSP1bnc8j[Q:AflbDFl\RQqc_9\C
;8_kTIP^o@^DYPZocZPWX:A_Rl[k?WTYOIqYQOT\ec@1VlPG7l_=5ZS:WcJ3l?ka
4<NZoqg5<fmY]<M4>BL@^2KVLQ[ked?JM];6@ln^2dDeUpJ6SJV?[L1e9U@aGWPa
<JN31<XcQOOS2?m[_6\hq8M?]A@a2Xm_ICB@^_>:fHEUT^@[[WnG53Yi9PO>V:1c
eEVNdp\;e589p@KGNVhp887AaM<kW^M]MWV`Dj8c\YE7>^<hdWqS:[M54mX0<X_T
K]a`]1C@7aB@^U?qg7]I<;Yd4Gkm2VQRPFh^eG3_Yogh=V0kaTgpnH:7B^5Y?T<m
?BZ\in[=6HOaXej7EUMqnG[Hge^bC2KabU4?m`KVb[E@DHG=]3DqEXMj<DAniJGH
?b1NBHeM4Uh^H5_@p8`hR<R`P19`0hF`M0jG5bb2UDRP;Jomq;Hk][mZjkjb<9M0
ai\c_bhi6bn?Hq8=]?S`=l1Se>SBULm<B6PgFK;EH`m6Cf0d`8cAbp]=hDYU]cC`
7Qi]dZ_0[c_<`2d1mT8dI^3Ap0HTXDlSGZ@92ml2BcIaW]O3Yd@2ogLb08i20m`i
qPXd9:9`\^5R0dZ0M52T\Ul@>FO[Q6o3BJ2aiH=pbni5;k5<=T5^3iSjKDAcJXa3
49G8[@c4COo_p;W9Qi=po3a]Z=paeKFOiSGGT7EGEDN]12cQfLGDd4d@KpAc_]LW
S9Cn<d3=_gcT]F3jaQ@5S1NZakqBn]FgK5[CW;Tm@5\<NI6gWdOd2OaACg6?Dfqf
:LnZVAU6fUOHUVgn_jBInD5N<8<m3`Z?aGqgfcO;<P16hhLVcCoWK>B7@`;g7CAF
nc\qoG>bT3^onaD6:QP@P9<WoTbhGXd?QDW<]Ynp9VMmXKY_G56j;P>IT_oE@:fM
MLm2>DFBq=5_1eL^Q7VXahTfe=cU]=H<OT\@2Qo8IMHT>dXd=I=05e]IRdQSj8\<
pY?77Bg7Y:f5RXF`@k;Z]S6g0K<PB1ZG5OhhF?MPka8Eqh_P?TcTYM1cf]dXQL5\
fmn=aij[URkK2nS=qnJ<nMl7L;X^lBBfVNNPB^mZP=K=V2LN>`@0p25DTohpTf3P
ghqUPI8TVd_Y48Qe_J4kKAmSOMBmZ^m5^Y`hRPCKYMeG>qKekPUP:bpc?\Ug;noD
KdiY:T`oVZGDk6<D4lIcL]i=AEd2>=qd8Wb;>p_f;\$
`endprotected endmodule


