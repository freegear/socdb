//===========================================================================--
//  This confidential and proprietary software may be used only as
//  authorised by a licensing agreement from ARM Limited
//    (C) COPYRIGHT 2001 ARM Limited
//        ALL RIGHTS RESERVED
//  The entire notice above must be reproduced on all authorised
//  copies and copies may only be made to the extent permitted
//  by a licensing agreement from ARM Limited.
//  
//
//-----------------------------------------------------------------------------
//  Version and Release Control Information:
//  
//  File Name           : InputStage.v,v
//  File Revision       : 1.4
//  
//  Release Information : BusMatrix-REL1v0
//  
//-----------------------------------------------------------------------------
//  Purpose             : The Input Stage is used to hold a pending transfer
//                        when the required output stage is not available.
//                        
//===========================================================================--
`timescale 1ns/1ps

module InputStage `protected
0:2\hSQd5DT^<`6YcSDdnQ[`8Ta_30UVMN3VVFi@BaeLF`oNO2ZD0CT2Wc4HZ<En
^a0IZAph]XY@19@]Pi6iL?E`3F>ZTW:[M8CBbD@i>8>VAE[Qhdmi=:Q0nVDioTpI
LP^Y7fRb>DQB\I@T;NUf=3Ab?l9L<`fZ`D\<HG7claLnk`N43Tq1eXW_b>p:D=ma
lA]02_9deZpE90X9M`7dFIO7V31bQGqMSmONgfBaY4I\QHCqV8=\XaGec@jIhd<n
:0qRfe]HP8mVPQ2[FU`B\;q8iD;LogS3K_XW3?gZhLp3oQ]H^QYJIV9bbAcMnTQ[
XUb>QjZ>8dDQlQ`jjP9l`p1TXD29h?E7hKQ0;Hm`qST]NV^]N8K[a3FCdd54q[>o
BjgLU:M5o8_Hj<Jq00l28mgEI[Ek5lQQbUhFQY:p9mR4B>\mSmMRYI9>NTfq?Nl6
Q2KLTh[8Ckc9Z?:K7W6p7LUmT]BgljE<=`BZcJq?@\ogNSfgcX4^Jp9nEVi?[@^J
j]CS=qb>D66kh?i`3@7BK_fR;1S1n=ZU0nmoU249SiiOlIaD?5bRSibLN:2Eh8BC
p9m1WVo2MNe_EekUIqK[@1iEDCGecR56e0p[nH\eF3>?QR?88Eq@h[GNVlk<_[;h
Z?0p9Eb68l=8WGeiXLnq56P1me^jRZ`@0:UY;ARXjlOW2GAE0;VqQ8IW7i;`1CUg
4jkbGjT8p^2JC8WMCE5ffRJYJ?[3gq9b8KMEYI;_9[ZFLK9cqIAVB@B86:dnQ7;R
48R<opoe\4]iZ`6:\`?5UDqQ791^l4aS`>belO=D[X]nJBBFLH2c>Y:S>]Peh:A2
2GAamU=C2Jo41OEH]Fmpf5>@533U>CifI_Y5pWiMiDTAfj?;Pk9D8k>2^p^l=\G?
`F2k@3ZnZ?cMq`INE?n?4]hF_<=B3fF]m<aB>LU02_kJTEKYLQ=0S4QW3f<N<@]J
Ljf2lhoYG7aOp]9jA>lHhklkckde63j99Zg0Y]MOi\RXC=1qMEIE]E?1h;R;gWI_
1C^:LXlD2WRc2d]en<qkRWgQb[o^RC<NEk1k1UWq<<>coAAc5cI<PKP7E?B>BQbV
JnHFiM=4pcmPHDF0Z@ZUH=Eb;:@DYfEK_R@1:eL6T=`qT^U?^_USZA?MJcNam1O;
c^^o6Z2N^8:mqeiB^2T9OfI97Ck`U<g=nJbo:SJPoq\k`gW5a5<R18>Td0L=IKV<
KJpAmFKe:XB3OZ4TW[>elU`pfECX>^2<\]^2b9mUGh9qc3@4IBM;e1LRaHVZFI^Q
QPqL`b]=TkcGb8H1UR;Jf_=Yd\bj3;Qi1qiGBLWcC]PWkF6TclPLhRo=l_pj7c[T
0=^>1TMkIh=Df<L6bp5Efn_LifYj7nK\1SWXR20k0PS^5LU^2FpZ>P<>a1_53QkH
Slqc3IKAIQDClE4WlYXk=?e5F@MAC=l\bdp?5CAKg=0h:MfjOZ3GDNLV90Ui3MHJ
UgpFU:O:GT`kYP9^56<TWq5mCiMFmT1=`OaS]I;1ml35<ciG7KB9p[`THJdAUOD6
8jR3=nQK5OOPA]iE=AK]q9g__]D7OejO?60HQX:M5?I2?GffiHX=hWBmelW[TR^R
ZIX^TTKK;bJfY]CqIJDY^a:EElf^@@Y`dS:VPadjajDZ`QqeN[HF\M^RNIk7_0>?
:K8d=pIc[Il<1;db9eF<6A>Y1E;?pBNbb7YHQ?TmcBbnHq`o=nleEQ3lK>3aI6=J
NHqcd6LVoJV8@YCkd7RC`pCh?`=]021D:IUieAcg0LaLTaNAfpDBh5ZKPahNND=S
5]=K8O:\j]CfL4TSL49`qL6gHVUUIcG\9@QVTi>jZfgnj6Jn_=jlnaYpFd[jm:hZ
j^2Lji1LkIWXqA9dO39]g[^iYF=N[cV6CEJ6<73ViY[B5q3H_XH3e5CDZ=mY3a[Q
[A5I5^F01e4Oehe?p7aW;@[RF;G6CIOb<]PG5dIH[4E5Q_:lYp<C\ie^SHbhQ2j^
`FgYdHN=\WFd0IXRhM66^hiK?2Z1aqfOWCV@5Fh`QHBTZXTWkRedcdq`NRW96mNN
NTgoH[6K2\5q>2UM;NT8dbjGF>PccMoM7ILJpHb07djVal1Z\3M2jD;A>K4=6n:8
[[9W6pFRRhiinFHd01QgoNkAB<J1XYg94B7DT763=SjJA;cLAG0I<L=BPU9ER`5V
D4eI\Wq7`EAlkCn3WSJnfHpL<MbcgK@=HVFo1mE:]4dcibf\fC0_b>pV;E1HlfKU
h?<beS519@`9SAh=9BF2^ep@3Y82QT?2NdR3g4Y>Ep5cHmaPm0SP\o<>om9iUM1J
URhVWdocpV`^KWK7_m3Po<Jdpko?`\=3II^j7<QZ4_lP2ihRX5ok6Hg;q2V_=]5g
EXMRcQDVgJTnSQH\8436m12p05G;N[S\2lN28oVJM=`DJ^q;o>oH`DGf@2Cd6N[<
8Di^4pZ6?E0_A14[VjlaKlSYnp7_0;Wl`o91eLgl<YOXfJE=qiAJ?@K[=O6akIh7
D_CI2Y5X35\c6@7qVbKEk22\3UCao9[I7KlEp3jPkII9[^`n::\UWZSX9>3hp=VN
IGC9Vock8]kPMY_bGGa:ah6^39e=O6R<a87?pBndfBjH?aLd61ZNSc\9FJRbCV0q
V^cKh66\hVi7HeR9_8p57C82;K2X28U;X3`O<>B7H=qo:QeVNP[Kab:bk>eLl1Gm
VciMIn<Yeo>AJHpC[FC_N>BOC@VMiklShBDA6pQ9:X@6JFTF9W@=MVK=6:9W>G_X
BJRd]jeJqb;S^7MQd@FS]CFAl9KU>L2X]UlS<X^Kj`iFqV65lKi<NUO9R@MlAELS
0U9jD?8`TXa<\M:piTTFmNNhg@?]OcZVRQ]>H0h5V7pfc>XJK5m9JIbIMo>m]`d<
6ggDO]iklqDCoQLJZF9X?lcDQ`\\QeA9CBfV4Ee8;AZCVq\VjknECLGW_M=2;dQ0
C6]Z`>d=N;7GF71RNpf3Xm9NNUT[ndSmKMWTAI3X8=:haN4K4ToXcfZnphAdgW8e
b^G]2Dj\^BKb>SkIb;lYGWOYb2o=mqH98TYNM3Ca3k>PNPW^6A04>7_k_7qJ:2W=
km<mI332=X5jAQFNgC6XGRS<EMG>WpUHI`2o6f59UCD@d;EepSQ8kGQ?CbieoFk7
7gW2ZT[Op\@J0UfOGC:0Fc5NVTWZg_g=1CDJmL4IXqZXDRRdZkYjc`X`7C435?qO
JJNb7qa<4?>]eSS551CK\FJOPF_D0\p154]d1>[am;B\b`Ced3el2FE^dF[gg^cB
JT\_4ETd^j`;hUXKgYO0ll1`gf2ebfZpJ:?O:V2lmV6ad2An=Nhn73>AqTWoBd]0
7f92V?IeMY:_6bW@Q^DB1^0pCEbf[`F0jJNP=_52NA^jUg3QY[nkMHqJTI^Oo@@1
TlQgm6O@=hh7GB_85;cDEN_phEEbknLi\`>nO;jo8c9?8n@?7:lMpgc=WkCTJbk6
78fQLiQXC:[Of>gh63=pgF;Kh:MF_?dDS=Y>Teajn<gWmaK<glqg:fXiHY<mZ:Cl
4HKSYE?8Ckdkkiq_IJen>aU]QZP\jU5Mblb:0DZ3>J]5DpD`eVS5;<P^PfEcbi3W
I`M097Y1cg[EdbJ6p\lJ>:BoCg;m=_mNM=ZmhOQ`m7CY2Y>fp?VS_[Rm8Q0@Dk:l
@I9q@n[ag;JLKjgN7U53LHB;<aLC8ZaIf_CPp>XYJn:X\g^D00?l0hMbXK<<Y<GV
naRU8paK\QPe:=M:E[IKI9Q^;XZ1<bH60SR:oNqMJYMg]DN6>\iUUDJaY@4S8o2j
5SUNT7YqGdSDG6NHYRT\95Ch0Q:3ldbmpQ`8^Kl=J<M131kZ^56k8kjAe8HYnaO4
^Z>q^DWVM0[>BX[M92l46eaT3>[8`k<]f`254mp\\gn]oXF>GMcY[ag5A68Q0NaM
dSeEVplT\:OIb_AQdXZoafMO1PS`I9GUWS97EdX4JG`_dApW4SRcZ0C<5]]RLJF9
fjWNQZbZTVTj7fnY`J2D5Q<?]MMZj9joYQ4IGA9LBXF486Y9J1UplcMQlOT]h6P\
[3>7`DiKZnn\?X[2d1G:3Dp^M_1mK^lWV4@Vn1@gh?We?m[FZ`k\7HkYEZoplQN6
kFXqoT_FVKU>Vb9ZSBl`>2>;>=mMfSm=SlkKEU83]oB4]bpXoa[I<ZTokXT4@jf:
3oB1?YgQMlDf06a\bqfoYKZA3VZ]eOOZIBeM9<i8]S@]jMAg==<lqF11FYeBnWNl
OPM1`V3Y[UL56A@PWFKRRmI6ZCe@RqD5@EJF1_^f;VVed:31=1Z]VLePJn9jl;PJ
bpl6VCk03`93OlCkaQVm7e_BLEYgo[jh1anS?q?HKGG`e;[UZ=[eP]9SO7[mMmRb
IloZX=QMX`\>pLjo17h^qNlZ\]Q3pg9kC>O:qQ<_alOc=01\\gkJ46V\2HInE3em
coaaFhni^fDlTN@^dfj=B`E=Dm;W;HPp6Abjl9ZN1XXN[[eJBS;dFdgop4@g6j:G
qQZ2n9V4[Gi^kNa\Z6oE`Z[RbV:c\``=9pSD[466cQ[LgDKX2CgmRl391_L[];80
7E[KiqW5g4M3`=:L?0f\;o`9bZ?DJNLP^ckUOBqlC<lj0@1UKDH0V>CPW\[7<ldI
23m[^\6O6Wp[YP3m^DdY<9odIU9Y4IJGVkGdM8Mf3CUp?B35;?J=_6B[Z\qWM:Ng
0Um88?A4WMM`hbhhCF;OOGgK:ak[<\KB9UXLJmp`HmZ;Xlq[>?@jdhqX>nNO;=q^
9M\hPbmaJelGipWehQ=HBcfBKRSgNf^B>^A02:4Kg:eSG6kZLocRWGF?d3_me@d>
`:b9D5k[LOmiWi_le64:j[F<I7L18X^M8Rn9Gq1;dUZBp;KH0`=>O0GAClVVXa<X
`ZG;\5;:NY=BN07QfXoO2fFMPdT=GY;;?_=]_PcJ;L55aFd@VZL8SP6L<8bH81ZS
hFJJI4?BGYml1ZV_Tb<Gekd:hN3QWKCpHTHYWY1mbO[YM>gfL[:LLoFeXF@mBLd0
;JR=Y\0Pp7@ko\ea[Bb`c5`De>mb]B\YUGQp]64LJ0m;V8D`=6<IAb8bX6]N=Bc;
1WVf5KI6FUZd86gId7p=Bcn\UJm^^RZF;=o1aJ:;j2hZ[03Q]E`ciPkqhQ@^OGTB
;Ra24HoneRXgYGXChfTN6bpeZ6C<k0qhVZVI7AqQ4?NPkoTk7jhc;e1M=I6n0b>p
3Mh?o\n>o]CXP26E03SYF]>ob<XM2[5YYWp`<Loj9VphgK3UGHp?:QHCDlg81O6Y
0\M1N@XCR0\JUE2Xaa2VK>8CWDJVUX^TSljR[CFTg6m8<qONChVVPaNkQ0R3UNWm
g]en2789[JjJf>7UL^_jgX\51@BMCdHPR=i=iV=dSh3WqlUdh:K66kc0ISX6:mdB
oX4<F3G5?R_OmnSQ8LHH?Q6^FTl=?Y5ij;Ol`00<18g`IQ7hk\fnWgmKIV9i=^Z\
[p:3YOFV252da_GR4eX@iX;?hK`6^5Oa6fCgD?Vm\PpbS52fJO_GJi?m3mfEjjWC
LQSEWFJ7lp@hlWUbP^a0YQc8To@5M46V`0>T9bjKVDX2GlpicoU8@AhUK8f1JL`R
C`h_ogBE<20CFOlQ6m>5nqCRlQABlh@AI<=00_cWZD138>L;@a7YE8dl=>:oSh@9
^`@m]dM;HoKFXl>EedAFdd^Nqd1jLi`=pFE93NPCGAimAbQdf<L>]4:I;bS\>6eV
?foKY3;PXmoq\RWkPi^qPQ_P?LXo[<e\i@>5KT3K[OY`>c8?IPYZC44WF^EHp_m=
cQ2n]EUTL>ZB<mFHM[j010ilZ`KP`lBgkgl=GlIYLi_RX8bf^=m8T=cT4q2=W_;Z
:G0m>UjCHmnS<^1cV7AbTcQc7:VC>01];WMP_Xbc<Lfk`B3E;adF>cUTDU=^CS:c
N3UVP6jVHbaX?pB2T;iTW3gCI[lkS:@U:4a6iFeAR?`ogBaLfAV>cGU29R\3M[bU
d>lfkacK0=Cflkg29?:]fnCl83bd]qmcDBWFYm6=Pf;CRZa8h0DGQKLbF;W7AccL
_g]lY`4ljFM_@9<6mV4Li<^nJ3k;bnmWjfdX:f=ORa^NKAY1h59:6qV<7kcd1?>6
i:BeJ[X1F`6IV<li=nW_WDn2A9InFUC8K1jNkF34epM\<N3HKK;K^JoHGeY0YXGT
\<qNQa<6gQ\BCYhZ[T=7>4\C6J:VCDC9[fZYH64^`AFBeq^H]3H3kpdoVol9DNX\
ATVk[mT6DHB?hm0Eqkd_E1bPX;d?Ti@gNK663m:E<a2oVh;fIUd7p_XhRE?]?9W9
QOAX[5:YfHcOCIXXCq8aAjcJ?[SJc0U1jh[UoDoibAc0Fa<L^pB^^_PDon4ZNBQ_
QNfBUOB[_\8>`\qSDC?nHMF?16HZ>Q[E1O<3>ONRV9>;>6oA68q?U7<8@67@IcI_
aL^86a4`=V9GlSjnd@HkEOINMG=f6iHL1:Kma@=n=`RZEp9hdIQm_Rj^=HdDMmT7
eh=m?iJ9IlpdK8J2UcAUcDdHcbXOmNZGG\>AN<;nQdJRHV6R@\pK5Vj38_q:S@Ae
J:qA8XjSB5qV`b97MJKJJ@fV?:qT]ZR6I?Tk^:>Glf2DMG88=T03=2qWTH<1UQ;n
5bhgZjmSV72ZV3CY;@TmaLCL]QXB\UpT8\W9h]QV\6WBB?T^IOD?\a\U3;U`npKR
OI_`]W>HQDcUnG7]XF5PB1>k:b[C@;p>RO\2XYlh?E<LhmhS9YX`VXkZHM4Laq5k
gC_hDD5g:BSAkE8hmDI1<KMIH69gUD\O1fqR\8dHOSa8UR]FC2e50fdK;kR87>TA
CqcmRc@RIQi;Jf5N\FioFPX^C@GIp;hg5R;m]KYgRiDbnoGkZ[o51^Gn_Hg@j8Pa
;QFjMpBMj7a`6pG@bMVHXq<eB]?=DZ@X9ocZYjQFe>jn7Vn[h\OZ5UO<8d5>n62e
9P0;m97cCP769F>?@>?XiQ<=<K;RUP2k[dITC0G:n=Y7J2lHJhTZibA;8M4F:pj@
RdTWHPWZ0\b^`ai6hgIFVPFE7fCcIm`m5eE=IRf05OaB8RiJUN_0doK[;KmDO\2>
dIn^0gbb>EUW31F<h]d2[>oKq\?O^XQhjfHLMB3bBGEGcbI=KXnSVLfXQZMX0@N6
L585B]hcgphac8\AVEf33\FG6f[XmmE0pemL_1<2N>WoP^2OT[6;eaka>dKjcfGG
`F2Qh^Z\loaTgZClfBoa6`PgT6\9=0K\c;9efC:T[e]daWET;n4CHdR`WY=4pUPf
4e14dLk4`OGMCHo]Oc2qXJ\98QQJ\>]Y=bPLoHQg6YM07[fmIEQ\XlmNX`L[hgf\
Z2SlgDBYP2I36fc[3<XPXgB]pbFEOoD4QmBcT@U[K35IUGC50_jfqWVPVVbCF9oM
n?1S<]jEYb7JaUmX_:6`3q^FGGRmkpS1;m?RfWha`=EJFIXLR_3<=S;[5TBI=_1Y
8T4H[e6G42EViGEWY3q:0:kQ\i_`>aAO^4Y?fF?[=6afa6[k4H48V>FqoHV=GLX>
<GK7o7PHLnCP2@gk[1\9K@:K19q@DRcoE3q^6dZTIT8P_G^\kb=_Hd[gORH`[oKO
Q4apjMbTU\Fp8g0k0YcXW\boeo<T?0if^fQo0k0YE5W:Jj>eq3;7PGHl47^@BofE
9gi_Md9\iJlI_SRZoC`pMBIY<k@:2fnf01VW1CXT0W=3j>16Te[F<XXCDU=9qV@i
^4XCqTm@kLLPqAmVLlbVp=DH@_bXdWb5>@15jnmjlj@oOogK[IIl5DT?YM6JqMXW
<IX8?K4>Y]h94^l30N:Se7bl>qmPWhNLBpG7>i0LRqcB3VOG^RGFgk<kfdDRi_KM
3K8=\83X=]lomnC\j4E7U`Q2oV2ecLZPXcekEGGE[JcWP2q@MgGTT1FVgk_BoUHi
NcKaOU[kaOZO_RII^5@LV@37@aNaSnTpC@fR2HN95^Gb[bdd;COkTeU]>LBKBQSe
IFd2fTi[I@B8c?e:0eJpX:NJ\i0nWl5mY7dnE\_1BSX0`MiX]OL_8_g:jcCLhlWC
MVpNE84H3W;cmgaYl;OoGmC]HH5DDlQiIq63FKiSqkedH1iU^hS1URTVGRe@J68a
EXQY1RD>PSj?@c9]CpL:592XFL0=nLSEhII5Vi>I>8Y@L9F[l4=j\Lqe0;4Pi4?4
2TYW1R[kfn<GNPhc_NWZ]C5GD`?Jf<G5RKTVn=0jY0gKnW`T5G`=YBMjGp0a;RN^
TN741ij^D9@lB>NcfJLdG<@<fY13bGp:VAgjhQ<<M<GR:dN<aA_BXVRBY8l\lkWg
AkSQfRJp?<N1Q\ep40mIk[[Y6cMWgMle7fAS;7?F>D[A^ih=Hh@C4kIEeeTE64@i
?ZFLZ0bp7[>IhY7pk@7h`@n>a`?MDd0oZ2VB<4GQ5L:[lfGiLYkJpaMoU[>RjjEb
LJlc5d75KNj9U[HGQ:bNG>LEQfogMP2Yh<T@LdOQpK8REK]QBNZMk?DSXfF7KQfk
7`lcO7f``VXql`IX;FNSA2k_X3:BFHMneXpnOi7Ei1^jLL]jWgoXd;W0k:mLegNb
aFXQTDjUS1nFYS_PkB7Amo5e9J<TH=6\6q8BG3VE4<6kY5mLgFi:kk[G1KWWm>hn
Q?l[QjC2D?6PYO>@49EAn^^?An?U:V7nqXmWlO@o3D==[oPVC\fJhW6efEJ6_k?Q
NV24J3PXnn3]FL2e?S2g5SZQ;in_;gDpFjQYI;Tmo[cm=5CkSih2d?koP=6WW>ZK
^g?]>kSK@3K9C?1658<4PjI>^fh_E5p9a_TDR^L?1ki9g]^V_GjJam90Vf>1_kRT
PdfV8WeaC^4XfSXEa0qiJl5IQ8pLMK5i1BeZ_N2Y?SlLWEK2Y=SGDEn]K2P=SDHX
?^>Jj0H<VKnl^qn_g]3B=p0=QC>R6[LPQXc[BRKd^e\ElF^RhahTT;]hIYRbW_jO
hqA5?7WVDDWZKO9l2e31c;_F\SFlN7XVi`qOTj4:J;4Q]VSik@CMNWJbGOp:UZP4
TXH5W8mai_Bh:e2XBp^<c72P5N`S_[iLIWiYCk?0;bpE:DE70nbhk@=_:]g3Em;L
;7m]n2jMkm]VHP[mC^LDDcn8niERg@:\Cgc<PD>mI1qJ\l]h3?CCQTb6M<NXa3HO
@GC3BkCRj]X>^PA4MYX3Bc`QP6qS]ZmiM[q7IfZ_TWgdQ]3TVS<h7jFjV6JmijLo
ZC`Uf0EdHg0gEVBUhW16CE[74neSf2<R;nO<jXg`L[pLeSDNcM;d^XE0D>df61Ei
?bAqiBYjZC3IM6]0E[Lf0m:oLLm=MXI\`B5B\bVUKTX<Mo>mdEdVh_=696mZ7jLC
A@DqI1Vm8B_Hl7G<83KbY?8Ld@A^UFYJh;V]g7niZD?lEmpGZ_Ck^Hq[\9G`:7ZQ
eH;=cGhA=HF1cG6KhqV9lOAAAiYfnnAVSn^QUbV?NDCeQ[<?h?6WKV\mX4eAGH`Z
nHkDQf=Yno:;54`l^qegCJC\MqdK=0gaAM?J1p_TYohlAc^mMf58iJJ>fGiijPGP
l_]P_m4eA6hINGPC5Jg=LCTAp9=56\E6G=nXieRNPJKN93fo>Cd?Z4lgaiTEOWi5
D<5;8n1^2cHUl;Q6Q]MKm1CGZ?_PFZS81p>_F_ILDph]9i_6Gph==Ic>0pHR?iFk
f;jJ[e6`FB65\2]CR^gNK=WZ]F6]7b84GgO[lQI?LglMcEAVMJ<Z4A>ldHU6WlF0
dX?FJP=9UICd\^bkHnXgqlfeb6KS777JfO8<lJ?a:_C\Vm`NU`9LOOF^N;bWE^8P
;e97ENne5ihZmLIo6Ma:RJj_]I:oA`hX5b5^loA`jRB?>5lqi2_1C3LDn_gQD:4S
UYd7W<H=C5`LVd@T6eL86bJL^46nF8\GU2MHBaFnn_WhoclOW0R`EP_IpK3IQF`q
MP>jEX[ed3[O?CAlmAOD02dHmidQ^<VLVDjl>n@=qcT5hNlZLQ^oRJ6Z:kFV7Tg7
68IqV]mc1i7o]Ke7\UqH9L^nOCed>XjgaBehXPVbCUj6H;keD@?Gfo=qHjgA5@^j
0m[lnM9FMCFdlj86Cg@3WdqhOm6Q3`pXeMm5Njpkn1bYCS?S_5GH1=B=nPMmcq5g
XAeP7\1Y4jFA^>O>YWkHP5]CYg<?RL@jc^73LP0jXenN3SDNb3pS_PJ>[1:nCS>6
F=;`]YeTS1@a2kO78\B0eqKIg5F6\qWMgFh[DpY<HG$
`endprotected endmodule
