`timescale 1ns/1ps

module EASY_FRBM ( XCLKIN, nReset, GPIN, GPOUT, nGPEN, nGPAFEN, GPAFOUT, 
        GPAFIN, SCANENABLE, SCANINHCLK, SCANOUTHCLK, SCANINPCLK, SCANOUTPCLK
 );
  input [7:0] GPIN;
  output [7:0] GPOUT;
  output [7:0] nGPEN;
  input [7:0] nGPAFEN;
  input [7:0] GPAFOUT;
  output [7:0] GPAFIN;
  input XCLKIN, nReset, SCANENABLE, SCANINHCLK, SCANINPCLK;
  output SCANOUTHCLK, SCANOUTPCLK;
  wire   XCLKIN0, nReset0, WDOGRES, HRESETn, WDOGRESn, HWRITE, HSELS12, HREADY,
         HREADYS1, PADDR_11, PADDR_10, PADDR_9, PADDR_8, PADDR_7, PADDR_6,
         PADDR_5, PADDR_4, PADDR_3, PADDR_2, PWRITE, PENABLE, PSELS0, PSELS1,
         PSELS2, PSELS3, PSELS4, PSELS5, PSELS6, PSELS7, PSELS8, PSELS9,
         PSELS10, PSELS11, PSELS12, PSELS13, PSELS14, PSELS15, SCANENABLE0,
         HSELS13, HREADYS2, HSELS15, HPROT_1, HREADYS3, nFIQ, nIRQ, GPIOINTR,
         WDOGINT, TIMINTC, TIMINT2, TIMINT1, HBUSREQM2, HBUSREQM1, HLOCKM2,
         HLOCKM1, HGRANTM2, HGRANTM1, Pause, Remap, HSELS0B, HSELS0R, HSELS0,
         HSELS1, HSELS2, HSELS3, HSELS4, HSELS5, HSELS6, HSELS7, HSELS8,
         HSELS9, HSELS10, HSELS11, HSELS14, n_1, n_2, n_3, n_4, n_5, n_6, n_7,
         n_8, n_9, n_10, n_11, HSELDefault, HSELIntMem, HREADYDefault,
         HWRITEM1, HWRITEM2, HREADYS0, PRDATAS4_7, PRDATAS4_6, PRDATAS4_5,
         PRDATAS4_4, PRDATAS4_3, PRDATAS4_2, PRDATAS4_1, PRDATAS4_0,
         PRDATAS8_7, PRDATAS8_6, PRDATAS8_5, PRDATAS8_4, PRDATAS8_3,
         PRDATAS8_2, PRDATAS8_1, PRDATAS8_0;
  wire   [31:0] HADDR;
  wire   [1:0] HTRANS;
  wire   [31:0] HWDATA;
  wire   [31:0] HRDATAS1;
  wire   [1:0] HRESPS1;
  wire   [31:0] PRDATA;
  wire   [31:0] PWDATA;
  wire   [2:0] HSIZE;
  wire   [31:0] HRDATAS2;
  wire   [1:0] HRESPS2;
  wire   [1:0] HRESPS3;
  wire   [31:0] HRDATAS3;
  wire   [7:0] GPIOMIS;
  wire   [2:0] HBURST;
  wire   [1:0] HRESP;
  wire   [3:0] HMASTER;
  wire   [3:0] HMASTERD;
  wire   [1:0] HRESPDefault;
  wire   [31:0] HADDRM1;
  wire   [1:0] HTRANSM1;
  wire   [2:0] HSIZEM1;
  wire   [2:0] HBURSTM1;
  wire   [3:0] HPROTM1;
  wire   [31:0] HWDATAM1;
  wire   [31:0] HADDRM2;
  wire   [1:0] HTRANSM2;
  wire   [2:0] HSIZEM2;
  wire   [2:0] HBURSTM2;
  wire   [3:0] HPROTM2;
  wire   [31:0] HWDATAM2;
  wire   [31:0] HRDATAS0;
  wire   [1:0] HRESPS0;
  wire   [31:0] HRDATA;
  wire   [31:0] PRDATAS1;
  wire   [31:0] PRDATAS2;
  wire   [31:0] PRDATAS15;
  wire   [7:0] GPIN0;
  wire   [7:0] nGPAFEN0;
  wire   [7:0] GPAFOUT0;
  wire   [7:0] nGPEN0;
  wire   [7:0] GPOUT0;
  wire   [7:0] GPAFIN0;
  wire   SYNOPSYS_UNCONNECTED__0, SYNOPSYS_UNCONNECTED__1, 
        SYNOPSYS_UNCONNECTED__2, SYNOPSYS_UNCONNECTED__3, 
        SYNOPSYS_UNCONNECTED__4, SYNOPSYS_UNCONNECTED__5, 
        SYNOPSYS_UNCONNECTED__6, SYNOPSYS_UNCONNECTED__7, 
        SYNOPSYS_UNCONNECTED__8, SYNOPSYS_UNCONNECTED__9, 
        SYNOPSYS_UNCONNECTED__10, SYNOPSYS_UNCONNECTED__11, 
        SYNOPSYS_UNCONNECTED__12, SYNOPSYS_UNCONNECTED__13, 
        SYNOPSYS_UNCONNECTED__14, SYNOPSYS_UNCONNECTED__15, 
        SYNOPSYS_UNCONNECTED__16;
  assign XCLKIN0 = XCLKIN;
  assign nReset0 = nReset;
  assign SCANENABLE0 = SCANENABLE;
  assign GPIN0[7] = GPIN[7];
  assign GPIN0[6] = GPIN[6];
  assign GPIN0[5] = GPIN[5];
  assign GPIN0[4] = GPIN[4];
  assign GPIN0[3] = GPIN[3];
  assign GPIN0[2] = GPIN[2];
  assign GPIN0[1] = GPIN[1];
  assign GPIN0[0] = GPIN[0];
  assign nGPAFEN0[7] = nGPAFEN[7];
  assign nGPAFEN0[6] = nGPAFEN[6];
  assign nGPAFEN0[5] = nGPAFEN[5];
  assign nGPAFEN0[4] = nGPAFEN[4];
  assign nGPAFEN0[3] = nGPAFEN[3];
  assign nGPAFEN0[2] = nGPAFEN[2];
  assign nGPAFEN0[1] = nGPAFEN[1];
  assign nGPAFEN0[0] = nGPAFEN[0];
  assign GPAFOUT0[7] = GPAFOUT[7];
  assign GPAFOUT0[6] = GPAFOUT[6];
  assign GPAFOUT0[5] = GPAFOUT[5];
  assign GPAFOUT0[4] = GPAFOUT[4];
  assign GPAFOUT0[3] = GPAFOUT[3];
  assign GPAFOUT0[2] = GPAFOUT[2];
  assign GPAFOUT0[1] = GPAFOUT[1];
  assign GPAFOUT0[0] = GPAFOUT[0];
  assign nGPEN[7] = nGPEN0[7];
  assign nGPEN[6] = nGPEN0[6];
  assign nGPEN[5] = nGPEN0[5];
  assign nGPEN[4] = nGPEN0[4];
  assign nGPEN[3] = nGPEN0[3];
  assign nGPEN[2] = nGPEN0[2];
  assign nGPEN[1] = nGPEN0[1];
  assign nGPEN[0] = nGPEN0[0];
  assign GPOUT[7] = GPOUT0[7];
  assign GPOUT[6] = GPOUT0[6];
  assign GPOUT[5] = GPOUT0[5];
  assign GPOUT[4] = GPOUT0[4];
  assign GPOUT[3] = GPOUT0[3];
  assign GPOUT[2] = GPOUT0[2];
  assign GPOUT[1] = GPOUT0[1];
  assign GPOUT[0] = GPOUT0[0];
  assign GPAFIN[7] = GPAFIN0[7];
  assign GPAFIN[6] = GPAFIN0[6];
  assign GPAFIN[5] = GPAFIN0[5];
  assign GPAFIN[4] = GPAFIN0[4];
  assign GPAFIN[3] = GPAFIN0[3];
  assign GPAFIN[2] = GPAFIN0[2];
  assign GPAFIN[1] = GPAFIN0[1];
  assign GPAFIN[0] = GPAFIN0[0];

  ResetCntl uResetCntl ( .HCLK(XCLKIN0), .nPOReset(nReset0), .WDOGRES(WDOGRES), 
        .HRESETn(HRESETn), .WDOGRESn(WDOGRESn) );
  APBif uAPBif ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HADDR({HADDR[27], 
        HADDR[26], HADDR[25], HADDR[24], HADDR[23], HADDR[22], HADDR[21], 
        HADDR[20], HADDR[19], HADDR[18], HADDR[17], HADDR[16], HADDR[15], 
        HADDR[14], HADDR[13], HADDR[12], HADDR[11], HADDR[10], HADDR[9], 
        HADDR[8], HADDR[7], HADDR[6], HADDR[5], HADDR[4], HADDR[3], HADDR[2], 
        HADDR[1], HADDR[0]}), .HTRANS({HTRANS[1], HTRANS[0]}), .HWRITE(HWRITE), 
        .HWDATA({HWDATA[31], HWDATA[30], HWDATA[29], HWDATA[28], HWDATA[27], 
        HWDATA[26], HWDATA[25], HWDATA[24], HWDATA[23], HWDATA[22], HWDATA[21], 
        HWDATA[20], HWDATA[19], HWDATA[18], HWDATA[17], HWDATA[16], HWDATA[15], 
        HWDATA[14], HWDATA[13], HWDATA[12], HWDATA[11], HWDATA[10], HWDATA[9], 
        HWDATA[8], HWDATA[7], HWDATA[6], HWDATA[5], HWDATA[4], HWDATA[3], 
        HWDATA[2], HWDATA[1], HWDATA[0]}), .HSEL(HSELS12), .HREADY(HREADY), 
        .HRDATA({HRDATAS1[31], HRDATAS1[30], HRDATAS1[29], HRDATAS1[28], 
        HRDATAS1[27], HRDATAS1[26], HRDATAS1[25], HRDATAS1[24], HRDATAS1[23], 
        HRDATAS1[22], HRDATAS1[21], HRDATAS1[20], HRDATAS1[19], HRDATAS1[18], 
        HRDATAS1[17], HRDATAS1[16], HRDATAS1[15], HRDATAS1[14], HRDATAS1[13], 
        HRDATAS1[12], HRDATAS1[11], HRDATAS1[10], HRDATAS1[9], HRDATAS1[8], 
        HRDATAS1[7], HRDATAS1[6], HRDATAS1[5], HRDATAS1[4], HRDATAS1[3], 
        HRDATAS1[2], HRDATAS1[1], HRDATAS1[0]}), .HREADYOUT(HREADYS1), .HRESP(
        {HRESPS1[1], HRESPS1[0]}), .PRDATA({PRDATA[31], PRDATA[30], PRDATA[29], 
        PRDATA[28], PRDATA[27], PRDATA[26], PRDATA[25], PRDATA[24], PRDATA[23], 
        PRDATA[22], PRDATA[21], PRDATA[20], PRDATA[19], PRDATA[18], PRDATA[17], 
        PRDATA[16], PRDATA[15], PRDATA[14], PRDATA[13], PRDATA[12], PRDATA[11], 
        PRDATA[10], PRDATA[9], PRDATA[8], PRDATA[7], PRDATA[6], PRDATA[5], 
        PRDATA[4], PRDATA[3], PRDATA[2], PRDATA[1], PRDATA[0]}), .PWDATA({
        PWDATA[31], PWDATA[30], PWDATA[29], PWDATA[28], PWDATA[27], PWDATA[26], 
        PWDATA[25], PWDATA[24], PWDATA[23], PWDATA[22], PWDATA[21], PWDATA[20], 
        PWDATA[19], PWDATA[18], PWDATA[17], PWDATA[16], PWDATA[15], PWDATA[14], 
        PWDATA[13], PWDATA[12], PWDATA[11], PWDATA[10], PWDATA[9], PWDATA[8], 
        PWDATA[7], PWDATA[6], PWDATA[5], PWDATA[4], PWDATA[3], PWDATA[2], 
        PWDATA[1], PWDATA[0]}), .PENABLE(PENABLE), .PSELS0(PSELS0), .PSELS1(
        PSELS1), .PSELS2(PSELS2), .PSELS3(PSELS3), .PSELS4(PSELS4), .PSELS5(
        PSELS5), .PSELS6(PSELS6), .PSELS7(PSELS7), .PSELS8(PSELS8), .PSELS9(
        PSELS9), .PSELS10(PSELS10), .PSELS11(PSELS11), .PSELS12(PSELS12), 
        .PSELS13(PSELS13), .PSELS14(PSELS14), .PSELS15(PSELS15), .PADDR({
        SYNOPSYS_UNCONNECTED__0, SYNOPSYS_UNCONNECTED__1, 
        SYNOPSYS_UNCONNECTED__2, SYNOPSYS_UNCONNECTED__3, 
        SYNOPSYS_UNCONNECTED__4, SYNOPSYS_UNCONNECTED__5, 
        SYNOPSYS_UNCONNECTED__6, SYNOPSYS_UNCONNECTED__7, 
        SYNOPSYS_UNCONNECTED__8, SYNOPSYS_UNCONNECTED__9, 
        SYNOPSYS_UNCONNECTED__10, SYNOPSYS_UNCONNECTED__11, PADDR_11, PADDR_10, 
        PADDR_9, PADDR_8, PADDR_7, PADDR_6, PADDR_5, PADDR_4, PADDR_3, PADDR_2, 
        SYNOPSYS_UNCONNECTED__12, SYNOPSYS_UNCONNECTED__13}), .PWRITE(PWRITE), 
        .SCANENABLE(SCANENABLE0), .SCANINHCLK(1'b0), .SCANOUTHCLK() );
  RetrySlave uRetrySlave ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HADDR({
        HADDR[31], HADDR[30], HADDR[29], HADDR[28], HADDR[27], HADDR[26], 
        HADDR[25], HADDR[24], HADDR[23], HADDR[22], HADDR[21], HADDR[20], 
        HADDR[19], HADDR[18], HADDR[17], HADDR[16], HADDR[15], HADDR[14], 
        HADDR[13], HADDR[12], HADDR[11], HADDR[10], HADDR[9], HADDR[8], 
        HADDR[7], HADDR[6], HADDR[5], HADDR[4], HADDR[3], HADDR[2], HADDR[1], 
        HADDR[0]}), .HTRANS({HTRANS[1], HTRANS[0]}), .HWRITE(HWRITE), .HSIZE({
        HSIZE[2], HSIZE[1], HSIZE[0]}), .HWDATA({HWDATA[31], HWDATA[30], 
        HWDATA[29], HWDATA[28], HWDATA[27], HWDATA[26], HWDATA[25], HWDATA[24], 
        HWDATA[23], HWDATA[22], HWDATA[21], HWDATA[20], HWDATA[19], HWDATA[18], 
        HWDATA[17], HWDATA[16], HWDATA[15], HWDATA[14], HWDATA[13], HWDATA[12], 
        HWDATA[11], HWDATA[10], HWDATA[9], HWDATA[8], HWDATA[7], HWDATA[6], 
        HWDATA[5], HWDATA[4], HWDATA[3], HWDATA[2], HWDATA[1], HWDATA[0]}), 
        .HSELRetry(HSELS13), .HREADY(HREADY), .HRDATA({HRDATAS2[31], 
        HRDATAS2[30], HRDATAS2[29], HRDATAS2[28], HRDATAS2[27], HRDATAS2[26], 
        HRDATAS2[25], HRDATAS2[24], HRDATAS2[23], HRDATAS2[22], HRDATAS2[21], 
        HRDATAS2[20], HRDATAS2[19], HRDATAS2[18], HRDATAS2[17], HRDATAS2[16], 
        HRDATAS2[15], HRDATAS2[14], HRDATAS2[13], HRDATAS2[12], HRDATAS2[11], 
        HRDATAS2[10], HRDATAS2[9], HRDATAS2[8], HRDATAS2[7], HRDATAS2[6], 
        HRDATAS2[5], HRDATAS2[4], HRDATAS2[3], HRDATAS2[2], HRDATAS2[1], 
        HRDATAS2[0]}), .HREADYOUT(HREADYS2), .HRESP({HRESPS2[1], HRESPS2[0]}), 
        .SCANENABLE(SCANENABLE0), .SCANINHCLK(1'b0), .SCANOUTHCLK() );
  Interrupt uInterrupt ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HSELIC(HSELS15), 
        .HWRITE(HWRITE), .HREADY(HREADY), .HPROT(HPROT_1), .HTRANS(HTRANS[1]), 
        .HSIZE({HSIZE[2], HSIZE[1], HSIZE[0]}), .ICINTSOURCE({GPIOMIS[7], 
        GPIOMIS[6], GPIOMIS[5], GPIOMIS[4], GPIOMIS[3], GPIOMIS[2], GPIOMIS[1], 
        GPIOMIS[0], 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, GPIOINTR, WDOGINT, TIMINTC, TIMINT2, 
        TIMINT1, 1'b0, 1'b0, 1'b0, 1'b0}), .nICFIQIN(1'b1), .nICIRQIN(1'b1), 
        .ICVECTADDRIN({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .SCANENABLE(SCANENABLE0), .SCANINHCLK(1'b0), .HWDATA({HWDATA[31], 
        HWDATA[30], HWDATA[29], HWDATA[28], HWDATA[27], HWDATA[26], HWDATA[25], 
        HWDATA[24], HWDATA[23], HWDATA[22], HWDATA[21], HWDATA[20], HWDATA[19], 
        HWDATA[18], HWDATA[17], HWDATA[16], HWDATA[15], HWDATA[14], HWDATA[13], 
        HWDATA[12], HWDATA[11], HWDATA[10], HWDATA[9], HWDATA[8], HWDATA[7], 
        HWDATA[6], HWDATA[5], HWDATA[4], HWDATA[3], HWDATA[2], HWDATA[1], 
        HWDATA[0]}), .HADDR({HADDR[11], HADDR[10], HADDR[9], HADDR[8], 
        HADDR[7], HADDR[6], HADDR[5], HADDR[4], HADDR[3], HADDR[2]}), 
        .HREADYOUT(HREADYS3), .HRESP({HRESPS3[1], HRESPS3[0]}), .nICFIQ(nFIQ), 
        .nICIRQ(nIRQ), .ICVECTADDROUT(), .SCANOUTHCLK(), .HRDATA({HRDATAS3[31], 
        HRDATAS3[30], HRDATAS3[29], HRDATAS3[28], HRDATAS3[27], HRDATAS3[26], 
        HRDATAS3[25], HRDATAS3[24], HRDATAS3[23], HRDATAS3[22], HRDATAS3[21], 
        HRDATAS3[20], HRDATAS3[19], HRDATAS3[18], HRDATAS3[17], HRDATAS3[16], 
        HRDATAS3[15], HRDATAS3[14], HRDATAS3[13], HRDATAS3[12], HRDATAS3[11], 
        HRDATAS3[10], HRDATAS3[9], HRDATAS3[8], HRDATAS3[7], HRDATAS3[6], 
        HRDATAS3[5], HRDATAS3[4], HRDATAS3[3], HRDATAS3[2], HRDATAS3[1], 
        HRDATAS3[0]}) );
  Arbiter3 uArbiter3 ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HTRANS({HTRANS[1], 
        HTRANS[0]}), .HBURST({HBURST[2], HBURST[1], HBURST[0]}), .HREADY(
        HREADY), .HRESP({HRESP[1], HRESP[0]}), .HBUSREQM3(1'b0), .HBUSREQM2(
        HBUSREQM2), .HBUSREQM1(HBUSREQM1), .HBUSREQM0(Pause), .HLOCKM3(1'b0), 
        .HLOCKM2(HLOCKM2), .HLOCKM1(HLOCKM1), .HLOCKM0(1'b0), .HSPLIT({1'b0, 
        1'b0, 1'b0, 1'b0}), .HGRANTM3(), .HGRANTM2(HGRANTM2), .HGRANTM1(
        HGRANTM1), .HGRANTM0(), .HMASTER({HMASTER[3], HMASTER[2], HMASTER[1], 
        HMASTER[0]}), .HMASTERD({HMASTERD[3], HMASTERD[2], HMASTERD[1], 
        HMASTERD[0]}), .HMASTLOCK(), .SCANENABLE(SCANENABLE0), .SCANINHCLK(
        1'b0), .SCANOUTHCLK() );
  Decoder uDecoder ( .HADDR({HADDR[31], HADDR[30], HADDR[29], HADDR[28], 
        HADDR[27], HADDR[26], HADDR[25], HADDR[24], HADDR[23], HADDR[22], 
        HADDR[21], HADDR[20]}), .Remap(Remap), .HSELS0B(HSELS0B), .HSELS0R(
        HSELS0R), .HSELS0(HSELS0), .HSELS1(HSELS1), .HSELS2(HSELS2), .HSELS3(
        HSELS3), .HSELS4(HSELS4), .HSELS5(HSELS5), .HSELS6(HSELS6), .HSELS7(
        HSELS7), .HSELS8(HSELS8), .HSELS9(HSELS9), .HSELS10(HSELS10), 
        .HSELS11(HSELS11), .HSELS12(HSELS12), .HSELS13(HSELS13), .HSELS14(
        HSELS14), .HSELS15(HSELS15) );
  GTECH_OR2 S_0 ( .A(HSELS0B), .B(HSELS0), .Z(n_1) );
  GTECH_OR2 S_1 ( .A(n_1), .B(HSELS1), .Z(n_2) );
  GTECH_OR2 S_2 ( .A(n_2), .B(HSELS2), .Z(n_3) );
  GTECH_OR2 S_3 ( .A(n_3), .B(HSELS3), .Z(n_4) );
  GTECH_OR2 S_4 ( .A(n_4), .B(HSELS4), .Z(n_5) );
  GTECH_OR2 S_5 ( .A(n_5), .B(HSELS5), .Z(n_6) );
  GTECH_OR2 S_6 ( .A(n_6), .B(HSELS6), .Z(n_7) );
  GTECH_OR2 S_7 ( .A(n_7), .B(HSELS8), .Z(n_8) );
  GTECH_OR2 S_8 ( .A(n_8), .B(HSELS9), .Z(n_9) );
  GTECH_OR2 S_9 ( .A(n_9), .B(HSELS10), .Z(n_10) );
  GTECH_OR2 S_10 ( .A(n_10), .B(HSELS11), .Z(n_11) );
  GTECH_OR2 S_11 ( .A(n_11), .B(HSELS14), .Z(HSELDefault) );
  GTECH_OR2 S_12 ( .A(HSELS0R), .B(HSELS7), .Z(HSELIntMem) );
  DefaultSlave uDefaultSlave ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HTRANS({
        HTRANS[1], HTRANS[0]}), .HSEL(HSELDefault), .HREADY(HREADY), 
        .HREADYOUT(HREADYDefault), .HRESP({HRESPDefault[1], HRESPDefault[0]}), 
        .SCANENABLE(SCANENABLE0), .SCANINHCLK(1'b0), .SCANOUTHCLK() );
  MuxM2S uMuxM2S ( .HMASTER({HMASTER[3], HMASTER[2], HMASTER[1], HMASTER[0]}), 
        .HMASTERD({HMASTERD[3], HMASTERD[2], HMASTERD[1], HMASTERD[0]}), 
        .HADDRM1({HADDRM1[31], HADDRM1[30], HADDRM1[29], HADDRM1[28], 
        HADDRM1[27], HADDRM1[26], HADDRM1[25], HADDRM1[24], HADDRM1[23], 
        HADDRM1[22], HADDRM1[21], HADDRM1[20], HADDRM1[19], HADDRM1[18], 
        HADDRM1[17], HADDRM1[16], HADDRM1[15], HADDRM1[14], HADDRM1[13], 
        HADDRM1[12], HADDRM1[11], HADDRM1[10], HADDRM1[9], HADDRM1[8], 
        HADDRM1[7], HADDRM1[6], HADDRM1[5], HADDRM1[4], HADDRM1[3], HADDRM1[2], 
        HADDRM1[1], HADDRM1[0]}), .HTRANSM1({HTRANSM1[1], HTRANSM1[0]}), 
        .HWRITEM1(HWRITEM1), .HSIZEM1({HSIZEM1[2], HSIZEM1[1], HSIZEM1[0]}), 
        .HBURSTM1({HBURSTM1[2], HBURSTM1[1], HBURSTM1[0]}), .HPROTM1({
        HPROTM1[3], HPROTM1[2], HPROTM1[1], HPROTM1[0]}), .HWDATAM1({
        HWDATAM1[31], HWDATAM1[30], HWDATAM1[29], HWDATAM1[28], HWDATAM1[27], 
        HWDATAM1[26], HWDATAM1[25], HWDATAM1[24], HWDATAM1[23], HWDATAM1[22], 
        HWDATAM1[21], HWDATAM1[20], HWDATAM1[19], HWDATAM1[18], HWDATAM1[17], 
        HWDATAM1[16], HWDATAM1[15], HWDATAM1[14], HWDATAM1[13], HWDATAM1[12], 
        HWDATAM1[11], HWDATAM1[10], HWDATAM1[9], HWDATAM1[8], HWDATAM1[7], 
        HWDATAM1[6], HWDATAM1[5], HWDATAM1[4], HWDATAM1[3], HWDATAM1[2], 
        HWDATAM1[1], HWDATAM1[0]}), .HADDRM2({HADDRM2[31], HADDRM2[30], 
        HADDRM2[29], HADDRM2[28], HADDRM2[27], HADDRM2[26], HADDRM2[25], 
        HADDRM2[24], HADDRM2[23], HADDRM2[22], HADDRM2[21], HADDRM2[20], 
        HADDRM2[19], HADDRM2[18], HADDRM2[17], HADDRM2[16], HADDRM2[15], 
        HADDRM2[14], HADDRM2[13], HADDRM2[12], HADDRM2[11], HADDRM2[10], 
        HADDRM2[9], HADDRM2[8], HADDRM2[7], HADDRM2[6], HADDRM2[5], HADDRM2[4], 
        HADDRM2[3], HADDRM2[2], HADDRM2[1], HADDRM2[0]}), .HTRANSM2({
        HTRANSM2[1], HTRANSM2[0]}), .HWRITEM2(HWRITEM2), .HSIZEM2({HSIZEM2[2], 
        HSIZEM2[1], HSIZEM2[0]}), .HBURSTM2({HBURSTM2[2], HBURSTM2[1], 
        HBURSTM2[0]}), .HPROTM2({HPROTM2[3], HPROTM2[2], HPROTM2[1], 
        HPROTM2[0]}), .HWDATAM2({HWDATAM2[31], HWDATAM2[30], HWDATAM2[29], 
        HWDATAM2[28], HWDATAM2[27], HWDATAM2[26], HWDATAM2[25], HWDATAM2[24], 
        HWDATAM2[23], HWDATAM2[22], HWDATAM2[21], HWDATAM2[20], HWDATAM2[19], 
        HWDATAM2[18], HWDATAM2[17], HWDATAM2[16], HWDATAM2[15], HWDATAM2[14], 
        HWDATAM2[13], HWDATAM2[12], HWDATAM2[11], HWDATAM2[10], HWDATAM2[9], 
        HWDATAM2[8], HWDATAM2[7], HWDATAM2[6], HWDATAM2[5], HWDATAM2[4], 
        HWDATAM2[3], HWDATAM2[2], HWDATAM2[1], HWDATAM2[0]}), .HADDRM3({1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .HTRANSM3({1'b0, 1'b0}), 
        .HWRITEM3(1'b0), .HSIZEM3({1'b0, 1'b0, 1'b0}), .HBURSTM3({1'b0, 1'b0, 
        1'b0}), .HPROTM3({1'b0, 1'b0, 1'b0, 1'b0}), .HWDATAM3({1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .HADDR({HADDR[31], HADDR[30], 
        HADDR[29], HADDR[28], HADDR[27], HADDR[26], HADDR[25], HADDR[24], 
        HADDR[23], HADDR[22], HADDR[21], HADDR[20], HADDR[19], HADDR[18], 
        HADDR[17], HADDR[16], HADDR[15], HADDR[14], HADDR[13], HADDR[12], 
        HADDR[11], HADDR[10], HADDR[9], HADDR[8], HADDR[7], HADDR[6], HADDR[5], 
        HADDR[4], HADDR[3], HADDR[2], HADDR[1], HADDR[0]}), .HTRANS({HTRANS[1], 
        HTRANS[0]}), .HWRITE(HWRITE), .HSIZE({HSIZE[2], HSIZE[1], HSIZE[0]}), 
        .HBURST({HBURST[2], HBURST[1], HBURST[0]}), .HPROT({
        SYNOPSYS_UNCONNECTED__14, SYNOPSYS_UNCONNECTED__15, HPROT_1, 
        SYNOPSYS_UNCONNECTED__16}), .HWDATA({HWDATA[31], HWDATA[30], 
        HWDATA[29], HWDATA[28], HWDATA[27], HWDATA[26], HWDATA[25], HWDATA[24], 
        HWDATA[23], HWDATA[22], HWDATA[21], HWDATA[20], HWDATA[19], HWDATA[18], 
        HWDATA[17], HWDATA[16], HWDATA[15], HWDATA[14], HWDATA[13], HWDATA[12], 
        HWDATA[11], HWDATA[10], HWDATA[9], HWDATA[8], HWDATA[7], HWDATA[6], 
        HWDATA[5], HWDATA[4], HWDATA[3], HWDATA[2], HWDATA[1], HWDATA[0]}) );
  MuxS2M uMuxS2M ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HSELS0(HSELIntMem), 
        .HSELS1(HSELS12), .HSELS2(HSELS13), .HSELS3(HSELS15), .HSELS4(1'b0), 
        .HSELS5(1'b0), .HSELS6(1'b0), .HSELS7(1'b0), .HSELDefault(HSELDefault), 
        .HRDATAS0({HRDATAS0[31], HRDATAS0[30], HRDATAS0[29], HRDATAS0[28], 
        HRDATAS0[27], HRDATAS0[26], HRDATAS0[25], HRDATAS0[24], HRDATAS0[23], 
        HRDATAS0[22], HRDATAS0[21], HRDATAS0[20], HRDATAS0[19], HRDATAS0[18], 
        HRDATAS0[17], HRDATAS0[16], HRDATAS0[15], HRDATAS0[14], HRDATAS0[13], 
        HRDATAS0[12], HRDATAS0[11], HRDATAS0[10], HRDATAS0[9], HRDATAS0[8], 
        HRDATAS0[7], HRDATAS0[6], HRDATAS0[5], HRDATAS0[4], HRDATAS0[3], 
        HRDATAS0[2], HRDATAS0[1], HRDATAS0[0]}), .HREADYS0(HREADYS0), 
        .HRESPS0({HRESPS0[1], HRESPS0[0]}), .HRDATAS1({HRDATAS1[31], 
        HRDATAS1[30], HRDATAS1[29], HRDATAS1[28], HRDATAS1[27], HRDATAS1[26], 
        HRDATAS1[25], HRDATAS1[24], HRDATAS1[23], HRDATAS1[22], HRDATAS1[21], 
        HRDATAS1[20], HRDATAS1[19], HRDATAS1[18], HRDATAS1[17], HRDATAS1[16], 
        HRDATAS1[15], HRDATAS1[14], HRDATAS1[13], HRDATAS1[12], HRDATAS1[11], 
        HRDATAS1[10], HRDATAS1[9], HRDATAS1[8], HRDATAS1[7], HRDATAS1[6], 
        HRDATAS1[5], HRDATAS1[4], HRDATAS1[3], HRDATAS1[2], HRDATAS1[1], 
        HRDATAS1[0]}), .HREADYS1(HREADYS1), .HRESPS1({HRESPS1[1], HRESPS1[0]}), 
        .HRDATAS2({HRDATAS2[31], HRDATAS2[30], HRDATAS2[29], HRDATAS2[28], 
        HRDATAS2[27], HRDATAS2[26], HRDATAS2[25], HRDATAS2[24], HRDATAS2[23], 
        HRDATAS2[22], HRDATAS2[21], HRDATAS2[20], HRDATAS2[19], HRDATAS2[18], 
        HRDATAS2[17], HRDATAS2[16], HRDATAS2[15], HRDATAS2[14], HRDATAS2[13], 
        HRDATAS2[12], HRDATAS2[11], HRDATAS2[10], HRDATAS2[9], HRDATAS2[8], 
        HRDATAS2[7], HRDATAS2[6], HRDATAS2[5], HRDATAS2[4], HRDATAS2[3], 
        HRDATAS2[2], HRDATAS2[1], HRDATAS2[0]}), .HREADYS2(HREADYS2), 
        .HRESPS2({HRESPS2[1], HRESPS2[0]}), .HRDATAS3({HRDATAS3[31], 
        HRDATAS3[30], HRDATAS3[29], HRDATAS3[28], HRDATAS3[27], HRDATAS3[26], 
        HRDATAS3[25], HRDATAS3[24], HRDATAS3[23], HRDATAS3[22], HRDATAS3[21], 
        HRDATAS3[20], HRDATAS3[19], HRDATAS3[18], HRDATAS3[17], HRDATAS3[16], 
        HRDATAS3[15], HRDATAS3[14], HRDATAS3[13], HRDATAS3[12], HRDATAS3[11], 
        HRDATAS3[10], HRDATAS3[9], HRDATAS3[8], HRDATAS3[7], HRDATAS3[6], 
        HRDATAS3[5], HRDATAS3[4], HRDATAS3[3], HRDATAS3[2], HRDATAS3[1], 
        HRDATAS3[0]}), .HREADYS3(HREADYS3), .HRESPS3({HRESPS3[1], HRESPS3[0]}), 
        .HRDATAS4({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .HREADYS4(1'b1), .HRESPS4({1'b0, 1'b0}), .HRDATAS5({1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .HREADYS5(1'b1), .HRESPS5({1'b0, 1'b0}), .HRDATAS6({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .HREADYS6(1'b1), .HRESPS6({1'b0, 1'b0}), .HRDATAS7({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0}), .HREADYS7(1'b1), .HRESPS7({1'b0, 1'b0}), .HREADYDefault(
        HREADYDefault), .HRESPDefault({HRESPDefault[1], HRESPDefault[0]}), 
        .HRDATA({HRDATA[31], HRDATA[30], HRDATA[29], HRDATA[28], HRDATA[27], 
        HRDATA[26], HRDATA[25], HRDATA[24], HRDATA[23], HRDATA[22], HRDATA[21], 
        HRDATA[20], HRDATA[19], HRDATA[18], HRDATA[17], HRDATA[16], HRDATA[15], 
        HRDATA[14], HRDATA[13], HRDATA[12], HRDATA[11], HRDATA[10], HRDATA[9], 
        HRDATA[8], HRDATA[7], HRDATA[6], HRDATA[5], HRDATA[4], HRDATA[3], 
        HRDATA[2], HRDATA[1], HRDATA[0]}), .HREADY(HREADY), .HRESP({HRESP[1], 
        HRESP[0]}), .SCANENABLE(SCANENABLE0), .SCANINHCLK(1'b0), 
        .SCANOUTHCLK() );
  MuxP2B uMuxP2B ( .PSELS0(PSELS0), .PSELS1(PSELS1), .PSELS2(PSELS2), .PSELS3(
        PSELS3), .PSELS4(PSELS4), .PSELS5(PSELS5), .PSELS6(PSELS6), .PSELS7(
        PSELS7), .PSELS8(PSELS8), .PSELS9(PSELS9), .PSELS10(PSELS10), 
        .PSELS11(PSELS11), .PSELS12(PSELS12), .PSELS13(PSELS13), .PSELS14(
        PSELS14), .PSELS15(PSELS15), .PRDATAS0({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0}), .PRDATAS1({PRDATAS1[31], PRDATAS1[30], 
        PRDATAS1[29], PRDATAS1[28], PRDATAS1[27], PRDATAS1[26], PRDATAS1[25], 
        PRDATAS1[24], PRDATAS1[23], PRDATAS1[22], PRDATAS1[21], PRDATAS1[20], 
        PRDATAS1[19], PRDATAS1[18], PRDATAS1[17], PRDATAS1[16], PRDATAS1[15], 
        PRDATAS1[14], PRDATAS1[13], PRDATAS1[12], PRDATAS1[11], PRDATAS1[10], 
        PRDATAS1[9], PRDATAS1[8], PRDATAS1[7], PRDATAS1[6], PRDATAS1[5], 
        PRDATAS1[4], PRDATAS1[3], PRDATAS1[2], PRDATAS1[1], PRDATAS1[0]}), 
        .PRDATAS2({PRDATAS2[31], PRDATAS2[30], PRDATAS2[29], PRDATAS2[28], 
        PRDATAS2[27], PRDATAS2[26], PRDATAS2[25], PRDATAS2[24], PRDATAS2[23], 
        PRDATAS2[22], PRDATAS2[21], PRDATAS2[20], PRDATAS2[19], PRDATAS2[18], 
        PRDATAS2[17], PRDATAS2[16], PRDATAS2[15], PRDATAS2[14], PRDATAS2[13], 
        PRDATAS2[12], PRDATAS2[11], PRDATAS2[10], PRDATAS2[9], PRDATAS2[8], 
        PRDATAS2[7], PRDATAS2[6], PRDATAS2[5], PRDATAS2[4], PRDATAS2[3], 
        PRDATAS2[2], PRDATAS2[1], PRDATAS2[0]}), .PRDATAS3({1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .PRDATAS4({1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, PRDATAS4_7, PRDATAS4_6, 
        PRDATAS4_5, PRDATAS4_4, PRDATAS4_3, PRDATAS4_2, PRDATAS4_1, PRDATAS4_0}), .PRDATAS5({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .PRDATAS6({
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .PRDATAS7({1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .PRDATAS8({1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, PRDATAS8_7, 
        PRDATAS8_6, PRDATAS8_5, PRDATAS8_4, PRDATAS8_3, PRDATAS8_2, PRDATAS8_1, 
        PRDATAS8_0}), .PRDATAS9({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0}), .PRDATAS10({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), .PRDATAS11({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .PRDATAS12({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .PRDATAS13({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .PRDATAS14({1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 
        1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0, 1'b0}), 
        .PRDATAS15({PRDATAS15[31], PRDATAS15[30], PRDATAS15[29], PRDATAS15[28], 
        PRDATAS15[27], PRDATAS15[26], PRDATAS15[25], PRDATAS15[24], 
        PRDATAS15[23], PRDATAS15[22], PRDATAS15[21], PRDATAS15[20], 
        PRDATAS15[19], PRDATAS15[18], PRDATAS15[17], PRDATAS15[16], 
        PRDATAS15[15], PRDATAS15[14], PRDATAS15[13], PRDATAS15[12], 
        PRDATAS15[11], PRDATAS15[10], PRDATAS15[9], PRDATAS15[8], PRDATAS15[7], 
        PRDATAS15[6], PRDATAS15[5], PRDATAS15[4], PRDATAS15[3], PRDATAS15[2], 
        PRDATAS15[1], PRDATAS15[0]}), .PRDATA({PRDATA[31], PRDATA[30], 
        PRDATA[29], PRDATA[28], PRDATA[27], PRDATA[26], PRDATA[25], PRDATA[24], 
        PRDATA[23], PRDATA[22], PRDATA[21], PRDATA[20], PRDATA[19], PRDATA[18], 
        PRDATA[17], PRDATA[16], PRDATA[15], PRDATA[14], PRDATA[13], PRDATA[12], 
        PRDATA[11], PRDATA[10], PRDATA[9], PRDATA[8], PRDATA[7], PRDATA[6], 
        PRDATA[5], PRDATA[4], PRDATA[3], PRDATA[2], PRDATA[1], PRDATA[0]}) );
  Watchdog uWatchdog ( .PCLK(XCLKIN0), .PRESETn(HRESETn), .PENABLE(PENABLE), 
        .PSEL(PSELS1), .PADDR({PADDR_11, PADDR_10, PADDR_9, PADDR_8, PADDR_7, 
        PADDR_6, PADDR_5, PADDR_4, PADDR_3, PADDR_2}), .PWRITE(PWRITE), 
        .PWDATA({PWDATA[31], PWDATA[30], PWDATA[29], PWDATA[28], PWDATA[27], 
        PWDATA[26], PWDATA[25], PWDATA[24], PWDATA[23], PWDATA[22], PWDATA[21], 
        PWDATA[20], PWDATA[19], PWDATA[18], PWDATA[17], PWDATA[16], PWDATA[15], 
        PWDATA[14], PWDATA[13], PWDATA[12], PWDATA[11], PWDATA[10], PWDATA[9], 
        PWDATA[8], PWDATA[7], PWDATA[6], PWDATA[5], PWDATA[4], PWDATA[3], 
        PWDATA[2], PWDATA[1], PWDATA[0]}), .PRDATA({PRDATAS1[31], PRDATAS1[30], 
        PRDATAS1[29], PRDATAS1[28], PRDATAS1[27], PRDATAS1[26], PRDATAS1[25], 
        PRDATAS1[24], PRDATAS1[23], PRDATAS1[22], PRDATAS1[21], PRDATAS1[20], 
        PRDATAS1[19], PRDATAS1[18], PRDATAS1[17], PRDATAS1[16], PRDATAS1[15], 
        PRDATAS1[14], PRDATAS1[13], PRDATAS1[12], PRDATAS1[11], PRDATAS1[10], 
        PRDATAS1[9], PRDATAS1[8], PRDATAS1[7], PRDATAS1[6], PRDATAS1[5], 
        PRDATAS1[4], PRDATAS1[3], PRDATAS1[2], PRDATAS1[1], PRDATAS1[0]}), 
        .WDOGCLK(XCLKIN0), .WDOGCLKEN(1'b1), .WDOGRESn(WDOGRESn), .WDOGINT(
        WDOGINT), .WDOGRES(WDOGRES), .SCANENABLE(SCANENABLE0), .SCANINPCLK(
        1'b0), .SCANOUTPCLK() );
  Timers uTimers ( .PCLK(XCLKIN0), .PRESETn(HRESETn), .PENABLE(PENABLE), 
        .PSEL(PSELS2), .PADDR({PADDR_11, PADDR_10, PADDR_9, PADDR_8, PADDR_7, 
        PADDR_6, PADDR_5, PADDR_4, PADDR_3, PADDR_2}), .PWRITE(PWRITE), 
        .PWDATA({PWDATA[31], PWDATA[30], PWDATA[29], PWDATA[28], PWDATA[27], 
        PWDATA[26], PWDATA[25], PWDATA[24], PWDATA[23], PWDATA[22], PWDATA[21], 
        PWDATA[20], PWDATA[19], PWDATA[18], PWDATA[17], PWDATA[16], PWDATA[15], 
        PWDATA[14], PWDATA[13], PWDATA[12], PWDATA[11], PWDATA[10], PWDATA[9], 
        PWDATA[8], PWDATA[7], PWDATA[6], PWDATA[5], PWDATA[4], PWDATA[3], 
        PWDATA[2], PWDATA[1], PWDATA[0]}), .PRDATA({PRDATAS2[31], PRDATAS2[30], 
        PRDATAS2[29], PRDATAS2[28], PRDATAS2[27], PRDATAS2[26], PRDATAS2[25], 
        PRDATAS2[24], PRDATAS2[23], PRDATAS2[22], PRDATAS2[21], PRDATAS2[20], 
        PRDATAS2[19], PRDATAS2[18], PRDATAS2[17], PRDATAS2[16], PRDATAS2[15], 
        PRDATAS2[14], PRDATAS2[13], PRDATAS2[12], PRDATAS2[11], PRDATAS2[10], 
        PRDATAS2[9], PRDATAS2[8], PRDATAS2[7], PRDATAS2[6], PRDATAS2[5], 
        PRDATAS2[4], PRDATAS2[3], PRDATAS2[2], PRDATAS2[1], PRDATAS2[0]}), 
        .TIMCLK(XCLKIN0), .TIMCLKEN1(1'b1), .TIMCLKEN2(1'b1), .TIMINT1(TIMINT1), .TIMINT2(TIMINT2), .TIMINTC(TIMINTC), .SCANENABLE(SCANENABLE0), .SCANINPCLK(
        1'b0), .SCANOUTPCLK() );
  Gpio uGpio ( .PCLK(XCLKIN0), .PRESETn(HRESETn), .PSEL(PSELS4), .PENABLE(
        PENABLE), .PWRITE(PWRITE), .PWDATA({PWDATA[7], PWDATA[6], PWDATA[5], 
        PWDATA[4], PWDATA[3], PWDATA[2], PWDATA[1], PWDATA[0]}), .PADDR({
        PADDR_11, PADDR_10, PADDR_9, PADDR_8, PADDR_7, PADDR_6, PADDR_5, 
        PADDR_4, PADDR_3, PADDR_2}), .GPIN({GPIN0[7], GPIN0[6], GPIN0[5], 
        GPIN0[4], GPIN0[3], GPIN0[2], GPIN0[1], GPIN0[0]}), .nGPAFEN({
        nGPAFEN0[7], nGPAFEN0[6], nGPAFEN0[5], nGPAFEN0[4], nGPAFEN0[3], 
        nGPAFEN0[2], nGPAFEN0[1], nGPAFEN0[0]}), .GPAFOUT({GPAFOUT0[7], 
        GPAFOUT0[6], GPAFOUT0[5], GPAFOUT0[4], GPAFOUT0[3], GPAFOUT0[2], 
        GPAFOUT0[1], GPAFOUT0[0]}), .PRDATA({PRDATAS4_7, PRDATAS4_6, 
        PRDATAS4_5, PRDATAS4_4, PRDATAS4_3, PRDATAS4_2, PRDATAS4_1, PRDATAS4_0}), .nGPEN({nGPEN0[7], nGPEN0[6], nGPEN0[5], nGPEN0[4], nGPEN0[3], nGPEN0[2], 
        nGPEN0[1], nGPEN0[0]}), .GPOUT({GPOUT0[7], GPOUT0[6], GPOUT0[5], 
        GPOUT0[4], GPOUT0[3], GPOUT0[2], GPOUT0[1], GPOUT0[0]}), .GPAFIN({
        GPAFIN0[7], GPAFIN0[6], GPAFIN0[5], GPAFIN0[4], GPAFIN0[3], GPAFIN0[2], 
        GPAFIN0[1], GPAFIN0[0]}), .GPIOINTR(GPIOINTR), .GPIOMIS({GPIOMIS[7], 
        GPIOMIS[6], GPIOMIS[5], GPIOMIS[4], GPIOMIS[3], GPIOMIS[2], GPIOMIS[1], 
        GPIOMIS[0]}), .SCANENABLE(SCANENABLE0), .SCANINPCLK(1'b0), 
        .SCANOUTPCLK() );
  RemapPause uRemapPause ( .PCLK(XCLKIN0), .PRESETn(HRESETn), .PENABLE(PENABLE), .PSELRPC(PSELS8), .PADDR({PADDR_5, PADDR_4, PADDR_3, PADDR_2}), .PWRITE(
        PWRITE), .PWDATA({PWDATA[7], PWDATA[6], PWDATA[5], PWDATA[4], 
        PWDATA[3], PWDATA[2], PWDATA[1], PWDATA[0]}), .PRDATA({PRDATAS8_7, 
        PRDATAS8_6, PRDATAS8_5, PRDATAS8_4, PRDATAS8_3, PRDATAS8_2, PRDATAS8_1, 
        PRDATAS8_0}), .nFIQ(nFIQ), .nIRQ(nIRQ), .Pause(Pause), .Remap(Remap), 
        .SCANENABLE(SCANENABLE0), .SCANINPCLK(1'b0), .SCANOUTPCLK() );
  EgAPBSlave uEgAPBSlave ( .PCLK(XCLKIN0), .PRESETn(HRESETn), .PENABLE(PENABLE), .PSEL(PSELS15), .PWRITE(PWRITE), .PADDR({PADDR_11, PADDR_10, PADDR_9, 
        PADDR_8, PADDR_7, PADDR_6, PADDR_5, PADDR_4, PADDR_3, PADDR_2}), 
        .PRDATA({PRDATAS15[31], PRDATAS15[30], PRDATAS15[29], PRDATAS15[28], 
        PRDATAS15[27], PRDATAS15[26], PRDATAS15[25], PRDATAS15[24], 
        PRDATAS15[23], PRDATAS15[22], PRDATAS15[21], PRDATAS15[20], 
        PRDATAS15[19], PRDATAS15[18], PRDATAS15[17], PRDATAS15[16], 
        PRDATAS15[15], PRDATAS15[14], PRDATAS15[13], PRDATAS15[12], 
        PRDATAS15[11], PRDATAS15[10], PRDATAS15[9], PRDATAS15[8], PRDATAS15[7], 
        PRDATAS15[6], PRDATAS15[5], PRDATAS15[4], PRDATAS15[3], PRDATAS15[2], 
        PRDATAS15[1], PRDATAS15[0]}), .PWDATA({PWDATA[31], PWDATA[30], 
        PWDATA[29], PWDATA[28], PWDATA[27], PWDATA[26], PWDATA[25], PWDATA[24], 
        PWDATA[23], PWDATA[22], PWDATA[21], PWDATA[20], PWDATA[19], PWDATA[18], 
        PWDATA[17], PWDATA[16], PWDATA[15], PWDATA[14], PWDATA[13], PWDATA[12], 
        PWDATA[11], PWDATA[10], PWDATA[9], PWDATA[8], PWDATA[7], PWDATA[6], 
        PWDATA[5], PWDATA[4], PWDATA[3], PWDATA[2], PWDATA[1], PWDATA[0]}), 
        .SCANENABLE(SCANENABLE0), .SCANINPCLK(1'b0), .SCANOUTPCLK() );
  FileReader uFileReader ( .HCLK(XCLKIN0), .HRESETn(WDOGRESn), .HGRANT(
        HGRANTM1), .HREADY(HREADY), .HRESP({HRESP[1], HRESP[0]}), .HRDATA({
        HRDATA[31], HRDATA[30], HRDATA[29], HRDATA[28], HRDATA[27], HRDATA[26], 
        HRDATA[25], HRDATA[24], HRDATA[23], HRDATA[22], HRDATA[21], HRDATA[20], 
        HRDATA[19], HRDATA[18], HRDATA[17], HRDATA[16], HRDATA[15], HRDATA[14], 
        HRDATA[13], HRDATA[12], HRDATA[11], HRDATA[10], HRDATA[9], HRDATA[8], 
        HRDATA[7], HRDATA[6], HRDATA[5], HRDATA[4], HRDATA[3], HRDATA[2], 
        HRDATA[1], HRDATA[0]}), .HBUSREQ(HBUSREQM1), .HTRANS({HTRANSM1[1], 
        HTRANSM1[0]}), .HBURST({HBURSTM1[2], HBURSTM1[1], HBURSTM1[0]}), 
        .HPROT({HPROTM1[3], HPROTM1[2], HPROTM1[1], HPROTM1[0]}), .HSIZE({
        HSIZEM1[2], HSIZEM1[1], HSIZEM1[0]}), .HWRITE(HWRITEM1), .HLOCK(
        HLOCKM1), .HADDR({HADDRM1[31], HADDRM1[30], HADDRM1[29], HADDRM1[28], 
        HADDRM1[27], HADDRM1[26], HADDRM1[25], HADDRM1[24], HADDRM1[23], 
        HADDRM1[22], HADDRM1[21], HADDRM1[20], HADDRM1[19], HADDRM1[18], 
        HADDRM1[17], HADDRM1[16], HADDRM1[15], HADDRM1[14], HADDRM1[13], 
        HADDRM1[12], HADDRM1[11], HADDRM1[10], HADDRM1[9], HADDRM1[8], 
        HADDRM1[7], HADDRM1[6], HADDRM1[5], HADDRM1[4], HADDRM1[3], HADDRM1[2], 
        HADDRM1[1], HADDRM1[0]}), .HWDATA({HWDATAM1[31], HWDATAM1[30], 
        HWDATAM1[29], HWDATAM1[28], HWDATAM1[27], HWDATAM1[26], HWDATAM1[25], 
        HWDATAM1[24], HWDATAM1[23], HWDATAM1[22], HWDATAM1[21], HWDATAM1[20], 
        HWDATAM1[19], HWDATAM1[18], HWDATAM1[17], HWDATAM1[16], HWDATAM1[15], 
        HWDATAM1[14], HWDATAM1[13], HWDATAM1[12], HWDATAM1[11], HWDATAM1[10], 
        HWDATAM1[9], HWDATAM1[8], HWDATAM1[7], HWDATAM1[6], HWDATAM1[5], 
        HWDATAM1[4], HWDATAM1[3], HWDATAM1[2], HWDATAM1[1], HWDATAM1[0]}) );
  EgMaster uEgMaster ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HRDATA({HRDATA[31], 
        HRDATA[30], HRDATA[29], HRDATA[28], HRDATA[27], HRDATA[26], HRDATA[25], 
        HRDATA[24], HRDATA[23], HRDATA[22], HRDATA[21], HRDATA[20], HRDATA[19], 
        HRDATA[18], HRDATA[17], HRDATA[16], HRDATA[15], HRDATA[14], HRDATA[13], 
        HRDATA[12], HRDATA[11], HRDATA[10], HRDATA[9], HRDATA[8], HRDATA[7], 
        HRDATA[6], HRDATA[5], HRDATA[4], HRDATA[3], HRDATA[2], HRDATA[1], 
        HRDATA[0]}), .HREADY(HREADY), .HRESP({HRESP[1], HRESP[0]}), .HGRANT(
        HGRANTM2), .HADDR({HADDRM2[31], HADDRM2[30], HADDRM2[29], HADDRM2[28], 
        HADDRM2[27], HADDRM2[26], HADDRM2[25], HADDRM2[24], HADDRM2[23], 
        HADDRM2[22], HADDRM2[21], HADDRM2[20], HADDRM2[19], HADDRM2[18], 
        HADDRM2[17], HADDRM2[16], HADDRM2[15], HADDRM2[14], HADDRM2[13], 
        HADDRM2[12], HADDRM2[11], HADDRM2[10], HADDRM2[9], HADDRM2[8], 
        HADDRM2[7], HADDRM2[6], HADDRM2[5], HADDRM2[4], HADDRM2[3], HADDRM2[2], 
        HADDRM2[1], HADDRM2[0]}), .HTRANS({HTRANSM2[1], HTRANSM2[0]}), 
        .HWRITE(HWRITEM2), .HSIZE({HSIZEM2[2], HSIZEM2[1], HSIZEM2[0]}), 
        .HBURST({HBURSTM2[2], HBURSTM2[1], HBURSTM2[0]}), .HPROT({HPROTM2[3], 
        HPROTM2[2], HPROTM2[1], HPROTM2[0]}), .HWDATA({HWDATAM2[31], 
        HWDATAM2[30], HWDATAM2[29], HWDATAM2[28], HWDATAM2[27], HWDATAM2[26], 
        HWDATAM2[25], HWDATAM2[24], HWDATAM2[23], HWDATAM2[22], HWDATAM2[21], 
        HWDATAM2[20], HWDATAM2[19], HWDATAM2[18], HWDATAM2[17], HWDATAM2[16], 
        HWDATAM2[15], HWDATAM2[14], HWDATAM2[13], HWDATAM2[12], HWDATAM2[11], 
        HWDATAM2[10], HWDATAM2[9], HWDATAM2[8], HWDATAM2[7], HWDATAM2[6], 
        HWDATAM2[5], HWDATAM2[4], HWDATAM2[3], HWDATAM2[2], HWDATAM2[1], 
        HWDATAM2[0]}), .HBUSREQ(HBUSREQM2), .HLOCK(HLOCKM2), .SCANENABLE(
        SCANENABLE0), .SCANINHCLK(1'b0), .SCANOUTHCLK() );
  IntMem uIntMem ( .HCLK(XCLKIN0), .HRESETn(HRESETn), .HADDR({HADDR[31], 
        HADDR[30], HADDR[29], HADDR[28], HADDR[27], HADDR[26], HADDR[25], 
        HADDR[24], HADDR[23], HADDR[22], HADDR[21], HADDR[20], HADDR[19], 
        HADDR[18], HADDR[17], HADDR[16], HADDR[15], HADDR[14], HADDR[13], 
        HADDR[12], HADDR[11], HADDR[10], HADDR[9], HADDR[8], HADDR[7], 
        HADDR[6], HADDR[5], HADDR[4], HADDR[3], HADDR[2], HADDR[1], HADDR[0]}), 
        .HTRANS({HTRANS[1], HTRANS[0]}), .HWRITE(HWRITE), .HSIZE({HSIZE[2], 
        HSIZE[1], HSIZE[0]}), .HWDATA({HWDATA[31], HWDATA[30], HWDATA[29], 
        HWDATA[28], HWDATA[27], HWDATA[26], HWDATA[25], HWDATA[24], HWDATA[23], 
        HWDATA[22], HWDATA[21], HWDATA[20], HWDATA[19], HWDATA[18], HWDATA[17], 
        HWDATA[16], HWDATA[15], HWDATA[14], HWDATA[13], HWDATA[12], HWDATA[11], 
        HWDATA[10], HWDATA[9], HWDATA[8], HWDATA[7], HWDATA[6], HWDATA[5], 
        HWDATA[4], HWDATA[3], HWDATA[2], HWDATA[1], HWDATA[0]}), .HSELIntMem(
        HSELIntMem), .HREADY(HREADY), .HRDATA({HRDATAS0[31], HRDATAS0[30], 
        HRDATAS0[29], HRDATAS0[28], HRDATAS0[27], HRDATAS0[26], HRDATAS0[25], 
        HRDATAS0[24], HRDATAS0[23], HRDATAS0[22], HRDATAS0[21], HRDATAS0[20], 
        HRDATAS0[19], HRDATAS0[18], HRDATAS0[17], HRDATAS0[16], HRDATAS0[15], 
        HRDATAS0[14], HRDATAS0[13], HRDATAS0[12], HRDATAS0[11], HRDATAS0[10], 
        HRDATAS0[9], HRDATAS0[8], HRDATAS0[7], HRDATAS0[6], HRDATAS0[5], 
        HRDATAS0[4], HRDATAS0[3], HRDATAS0[2], HRDATAS0[1], HRDATAS0[0]}), 
        .HREADYOUT(HREADYS0), .HRESP({HRESPS0[1], HRESPS0[0]}) );
endmodule

