//  ====================================================================
//  This Confidential and proprietary software may be used only as
//  authorised by a licensing agreement from ARM Limited
//    (C) COPYRIGHT 2000 ARM Limited
//        ALL RIGHTS RESERVED
//  The entire notice above must be reproduced on all authorised
//  copies and copies may only be made to the extent permitted
//  by a licensing agreement from ARM Limited.
//  --------------------------------------------------------------------
//
//  Version and Release Control Information:
//
//  File Name              : GpioApbif.v.rca
//  File Revision          : 1.1
//
//  Release Information    : PrimeCell(TM)-PL061-REL1v0
//
//  --------------------------------------------------------------------
//
// ---------------------------------------------------------------------
// Purpose                 : GpioApbif is the APB interface for the Gpio
//
// =====================================================================

`timescale 1ns/1ps

// ---------------------------------------------------------------------

module GpioApbif `protected
=clmcSQd5DT^<1\KMlELGXh_9H?JBI>nh@4J@Q`V]hdg6WFVUREMaXdO_QA68[PU
?Eq5WQNC6DMTTZ;n0a2f7e^J]N[O7hb>7;S0h>91n[lkmMDWcj:VAeUYbWaELFXN
`ZAP4DYql450BS^WXAAL14dJA:YP@PLp`0a3jC3pFTZSba6S7;]ik^qZeMY?gOGa
GV]PXVfe^p8E7V?=ieK@d:gBpaO8l>1\L10:Gl43MeXpQaIhMSA4`\a2lNT4qaLi
I7J2;P:Jh\]TBq]<A<>@kiicOT0K0q;D\DR?KWciEmVHPY=D<6@1b7IFLcT66fH4
N7Z>ER;QO:pFO]>\^4iYVh@J1X4]?KGqMKJJU@a4geQO6eCAmJpj]6]U8\YQ>cGo
aD^4Y76dDqh:ef@2WecYmjQ5Q4S77enBqR=Uib?WWh[f58CODD^flq:o3jXjE^49
e6=J^gjP;peicO7[<\aS2HbgLnqP<@OY@O[a=jn><KGIc3FAb>^S2iI_bEH]2IG5
HS2_P11`_eNjjFf2PHXnLTa3WUQ5Wp<TKFeiF:BSWBnei>F^ap8_8PLkmXQKKoM_
H?UV`qX<hXeUcU;iBK0CS:2>54q6kC9kYVDcZMjkoc0qcngMX=8Q>HiZE;dXCBp[
iG^cSQ6AMl2WAJ@p83WUdHA=[a306j:1ZapK4EX0lV3dLYg8P5]SPJq;57cTOH>K
KS\S@133mp<64i24GbHlmoI<CbRo9DgUbEiTjFG]d0?^hfDD5MAXd<<8]4pY\[8l
<m`;7?CKQHo<mAqT:2`ORR1QN=2^R<dMHKSpBn762b?b_m[n5WL8gOKFq@Y4E1SR
6jEMPnB=7;l^q=eUeBfmZqAYYg[nh?oQYij?4pTMPJDYN<[4n\9dNGoN4pBM9Fgf
R?4Vb3GhVpUlo?a35Pm\ceI\5cJW1]i1f3lg7_>@ASDFUmIo@b]HCY=A[A^QeKND
;7clXZpa@Vn8fR?FhnEWFC8HBbqBf0=0D[SjbeN3EY?6?qLH^F^ThDnb:ML:Ygli
6ME3o5F_>mZ3jphMTgiSnj@HLNP6WJ64<DbKMmOEd<GTN>OJI^cFBd`c_kKQm^gB
9DIeobhQ;V?Bn:Pbp75o7^]maE:iM\Z14E5Nb9OiaDVSeC@YpPcE3l_WZCljR<\J
X1>9EO:Oa1MYC]=LDS;<q@f3[eHE<DQ;X7cn0hgc8D4\OcK9C0=MTq0O:=gnUE8P
681KG0N[c\6XRlW27TSlY@CPc5qfWQ01>cP]MD>5L01bO]08>A3`Nfg4H[F3`9jp
1]C6ZXP28E5WCcB0CW>>Ff_GS0PZSg2>;NKQnL2<VW64XX:Kcen8UP^U^Zc3HoJ8
lBoo]JpQ>^;c?B<lZZ3VV_D`B7K20bc^J[6m3=kCOgq78<=Te9hFh1ojjMKZ9UET
C=_FnUPn<:Imgp?NZ6\PgMSYYGO4Hl7<E8kZR\FAX0U[hqe01C<:V;4c:\5]La5b
;XCK^V8e4ebQd?3hqoO\BNR0SHhajH=QFo:m\NBJ9?jf`@UWEJ;GZon^:6Eq89Oa
6A2Bal\nkOiTehfFd<UcK2HY0LMR\lqZjVO2Z\1GB;Wj=MY4dMQ5j?:bKKRA1J19
0oqL:46mbJS<=Lm@@WAMf@HaZOT4J^Zee=p[\dQTL9C@YP`^n<J:;MOMFC:VQE=S
D<3q=cV6cNY\dN_iBb_n<2:Rgh?eLmiC@ZNqbS_>G_o;UVX_5@0h\A2Y[QaTWmUV
fan_q\9;j@;`\nCB0L]E?1h9K^CLeN?acF:=6oC6]gbG?QZ\Oh1I[RAqY9EITci<
28iU5M3CghZSqIM4V>X3DE=GNoXD5GT?;l]7fEk1n0AA_pKEda6i<f25BH02K=15
\Pp3nf:WmaUS:_7D@Bb`RLSiPDZA69Dg=1Z9B@pbok7mG;BIX[YeW1\gNEK`7Voo
DFbI9@e^B0pJ3koN1WoH2=ol7A09nD_j49MJB;V4iL3;JYVh=90L7PCe<ZeE82_g
n::mOdXm;\QKiDlO`]TqA?de^Hc9>lFgbF3VnB4PXIh=JA]DE4=S>j0q<JJYf_mF
0nC\DcVpmS?7ZIJN^FP;AFJ:aHkp8f5G=9^91M>JiHjpNYL>bC]_c]=`J=9OaZQp
ldAAELfI1kOD0fSDF<LdFYiqGhiE0FbKL@=4EhL6>lp:MmNC3m8RJ:AeVHIcJ=?H
Y_?W@543FapL`a<Ve=8e`OZcdQd3NP>I[04D0jhfU6qMQ5Hc=jW\a?h=@[OAFUg8
YBY3W@=Q:12f2BqHjW6301jiLY]Zh7PcJNXC12R_BWIV;ADpR>UMb?WWI[f?8CiX
TR@P\oR9>KndaA2;_4U7qO;M0Jc_RERT0AA5RbYjmb_FIaHb7gDcc^Tc^p@_;AjM
MJf4ZElcjmD9dgaDIG9I4H?lT:h=b^K;BQJIMcX5F<:KK:iQngJS[;04@pje_EAA
:_3o]CkQ5JlRcAbI4bkJgGW?ZV:^RpX_;CUAI=AJT[QQOEegVXCgAoGjjkW4W=8a
plSQ\90k_mTa<fRZ9m3PFPD27XSjE?4Qp`5lgai?9kF=R9a4>V8kFjh>[B=hh5Y_
DK0qeDJLDM?QE_C;GfRjX>G9akF4WK[g5m8IHIpD418>GcN\a1G\hTjYQoPGQkL@
ab77dDocLEUa6ip6^o[=6>TV75>ZB\^`7TQ6b=?8W1R8G=@g1PpU^f\8FOlFYA;F
l6Z7318MmFX8n5=JIap:AM157;3KHkU3T?TCn[jEPmh?h<T\L4Oq>@99;2ngP[c2
TNMUEc^<;_>==n[icLXq>CCMT;GENhCQndTmMB7]MZVe1FdX;ZA:qHD8?4^aMhMQ
kh[m`ZV75pnX9\`IQ^HD:QZ@H^IVM2X1]LDN1fU1R6qld07m[0hP7ZRKOb?4I5Iq
^34?eL\if@<]M6S\d<[99c5>Kf[m[8;YXF2SL]QGaUqM97`^B^1fSaH]B1kH5H1k
nm<=JEo2bRBamLqf`@HbFXiJ<SfNGXNNcdk\8I]3a4N?TICaNBp0BO2CRL02LQZ1
fUE;OR96GkQMjLZJT=V]f9pi3VZnmYH:f;JhFgVNm2KcPajBI\A[Umk^0ee]<eSU
eGq`bd=d8I3eIRRGPG7JmO<i[LO`=^c>G299k=CeIj52VjFj7lJWX]?LilqaJ^<m
bJN:f>IdcU36iMZeOI[ZCok\3=dT[9a[ib6VS\901c[Bek2R7CqAKVh8@VKio2JX
cDC7F7f833DHmAaQIi@O9If[I;O`LcZ:oEf2lXW;9YpRIQ==aiQSBGF^Zhka2mW:
@;[\hR]WQR^ZkPb3E8N>6f?ND8[^[9P\iBpjm0m55c\R8i6OVnY8IEk76fW=TB]F
U0je:R0YShV<[Q;7lYhfbWmZIUaNR=U38DoXT0[B0p=WEZa?MO]6DbF3:>7ZA7kP
[\YBjaa=JZcTS:ZghN:cS^YPT_VfYKAm`qOLEY0ddlM7[=6=1h2@jPRaOc>M5SRY
3l<ho_GYL?0Ij;Q7j8O3P1>VUp=CL_EVBH;bNQNa`K;OSV2\EL]eAC]P;O?alB3T
W^alTQ3SoNMQnhKVcpVMZ?NKU34mBnR:aZWd[PdT0G7G\i`W66GgLDlWBaBIJ@7S
leM9He^;>qPl\<eKWfC^0B_P?a[VFXQol;E<n_4kPKE^3SMAi\1S[oIW4b427^aK
\p`[oE6K3>kRn7a0Nn\W26oCmAoiW_RXk:ICPH;f;>F_5_k0RTqF^BNo6_hAVRSj
8haGHiSa6`k?f=OD:fgSHVOnSP5CFUnjVf8eBJ;]=XqXlXJ7ZIckEUjX6AlLa:AX
]EehIH@:2jjVbQM^3N[fThPFmhaBcnkG7=q@6DC=fd[1J9fQcH2V@4L0bX=;66bX
0Z1_A4cnf4PdS?I[FBHk[L08XfpC<[AD^1FoW\NQ`L4oX]3ECE`9YfmT=5L]:2Ao
DLGf>M]_[q9Lm^SFi=lnF8BaKcEdaYk2[OYHRi8CoD_cXe33_jNcjSikf^j:Xh\1
Eq0\g?`G6kgg`O<GQ8Kd1^Xc`GLYh8dkG1BjXIP\R8YQ<8[YOTIilkioYqa34>0d
nRK`LFDcY:9hiM`P4`h\_SO4a1beG?Sc\8RFV[j_g7a\3]o8[p\?oRROhIbAmY@;
hcdGi]ifo\e069DKQMA5PH@LH=KMf\^^;XC0bcRf=pjS^X\B_lSJioF8iM644XMi
mP@T=gKQlbVF2oIPKCf\A:SB>i]`QQR2Pph>7aVebLNIcW7ETgT6cUgJ1lhAk]6P
:YGgTLaJ>5T;>I^RoedNjB^BTq`L6[MMl]jV=YI7Z?8k@oEo[IE3[e@nY:9RCTT<
So3mV6neLPG0=hOCYpOeS\hdO<RUlRgj^NoMB\_Lo[QdD=VM=T>`8l7RMB7`F^JI
>^o[1lM<npR3Lh?hndC]eSf1=A]`Vc>=ApR=MD6DU<eSjWVj[[\EETnod22i30cN
F\3nA=0jSo5@9aoXj0Z;J:;miq>aX`23W]4S9WjWMOJNQ@9Ch1jYD?dI<9CbPQb=
njI6CRLTVo8F[]WKCq`4iDP7kjeIDTQ5Jgl7E84WU>QJ6VeQ0Lg?:cK:[8?RX<oY
KjA2R2Te@poOA]=Ij?El`E\5gBUj?2EDe25hNYnM23O_eBO>Y]D`05ImlVNDoU8J
bZq?WCB8EV4B8R?OOalkC@D\o182EYBK8<C@Kn?0XfO?nP_;Z_nN>pa5BC]fM3]\
ba0oj]F?Z;6HOfF6iYJO3Q[n15O`RRSB@H\RM5C^pkGFC6fKQ:8GHUHcDU`]i16Z
<3T`0YK<[?nYTH_4`\7Y06?oiX6p0;8eIULb^Z@OQVloL9eQ]La4PL]ilYAVgA;V
i7;61=R5JAoeHbGgE@`GjG>E:Vo<a=6Pl\M`30e_4;0E2AJqhFHJP2::DC\?lhO4
KBS;bWIfC2kfHjDVc3jgq:@RBWBn1Zo\JC0R7YXS7BnW2<VB_0ok_4gS79l1@p>=
XimLHj4WW6a_UKm?fPQN7d\H<8`]CBXMqagS<=8EODW[BY7B??[HiJIUolZgTVFJ
Ap;]an1^;^3;`h=M40b1P^7HleAXd3^6R?N][KpQ78Qgbmd_NOVRJEYV@PYGU2?5
^dacCmhG\PYn^XK7EQml1[_qf0Vio^YYeKR7LVmDCMAiP9n5V@LDalTp3YJ8n<g]
KV`E33Jc]bgCU;m?5VNPLHbQd>fq;fX_eiF;Aa7@^1NkPn1RPL@<ZmB1ZL[Kf]`_
Q6p1hQoGMh6n8fYZ49iTOK2WU:LMhG0CGhpV@4V5KS;`eF`>[8pC5;WUkmhNnTdk
MSq7o50Jb?`A\KIQYW]DY?epfCXfK[\f8kD8U:I7>PK\M>a__]M?YeJ_=hqH55gD
jV3E1`5l^egi6l?fBk:mWe<HnRNG`E6XA<T^?6R\a0i`DZ0cV=q4EO<D<I6@CQGj
<WYld2ONnipEkoUe<]@Og\n]B0W@J_SjPpcj\Pd]@l__BJC[PRNGToqI4mXKGi0;
5RDI4;T8c6491p`1lVXBhWcW^Bkl0IY\5569qTR;jWU9l1Fi;3cQBbU44bdO4F73
75P56f5Rf;A6FINaIqWVaR1?Rf[[mdlZoY9mU[p2jhI:ldT20KNI[<:Tl38NKpH6
f5;?L<J1Y<FUQXbNRP4[qLmDQ@<f=]OF1jI3H[oS\FbU>qScGU<7l[1g8aEdi>RN
MMloAq7[lY[5f>?7bR>k3k98;PSo^Sp^k14JPTB\^1^SVCg;OR@B_LJqbh\3FR5d
7EhCjf?Xi`=g<RKgqUQ?R;DL;_]k]9=T7_S7:XgJ2JhdK1ETMOP7Yila5[2aHNni
9;fBXcn3qYe?iFWMg;5EC_FI<TdnKXUh8p`c\E6nFAOJVhUT]<:?@A:W8HpPRmJ1
Tk21YGY:X1N?3eZOMC6q=\79kU<\>;RdfKR[]K[35YbgpWS`OVS9ab9HXboBb8M[
1DilJq<Hl>>`kjZC]b;hFgQT`RhZ`?qn4D6YXS@Co3>9hm4gcl_nXRPp12m]G\0_
UdO8g2n=>DJK\oZjqnM\DJG6MF]^R@Wl5<<151GAGq3PK51:f;OdmB4o2\aT=YJS
_\XmAIXaec^6qCoWU>4?^?:iNV<l_]NEh00Jp=cUCf<8^;o<A7lRZC@c01VpHQOm
3G:T`]j?RJ6^?;MZphgi76bj\Pj<<XjN`2`li5JpBTZ`=UNT2=W7??<3Ah62>hpY
CQW`^]lkWZOR:@d6Iabp@Mca3Xf\lkN3:8VkUMBRpbiR>KHZYJKoFe5ZWYJS2LlA
fqeM;0_iK[j]GkJ7C?9iQnNZ[q;gX__;1bEcZ`UWLQEck]\A8i1a@XlVa=IOapCa
_LYO?^kUVaoD\nW?QfPbM?qS2`6RJN\GX^4oJccU`WHhL6fp=C^5d:g95fTG;cea
QdROagCfp21eELYWNo>APPgIEWl1hW^_apm04iCRiH_OCf\\2eh1hAe4\Xj2>O3\
6CfHUfpfRLmOCjTHLAA`]al\XW9DB\J14N73gfDpDN;i_;7Yngi`5@mO_^\OQ?8X
VK5OFfWgac<paDDANoIYY9C7h[CI6Yl0qfWC2^K>S2<dGG;^4XeZ0aJ;F7N8A@Kj
?42qnXOJYG1CJB59_F>IA0n5O>R9UI1E2Q:Yp>0kS2j?oR7AVUn\8bB>UNl5R>PQ
;i:[ca6p?W7XLa?Z=UaJG3NFcW5eUGSn\R;GIe9=`Jp8^6Dbn1M;0^`bR=]SZMOe
bWIn[@]Uc]JqUloJS2F^\BUFHj=7Yo\J?QFc8[5D[g7Kd>fUef6j2CVLNGl@6D3;
PePi;>10>\N1_21@>0;Lqo5lYV0lTKM^eK=l1lda?XBUCHGaf^=S51@p`2a:]mBh
fBlEW;_I8V7AK?pTeFFW9AI=`JChok[]4GlT]`^\RJb8\anpXgd4DaCI:c`L<io<
O52eK=BE_Rl9l8OT:6G_q5P?Xb9?5_7QR:A`hgkj9MW3`;LE3I[XF=g?;_@e;Zf0
4T7UH516D<kpo6\9k;54ZOH:1BRb4>ba6lqh\ASi[0bL:hifERWmAAi@BiACR_Na
9CZXJIKqcgfEGcQ@T\H5g`_6ZE=B75MOB4m2Lm14jHNnp:EBlFMcG@F`MgQ4LlKd
^A88A0XY9`bLlQCbPqe:OSZRed`Z;FQL;P=GUB6\3797Mjio\QJo^?qC@KgjLXE8
fAE:2cLpJ9B328g7hcA=KaB6O^fQOV8NR0bi^VN`kdf<Acnq:^m1\35f`hYV1F`c
AOJAP>fQ\K7FXj7WKeOO9Kq\X1f:[]]\98@cE]nkO8>II_4WjbGW04[jAP0qiaRm
jc9Xb8S0Vehj\4Y:3^3UVMBbQOR373cX=lqXJKd\e8ELPN1cg0iddn7bme55Bm=[
I3fLWoLYbpAVBORjjUgKLhm>AH<\?a`i7A:5ZNKCTH6c4^poIN1^jdg3C_4CJY=<
[SGe=K@J_=hPc9@Jl>epn;dW`_]CS=k65@:eaNd=i@R=KNcMLC9Bei=1K8OoqKMB
WB:YfBGFoE@o=5fkQn:2K5=qcg4O=UFhZ<G?^LQZUNaiNj7`0=jqkb:_2`Pc@MF4
UfFo`;iaH;ISd@<8o;N5ng6=HWKGpUc36Kd0_EY8QhE1h74f]WAIMg\JZg]3@JY6
Bo4j4pREHk9bE0H6]nGCRaXhoL::YjDT>JiCIQ28TB\S5^qB1o7X5UGiT:Q[OD59
hIedoH6O1E`i_Z_l4jE;E1KqH]2Df_XdJ2<qld_P^O<QcPhaRH]9??N9boN7b\V?
XDC96[@5@1qoK_nE>:Y079oBVK2XajqAdK=PeXPn\1Q1]0<g2;2Zo;g4EXRhE:UP
Ujq:6e5iBEL=QF5[\4Nm^Re6:e;Ka\6?:Bh3KTBZhcAm1hZYnCOf[RS[0fPYHilg
9aASeLUIbP3bFX4ak<fRD_lNFELlF>pJ[InC:Q9VR1AU?m9RT>L<a^\JWBPqLbJj
DnKW=g1CEf15W?0;3MHYGPMOm>BW=gDGfbUIMl]SL5YqnC9ZAm;iA@Uoe=TLlOl]
Ljm4Vc:g9:`QG4U573bUINO?7`MZ<1>@i4@T3Le=Rg]a8J3_6>nUFJ84aJQZ_0GK
IR35X\7q1Z@JUn8and04jio8lVB`OQ6VfRF@FMShF5BaOj4OcTnAB\@8HK;Dmlq?
KeaR9=Z>iTV8S@D7hF8PXXRnRIaER:cS==>:@VOmQ>3Hf4aGo`Qp?=b`^M597[EB
Mn?c`kG85g4:al[XPZ]n\^8nh2WHYf\5BAd@c]EO\D0kja\SO=p;0`^>mNA65?bP
Ri95Z@Zck48CFK1[29@pOnB\57`=B@S0B:[GnTG`@diU0:l_VkGEF`Ce;1Md<m0?
O[9No<>;eXVfVFo^hVM]N=9`h[[PYGX`[Xf9V]@B38X\SFiipcXA:4m5`En\lEFm
5P3EdKoR2Ef04AeJhpaHda=DTW@EOlTn2FTUdU61d9>Eh]mnTM:7LhKEbYHESC[;
2iMT9I4VR<CdYZE6B5b7GIMdge1fOlTn2FTUF=66>5@Hqk0A`fk?oeKDL9HLWic_
pKUYPTcfW?W9=?07h9NHJe69`g88XoPKlp6cmakFK4a?F?j<2;dm?WFWm0D]ERf5
N;C`4ZbFV_K_LCa1PAXjGJM:4K;;ahLWnaA[@DR?UNTRcR@Z^W[EgDR0hENJ4jpP
I1dd7LN\MRcCa2_[_U7VYl4jT4DQc@kq;W=BMlih5[I4JQe26@@09c16o89mRUd3
>cYO5^FhA=E1RnjFOh^6bJ637hj`gM92ldKQk_DfD83MSPRn2LW`GjMEB\XcqIU1
W9o^@VaPQ5MlRK^^2^ZedRMnHe1<2q76T1^NKPlbK`^^jZVhn7IU:XN39N`^6YfM
;T441ilXP[nPX_^MFQE>43<k4_HZY<g3_X]]i?kIKH^^jZVh17I\lXZSqB9ThRFQ
FeacJkakF`;B`C]1E4n=4M\EhqLhWP7HLg?E<GoSgm6NhW[3iQk:75Fmj<8^5aoZ
Uce:G@9fijc`cN?VbYcIdlZ\CjT1>ldlT0HA<KoSgm6NkO[GHF7oq0UX2bFXm5J3
C>4A?_K6WPBU`lG_kKE9@Cgdgcahh70pmZ35K\d6B?J3:<02>=m3bSoA`7VQWN^O
qbPDEd:a_N:W>lIW58SgP6NhW[3iQk:75Fmj<8^5aoZUce:G@9fijc`cN?VbYcId
lZ\CjT1>ldlT0HAaXoP\[K6Sg6Qg4nM\G5Hq:U6c:_H`ZD421b<14jol=H5Y1fAX
\HGTqn[TMmAl=XUS;=eTYP7EI56SJToe`oaci^7Uid_Q37L^a4ILi690?fcRF=m=
WGooBb`HGKk[DR7KXi\_:C7RMSYFbPonY0eZqj^l1:LiKC4\okFc5oJ1FVcNX4mT
WU3i_q6GXNHkO85n=ljimbNl`^<5<AhLF_?G_D]]eV>:LMY6c2[M1_kPDjh3dabB
Rc7PJ]@ifh5j]QKT83ZMYCYl]ZODZQZ[Ii]e?T09qjof`S1\ZOL4G1Sdjf^G;R7`
1K^GB=EH>pbgW`>RkoSSYXEYRn2L7P>=b\`ipK2aE=kPTDV=VZg<Iefj>SJO428a
<`NTI]eU3Shc6^D>]Ge951GA\]A7b=[Na;`fAajUl<3:2AF<ZRb6iHfJ[KXom;G@
5oQVDimq@60bVJ<^\LBag;ck[FGMXnF?W07hDFjMp[3W3gX5m@E5T0KPF5ickXCh
JZ`Cne7@iHHjB`b]TfV@kS_FjAnkCTHOIh7`4IYYW>eR6B>68?hEULXWdoP7gBT4
@cQR;\[W2Vap6YioFMcWaeO;5N6`WJ3l^`>n6]DS^mc\pP3448Z57=e5bM;>lT;W
=ha6LHcTW1nF[@fm5^mQ?YCQb34_YIO\fAKPK4le_fH>DI@odcWeDPEla<IZj2Ck
C9DMT=FJoM=4?7TqB7?A75XP]N7P<_SnEUfS8JaKNN=\BQ\Xp8oCH^22oQDVV[dl
^`=BG=0V<9jCF<SN8i5Xl?C:>b9KqeV<06Q^c^b\\mX\B<?bN3iTEkb[aZKGo0eG
11WCNAkLoFDj:R09QnN2T96@LEJqJ@XCn0CIXGUgUfETiGXUdn>_d32Y:DVQHJG2
YnQJanl9hC3\qQDcA[RS^]kg8@:==3NITO`4>3H@i8^mR2bWA42P]X2o;X08aTk^
oD7f0AFS3Y3?7Ho_qDHQcQi7X32mIEE6DC033AUbL2Q7_JmEE4d?@hD9gGVX\4SX
2fG4[3JdYGgCha[J3X=::>JSGV4?SJIMN53lBHgdp`Pf__iX34\SN?jnHNOkjaee
eo]2pA7iV:aiL7T`T]SI]UB8@GHIdOlMh7QkAp1H<gP;E5H79Y]kNnMGejX;1fVl
M??TQIT2Tc7DffLYe_V_OKYf5G8a20j4PcjUDlWRA;R>bYomhMK`NP?KDo5co[P?
Z=qkk24JNk_8dT\nYVCOKj<06k]0RMbVS0DaA5Q_ZWM4g@EU3<c^k:l;`clDb1bp
ifPf4:emQNhK6CRbVfVggaSLG<mhRe_MqZQmk^^9kJFXTMf63LR\]kSmQENdX[:k
j`0Q\T7m`YQAP;fDX9@\kLC6bI4N3bl9U6?RDjFD>8[X@Mf63LRW<kgi=mmqFkPY
S>lSKi``]?7WV<7Djd8T:ngI^I8npUXiNbE1Z2R6BBQ3>gRaj[i4gjl0\_Un9mBF
dc]g=0S\:Yf?5M3nY7Vik0oSW^gK`kLbHNOlQkjRYoP=eAAT_m?Y1^=LfpacLo7S
knDdKV^adBDj>n`WGQlL6RA7b6pE8g2OjQQm^L0FZ1A`5;mBeEnE^TIR=H2lA`Tl
SIF9N^dkc22][O5WlUOab82@KSNdFAU8jaE3jW[n9fXFh3[4aTo:7OJq6<QgDM4[
b]g\M]<D9KADm]QDoeag`fj0q@`8Zk^K4RG]ni9WHIT=h;f@oI\HBGjjo4f>gfJa
4k[>oPfKFP0gS]OTm]Fl[5M60LClU[PiQBE]9i9WHITYJ;7j^;9q4?OmNgB@WP:o
cO4Y2YQXPLISU3iB_GI3q:=1<`K75e_G3POe^[4hiDNaq>hoi_n\I`[2e@]4[lL<
L`_Zlmdmab]4lJD`OQel60ml?H7KH:hCe]]X@]^_lQ19E>0HJbJ1[_OUY9kKHQkF
9?C@8eCSdqGl8TQUGgnEOdln;K_Y8<M6<Kh`KN`R8jp1;7`1SAS_5No[;=GdJ[_8
nc@0;_0Y2S3=K<Ge=TKi2W8>l0<>jF?R2dHa`8AXMmU?A9oI6Y]V\:aoHoahknKT
51<fnPlqklcU;D09ol2DJeG53\95J?HYD\0OI^lYq3YV;gW::obCg_QUpgTXF1J3
`XYBP>@BD]m4eGN\DbJj89Sdn7J^Pm^:Ce@H:k8Ej8LnPF;[g?9>dAfV5h2nhaAj
n8S4:cV7=d;:ojk\_Q6Dod=V_l=q]GYi<E@hfID<Zogd;NG6Qh2_X6J3>c75pY2D
==ekDfVjMSLQF[60`dnFF:YlLZ\`ekXZe8\a=Q5<BnCDj^F=kbU2\Y^;k2k7L`^d
[n9Sd8eQ?^dWah6aXfmfgKYB7aNcqi9c2E_KTZoI>0ZMCUb>H9[\PRJmNgim]qYg
FD>IWJY0gYg>j37^nX`:md1II0X<?kZ@dk9^G@IN8MHn;OfhWe6YH[b99@`[NQ\F
O`UYO3o3dcjO0FW^ON8dIWMm=ODU@]Omq4i9alkLMjM@l@:W]ce05LcAbnIM4BHW
PqW<l8a@8CjR45DKXLP826Kl0ESf32`oSITTLIhJR?4_IEDHA?j;=je<6\UQiiBk
=J;jWEiLFO^Gi4VfCGE8AD62Am2[_[GhiZ<Wq?IWI77a45k\O:LT2n09geXgjVD5
6HEiepNS`>ld;>9_FMISHH0kNORQWQ\D88O5n<Yc6Ycb3U3ac[D;<f@4bR3]Zb;5
[c1oJZfebH<QbQZJG<l1PL1D_]:G291NQWWJAio2pHJ<oV=dfOTWIfGIOI0QBQ6I
9>IjOHDLAV;08WmohR`hUbZBB:aCn3ADka\\dQ=EB]6MIp?P9cR\8?`TEDHJ?WEP
8JXL=[A0R8CFdIpSka:DL]_e@>GnUPa]cE<eZnd6PMGcLYiNO<I53Q[A8LK0Vdo1
L@We4NMa<kch0jWLh7d9O>P9V7Y=?cT]EOJohGX_k<HJ33Wg=qm@k5j6f?]4K_b4
Y=BJERY2Q:ieThFadQq<I:fSN[E5EEif?ADSc\Rg>ja]?J1JiDULc_F\QRojGeDo
6`XSb=Of[>c7SQY6TPAe@_Hf83ZDDD9?@=RWcRUYdgSP12Ja=Yn<Sp0:P]d@b3Ob
feY84DAjFkSBMDG_08Zl@_p\YDNTlS14YnE9[7?7c8dWH:5CKJ`=nSZfRNNKZ;ip
3SCH7\R<YCCb=a2WDAo:J_WEFCG?UWC;3PR<a0cA80HO=@XfT4H0M9fmZ5Li<4;7
ljGEe:<ENU7;]H6\1A\ImCFoSWkMkG_IRkq28:_5`gRZ;gO<fjPhY[gF`?o?F=Y:
f?Np4i@5S@5@;ZljNH>elg=dL9[2TjD3FmhFe3G2d9HQHLkPN5ZV[iU`lRUVfZVB
YOX`j=UBcSfR9oW<<U`I`g2FCVSIe_KWEBdN^6pMTahQ7JE8^5oU0E7\c6;E4Cec
bR2dT6LpQkcn\Zi[]E@Mb0V;]<OSCMP:1De]IF1JjjQXjT5^eE]E]ci`L^dJjP7K
AfCn83?HjIaR<:X_8hHL_A[^d<9IWLE=9MAj89CXIhpjQVPTRb976CVAgS`>9Lnk
0cn=^jn@B6Dp`>KiRE]8DWOcDERIhL7V8F>9^@icbMk8=NkCXb^ATA@PGc>;Hf4E
WSm13b@EGh=P5jNkSUdUXIiT8=>F83fDkFcG@L2F6CnE3aplo3`4\<PM<P0GV09c
L]d69fddk:MXgcoqD0NgiSCeH3HkQDnB=;<H?dZGWi4g_<C6ERN73]3h4fhn^2I>
RaLSH[`n8d;Xj<FCFCR1M\FDB4kSRJi@FULQhd0:FTBT]hQJ9mpEBbCUT4cdbC]O
5JIeU0SHc8YS1j<oe148[_UTleg5P?m51qH=9nDbdX7coNXRDOGB]g5a=Jd81c^7
a?qhj9jTF:kDg`kKI9bWC>UH4H8:\HBa>LNif0IIX`g;U?S8_0IA186hB>d=Ed16
h[V;_N47:Ro[[MZ`Ta_\Hl5=46A;jRoSiO8W<p`;f_GgR7h<KfIY=Keee1R]Y]1Z
7PbiWZq7Hg_ZQD7MM>BlifB<W5VGeSaFh[b;MJSB8^Jn=3PIJC0ld;Gdcf7_I5CM
3@H4BgRN__KhUVmq;hPjBkm4V;Zb1@]?imkU`l5QSdU4dCYOL`_X\Ra]7oIme575
AV3A>PMnP4kNcl8JCVR\g`Og11:M9hLW2<\N`l2^hhNfZ88EF:pocaV9ONjAT5Qb
=aGjS`j0oRZ@<63CV1jqHc9IMQ2_7eAKm;fn^[3o8kR<<Fk3BR3Bk83=dV7VZFhB
8iGAR@gWNH`[jQa@i`1n]UeINn[8Ln46qgPVMBWO_A^Ng6U>onIX^6IBQb7=<a9`
nA`Jc1^HQY[PJS`fIdZMjq?i>X28DPPg<G5bTVngan9:T:jf8dk6MPWD`;kl11fL
6EKYVY_>_4KlebJ?Nb58?2lV>ffR1q_K`i`=ghMG3YjIP6lH8e3I9:?5^nfcNemI
YTeDL]j>logjQUKXUpBCQChG8RhB6bMk_b6QHRioKG48Zo]5<[OCOobSfD_ahWLh
C4LDMdX4plaZ64<iomN5fDWTRO?EjoXEd1B58lF>5EgRK9iB13TPkTcfHin4>HYq
>EkLb5PeiEV6D\X>@Xl;bK<825mU`3CjSPmWhW3?WId93Z8FkXaqjJ=\OgLHKaSI
@WdIL=mF6Kd[iMmb:@eD1iDTQmI92fI_<;n0K7cnqe\fF2GE<Q[g_]n<I0HVW9MY
UC68WUOjaj3NPJkjXGU9hiLcF\`nfhJp8ZnLiY[HQYkT\FBbK82fO?6[<@;>5Y`U
<mCMWg4B^VaP?G7_lCWlWOS\IA^q3gf>lXd?cE^g7k24ZkR06^mggN1X[DN;l:GR
9?X9o<TJOoZWRBA6SE[F3`hC8Be=3\aLlXd?cE^g7kHgOkNokkq`WnX68GabJ2T\
5gl[l6qM2PDhDVjS5koBhK1;S;WD8mbV:=eQYPlg1R;No=Q`M\ZfM\TDK;5c?C@;
eYJhh=fFGdhmKo`S5koBhdgPS20TbpP;[goa?VN]i[@F=I9O:j?>\Oe<>4XBCX0K
dN=I\^9^`Yo1nQ\N<:UIj]FopWANoXo_`SHLiA>IEOV3A`@b]N8go^]a5oNl2<g8
b=UI:\2:hX9lCS5=[bm4q3No[?iicXLFH0eT2=8;KH0UG4F7j5UZMcVVYXAY6Bjg
lb3YYR9UHmFe=8CPpSB5PnLhK@D4fX>aJl:HY]T6CYE6^8MB^TM?IYcdMA^f:Ce?
kbd>M=G;L8gVU2WEDWRT^`;Nde6p2Ogm6de0=7SR@2Gagc=6YgCl;Fanj?AP?]G:
A@FQSc4DeYbE]bQVVna9]b1Se8mCC6jY0EYo;2YqUDCR`a98c_NP^jGE8c;VcV6d
fe=`=Ui`KBSf1?<O@]4DmPMJY=eSTi?P@MPb7M>]6cd>eM@DQmN\p\^]]NL6DG95
hJh4DbGjb4cX6idRhES6kW=SAA26k0:W]h9=YE93Rljf]_`HOWbFnP41ZA7>0WO4
1pH0TmZDcAT8LRl4?X1E0bN^6M7D=CMAK89<Al_\=H;jT0gF[7ZFk_LEAkW@U?>b
ff9gai1hpWID@GlH[4G3BHK7ii2D]]AeNFMJ@HQ=YCaNc7G1TY0knonCKbDEDF\B
76o4f;;c8poa1Qe:om<KdaOfD0hkc@K7WSFd08KMP>[Sml0J]1:0heJm9_[80Wh\
]C<TVOQXHf0o1C7ecp583_9fj1<ZSE@jCo9F^fZh6iNOG0[oV[[?^L[N7nPdT5mL
1g;Z>RH`E0[d7e[]DfW_4_l2Icq3Bm08R\C]];fihc=lZKHj_mceY?LBYAkHA7]2
_S`7_ho95l=6m^o5i;3EQcL7M7Xnf1Pi_3[q0;^f^T7@UGe^Y6W@1F]_>EgGK3DX
HW0[VZbdblcWci8M`\Vg=?5jc?ZcXQa\CB\MOiaUq@n`gbWWD@9;mN3EFY08pg^@
?`CGS0OjSjDkWOGaO5BLW2WXbk;@?;ZgYnRp6hA>Ibg2RBW@=0AcAdODKK][p=nE
kmaPj<aN0M=?[1[P_D:b[jm5j`CD6ARjp4jA9;4\?_2dWl479`f4ncmnXe36l\B?
dNoU_]OVUjP<D5_G:1ijog5h:dVGYFPE4TlcT9epigXfU18:kZZE3AOh77Se]ZXf
d6bY<APi]9JY^H[3qdJ``l>hqh9_N[fe[ekbRae9CmXGlNKjdIh2KUY]DLS5Vq\3
cG9mpTI`YD?46QoTgad4:fkE5l:EcPRmLhAeQq]3]:e`bHhgRQ<IcHPb7X[@?gFB
Z6OhI7a\=G=XTNQjc@pIHBX]IiiK4Wh<X1]b8Z^4kQ1pUmB0dOXnBRMhhJSL:kBh
;PWk5FmLdV[S5VD>HVTPoBP7UCfd;bkU54UpPV:TGMPCFQ75[g[Hcc>7Ch[Jjk<J
UZUm@K6fmU7I^?aI]WijJkB<JH2^mZSf`@BKq9^@0YGmV>`NSSHP3ofLHa_1OlRd
[:eT?0QLZK@51EKimV9i[=R@Z8Y__8:JVDFbEE5b_;nO4kK^4Mdap;g<CDhqX_kY
@Q9Tc=B0V@TYF8i6OFG`o>V3BPC[ibSh`gBS]@ApY>WHXPD36^_7:7gdB?JQCIF\
T10FMMHjG5c9q:Xf5C@A]TC89L]I9Gm>]VTTKp63L9BJ?WVE6CF\ID@lTSReH9dE
1dYV<I289<_@dUBe`NQ6A_S3KLW1Iq`oVX9J<4Wi:Rg_^62`L7a[WB^i^NMcifmj
eT[hm7Qo8Gkd70G><PgaVe5:?;_TSoHM0\2M\cmMYPcBZFpdcFbbbp2k3=:T@Eb:
<jHCd?[BEh11DoIR@ba[TBE5LWm3mgH]E@:=NCo1KRUU@KkjXW<C=5`?EPXg5>QT
nFIJbq1g:;]XFF8Z7Jk>A_X4I[7X7q5G]AL6`FWhY?AhahF_Gq_^>:R;?hnX38ND
nOWM3>mH]j20pbG5b`K>4ZlYdW<IKUAHC22\MZTQ[_9ZJa?B7oICQ]^Qm?3SHI7j
Qo6[pHB0DoOfGLn]cj^JT5m7N1lCY^1C>c;8a[`UEN;KB]94I;RA1h2`\<;oGi3p
VnXoIbNp\P6>6[jRO\>2h1^>]Eeh@BKkFh?h^F:nNH0m<jLXcgpQ5K]4_nk]C@R^
@O3nPXc>GJQWNS?1:lJ0GcoV=`X;J46FkHN;YNMq\b:1^[d^?7G7WVV^QPMBUYEn
OUSLR2hMYVlQNgFm25>mAAT;\bi:6=<hf7pEP6_A@HgCE6TCXe?X\Ad2ibJSQRPb
UelFNS3X9NklfoF>UUip2fX\m^N1PA\`0`;k9c0]4ejDcP4`<d@2NS@:O=nZiagD
=j>QZRTpJ1_idK1pj`[o[T>=QKaVE3@H]j`ZDKH^l]CCBA2O9ZWUlVYIe3S<1@ZG
^h]SqYnnHOcLoQ;hV\\kVol9pN:3CoEHqAKH^D6qjBi?0h_a>YZ5A8kREbUMnP=W
QZB\6eIkZ3R4P[q32SiUE3jL5G5c^6a@geDZ20;qgOUM[8T6kdXg=KY`>9F4V^ha
onIC30\lpLVdo]=0jgc?B0PmK`bjm[NX?Pm@ST:5OJm=q6JL2P`CGT11ITbclaCL
_g[;SB]JY_R?kR;BcCW@]\MWqHZBQNJPq[18;4leF[813M[4D=8^eeJ=LcKHiHKQ
mR15ncH7WiDpCjOnc2plMiNi_jLmoEAGfCCK@JYlb9ZZ9WGaW:`fY0P[2qbYHc9@
@S7I7o49F1oL4[iKCP1aL<Bo_<Ai<02a900WHn?8Ya2N1F281KpDLgPj8kBUnCBV
;HMkmDK7VGmi?4=P@HeqjBW8X9oa9DRlAeb273nc?L2c3@EZq@EJJK`nLcm5IBTG
C4N;8j=\G9U8?YQQ[ReVjE3q[>Poj:_lP^nb@f]?hUMEM;T0U<eXm`TK]\H5kFap
E?Xjm7^a\W]T4aEA]m:mmCWVA:<HA6E4@`81A32qPBl[@gfp87IJ4Y_lS75i?hP\
Gl<U@I=;g@6jm;DeglXEJQ1qIP1hbDpQlYRH4HoW6R0A@2W1[CeEMGGjRZDHOJeb
I9MBZiOY7pR`mlV?=7WPPIg8lTY5l6ac60<5J_g@6:mYZHS8p52H;CkD9`a_IMVQ
53QeUBm62[dCpLVdo]=0jgc?B0PmK`bjm[NX?Pm@ST:5OJmXqo4EjI`5?9?m;jfI
;FnSbAg<XO]][KCU[hY>;oBKSG>qhe9<o@cq2h>A36Ei<PW=9i6^U\QAGYpWV=@b
dWGdMi3NS7AO:aW9LZZ7@OHYB_Jk786B_dpJL>;Lap=g6MljPLJTINdYW81P<IBM
<Ai=AWnD=<;iApJ2nT[Gled10<9MHh7LBK10>AjZaa7a2l0VjSmCGqmIb^L8>Pc@
Zn:4?:DbY?]CmWg:Vi^\^^^;fESBWLX4ZWEE3d8dj]Baqhh^1g4S8E]jd><UhCAf
FR3Vq[BdUYXY[YPg@WAZV:1HgM?1Ki2e<=O[;PC>8qKf`a5ZFJgiNM;9L_lZI;^j
eB8TjcKGL]@863>nQS3f46mZ]eqHC_k<Yh\BIibK=^2UeOiIIcGn2b4Od<5g7;k6
GqG025>4TpOA1nCX?:S;iS:375KE37OA?fTOWSQOI6\]>CqGL;Ph`p@NMM7S4[LV
L>^MH6Rie_aYaAXbdE?Zob@?Z33XpF;:1jBB9T@BLg6c_[Gd[pnRaL86:ROo8Gia
R;n3PB1mp5Bb31Z[jW5O5W2N3J:g9MYfg_g`i6bi5F8Vpab=j;>94^FN=HoPUnkm
:[I?JD@GTgh]iW[]7ITTIqL8R\WiWq?nUnQ\N?h=dd?B;?Jm]UJ:@Nb0mK<gEJ;R
35q59]6\<k^RS[dkoU`ome>EjW0Ef9hFZPFj`;?lan:jAWXRjJOf[e6[<JF=?pgE
PR6kp^ONZDNL`dUiM9COaP[:Z`>bGaUb0JN@NqhIdZEnNCPX<bKJDWXRSYOT1h1`
mTf9jhZMNA[n:kGRL:1HXfl^LXi>dDqGGEoPC1L<FAa@Gn@hejL[CZnp3SC>48nl
@LjDiXmNLBkSaCR_lW18h;k2a=7fEap7V\7N4BDc6Bf]eHTFhdj:7[ZCiEZJEEoC
_;78NMq6=[L03^qA?>9UBTNE[m^Pm8mJO\cEOUi;:@NTIRg6V3AM6?pS8N;_KqGB
B\L534H]:C3n3Z<42XJ8b2Q7>iccT1<?F?Y21U32;fn2^M_1\q\4JMU5nR^lKg[Y
8@>iT^8Tj@NWn>o39bRo`YV^qeTEH>P7k:X2jUN2_bDV9DK1p\R5c;?XmhaRB;L_
c<5MEZJ]iHXB4cY0Kioeq8Q@^I<5Mo25Y=l3IKe7U\ZaI76b60h_:2mBh8WT0k6p
XBkHThUqJH?HboeEe7E5>9CKMAg9H18^NHV?NNdOJHmf@IPqb7ZRYccfbTnEdb:C
4Je]lidTJ8nDaJ8[EBT<@VD\DS3pM?U?gTp:6KXBACMo79VXWm1>D?V>Hj`6IE\5
7e<=6dpnQ]JL<]Hg:LWlb\KMk80cS>L>G<nP3VD`CkkiLFLK@V7gTC6=U9JHOUmp
J5n_jPg^IR6cK<fMDZaU5@IBq<R9Se>\kVOR5N1ZFL\A=h0C:fJIT:ESBe5NnTmp
]LB:AF@SfL\J<CPZ2F]BMFPaZdHHH4jIIiXi`9b4_iMgDNP99FW0@0e3Vbbo_AYh
6mq@o8@3PZc=m@oV?cQLYCXEH<WPfHFldQW:D^;3G=q:FU4gL;pZIi:LJmWE1Qic
W5nNEKjCDCL?WdLAQDnm75liSLp\V<UXWq=53dO9`S2eFJO4Nho]bi>C]C]mX6?A
TN^\O<o]pT\N[3;3ceEPoZ0hh^b\VPZHq\FToK`[[6LaRhE`c5]Tn2GRDBL1^<mV
^p_WckL<n5nXWhnGeab2=fQTm:YV7@\m^l?YDqZ@bCUlmWUA=4aF4f5HBcKe`[A5
>KDN;=YD`Q<dIo@Sqan468^TpA[3?6@lV8Q09kNiM95dDiJ0YYDR3GhBU@HO8XgN
pZ2^L\L_5I91D<B]BkGgnReoK=mVHWAZ8ba8OBA^>^fiUXV2MIcjLA6p\D>ih6q7
6>JRQ0iM]0nBDP5ZVh?C7@99k[?<RVC2gVq<<kDm7:c<cI74d=YB1aiQf6[?g>QE
0B;dYnnVd2k1W4\HPHD9ni>Y6q23194gn0FoB<haIi<b\SXCHpjXU4YlZQmAdiN;
2`URkLD3Q2@`[H0hiDnho[p]o5@=>8k10k_BBE6>]M3:C8Z]F0oL\i5l=SD6GpNM
=5GL`q[QFOIM^h2[JeE\LHfYkVI33FB3O?dLP38dUYqUl2`giFOa^AmYI@FEQ`a1
YV>4C1Jkk5io;`XHQ[0A2WKfFKadLhQki`cf_?8hMB18a0q;<WikSp980TBA]99c
XT=JOf_;^6cH;]ZZFkKY\l3N_X[mq^4F<;V\4N@UM41kMPTCQG=qQ7=Io]38K_PU
M_o\lNeCfe<DYW7MNlQmkGCpnNL:1a9nKIfRb:G@QkmJ22HFCS;c\<E2ncG2C?Q\
plANjc:Lq75:A83eG>\TfXMCMofKMTK]dq0_KdXLYV1OR:\\o\Po8ic[]`1\Z3B6
@EgnHZq79A^k;q:kPCTLG1hd\Cg_M3E6KAZ4X7=9@`j]b[qDAK0mLb04:^]`DK4k
6eeXMd;GKH:2d0R8FoQZL?<8X28mKa_:0_@jEnSW9BqeIUXT\mKV_mA8KO[25S;a
gVBp]eICRCdAZnJP7d`GXo3ZL]C[74Q[BoJR<GgoQ_Tq:En]HnK78I`efb7aEE^W
UP<9O9fMbeY3D2T>EJJb4aHl9mCpjjKKE_[q0SN8@UULfHFB;M52GP7PLIP55iQW
>:d?_G8dId?]o;0GC^PF<2DjpZa`Ig]1RF50P5KmL>1PNi=^1m]=aKAMg25;>MRU
DU]pK3NT?bqQ81`h11g?lohdo2iLRAGVAi>kkUbBFiNdEU6JMpgD<HlQ0<<j<SXH
:52G:SMblpB4=U>Y4BD[ZMaD4YZ`k7m]n4QNU53DJBETPq6aXK67PjB7T>M?;5D6
n0SVeF`^QMN4mN13eanDcF79S\g<PB^Ki[PE2Q2[2M;X\aC<qnhB?bBh0;AgcdMa
X6D1kYiH9i`[6QV;N0^q=_dA]`WqZBM9P3U=`^o7UnZDjEeET@h^WjVXh@WhEUBK
L5bI:lpK\WX^lqEah?5<=`b<?D;OfaCX^Tn<5?gB?olmkA7KmI31q10AMXL7AMcJ
^Od\YnQ5:B81DgeJc\TF`d<6;>nE\fbjiYU05X^eB8dB;?\YH?QqPDmJ<Q]_0W9@
3@bn8i5e7^M7p=:Z^IlNK1XaTKPfF8fY2kl^OYc[ik3=`H^8aiRnkq;;RaLKWNDS
fW1mBoh\7OB?MZSjekcJG2R7CKLi33cm?C9>@Yna9N:Y9WVE9\AfZojdp=X6LUA;
>g_<i4=iZj_k];2SS01;l>SQiENia\FRZg`qT<C2SK[pIEMCiLj>W`S[iVdhQ0I]
O0@ERSXPRX6G?6\mgG@GL\41p_EfMa1pK]knTjPfhJXO:mKQYCf62^^lOh8c<GZM
;ioe9\q^VYj]9]nQF>gUX1M3a?H[g8q6dJGSJ]mHg43P2LHAcDk\f37KcSSPJ3^2
K0qc;OV;79BQ>fZ1;D988BV=9jO;[;jSi\N0LP4W8@[DLknqd1X^C5YqcAR:dUOV
hN3_9VW^E5\`;Xikl6q]NJNhaaMa0U3^H`41dOPHVEbGc:VM4FB9d5A?AN]@SM9q
6[40`YqTnFYXd]m4Q29<:BVmg=6c9INhY>o=Fl7l_FF_SiUpmjP:nb9fio]<blbL
g]7?C<FgF8:j:^F`Y7d[PT3DBJh1ZULM2SaBeA0TfBQfaBqkSQJJmYRZ<F23@PBD
>T=Q95`UEM]W7qZFTRJPHN7=oFR=Uc5heIlBRBAnC]nf2;EW;i^Oq:ZKcRc4_jbN
mK?V^c2E5\fm;bB@BO\70IiJ5g4p3k@JH:9q:3KH=9E_ajWjNEaIYWajYUfWaWeP
qH5n`gKW6T7D7_Lo<B[hm;>RD5lKbl`\6Kf4654qeWLeLWqeXQ<?@bi^GJi;U`<S
A2m71CHn<9[_HilnT0q98k\dRk_Giej6DJ;TI3hTXZCoETd?<:>TQWXq\2i6k9h=
<]QZIaW3Ni`_BeYVpHENO1i3@eH:I6T3h]F9h?@OS_]D89?9?[>F9N3^Z`;3IbWo
4QAY4Q6=q]5>JmVE59=nT=fmeoL;;@CqP[gOGoM?l>FJ_:\OEVnMNJL`U^i8=>QO
gRhhU:?O_UT[G;@CD:@g7Q_C=jUg`<R\=KJbUPqFFBm5PqkGD8kA;RS`g;8??0eo
LfXWVpjE\R_<;\BDUOf?\6]jmKVJT=mc9\]]BqSiES`L@<5ZP;G9BaZ6A1onq4aC
Ec\nZGE_VB6GK3ghkO9AQR1`JcGdj[`0_\iTL\1Bc`cgfSeJ>G>ReR7LFFWFT_o]
XBW\?>kbP0eGe3ghkO9AQPR>p8FlEFee`gXTB_3Gl1h0L\gbc;>4O>?3m5@[M76H
<;a82M^BV:K`KaB7bMoTHml`jeg8imEWCpe[Bb_;R;jZZkS>bfG;G3Rf8D7XdBUa
RR<G04c0:g?GI@AQWk3KqNSfOfoqTmYRU[Y?DL]IdWj:\iQ1AJn<0>SZZE<WC<`:
2:[TUQ3IBa;qYW7dE0<i\:[h9kk??\:0@e2>EESY@J\1D^[J<5pSWRge3lQLKOFl
:P:=aW\:cQ9\L=^mcdS:OgH=nLpCk3nKj`0ZhA:[XmMUgBRK05p1a1X@5ODdYWAg
S]?beRADfOcACMP9I`ZD1`5pCX:cmOiUKUU`[^bAY<OU[ll=82Q^Dm_N4gSB3dqX
H^HkIfp5R<IPX2fZ0D9O:fG8JIiNNFbB6nDM\VTM[WEe0R:THW_qGgF]m8qW=\RL
6`oA`^hB=D]KLUF62IJTU@EXn`>XV^Yfbq1`H;c7f^j8k^R2COOc]m]b_lqF>lC6
:RnX>=7XG86KEdH``p=f3S1QN<:oh>FeI[SZ4X4jO8N04l18oV;AlpNclMOm@?6o
RJZ:S2h^6haG155@EQHKB2Nc`lP>I?pl_ISo<1p`D\;l6al6Km>>iB]=mUbm>JAc
8jiO`ETQcDHq?5IE[CpOhcUNI;ml7b5M80TkaVPkV><LOAiJ>S^q]i;]l1oS<V:9
U]D:cGPWj=M@T<^_E<<>;k]IDTKc=4ehiG;Pnlld1CBCD4]_nmqA3^ZjZI2X\CSb
B?`W777I:4G:86fi:>iJBVZRCp9BK_e8=d;n=5JGMND8Mj7_m9?LCpABeOFJ01E7
5^cE?HdUochJTL5a>09oKK8BFRoZQ`q?c\MiUD?XWLB;3JWJYI8cmB1dB61ZBgeF
DaoZmji>XpO^Cn\Z=q=4BfmWDCL<WH>]:^E^ZS3H0OnY\<194T1gZEYJgM;N^YqA
EkO?Iq8Gh1i`W]LQilY3JU5Ec]=DQHJ>_R?iAMHRVO2ap]D?cQf1269X_NmGi?C>
E0hiEVRp9:h=N<@WVOR;27mTAb>ZiC>FXP0T;0@4;9IpU?2>JhIVD8;@lFimBL`?
mK6E^P]::\M2QWb0R@iXN7]MDeT1J5S4^:[PqEJK_8CF]FAldFYA@PhKSaMbN>4N
]8GVQfABZ<c<3i52Lp@4c2E`Qqh0=X:M:YQl8F8:^WoLh:_gMKB64cb85CG9]ak\
IBGOo:qBcbK;Bpb47^8>_A0gIikkW?gK5]To>H@coC^>2d5\QfjckjpObMooTOhk
Dcm8A8Ff>I5Wf3Q3IR]hQ1jo]71gaaRkN]aTE=2e^W<WB\QEZ9M7:qc>oNILCkLA
eBFIi[43T6Llg_qSNUl5[1;WHMo1>M87Da1:>hK^<dh\ZcScAnO6EOfpkKhCLd]D
N0BkmTP[<bcq_K=U9D?EQQ]G[]72WKViO=gIEDDbEE=7<^bYhGYLD8q>0[K8YGq4
E[hgE3[CaFNmgC6S^gWbJ3cOD>X:52S60O3N[cLG[;7qNJLMAmpl?KKmbTG^UPkH
d2C@fVJbf6BV8iJEI3\P30DG[p5DK57EnY1\9j`c28\\o[Z1hpWKcELV]EiV5GEC
hUmeYHk^;BV_5iUY[\8JIpVPMY5aG0=Aa_VTNf\[XYYbhBhmqVjbg0I=0]^Z^IQ_
V15gBkn`9CR2jA8QiNMbA;mKFh430pmL@bXeDpB9RW]6OF8`^jDb89DfJW7Y1R9X
lWo[dXk6j8oR;E[DAdp[W\;K1Y`SYGc7m`0@RIJ=RgXeYq@SGIh6q0m]dn5[a14`
4P`K8lXE2cSN54=L6<TlQHj:CMTFFqM7SMQML?F;oRcdGnoE\^6PKNMUjYI]bOTA
6C2V<kYg[6GUWJf=g?A2o^dYi2[RpL25j3PQ_:Em67KI4G3<o2SpnI?gAj94_DSd
a34WTNGYF\Dj^FM^3;[6Ga;n7FeOpQMCoZKR7FX3WeVdY5\Mj:JWVR0U?OFHiL:<
I4B8k]4pa_TN3K`p8P>VZDgd:0<k:61MnV?k77mKk?9boZoiQj10he`;SX??qj8V
U6Kd^>>j1h0qA?Q0HBq2OdRRnXU8Gnm5k;[N^GLFDHF_okI8c:JQ_LGF1pRVF;6V
f1nCBZ5<MQ5P8Oq[^Tm[`o`:X\@JY]bF`UAb=NJRNj4\mC9oJKpATEPIQlG]AQB6
;97ePI5oT79^;ZkkmmK00mUROV78oOVq>T\@8Kcpo3OS76oC2Wn[HEYhPJMNL\N2
fcUc851Jm602hiGK?d?EqOP4CncpCGLe3<9lVPh6Rkb3a69edc^;KkaJanc^C2Oa
nA65qYRdZ[dRcEj:kH8n86hCGi`\4=0DmjMLCL:`@ZGbmbXO2n\=Aqe\L<?8mH:G
QSBjIJ4eaf90H2iD7<[V0QQDWEo75ID]H5aGo6^Bi`RTIS]m_R:hqY0Y_591e1LD
W35CGDfJ7Y3lq1Od6TdZ3An0Kj9G\h7VVj94@cli?bmLFEn7_62\<plJe<iH6Beo
bR;1`S\iJlE3fceZMOQUGY4iK1Uh2[<lp93E35`Kp;2mdc:X=j9D2Y8AA^iW7F`I
gQVLkFU;62]YG]K]jI>e@pfD1jSQpFZ:CM94^?fF@6e_5e\Rbd]>GO\PI`H^VX58
^[EADfeLX42=5kG]7B=W@SkqLIZRchXIDak]RhL@kiNgi[`B4`_5AGb6U1WLNMqQ
=;=CCC52g\I==3CVYBm2Wp]k8:IL9e0>D^X[d=8Zo4jjj\3`3644>0NF[p6;KRAM
iRAQ]2`Xi\SY^hNLgBGG<49;1DCK3H0:Jbh?i;p70dV1E3pQFHPg:kabHVP390<P
D1?\4a1l<jbhl2Y`k:TA:THb5BFq>0VOC:pLki2lTJ6M\56@@P;4`H5fGnj7YWDE
Ph^bgm5U6Whpa0Nb>OBWUo1B=[d85BaaTe]X4\ob8^p>D0F:U8GNeU;IO5eh8o;^
j]4R6PB1<Y>h6D8XHY_N\LONc7\cQ6Jen03X7f6L9m[kQOKBlEnX=K8U6Udp_T=1
H[naj88MF4VV[PAEkK_ql3ZZ^]=>Mkh3_Sd`?PK1WaGE[bD27=QLTjMdHX>UpjZ>
B$
`endprotected endmodule

//============================ End of GpioApbif ========================
