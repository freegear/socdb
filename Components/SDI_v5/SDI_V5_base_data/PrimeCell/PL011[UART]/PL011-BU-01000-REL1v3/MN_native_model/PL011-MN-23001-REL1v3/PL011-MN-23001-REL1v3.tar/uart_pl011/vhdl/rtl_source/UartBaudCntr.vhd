--  ----------------------------------------------------------------------------
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 1999-2001 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
--  ----------------------------------------------------------------------------
--  
--  Version and Release Control Information:
--  
--  File Name              : UartBaudCntr.vhd.rca
--  File Revision          : 1.21
--  
--  Release Information    : PrimeCell(TM)-PL011-REL1v3
--  
--  ----------------------------------------------------------------------------
--  
--  
--  
library IEEE;
use IEEE.std_logic_1164.all;
use IEEE.std_logic_arith.all;

entity UartBaudCntr is
  port (
        UARTCLK        : in  std_logic;      -- Main UART Clock
        nUARTRST       : in  std_logic;	     -- Muxed Reset (from nUARTRST)
        
        LCRUpdateSync  : in  std_logic;	     -- Sync control for LCR
        ILPRUpdateSync : in  std_logic;	     -- Sync control for ILPR
        FBRDUpdateSync : in  std_logic;	     -- Sync control for FBRD

        SIRENSync      : in  std_logic;      -- SIR Enable
        SIRLPSync      : in  std_logic;      -- LP SIR Enable
        CharTxComp     : in  std_logic;      -- Tx character complete
        CharRxComp     : in  std_logic;      -- Rx character complete
      
        StopBaudCnt    : in  std_logic;      -- Stop baud count
        FracValue      : in  std_logic_vector(5 downto 0);
                                                 -- Fractional part of baud rate divisor
        
        UARTLCRHInt    : in  std_logic_vector(6 downto 0);
                                                 -- 1st stage
        UARTLCRM       : in  std_logic_vector(7 downto 0);
                                                 -- 1st stage
        UARTLCRL       : in  std_logic_vector(7 downto 0);
                                                 -- 1st stage
        UARTILPR       : in  std_logic_vector(7 downto 0);
                                                 -- 1st stage
        
        Baud16         : out std_logic;	     -- Stream of UARTCLK-wide pulses
        IrLPBaud16     : out std_logic;	     -- For Low power IrDA
        LCRH           : out std_logic_vector(6 downto 1);
                                                 -- 2nd buffer
        Abort          : out std_logic;	     -- TX Abort
        Zerobaud       : out std_logic       -- Illegal divisor value
        );
end UartBaudCntr;

--------------------------------------------------------------------------------
-- Purpose     : This block contains the 16 bit down counters used to
--               generate the Baud16 signal
--------------------------------------------------------------------------------
--
--------------------------------------------------------------------------------
--
--                   UartBaudCntr
--                   ============
--
--------------------------------------------------------------------------------
--
-- Overview
-- ========
--
-- This block generates the Baud16 signal by dividing down the input clock
-- UARTCLK. It contains a 16-bit down-counter, which reloads to either the
-- LoadValue or (LoadValue + 1) every time it reaches one. The value loaded
-- depends on the carry part of an adder. This adder combined with the different
-- load values is used to generate a Fractional divider as well.
--
-- When the count reaches one, a one UARTCLK clock wide pulse is created
-- on the Baud16 signal.  This signal is used to add a fractional part to a
-- 6-bit adder and the carry output from this adder is used to control the load
-- value of the 16-bit counter described earlier.
--
-- This block also generates the IrLPBaud16 signal by dividing the
-- input UARTCLK by the value (IrDA Low Power Divisor). The 
-- SIRLPC counter that generates this signal is an 8-bit wide
-- down counter.
--
-- This module contains the second stage buffers for the LCR
-- registers (UARTLCRH, UARTLCRM and UARTLCRL) and the UARTILPR
-- register. Data on the corresponding first stage inputs are
-- clocked into the second stage buffers when the LCRStg2WrEn
-- signal or the ILPRStg2WrEn signal is asserted. 
-- The LCRStg2WrEn signal is generated by XORing the UpdateLCRSync
-- input with the internal delayed version of that signal. The
-- delayed version is only updated at the end of the character
-- being transmitted or received, so that the registers do not get
-- updated during transmission or reception.
-- The ILPRStg2WrEn signal is also generated in a similar manner.
--
--
--------------------------------------------------------------------------------
--
--=============================== ARCHITECTURE ===============================--
--
--------------------------------------------------------------------------------
-- Architecture Packages
--------------------------------------------------------------------------------

architecture synth of UartBaudCntr  is

--------------------------------------------------------------------------------
-- Internal Constants
--------------------------------------------------------------------------------
  constant FBRDAdderValue    : std_logic_vector(5 downto 0) := "011111";
  
--------------------------------------------------------------------------------
-- Internal Signals
--------------------------------------------------------------------------------
--------------------------------------------------------------------------------
-- LCRH , LCRM , LCRL and ILPR registers             
--------------------------------------------------------------------------------
  signal iLCRH               : std_logic_vector(6 downto 0);
  -- 2nd stage buffer for UARTLCRH

  signal NextLCRH            : std_logic_vector(6 downto 0);
  -- D-input for LCRH

  signal LCRM                : std_logic_vector(7 downto 0);
  -- 2nd stage buffer for UARTLCRM

  signal NextLCRM            : std_logic_vector(7 downto 0); 
  -- D-input for LCRH

  signal LCRL                : std_logic_vector(7 downto 0);
  -- 2nd stage buffer for UARTLCRL

  signal NextLCRL            : std_logic_vector(7 downto 0); 
  -- D-input for LCRL

  signal ILPR                : std_logic_vector(7 downto 0);
  -- 2nd stage buffer for UARTILPR

  signal NextILPR            : std_logic_vector(7 downto 0); 
  -- D-input for ILPR

  signal FBRD                : std_logic_vector(5 downto 0);
  -- 2nd stage buffer for UARTFBRD

  signal NextFBRD            : std_logic_vector(5 downto 0);
  -- D-input for FBRD

--------------------------------------------------------------------------------
-- Signals for current and next values of counter
--------------------------------------------------------------------------------
  signal LoadValue           : std_logic_vector(15 downto 0); 
  -- Counter that is used to generate the Baud16 signal

  signal CountBaud16         : std_logic_vector(15 downto 0);
  --  Counter that is used to generate the Baud16 signal

  signal NextCountBaud16     : std_logic_vector(15 downto 0);
  -- D-input of CountBaud16

  signal iSIRLPC             : std_logic_vector( 7 downto 0);
  -- Internal version of SIRLPC counter that is used to generate the IrLPBaud16
  -- signal

  signal NextSIRLPC          : std_logic_vector( 7 downto 0);
  -- D-input of iSIRLPC


--------------------------------------------------------------------------------
-- Delayed Bit 0 to detect 1 to 0 transition in the LSBit
--------------------------------------------------------------------------------
  signal LstCntBaud16Bit1    : std_logic;
  -- Delayed version of Bit 1 of CountBaud16

  signal LstSIRLPCBit0       : std_logic;  
  -- Delayed version of Bit 0 of SIRLPC

--------------------------------------------------------------------------------
-- signals for Baud16 signals
--------------------------------------------------------------------------------
  signal iBaud16              : std_logic;
  --  internal version of Baud16 signal

  signal iIrLPBaud16         : std_logic;
  -- Internal version of IrLPBaud16 signal

--------------------------------------------------------------------------------
-- Delayed versions of LCRUpdateSync, ILPRUpdateSync and FBRDUpdateSync
--------------------------------------------------------------------------------
  signal DelLCRUpdate        : std_logic;
  -- Delayed version of LCRUpdateSync

  signal DelILPRUpdate       : std_logic;
  -- Delayed version of ILPRUpdateSync

  signal DelFBRDUpdate       : std_logic;
  -- Delayed version of FBRDUpdateSync
  
  signal NextDelLCRUpdate        : std_logic;
  -- D-input of DelLCRUpdate

  signal NextDelILPRUpdate       : std_logic;
  -- D-input of ILPRUpdate

  signal NextDelFBRDUpdate       : std_logic;
  -- D-input of FBRDUpdate

  

--------------------------------------------------------------------------------
-- Load signals for second stage buffers 
--------------------------------------------------------------------------------
  signal LCRStg2WrEn         : std_logic;
  -- Load signal for 2nd stage LCR buffers

  signal ILPRStg2WrEn        : std_logic;
  -- Load signal for 2nd stage ILPR buffer

  signal DelLCRStg2WrEn      : std_logic;
  -- Delayed version of load signal for 2nd stage of LCR buffers

  signal DelILPRStg2WrEn     : std_logic;
  -- Delayed version of load signal for 2nd stage of ILPR buffer

  signal FBRDStg2WrEn        : std_logic;
  -- Load signal for 2nd stage FBRD buffers

  signal iZerobaud           : std_logic;
  -- internal version of Illegal divisor signal

  signal UARTFBRDCarry       : std_logic;
  -- Carry from Fractional baud rate counter
  
  signal NextUARTFBRDCarry   : std_logic;
  -- Carry from Fractional baud rate counter, next value
  
  signal UARTFBRDadd         : std_logic_vector(5 downto 0);
  -- Sum for fractional baud rate divider

  signal NextUARTFBRDadd     : std_logic_vector(6 downto 0);
  -- Output of addition for UARTFBRDadd

  signal FBRDadd1            : std_logic_vector(6 downto 0);
  -- Concatenation of 0 and FBRDadd for 1st part of addition

  signal FBRDadd2            : std_logic_vector(6 downto 0);
  -- Concatenation of 0 and FBRD for 2nd part of addition

  signal StopLPCntr          : std_logic;
  -- Stop Low power IrDa counter

  signal NextStopLPCntr      : std_logic;
  -- D-input of StopLPCntr
  
--------------------------------------------------------------------------------
--
-- Main VHDL code
-- ==============
--
--------------------------------------------------------------------------------

begin

--------------------------------------------------------------------------------
-- Generation of delayed versions of the Update trigger inputs. The
-- Delayed Update signals can only change once the current character has
-- completed.
--------------------------------------------------------------------------------
  p_DelSeq : process (UARTCLK, nUARTRST)
  begin
    if (nUARTRST = '0') then
      DelLCRUpdate  <= '0';
      DelILPRUpdate <= '0';
      DelFBRDUpdate <= '0';
    elsif (UARTCLK'event and UARTCLK = '1') then
      DelLCRUpdate  <= NextDelLCRUpdate;
      DelILPRUpdate <= NextDelILPRUpdate;
      DelFBRDUpdate <= NextDelFBRDUpdate;
      end if;
   end process p_DelSeq;


  p_DelComb : process (CharRxComp, CharTxComp, LCRUpdateSync, ILPRUpdateSync,
                       FBRDUpdateSync, DelLCRUpdate, DelILPRUpdate, DelFBRDUpdate)
    begin
       if((CharRxComp = '1') and (CharTxComp = '1')) then
        NextDelLCRUpdate  <= LCRUpdateSync;
        NextDelILPRUpdate <= ILPRUpdateSync;
        NextDelFBRDUpdate <= FBRDUpdateSync;
       else
         NextDelLCRUpdate  <= DelLCRUpdate;
         NextDelILPRUpdate <= DelILPRUpdate;
         NextDelFBRDUpdate <= DelFBRDUpdate;      
       end if;   
  end process p_DelComb;

--------------------------------------------------------------------------------
-- Generation of load signals for second stage buffers.
--------------------------------------------------------------------------------
  LCRStg2WrEn  <= (LCRUpdateSync  xor DelLCRUpdate) and (CharRxComp and CharTxComp); 
  ILPRStg2WrEn <= (ILPRUpdateSync xor DelILPRUpdate) and (CharRxComp and CharTxComp);
  FBRDStg2WrEn <= (FBRDUpdateSync xor DelFBRDUpdate) and (CharRxComp and CharTxComp);
  
--------------------------------------------------------------------------------
-- Write into LCRH , LCRM , LCRL and IrLPR registers  
--------------------------------------------------------------------------------
  p_RegWrComb : process(LCRStg2WrEn,ILPRStg2WrEn,FBRDStg2WrEn,iLCRH,LCRM,LCRL,ILPR,
                        FBRD,UARTLCRHInt,UARTLCRM,UARTLCRL,UARTILPR,FracValue)
  begin
    NextLCRH <= iLCRH;
    NextLCRM <= LCRM;
    NextLCRL <= LCRL;
    NextILPR <= ILPR;
    NextFBRD <= FBRD;
    if (LCRStg2WrEn = '1') then
      NextLCRH <= UARTLCRHInt;
      NextLCRM <= UARTLCRM;
      NextLCRL <= UARTLCRL;
    end if;

    if (ILPRStg2WrEn = '1') then
      NextILPR <= UARTILPR;
    end if;

    if (FBRDStg2WrEn = '1') then
      NextFBRD <= FracValue;
    end if;
  end process p_RegWrComb;

--------------------------------------------------------------------------------
-- Sequential process for write
--------------------------------------------------------------------------------
  p_RegWrSeq : process(UARTCLK, nUARTRST) 
  begin
    if(nUARTRST = '0') then
      iLCRH <= (others => '0');
      LCRM  <= (others => '0');
      LCRL  <= (others => '0');
      ILPR  <= (others => '0');
      FBRD  <= (others => '0');
    elsif(UARTCLK' event and UARTCLK = '1') then
      iLCRH <= NextLCRH;
      LCRM  <= NextLCRM;
      LCRL  <= NextLCRL;
      ILPR  <= NextILPR;
      FBRD  <= NextFBRD;
    end if;
  end process p_RegWrSeq;

--------------------------------------------------------------------------------
-- Assignment of the local copy to port   
--------------------------------------------------------------------------------
  LCRH <= iLCRH(6 downto 1);

--------------------------------------------------------------------------------
-- Delayed version of LCRStg2WrEn and IrLPRStg2WrEn
--------------------------------------------------------------------------------
   p_DelWrEn : process (UARTCLK, nUARTRST)
   begin
     if(nUARTRST = '0') then
       DelLCRStg2WrEn   <= '0';
       DelILPRStg2WrEn  <= '0';
     elsif(UARTCLK'event and UARTCLK = '1') then
       DelLCRStg2WrEn   <= LCRStg2WrEn;
       DelILPRStg2WrEn  <= ILPRStg2WrEn;
     end if;
   end process p_DelWrEn;

--------------------------------------------------------------------------------
-- Combining LCRM and LCRL registers
--------------------------------------------------------------------------------
  LoadValue <= LCRM & LCRL;

--------------------------------------------------------------------------------
-- Divide by n+1/n counter:
-- Reset the counter to its reload value whenever the StopBaudCnt signal is
-- asserted or when Zerbaud is asserted or when the count reaches one or when
-- the reloadvalue has been updated with a write to the MUBRLCR/LUBRLCR registers.
-- When the count reaches one, the counter will be reloaded with either n or n+1
-- depending on the state of the carry signal from the adder.
--------------------------------------------------------------------------------
    p_X16CntComb : process (CountBaud16, LoadValue,StopBaudCnt, UARTFBRDCarry,
                            DelLCRStg2WrEn, iZerobaud) 
  begin
    NextCountBaud16 <= CountBaud16;
    if ((StopBaudCnt = '1')  
        or (DelLCRStg2WrEn = '1') or (iZerobaud = '1')) then   
      NextCountBaud16 <= LoadValue;
    else
      if (CountBaud16 = "0000000000000001") then
        if (UARTFBRDCarry = '0') then
          NextCountBaud16 <= LoadValue;
        else
          NextCountBaud16 <= (UNSIGNED(LoadValue) + 1);
        end if;
      else
        NextCountBaud16   <= (UNSIGNED(CountBaud16) - 1);
      end if;
    end if;
  end process p_X16CntComb;

--------------------------------------------------------------------------------
-- Clock in the LSBit of the count to facilitate detection of a zero-to-one
-- transition.  LstCntBaud16Bit1 is generated from the divide by n/n+1 counter
-- and used to generate the Baud16 signal (high for 1 UARTCLK cycle).
--------------------------------------------------------------------------------
  p_X16CntSeq : process (UARTCLK, nUARTRST)
  begin
    if (nUARTRST = '0') then
      LstCntBaud16Bit1 <= '0';
      CountBaud16      <= (others => '0');
    elsif (UARTCLK'event and UARTCLK = '1') then
      LstCntBaud16Bit1 <= CountBaud16(0);
      CountBaud16      <= NextCountBaud16;
    end if;
  end process p_X16CntSeq;

--------------------------------------------------------------------------------
-- For the divide by n/n+1 counter:
-- Detect the counter counting down to one by seeing if the 
-- counter has reached one and the previous value of the 
-- LSBit is zero
--------------------------------------------------------------------------------
  iBaud16 <= '1' when (((LstCntBaud16Bit1 = '0') and  (CountBaud16 = "0000000000000001")) or
                        ((LoadValue = "0000000000000001") and (CountBaud16 = "0000000000000001")))
 
                  else
             '0';

--------------------------------------------------------------------------------
-- When the Baud16 signal is high, the adder is loaded with the fractional part.
-- Otherwise the adder retains it value. Also, at reset, the adder is
-- initialised with the value in FBRDAdderValue. This can be set to a non-zero
-- value to average out the pulse spread between /n and /(n+1).
--------------------------------------------------------------------------------
  p_AdderSeq : process(UARTCLK, nUARTRST) 
  begin
    if(nUARTRST = '0') then
      UARTFBRDadd   <= FBRDAdderValue;
    elsif(UARTCLK' event and UARTCLK = '1') then
      UARTFBRDadd   <= NextUARTFBRDadd(5 downto 0);
    end if;
  end process p_AdderSeq;

  -- Define the two values to add: M + CurrentAdderValue : Note that the MSB
  -- (Carry) in both is set to zero always.
  FBRDadd1 <= '0' & (UARTFBRDadd);
  FBRDadd2 <= '0' & (FBRD);
  
  p_AdderComb : process (FBRDadd1, FBRDadd2, StopBaudCnt, iBaud16)
  begin
    if (StopBaudCnt = '1') then
      NextUARTFBRDadd <= ('0' & FBRDAdderValue);      -- including carry
    else
      if (iBaud16 = '1') then
        NextUARTFBRDadd <= (UNSIGNED(FBRDadd1)) + (UNSIGNED(FBRDadd2));
      else
        NextUARTFBRDadd <= FBRDadd1;
      end if;
    end if;
  end process p_AdderComb;

  -- Once Carry is asserted, it should be held high for one Baud16 period, so that
  -- it can be used to load the 16-bit counter with n+1 (because it will have
  -- counted down to one). When carry is low and the counter has counted down,
  -- it should be loaded with n.
  p_CarrySeq : process(UARTCLK, nUARTRST)
  begin
    if(nUARTRST = '0') then
      UARTFBRDCarry <= '0';
    elsif(UARTCLK' event and UARTCLK = '1') then
      UARTFBRDCarry <= NextUARTFBRDCarry;
    end if;
  end process p_CarrySeq;

  p_CarryComb : process(StopBaudCnt, iBaud16, NextUARTFBRDadd, UARTFBRDCarry)
  begin
    if (StopBaudCnt = '1') then
      NextUARTFBRDCarry <= '0';
    elsif (iBaud16 = '1') then
      NextUARTFBRDCarry <= NextUARTFBRDadd(6);
    else
      NextUARTFBRDCarry <= UARTFBRDCarry;
    end if;
  end process p_CarryComb;
  
--------------------------------------------------------------------------------
-- If the Load value is 0 and the Fractional divisor value is 0, then
-- pull the Zerobaud output continuously  high, else Zerobaud is 0. 
--------------------------------------------------------------------------------
  p_ZeroBaud : process (LoadValue, FBRD)
  begin
    if ((LoadValue = "0000000000000000") or ((LoadValue = "1111111111111111")
        and (FBRD /= "000000"))) then 
      iZerobaud <= '1';
    else
      iZerobaud <= '0';
    end if;
  end process p_ZeroBaud;

-------------------------------------------------------------------
-- Assignment of the local copy to port
-------------------------------------------------------------------
  Zerobaud <= iZerobaud;


-------------------------------------------------------------------
-- Generation of StopLPCntr signal.
-- StopLPCntr is asserted when SIRENSync and SIRLPSync are both
-- deasserted and CharTxComp and CharRxComp are asserted. This signal
-- is used to stop the low power IrDa counter when the Uart is
-- operating in normal mode. The current character completes
-- transmission or reception before the counter stops.
-------------------------------------------------------------------

  p_StopLPCntrSeqComb : process(StopLPCntr, SIRENSync, SIRLPSync,
                                CharTxComp, CharRxComp)    
  begin
     NextStopLPCntr <= StopLPCntr;
    if ((SIRENSync = '0') and (SIRLPSync = '0') and
           (CharTxComp = '1') and (CharRxComp = '1')) then  
      NextStopLPCntr <= '1';
    elsif ((SIRENSync = '1') or (SIRLPSync = '1')) then
      NextStopLPCntr <= '0';     
    end if;
  end process p_StopLPCntrSeqComb;


  p_StopLPCntrSeq : process(UARTCLK, nUARTRST)
  begin
    if(nUARTRST = '0') then
      StopLPCntr <= '1';
    elsif(UARTCLK'event and UARTCLK ='1') then
      StopLPCntr <= NextStopLPCntr;
    end if;
  end process p_StopLPCntrSeq;

 
--------------------------------------------------------------------------------
-- IrLPBaud16 generation:
-- The counter is reloaded with it's initial value when any of the
-- following occur:
--   - the IrDa modes are both disabled and the current character has
--   - finished being transmitted or received.
--   - StopBaudCnt is asserted.
--   - the counter has counted down to 1.
--   - a new value has been written to the low power divisor register(ILPR)
--------------------------------------------------------------------------------
  p_SIRLPCComb : process(iSIRLPC, ILPR,StopBaudCnt, SIRENSync, SIRLPSync,
                         DelILPRStg2WrEn, StopLPCntr)    
  begin
    NextSIRLPC <= iSIRLPC;
    if ((StopBaudCnt = '1') or (DelILPRStg2WrEn = '1') or ((StopLPCntr = '1') and
                                (SIRENSync = '0') and (SIRLPSync = '0'))) then  
      NextSIRLPC <= ILPR;
    else
      if (iSIRLPC = "00000001") then
        NextSIRLPC <= ILPR ;
      else
        NextSIRLPC <= (UNSIGNED(iSIRLPC) - 1);
      end if;
    end if;
end process p_SIRLPCComb;
  
--------------------------------------------------------------------------------
-- Sequential process for the SIRLPC counter.
--------------------------------------------------------------------------------
  p_SIRLPCSeq : process(UARTCLK, nUARTRST)
  begin
    if(nUARTRST = '0') then
      LstSIRLPCBit0 <= '0';
      iSIRLPC       <= (others => '0');
    elsif(UARTCLK'event and UARTCLK ='1') then
      LstSIRLPCBit0 <= iSIRLPC(0);
      iSIRLPC       <= NextSIRLPC;
    end if;
  end process p_SIRLPCSeq;

--------------------------------------------------------------------------------
-- Detect the counter counting down to one by seeing if the 
-- counter has reached one and the previous value of the 
-- LSBit is zero. If ILPR is set to 1, then IrLPBaud16 is pulled high.
--------------------------------------------------------------------------------
  iIrLPBaud16 <= '1'    when (((LstSIRLPCBit0 = '0') and (iSIRLPC = "00000001")) or
                              ILPR = "00000001") else
                 '0';

--------------------------------------------------------------------------------
-- Assignment of the local copy to port   
--------------------------------------------------------------------------------
  IrLPBaud16  <= iIrLPBaud16;
  Baud16      <= iBaud16;
  
--------------------------------------------------------------------------------
-- Abort transmission if 
-- * 'BRK' bit in the LCRH is asserted
-- * zerobaud is asserted
--------------------------------------------------------------------------------
  Abort       <=  '1' when ((iLCRH(0) = '1') or (iZerobaud = '1')) else '0';

end synth;

--========================== End of UartBaudCntr =============================--













