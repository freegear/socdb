/* --=========================================================================--
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 2003 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
-- -----------------------------------------------------------------------------
--
--  Version and Release Control Information:
--
--  File Name              : AsyWRRDTests.c.rca
--  File Revision          : 1.8
--
--  Release Information    : PrimeCell(TM)-PL093-r0p3-00rel0
--
-- -----------------------------------------------------------------------------
-- Purpose :
--           Routines to perform different types of Asynchronous transfers.
--            
-- --=========================================================================*/

/******************************************************************************/
/************************* List of Functions Called ***************************/
/******************************************************************************/
/*** Function name                                      Located in          ***/
/*** ---------------------------------------------------------------------- ***/
/*** ConfigureMemory                                   SsmcCommon.c         ***/
/*** ConfigureUUT                                      SsmcCommon.c         ***/
/*** SingleWriteRead                                   SsmcCommon.c         ***/
/*** BurstWriteRead                                    SsmcCommon.c         ***/
/******************************************************************************/

/******************************************************************************/
/********************************** AsyWRRDTests *******************************/
/******************************************************************************/

void AsyWrRdTests()
{
  /*
     Summary: AsyWriteRead Tests
     =============================
     This function performs the following:

     o  Does the read/write operations with all combinations of
        - HSIZE values of BYTE, HWRD and WRD
        - Memory size of 8 bits, 16 bits and 32 bits
        - Different bursts
        - Bank values of 0 to 7
  */

  char report[100];
  
  struct parameters {
    int	  BANKNO; 
    int   HSIZE;
    int   MSIZE;
    int   WSTIDCY;
    int   WSTRD;
    int   WSTWR;
    int   WSTOEN;
    int   WSTWEN;
    int   WSTBRD;
    int   BURSTLENRD;
    int   BURSTLENWR;
    int   HBURST;
    int   RBLE;
  };

  struct caselist {
    char *CaseNumber;
    struct parameters *TestParams;
  };

  int Hsize, Msize;
  int32 BCRData, MemAddr1, TestData, WTCNCLData, ExtMuxData, SMBLSPOLData;
  int32 UnMask[3] = {0x000000FF, 0x0000FFFF, 0xFFFFFFFF};
  
  struct parameters *AsyWrRdParams ;

  /* 
     The parameters corresponds to the list of configurations defined for
     Test number "AsyWriteRead" in the block verification document.
     The BANKNO value as '9' indicates the end of the
     configurations, as in the last element of the parameters' list.       
  */
  
  struct parameters TestList1[85] = {
  0, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  1, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  2, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  3, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  4, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  5, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  6, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  7, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  0, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  1, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  2, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  3, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  4, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  5, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  6, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  7, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,   

  0, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  1, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  2, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  3, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  4, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  5, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  6, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  7, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,
  
  0, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  1, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  2, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  3, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  4, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  5, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  6, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  7, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  0, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  1, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  2, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  3, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  4, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  5, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  6, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  7, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,
   
  0, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  1, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  2, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  3, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  4, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  5, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  6, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  7, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  0, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  1, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  2, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  3, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  4, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  5, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  6, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  7, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,
 
  0, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  1, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  2, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  3, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  4, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  5, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  6, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  7, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,
   

  0, 32, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  1, 32, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  2, 32, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  3, 32, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  4, 32, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  5, 32, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  6, 32, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  7, 32, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList2[85] = {
  1, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  2, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  3, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  4, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  5, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  6, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  7, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  0, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  1, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  2, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  3, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  4, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  5, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  6, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  7, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  0, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  1, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  2, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  3, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  4, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  5, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  6, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  7, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  0, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  1, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  2, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  3, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  4, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  5, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  6, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  7, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  0, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  1, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  2, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  3, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  4, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  5, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  6, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  7, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  0, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  1, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  2, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  3, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  4, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  5, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  6, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  7, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  0, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  1, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  2, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  3, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  4, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  5, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  6, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  7, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  0, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  1, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  2, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  3, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  4, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  5, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  6, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  7, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  0, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  1, 32, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  2, 32, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  3, 32, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  4, 32, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  5, 32, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  6, 32, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  7, 32, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  0, 32, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList3[85] = {
  2, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  3, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  4, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  5, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  6, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  7, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  0, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  1, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  2, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  3, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  4, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  5, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  6, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  7, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  0, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  1, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  2, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  3, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  4, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  5, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  6, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  7, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  0, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  1, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  2, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  3, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  4, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  5, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  6, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  7, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  0, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  1, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  2, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  3, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  4, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  5, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  6, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  7, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  0, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  1, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  2, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  3, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  4, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  5, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  6, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  7, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  0, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  1, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,
  
  2, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  3, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  4, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  5, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  6, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  7, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  0, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  1, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  2, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  3, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  4, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  5, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  6, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  7, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  0, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  1, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  2, 32, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  3, 32, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  4, 32, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  5, 32, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  6, 32, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  7, 32, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  0, 32, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  1, 32, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9,  8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};


  struct parameters TestList4[85] = {
  3, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  4, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  5, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  6, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  7, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  0, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  1, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  2, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  3, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  4, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  5, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  6, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  7, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  0, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  1, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  2, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  3, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  4, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  5, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  6, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  7, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  0, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  1, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  2, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  3, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  4, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  5, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  6, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  7, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  0, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  1, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  2, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  3, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  4, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  5, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  6, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  7, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  0, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  1, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  2, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  3, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  4, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  5, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  6, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  7, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  0, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  1, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  2, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  3, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  4, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  5, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  6, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  7, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  0, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  1, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  2, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  3, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  4, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  5, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  6, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  7, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  0, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  1, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  2, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  3, 32, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  4, 32, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  5, 32, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  6, 32, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  7, 32, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  0, 32, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  1, 32, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  2, 32, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList5[85] = {
  4, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  5, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  6, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  7, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  0, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  1, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  2, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  3, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  4, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  5, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  6, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  7, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  0, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  1, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  2, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  3, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  4, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  5, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  6, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  7, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  0, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  1, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  2, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  3, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  4, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  5, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  6, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  7, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  0, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  1, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  2, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  3, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  4, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  5, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  6, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  7, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  0, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  1, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  2, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  3, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  4, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  5, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  6, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  7, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  0, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  1, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  2, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  3, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  4, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  5, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  6, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  7, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  0, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  1, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  2, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  3, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  4, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  5, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  6, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  7, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  0, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  1, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  2, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  3, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  4, 32, MW32, IC1,  RD1,  WR1, OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  5, 32, MW32, IC3,  RD5,  WR5, OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  6, 32, MW32, IC5,  RD9,  WR9, OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  7, 32, MW32, IC7, RD13, WR13, OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  0, 32, MW32, IC0, RD17, WR17, OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  1, 32, MW32, IC2, RD21, WR21, OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  2, 32, MW32, IC4, RD25, WR25, OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  3, 32, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW8, IC6, RD2, WR29, OEN6,  WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList6[85] = {
  5, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  6, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  7, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  0, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  1, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  2, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  3, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  4, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  5, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  6, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  7, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  0, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  1, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  2, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  3, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  4, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  5, 8, MW32, IC1,  RD1,  WR1, OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  6, 8, MW32, IC3,  RD5,  WR5, OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  7, 8, MW32, IC5,  RD9,  WR9, OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  0, 8, MW32, IC7, RD13, WR13, OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  1, 8, MW32, IC0, RD17, WR17, OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  2, 8, MW32, IC2, RD21, WR21, OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  3, 8, MW32, IC4, RD25, WR25, OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  4, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  5, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  6, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  7, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  0, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  1, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  2, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  3, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  4, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  5, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  6, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  7, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  0, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  1, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  2, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  3, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  4, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  5, 16, MW32, IC1,  RD1,  WR1, OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  6, 16, MW32, IC3,  RD5,  WR5, OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  7, 16, MW32, IC5,  RD9,  WR9, OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  0, 16, MW32, IC7, RD13, WR13, OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  1, 16, MW32, IC0, RD17, WR17, OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  2, 16, MW32, IC2, RD21, WR21, OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  3, 16, MW32, IC4, RD25, WR25, OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  4, 16, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,
  
  5, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  6, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  7, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  0, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  1, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  2, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  3, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  4, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  5, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  6, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  7, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  0, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  1, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  2, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  3, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  4, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  5, 32, MW32, IC1,  RD1,  WR1, OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  6, 32, MW32, IC3,  RD5,  WR5, OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  7, 32, MW32, IC5,  RD9,  WR9, OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  0, 32, MW32, IC7, RD13, WR13, OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  1, 32, MW32, IC0, RD17, WR17, OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  2, 32, MW32, IC2, RD21, WR21, OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  3, 32, MW32, IC4, RD25, WR25, OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  4, 32, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList7[85] = {
  6, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  7, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  0, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  1, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  2, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  3, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  4, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  5, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  6, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  7, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  0, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  1, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  2, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  3, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  4, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  5, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  6, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  7, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  0, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  1, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  2, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  3, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  4, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  5, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  6, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  7, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  0, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  1, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  2, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  3, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  4, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  5, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  6, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  7, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  0, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  1, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  2, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  3, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  4, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  5, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  6, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  7, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  0, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  1, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  2, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  3, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  4, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  5, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  6, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  7, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  0, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  1, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  2, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  3, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  4, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  5, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,
 
  6, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  7, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  0, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  1, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  2, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  3, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  4, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  5, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  6, 32, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  7, 32, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  0, 32, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  1, 32, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  2, 32, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  3, 32, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  4, 32, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  5, 32, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters TestList8[85] = {
  7, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  0, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  1, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  2, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  3, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  4, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  5, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  6, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  7, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  0, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  1, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  2, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  3, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  4, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  5, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  6, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  7, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  0, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  1, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  2, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  3, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  4, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  5, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  6, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  7, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  0, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  1, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  2, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  3, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  4, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  5, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  6, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,

  7, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  0, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  1, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  2, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  3, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  4, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  5, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  6, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  7, 16, MW32, IC1,  RD1,  WR1,  OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  0, 16, MW32, IC3,  RD5,  WR5,  OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  1, 16, MW32, IC5,  RD9,  WR9,  OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  2, 16, MW32, IC7, RD13, WR13,  OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  3, 16, MW32, IC0, RD17, WR17,  OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  4, 16, MW32, IC2, RD21, WR21,  OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  5, 16, MW32, IC4, RD25, WR25,  OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  6, 16, MW32, IC6, RD29, WR29,  OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  7, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0,  BRD0, BLRD4, BLWR4,   SIN, RBL0,
  0, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2,  BRD4, BLRD8, BLWR8,   INC, RBL0,
  1, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4,  BRD8, BLRD4, BLWR4,  INC4, RBL0,
  2, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BRD12, BLRD8, BLWR8,  INC8, RBL0,
  3, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BRD16, BLRD4, BLWR4, INC16, RBL0,
  4, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BRD20, BLRD8, BLWR8,  WRP4, RBL0,
  5, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BRD24, BLRD4, BLWR4,  WRP8, RBL0,
  6, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BRD28, BLRD8, BLWR8, WRP16, RBL0,
 
  7, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1,  BRD2, BLRD4, BLWR4,   SIN, RBL1,
  0, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3,  BRD6, BLRD8, BLWR8,   INC, RBL1,
  1, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BRD10, BLRD4, BLWR4,  INC4, RBL1,
  2, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BRD14, BLRD8, BLWR8,  INC8, RBL1,
  3, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BRD18, BLRD4, BLWR4, INC16, RBL1,
  4, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BRD22, BLRD8, BLWR8,  WRP4, RBL1,
  5, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BRD26, BLRD4, BLWR4,  WRP8, RBL1,
  6, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BRD30, BLRD8, BLWR8, WRP16, RBL1,

  7, 32, MW32, IC1,  RD1,  WR1, OEN1, WEN1,  BRD1, BLRD4, BLWR4,   SIN, RBL1,
  0, 32, MW32, IC3,  RD5,  WR5, OEN3, WEN3,  BRD5, BLRD8, BLWR8,   INC, RBL1,
  1, 32, MW32, IC5,  RD9,  WR9, OEN5, WEN5,  BRD9, BLRD4, BLWR4,  INC4, RBL1,
  2, 32, MW32, IC7, RD13, WR13, OEN7, WEN7, BRD13, BLRD8, BLWR8,  INC8, RBL1,
  3, 32, MW32, IC0, RD17, WR17, OEN0, WEN0, BRD17, BLRD4, BLWR4, INC16, RBL1,
  4, 32, MW32, IC2, RD21, WR21, OEN2, WEN2, BRD21, BLRD8, BLWR8,  WRP4, RBL1,
  5, 32, MW32, IC4, RD25, WR25, OEN4, WEN4, BRD25, BLRD4, BLWR4,  WRP8, RBL1,
  6, 32, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BRD29, BLRD8, BLWR8, WRP16, RBL1};


  /*
     The test cases and their corresponding parameters are listed here.
     The user can modify the 'caselist' to run the specific test cases.
     e.g., if the user wants to test only the first test case, the last
     element "ENDOFTEST" of the array may be put next to the AsyWriteRead_1
     test 
  */

  struct caselist AsyWrRdCaseList[10] = {
       "AsyWriteRead_1",   TestList1,
       "AsyWriteRead_2",   TestList2,
       "AsyWriteRead_3",   TestList3,
       "AsyWriteRead_4",   TestList4,
       "AsyWriteRead_5",   TestList5,
       "AsyWriteRead_6",   TestList6,
       "AsyWriteRead_7",   TestList7,
       "AsyWriteRead_8",   TestList8,
       "ENDOFTEST",        TestList1,
       "ENDOFTEST",        TestList1
       };

  struct caselist *TestCases = AsyWrRdCaseList;

  /*
      Programming SSMCCR and SSMCTrCR registers. The constants CLKRATIO and
      CLKSTATUS defined in the Ssmc.h set the required  MemClkRatioi and
      SMClockEn field bits.
  */
  SSMCCRDATA = CLKRATIO | CLKSTATUS;
  ConfigureCLKRatio(SSMCCRDATA);

  /*
      Programming the SSMCTrBurstWT register to turn the mask ON/OFF and to
      set the BeatNo and BurstWT counts. The constants BWtMask_ON/OFF,
      Beat0 to 15 and SSMCTrBurstWT0 to 15 are defined in Ssmc.h.
  */
  SSMCTrBurstWTData = BWtMask_ON | Beat15 | SSMCTrBurstWT15;
  ConfigureBurstWT(SSMCTrBurstWTData);

  /*
      Programming the SSMCTrWTCNCL register. The constant SMWTCNCLDI/EN
      disables or Enables the SMCANCELWait signal. The constant SMWAITIGNORE_0/1
      enables or disables the SMWAITIGNORE respectively and the constants
      WTCNCL0 to 63 are used to load the CANCEL WAIT count.
  */
  WTCNCLData = SMWTCNCLDI | SMWAITIGNORE_1 | WTCNCL10 ;
  HSA(SSMCTrWTCNCL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,WTCNCLData);

  /** Configuring the system to LITTLE endian mode **/
  ENDIANNESS = 0;
  HSA(SSMCTrEndian, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ENDIANNESS);
  HSEN(LITTLE);

  /*
      Programming the SSMCTrExtMuxWT register.The constant ExtMuxDI/EN disables
      or enables the  External Mux. The constants ExtMuxAss0 to 15 and
      ExtMuxDAss0 to 15 define the Assertion and Deassertion counts.
  */
  ExtMuxData = ExtMuxAss5 | ExtMuxDAss5 | ExtMuxDI;
  HSA(SSMCTrExtMux, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ExtMuxData);

  /** Programming the SSMCTrSMBLSPOL register **/
  SMBLSPOLData = SMBLSPOL_0;
  HSA(SSMCTrSMBLSPOL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,SMBLSPOLData);

  while (TestCases->CaseNumber != "ENDOFTEST")
  {
    sprintf(Message,"TEST NO : %s", TestCases-> CaseNumber);
    C(Message);

    AsyWrRdParams = TestCases->TestParams;
   while (AsyWrRdParams->BANKNO != 9)
   {

  /** Writing and Reading from the Memory before it's configured **/
  MemAddr1 = SSMCMEM_1 + (SSMCTrMEMBData[1] << 11);
  HSA(MemAddr1, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,0x55555555);
  HSA(MemAddr1, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSR( , 0x55555555, , NoMask, ,AsyWRRDTests_0);

  /* 
     Set the offset for the memory to zero.The offset can be given a new value 
     by changing the value of the variable SSMCTrMEMBData 
  */ 
  
  SSMCTrMEMBData[AsyWrRdParams -> BANKNO ] = 0x00000000;
  
  /* 
    The control register fields are configured as per the requirement.
    Also the value for the CRWAITEN_EN is derived from shifting the value
    of the RBLE constant.This is done so that the Bank gets programmmed with
    the extetrnal wait enaled when it's width is 16 & 32 bit.When the width is
    8 bit the bank gets programmed with the external width disabled.

    If it is required that the bank be programmed with external wait enabled or
    diasbled the constants CRWAITEN_EN or CRWAITEN_DI can be substituted in 
    place of (AsyWrRdParams -> RBLE << 2 )  

    A similar way as described above is adopted when the SSMCTrCS2WTRData
    is calculated .To enable or disable the external wait for the TrickMem
    the constants TRWAITEN_EN or TRWAITEN_DI can be used instead of calculating
    the value using the RBLE constant respectively
  */
  BCRData     =   CRADDRVALIDWR_DI              | 
                  CRADDRVALIDRD_DI              |
                  CRSYNCENWR_ASY                | 
                  CRSYNCENRD_ASY                |
                  CRBMWRITE_EN                  |
                  CRBMREAD_EN                   |
                  CRWP_DI                       |
                  WRAPRD_DI                     |
                  (AsyWrRdParams -> RBLE << 2 ) |
                  CRWAITPOL_0                   |
                  AsyWrRdParams -> BURSTLENWR   |
                  AsyWrRdParams -> BURSTLENRD   |
                  BIWRITE_DI                    |
                  BIREAD_DI                     |
                  SMBLSPOL_0                    |
                  AsyWrRdParams -> RBLE         |
		  AsyWrRdParams -> MSIZE;

  SSMCTrCS2WTRData[AsyWrRdParams -> BANKNO] = (AsyWrRdParams -> RBLE << 4 ) |
                                               TRWAITPOL_0 | 
                                               TRCS2WTR2   | TRWT2DEWT2; 

  ConfigureUUT(AsyWrRdParams -> BANKNO, 
               AsyWrRdParams -> WSTIDCY, 
               AsyWrRdParams -> WSTRD,
               AsyWrRdParams -> WSTWR, 
               AsyWrRdParams -> WSTOEN, 
               AsyWrRdParams -> WSTWEN,
               BCRData,
               SSMCTrCS2WTRData[AsyWrRdParams -> BANKNO],
               AsyWrRdParams -> WSTBRD );

  ConfigureMemory(AsyWrRdParams -> BANKNO,
                  SSMCTrMEMBData[AsyWrRdParams -> BANKNO ]);  
                  

  /** Generate TestData depending on the HSIZE **/
  switch(AsyWrRdParams -> HSIZE)
  {
    case 8 : TestData = ~(AsyWrRdParams -> BANKNO) & UnMask[0];
             break;

    case 16 : TestData = ~(AsyWrRdParams -> BANKNO) & UnMask[1];
              break;

    case 32 : TestData = ~(AsyWrRdParams -> BANKNO) & UnMask[2];
              break;
  } 

  /* 
      Assign values to Hsize  depending on the HSIZE values in testcases 
      Hsize = 0, 1, 2 when HSIZE = 8, 16, 32 respectively 
  */
  switch(AsyWrRdParams -> HSIZE)
  {
    case  8 : Hsize = 0;
              break;

    case 16 : Hsize = 1;
              break;

    case 32 : Hsize = 2;
              break;
  }

  /* 
    Assign values to Msize  depending on the MSIZE values in testcases 
    Msize = 0, 1, 2 when MSIZE = 8, 16, 32 respectively                    
  */
  switch(AsyWrRdParams -> MSIZE)
  {
    case MW8 : Msize = 0;
               break;

    case MW16 : Msize = 1;
                break;
    
    case MW32 : Msize = 2;
                break;
  }

  /*
     Perform BurstWrite followed by BurstRead on the selected Bank for the 
     given set of parameters values as listed in the AsyWriteRead in the
     verification plan.Also verify the data form the AHB side
  */ 
     BurstWriteRead(AsyWrRdParams -> BANKNO,
                    AsyWrRdParams -> HBURST,
                    0x00,
                    Hsize,
                    Msize, 
                    TestData);

    AsyWrRdParams++;
   }
   TestCases++;
  }
}


/********************************** END ***************************************/
