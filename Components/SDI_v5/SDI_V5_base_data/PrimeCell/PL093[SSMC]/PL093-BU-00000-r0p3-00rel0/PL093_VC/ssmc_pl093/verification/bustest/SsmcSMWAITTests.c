/*--=========================================================================--
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 2003 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
-- -----------------------------------------------------------------------------
--
--  Version and Release Control Information:
--
--  File Name              : SsmcSMWAITTests.c.rca
--  File Revision          : 1.8
--
--  Release Information    : PrimeCell(TM)-PL093-r0p3-00rel0
--
-- -----------------------------------------------------------------------------
-- Purpose :
--           Routines to perform tests on external wait functionality of the
--           SSMC.
--
-- --=========================================================================*/

/******************************************************************************/
/************************* List of Functions Called ***************************/
/******************************************************************************/
/*** Function name                                      Located in          ***/
/*** ---------------------------------------------------------------------- ***/
/*** ConfigureMemory                                    SsmcCommon.c        ***/
/*** ConfigureUUT                                       SsmcCommon.c        ***/
/*** SingleWriteRead                                    SsmcCommon.c        ***/
/*** BurstWriteRead                                     SsmcCommon.c        ***/
/******************************************************************************/


/******************************************************************************/
/******************************** SMWAIT Tests ********************************/
/******************************************************************************/

void SsmcSMWAITTests()
{
  /*
     Summary: SMWAIT Tests
     =====================
     This function performs the following:

     o  SMWAIT signal is asserted and de-asserted in various possible ways
     o  Repeats tests for read and write accesses and different polarities
  */

   char report[100];

  struct parameters {
    int   BANKNO;
    int   MSIZE;
    int   RBLE;
    int   WAITEN;
    int   WAITPOL;
    int   WTIGNORE;
    int   CS2WT;
    int   WT2DEWT;
    int   WTCNCL; 
  };


  struct caselist {
    char *CaseNumber;
    struct parameters *TestParams;
  };

  int n, i;
  char* ExpResp = OK;
  int32 SMBCRAddr, SSMCTrCS2WTAddr, SMBSRAddr, MemAddr, TestWrite = 0x00000000;
  int32 BCRData, CS2WTRData, BSRData, WTCNCLData, Mask, MemAddr2, ExtMuxData,
        SMBLSPOLData, TestData = 0x00000000 ;


  struct parameters *SsmcSMWAITParams ;

  /* The parameters corresponds to the list of configurations defined for
     Test number "SsmcSMWAITTests" in the block verification document.
     The BANKNO value as '9' indicates the end of the
     configurations, as in the last element of the parameters' list.       */

  struct parameters B0Cases[90] = {
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  0, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  0, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  0, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B1Cases[90] = {
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  1, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  1, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  1, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B2Cases[90] = {
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  2, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  2, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  2, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B3Cases[90] = {
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  3, MW32, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  3, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  3, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW32, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B4Cases[90] = {
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,
 
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  4, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  4, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B5Cases[90] = {
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  5, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  5, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B6Cases[90] = {
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  6, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  6, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };

  struct parameters B7Cases[90] = {
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  7, MW16, RBLE_1, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR3,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR3, WT2DEWT21, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1,  CS2WTR5,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1,  CS2WTR5, WT2DEWT21, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT3, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR10,  WT2DEWT5, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT10, WTCNCL63,
  7, MW8, RBLE_0, WTEN, WTPOL1, WTIG1, CS2WTR10, WT2DEWT21, WTCNCL63,

  9, MW8, RBLE_0, WTEN, WTPOL0, WTIG1, CS2WTR18, WT2DEWT1, WTCNCL63 };


  /* The test cases and their corresponding parameters are listed here.
     The user can modify the 'caselist' to run the specific test cases.
     e.g., if the user wants to test only the first test case, the last
     element "ENDOFTEST" of the array may be put next to the SsmcSMWAIT_B0
     test */
  struct caselist SsmcSMWAITCaseList[11] = {
       "SsmcSMWAIT_B0",    B0Cases,
       "SsmcSMWAIT_B1",    B1Cases,
       "SsmcSMWAIT_B2",    B2Cases,
       "SsmcSMWAIT_B3",    B3Cases,
       "SsmcSMWAIT_B4",    B4Cases,
       "SsmcSMWAIT_B5",    B5Cases,
       "SsmcSMWAIT_B6",    B6Cases,
       "SsmcSMWAIT_B7",    B7Cases,
       "ENDOFTEST",        B0Cases,
       "ENDOFTEST",        B0Cases
       };


  struct caselist *TestCases = SsmcSMWAITCaseList;
 

  /*
      Programming SSMCCR and SSMCTrCR registers. The constants CLKRATIO and
      CLKSTATUS defined in the Ssmc.h set the required  MemClkRatio and
      SMClockEn field bits.
  */
  SSMCCRDATA = CLKRATIO | CLKSTATUS;
  ConfigureCLKRatio(SSMCCRDATA);

  /*
      Programming the SSMCTrBurstWT register to turn the mask ON/OFF and to
      set the BeatNo and BurstWT counts. The constants BWtMask_ON/OFF,
      Beat0 to 15 and SSMCTrBurstWT0 to 15 are defined in Ssmc.h.
  */
  SSMCTrBurstWTData = BWtMask_ON | Beat15 | SSMCTrBurstWT15;
  ConfigureBurstWT(SSMCTrBurstWTData);

  /*
      Programming the SSMCTrWTCNCL register. The constant SMWTCNCLDI/EN
      disables or Enables the SMCANCELWait signal. The constant SMWAITIGNORE_0/1
      enables or disables the SMWAITIGNORE respectively and the constants
      WTCNCL0 to 63 are used to load the CANCEL WAIT count.
  */
  WTCNCLData = SMWTCNCLDI | SMWAITIGNORE_1 | WTCNCL10 ;
  HSA(SSMCTrWTCNCL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,WTCNCLData);

  /** Configuring the system to LITTLE endian mode by setting ENDIANNESS = 0 **/
  ENDIANNESS = 0;
  HSA(SSMCTrEndian, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ENDIANNESS);
  HSEN(LITTLE);

  /*
      Programming the SSMCTrExtMuxWT register.The constant ExtMuxDI/EN disables
      or enables the  External Mux. The constants ExtMuxAss0 to 15 and
      ExtMuxDAss0 to 15 define the Assertion and Deassertion counts.
  */
  ExtMuxData = ExtMuxAss5 | ExtMuxDAss5 | ExtMuxDI;
  HSA(SSMCTrExtMux, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ExtMuxData);

  /** Programming the SSMCTrSMBLSPOL register **/
  SMBLSPOLData = SMBLSPOL_0;
  HSA(SSMCTrSMBLSPOL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,SMBLSPOLData);

 
/*************************** CONFIGURING THE BANKS ****************************/
  
  sprintf(Message,"CONFIGURING THE SSMC & MEMORY BANKS WITH SMWAIT ENABLED");
  msg_info(Message);

  /** Set Bank 0 Memory Type as SRAM (32 bits width) **/
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SSMCTrMEMBData[0] = 0x00000000;

  SMBCRData[0] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_1      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW32           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[0] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR1 | TRWT2DEWT2;

  ConfigureUUT(BANK0, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[0], SSMCTrCS2WTRData[0], WSTBRD2);

  ConfigureMemory(BANK0, SSMCTrMEMBData[0]);

  /** Set Bank 1 Memory Type as SRAM (32 bits width) **/
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SSMCTrMEMBData[1] = 0x00000000;
  SMBCRData[1] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW32           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[1] = TRWAITEN_EN | TRWAITPOL_0 | TRCS2WTR1 | TRWT2DEWT1;


  ConfigureUUT(BANK1, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[1], SSMCTrCS2WTRData[1], WSTBRD2);

  ConfigureMemory(BANK1, SSMCTrMEMBData[1]);

  /** Set Bank 2 Memory Type as SRAM (32 bits width) **/
  SSMCTrMEMBData[2] = 0x00000000;
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case enabled **/
  SMBCRData[2] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW32           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[2] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK2, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[2], SSMCTrCS2WTRData[2], WSTBRD2);

  ConfigureMemory(BANK2, SSMCTrMEMBData[2]);

  /** Set Bank 3 Memory Type as SRAM (32 bits width) **/
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case enabled **/
  SSMCTrMEMBData[3] = 0x00000000;
  SMBCRData[3] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW32           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[3] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK3, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[3], SSMCTrCS2WTRData[3], WSTBRD2);

  ConfigureMemory(BANK3, SSMCTrMEMBData[3]);

  /** Set Bank 4 Memory Type as SRAM (16 bits width) **/
  SSMCTrMEMBData[4] = 0x00000000;
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SMBCRData[4] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW16           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[4] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK4, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[4], SSMCTrCS2WTRData[4], WSTBRD2);

  ConfigureMemory(BANK4, SSMCTrMEMBData[4]);

  /** Set Bank 5 Memory Type as SRAM (16 bits width) **/
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SSMCTrMEMBData[5] = 0x00000000;
  SMBCRData[5] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW16           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[5] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK5, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[5], SSMCTrCS2WTRData[5], WSTBRD2);

  ConfigureMemory(BANK5, SSMCTrMEMBData[5]);

  /** Set Bank 6 Memory Type as SRAM (8 bits width) **/
  SSMCTrMEMBData[6] = 0x00000000;
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SMBCRData[6] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW8            | RBLE_0           | SMBLSPOL_0;

  SSMCTrCS2WTRData[6] = TRWAITEN_EN | TRWAITPOL_0 | TRCS2WTR1 | TRWT2DEWT1;

  ConfigureUUT(BANK6, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[6], SSMCTrCS2WTRData[6], WSTBRD2);

  ConfigureMemory(BANK6, SSMCTrMEMBData[6]);


  /** Set Bank 7 Memory Type as SRAM (8 bits width) **/
  /** ExtWait Enabled, WaitPol = 0 **/
  /** Boundary Case disabled **/
  SSMCTrMEMBData[7] = 0x00000000;
  SMBCRData[7] = CRADDRVALIDWR_DI | CRADDRVALIDRD_DI |
                 CRSYNCENWR_ASY   | CRSYNCENRD_ASY   |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        |
                 CRWAITEN_EN      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW8            | RBLE_0           | SMBLSPOL_0;

  SSMCTrCS2WTRData[7] = TRWAITEN_EN | TRWAITPOL_0 | TRCS2WTR1 | TRWT2DEWT1;

  ConfigureUUT(BANK7, WSTIDCY9, WSTRD15, WSTWR15, WSTOEN0, WSTWEN0,
               SMBCRData[7], SSMCTrCS2WTRData[7], WSTBRD2);

  ConfigureMemory(BANK7, SSMCTrMEMBData[7]);


/****************************** STARTING EXECUTION ***************************/

  C("EXECUTNING THE CASELIST OF THE DIFFERENT BANKS"); 
 
  while (TestCases->CaseNumber != "ENDOFTEST")
  {

   sprintf(report,"EXECUTING TESTCASES IN TEST No : %s", TestCases->CaseNumber);
   C(report);
   SsmcSMWAITParams = TestCases->TestParams;
   i = 1;
   while (SsmcSMWAITParams -> BANKNO != 9)
   {
    /** CONFIGURING THE SSMC & THE MEMORY BANKS WITH SMWAIT ENABLED **/
    
   sprintf(report,"            TESTCASE NUMBER : %d ", i); 
   C(report); 
   /** Set the offset for the memory to zero **/
   SSMCTrMEMBData[SsmcSMWAITParams -> BANKNO ] = 0x00000000;
  
   /** CALCULATING THE VALUE FOR THE BCR REGISTER **/  
   /** The control register fields are configured as per the requirement **/
    BCRData     =   CRADDRVALIDWR_DI |
                    CRADDRVALIDRD_DI |
                    CRSYNCENWR_ASY   |
                    CRSYNCENRD_ASY   |
                    CRBURSTLENWR4    |
                    CRBURSTLENRD4    |
                    CRBMWRITE_EN     |
                    CRBMREAD_EN      |
                    SsmcSMWAITParams -> MSIZE |
                    CRWP_DI          |
                    WRAPRD_DI        |
                    BIWRITE_DI       |
                    BIREAD_DI        |
                    SMBLSPOL_0       |
                    ((SsmcSMWAITParams -> WAITEN) >> 9) |/* Used to enable ext*/ 
                    ((SsmcSMWAITParams -> WAITPOL) >> 9)|/* wait in uut when  */
                    SsmcSMWAITParams -> RBLE;            /*enabled in trickmem*/

    /** CALCULATING THE VALUE OF THE CS2WTRData **/
    CS2WTRData = SsmcSMWAITParams -> WAITEN  |
                 SsmcSMWAITParams -> WAITPOL |
                 SsmcSMWAITParams -> CS2WT   | 
                 SsmcSMWAITParams -> WT2DEWT; 

    /** INITIALLY FILL THE MEMORY BANK WITH 0s **/
    AHBFillMem(SsmcSMWAITParams -> BANKNO, 0, 4, 0x00000000);

    switch (SsmcSMWAITParams -> BANKNO)
    {
      case 0 : SMBCRAddr = SMBCR0;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR0;
               SMBSRAddr  = SMBSR0;
               MemAddr = SSMCMEM_0 + (SSMCTrMEMBData[0] << 11);
               break;
      case 1 : SMBCRAddr = SMBCR1;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR1;
               SMBSRAddr  = SMBSR1;
               MemAddr = SSMCMEM_1 + (SSMCTrMEMBData[1] << 11);
               break;
      case 2 : SMBCRAddr = SMBCR2;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR2;
               SMBSRAddr  = SMBSR2;
               MemAddr = SSMCMEM_2 + (SSMCTrMEMBData[2] << 11);
               break;
      case 3 : SMBCRAddr = SMBCR3;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR3;
               SMBSRAddr  = SMBSR3;
               MemAddr = SSMCMEM_3 + (SSMCTrMEMBData[3] << 11);
               break;
      case 4 : SMBCRAddr = SMBCR4;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR4;
               SMBSRAddr  = SMBSR4;
               MemAddr = SSMCMEM_4 + (SSMCTrMEMBData[4] << 11);
               break;
      case 5 : SMBCRAddr = SMBCR5;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR5;
               SMBSRAddr  = SMBSR5;
               MemAddr = SSMCMEM_5 + (SSMCTrMEMBData[5] << 11);
               break;
      case 6 : SMBCRAddr = SMBCR6;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR6;
               SMBSRAddr  = SMBSR6;
               MemAddr = SSMCMEM_6 + (SSMCTrMEMBData[6] << 11);
               break;
      case 7 : SMBCRAddr = SMBCR7;
               SSMCTrCS2WTAddr = SSMCTrCS2WTR7;
               SMBSRAddr  = SMBSR7;
               MemAddr = SSMCMEM_7 + (SSMCTrMEMBData[7] << 11);
               break;

      default : break;
    }

    /** RECONFIGURING THE SMBCR REGISTER **/
    HSA(SMBCRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
    HSW( ,BCRData);

    /** RECONFIGURING THE SSMCTrCS2WT REGISTER **/
    HSA(SSMCTrCS2WTAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
    HSW( ,CS2WTRData);

    /** PROGRAMMING THE SSMCTrWTCNCL REGISTER WITH CANCEL WAIT ENABLED **/
    WTCNCLData = SMWTCNCLEN                   |
                 SsmcSMWAITParams -> WTIGNORE |
                 SsmcSMWAITParams -> WTCNCL ; 
    HSA(SSMCTrWTCNCL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
    HSW( ,WTCNCLData);

    if ((SsmcSMWAITParams -> WT2DEWT       > 32 ) && 
        ((SsmcSMWAITParams -> CS2WT  >> 5) < 32 )) 
       
        {
          BSRData = 0x01;
          ExpResp = ERROR;
          Mask = MaskAll;
        } else
        {
          BSRData = 0x00;
          ExpResp = OK;
          Mask = NoMask;
        }
     
   /** PERFORMING WRITES INTO THE MEMORY THROUGH THE SSMC  **/
       TestData = TestWrite;
       HSA(MemAddr, NSEQ, INCR, ExpResp, WRD, , 0x1, , , , ,);
       HSW( ,TestData++);
       for (n=0; n<3; n++)
         HSW( ,TestData++);

   /** READING THE DATA FROM THE MEMORY THROUGH THE SSMC  **/
       TestData = TestWrite;
       HSA(MemAddr, NSEQ, INCR, ExpResp, WRD, , 0x1, , , , ,);
       HSR( , TestData & Mask, , NoMask, ,SsmcSMWAITTests_1);
       for (n=0, TestData++; n<3; n++, TestData++)
         HSR( , TestData & Mask, , NoMask, ,SsmcSMWAITTests_2);

   /** PROGRAMMING SSMCTrWTCNCL REGISTER TO DISABLE THE EXTERNAL CANCEL WAIT **/
    WTCNCLData = SMWTCNCLDI                   |
                 SsmcSMWAITParams -> WTIGNORE |
                 SsmcSMWAITParams -> WTCNCL ; 
    HSA(SSMCTrWTCNCL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
    HSW( ,WTCNCLData);

  /** POLLING AND THEN READING THE STATUS REGISTER  **/
      HSA(SMBSRAddr, NSEQ, SINGLE, , WRD, , 0x0, , , , ,);
      HPO( , BSRData, , NoMask, , 0xFF,SsmcSMWAITTests_3);
      HSA(SMBSRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
      HSR( , BSRData, , NoMask, ,SsmcSMWAITTests_3);

  /** CLEARING THE STATUS REGISTER BY WRITING 1's INTO THE REGISTER **/
      HSA(SMBSRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
      HSW( ,0x07);
      HSA(SMBSRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
      HSW( ,0x07);
      HSA(SMBSRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
      HSW( ,0x07);
      HSA(SMBSRAddr, NSEQ, INCR, , WRD, , 0x1, , , , ,);
      HSW( ,0x07);

      SsmcSMWAITParams++;
      i++;
   }
   TestCases++;
  }
}



/************************************ End *************************************/
