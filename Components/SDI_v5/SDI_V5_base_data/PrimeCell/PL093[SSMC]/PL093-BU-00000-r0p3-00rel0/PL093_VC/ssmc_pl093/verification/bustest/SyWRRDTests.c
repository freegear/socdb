/* --=========================================================================--
--  This confidential and proprietary software may be used only as
--  authorised by a licensing agreement from ARM Limited
--    (C) COPYRIGHT 2003 ARM Limited
--        ALL RIGHTS RESERVED
--  The entire notice above must be reproduced on all authorised
--  copies and copies may only be made to the extent permitted
--  by a licensing agreement from ARM Limited.
-- -----------------------------------------------------------------------------
--
--  Version and Release Control Information:
--
--  File Name              : SyWRRDTests.c.rca
--  File Revision          : 1.8
--
--  Release Information    : PrimeCell(TM)-PL093-r0p3-00rel0
--
-- -----------------------------------------------------------------------------
-- Purpose :
--           Routines to perform different types of Synchronous transfers.
--            
-- --=========================================================================*/

/******************************************************************************/
/************************* List of Functions Called ***************************/
/******************************************************************************/
/*** Function name                                      Located in          ***/
/*** ---------------------------------------------------------------------- ***/
/*** ConfigureMemory                                    SsmcCommon.c        ***/
/*** ConfigureUUT                                       SsmcCommon.c        ***/
/*** SingleWriteRead                                    SsmcCommon.c        ***/
/*** BurstWriteRead                                     SsmcCommon.c        ***/
/******************************************************************************/

/******************************************************************************/
/********************************** SyWRRDTests *******************************/
/******************************************************************************/

void SyWrRdTests()
{
  /*
     Summary: SyWriteRead Tests
     =============================
     This function performs the following:

     o  Does the read/write operations with all combinations of
        - HSIZE values of BYTE, HWRD and WRD
        - Memory size of 8 bits, 16 bits and 32 bits
        - Different bursts
        - Bank values of 0 to 7
  */

  char report[100];
  
  struct parameters {
    int	  BANKNO; 
    int   HSIZE;
    int   MSIZE;
    int   WSTIDCY;
    int   WSTRD;
    int   WSTWR;
    int   WSTOEN;
    int   WSTWEN;
    int   BURSTLENRD;
    int   BURSTLENWR;
    int   HBURST;
    int   RBLE;
  };

  struct caselist {
    char *CaseNumber;
    struct parameters *TestParams;
  };

  int Hsize, Msize;
  int32 BCRData, MemAddr1, TestData, WTCNCLData, ExtMuxData, SMBLSPOLData;
  int32 UnMask[3] = {0x000000FF, 0x0000FFFF, 0xFFFFFFFF};
  
  struct parameters *SyWrRdParams ;

  /* The parameters corresponds to the list of configurations defined for
     Test number "SyWriteRead" in the block verification document.
     The BANKNO value as '9' indicates the end of the
     configurations, as in the last element of the parameters' list.       */
  
  struct parameters B0Cases[85] = {
  0, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  0, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  0, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  0, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  0, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  0, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  0, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  0, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  0, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  0, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  0, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  0, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  0, 8, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 8, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 8, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 8, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 8, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  0, 8, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  0, 8, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  0, 8, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  0, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  0, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  0, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  0, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  0, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  0, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  0, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  0, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  0, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  0, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  0, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  0, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  0, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  0, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  0, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  0, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,
 
  0, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  0, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  0, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  0, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  0, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  0, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  0, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  0, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  0, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  0, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  0, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  0, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  0, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  0, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  0, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  0, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  0, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  0, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  0, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  0, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters B1Cases[85] = {
  1, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  1, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  1, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  1, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  1, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  1, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  1, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  1, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  1, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  1, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  1, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  1, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  1, 8, MW32, IC1,  RD1,  WR1, OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 8, MW32, IC3,  RD5,  WR5, OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 8, MW32, IC5,  RD9,  WR9, OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 8, MW32, IC7, RD13, WR13, OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 8, MW32, IC0, RD17, WR17, OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  1, 8, MW32, IC2, RD21, WR21, OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  1, 8, MW32, IC4, RD25, WR25, OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  1, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,

  1, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  1, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  1, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  1, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  1, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  1, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  1, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  1, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  1, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  1, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  1, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  1, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  1, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  1, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  1, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  1, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  1, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  1, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  1, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  1, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  1, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  1, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  1, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  1, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  1, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  1, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  1, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  1, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  1, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  1, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  1, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  1, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  1, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  1, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  1, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  1, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters B2Cases[85] = {
  2, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  2, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  2, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  2, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  2, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  2, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  2, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  2, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  2, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  2, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  2, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  2, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  2, 8, MW32, IC1,  RD1,  WR1, OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 8, MW32, IC3,  RD5,  WR5, OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 8, MW32, IC5,  RD9,  WR9, OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 8, MW32, IC7, RD13, WR13, OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 8, MW32, IC0, RD17, WR17, OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  2, 8, MW32, IC2, RD21, WR21, OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  2, 8, MW32, IC4, RD25, WR25, OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  2, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,

  2, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  2, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  2, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  2, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  2, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  2, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  2, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  2, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  2, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  2, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  2, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  2, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  2, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  2, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  2, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  2, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  2, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  2, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  2, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  2, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  2, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  2, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  2, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  2, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  2, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  2, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  2, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  2, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  2, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  2, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  2, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  2, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  2, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  2, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  2, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  2, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};


  struct parameters B3Cases[85] = {
  3, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  3, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  3, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  3, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  3, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  3, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  3, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  3, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  3, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  3, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  3, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  3, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  3, 8, MW32, IC1,  RD1,  WR1, OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 8, MW32, IC3,  RD5,  WR5, OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 8, MW32, IC5,  RD9,  WR9, OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 8, MW32, IC7, RD13, WR13, OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 8, MW32, IC0, RD17, WR17, OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  3, 8, MW32, IC2, RD21, WR21, OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  3, 8, MW32, IC4, RD25, WR25, OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  3, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,

  3, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  3, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  3, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  3, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  3, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  3, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  3, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  3, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,
 
  3, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  3, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  3, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  3, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  3, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  3, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  3, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  3, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  3, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  3, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  3, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  3, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  3, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  3, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  3, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  3, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,
 
  3, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  3, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  3, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  3, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  3, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  3, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  3, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  3, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  3, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  3, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  3, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  3, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};
 
  struct parameters B4Cases[85] = {
  4, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  4, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  4, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  4, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  4, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  4, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  4, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  4, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  4, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  4, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  4, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  4, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  4, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  4, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  4, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  4, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,

  4, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  4, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  4, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  4, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  4, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  4, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  4, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  4, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  4, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  4, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  4, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  4, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  4, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  4, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  4, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  4, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  4, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  4, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  4, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  4, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  4, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  4, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  4, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  4, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  4, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  4, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  4, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  4, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  4, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  4, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  4, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  4, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  4, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  4, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  4, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  4, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters B5Cases[85] = {
  5, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  5, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  5, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  5, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  5, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  5, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  5, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  5, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  5, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  5, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  5, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  5, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  5, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  5, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  5, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  5, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,
 
  5, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  5, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  5, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  5, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  5, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  5, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  5, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  5, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  5, 16, MW16, IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 16, MW16, IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 16, MW16, IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 16, MW16, IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 16, MW16, IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  5, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  5, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  5, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  5, 16, MW32, IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 16, MW32, IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 16, MW32, IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 16, MW32, IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 16, MW32, IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  5, 16, MW32, IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  5, 16, MW32, IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  5, 16, MW32, IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  5, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  5, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  5, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  5, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  5, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  5, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  5, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  5, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  5, 32, MW16, IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 32, MW16, IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 32, MW16, IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 32, MW16, IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 32, MW16, IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  5, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  5, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  5, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  5, 32, MW32, IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  5, 32, MW32, IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  5, 32, MW32, IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  5, 32, MW32, IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  5, 32, MW32, IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  5, 32, MW32, IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  5, 32, MW32, IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  5, 32, MW32, IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};
 
  struct parameters B6Cases[85] = {
  6, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  6, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  6, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  6, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  6, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  6, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  6, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  6, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  6, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  6, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  6, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  6, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  6, 8, MW32, IC1,  RD1,  WR1,  OEN1, WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 8, MW32, IC3,  RD5,  WR5,  OEN3, WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 8, MW32, IC5,  RD9,  WR9,  OEN5, WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 8, MW32, IC7, RD13, WR13,  OEN7, WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 8, MW32, IC0, RD17, WR17,  OEN0, WEN0, BLRD8, BLWR8, INC16, RBL1,
  6, 8, MW32, IC2, RD21, WR21,  OEN2, WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  6, 8, MW32, IC4, RD25, WR25,  OEN4, WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  6, 8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1,

  6, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  6, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  6, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  6, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  6, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  6, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  6, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  6, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  6, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  6, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  6, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  6, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  6, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  6, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  6, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  6, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  6, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  6, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  6, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  6, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  6, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  6, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  6, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  6, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  6, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  6, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  6, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  6, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  6, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  6, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  6, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  6, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  6, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  6, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  6, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  6, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9,8, MW32, IC6, RD29, WR29,  OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};

  struct parameters B7Cases[85] = {
  7, 8, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  7, 8, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  7, 8, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  7, 8, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  7, 8, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  7, 8, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  7, 8, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  7, 8, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  7, 8, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 8, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 8, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 8, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 8, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  7, 8, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  7, 8, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  7, 8, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,

  7, 8, MW32, IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 8, MW32, IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 8, MW32, IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 8, MW32, IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 8, MW32, IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  7, 8, MW32, IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  7, 8, MW32, IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  7, 8, MW32, IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  7, 16, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  7, 16, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  7, 16, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  7, 16, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  7, 16, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  7, 16, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  7, 16, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  7, 16, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  7, 16, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 16, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 16, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 16, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 16, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  7, 16, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  7, 16, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  7, 16, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  7, 16, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 16, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 16, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 16, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 16, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  7, 16, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  7, 16, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  7, 16, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  7, 32, MW8,  IC0,  RD0,  WR0,  OEN0,  WEN0, BLRD4, BLWR4,   SIN, RBL0,
  7, 32, MW8,  IC2,  RD4,  WR4,  OEN2,  WEN2, BLRD8, BLWR8,   INC, RBL0,
  7, 32, MW8,  IC4,  RD8,  WR8,  OEN4,  WEN4, BLRDC, BLWRC,  INC4, RBL0,
  7, 32, MW8,  IC6, RD12, WR12,  OEN6,  WEN6, BLRD4, BLWR4,  INC8, RBL0,
  7, 32, MW8,  IC8, RD16, WR16,  OEN8,  WEN8, BLRD8, BLWR8, INC16, RBL0,
  7, 32, MW8, IC10, RD20, WR20, OEN10, WEN10, BLRDC, BLWRC,  WRP4, RBL0,
  7, 32, MW8, IC12, RD24, WR24, OEN12, WEN12, BLRD4, BLWR4,  WRP8, RBL0,
  7, 32, MW8, IC14, RD28, WR28, OEN14, WEN14, BLRD8, BLWR8, WRP16, RBL0,

  7, 32, MW16,  IC1,  RD2,  WR2,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 32, MW16,  IC3,  RD6,  WR6,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 32, MW16,  IC5, RD10, WR10,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 32, MW16,  IC7, RD14, WR14,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 32, MW16,  IC9, RD18, WR18,  OEN9,  WEN9, BLRD8, BLWR8, INC16, RBL1,
  7, 32, MW16, IC11, RD22, WR22, OEN11, WEN11, BLRDC, BLWRC,  WRP4, RBL1,
  7, 32, MW16, IC13, RD26, WR26, OEN13, WEN13, BLRD4, BLWR4,  WRP8, RBL1,
  7, 32, MW16, IC15, RD30, WR30, OEN15, WEN15, BLRD8, BLWR8, WRP16, RBL1,   
  7, 32, MW32,  IC1,  RD1,  WR1,  OEN1,  WEN1, BLRD4, BLWR4,   SIN, RBL1,
  7, 32, MW32,  IC3,  RD5,  WR5,  OEN3,  WEN3, BLRD8, BLWR8,   INC, RBL1,
  7, 32, MW32,  IC5,  RD9,  WR9,  OEN5,  WEN5, BLRDC, BLWRC,  INC4, RBL1,
  7, 32, MW32,  IC7, RD13, WR13,  OEN7,  WEN7, BLRD4, BLWR4,  INC8, RBL1,
  7, 32, MW32,  IC0, RD17, WR17,  OEN0,  WEN0, BLRD8, BLWR8, INC16, RBL1,
  7, 32, MW32,  IC2, RD21, WR21,  OEN2,  WEN2, BLRDC, BLWRC,  WRP4, RBL1,
  7, 32, MW32,  IC4, RD25, WR25,  OEN4,  WEN4, BLRD4, BLWR4,  WRP8, RBL1,
  7, 32, MW32,  IC6, RD29, WR29,  OEN6,  WEN6, BLRD8, BLWR8, WRP16, RBL1,

  9, 8, MW32, IC6, RD29, WR29, OEN6, WEN6, BLRD8, BLWR8, WRP16, RBL1};


  /* The test cases and their corresponding parameters are listed here.
     The user can modify the 'caselist' to run the specific test cases.
     e.g., if the user wants to test only the first test case, the last
     element "ENDOFTEST" of the array may be put next to the B0SYWRRD test */
  struct caselist SyWrRdCaseList[10] = {
       "SyWriteRead_B0",   B0Cases,
       "SyWriteRead_B1",   B1Cases,
       "SyWriteRead_B2",   B2Cases,
       "SyWriteRead_B3",   B3Cases,
       "SyWriteRead_B4",   B4Cases,
       "SyWriteRead_B5",   B5Cases,
       "SyWriteRead_B6",   B6Cases,
       "SyWriteRead_B7",   B7Cases,
       "ENDOFTEST",        B0Cases,
       "ENDOFTEST",        B0Cases
       };

  struct caselist *TestCases = SyWrRdCaseList;


  /*
      Programming SSMCCR and SSMCTrCR registers. The constants CLKRATIO and
      CLKSTATUS defined in the Ssmc.h set the required  MemClkRatio and
      SMClockEn field bits.
  */
  SSMCCRDATA = CLKRATIO | CLKSTATUS;
  ConfigureCLKRatio(SSMCCRDATA);

  /*
      Programming the SSMCTrBurstWT register to turn the mask ON/OFF and to
      set the BeatNo and BurstWT counts. The constants BWtMask_ON/OFF,
      Beat0 to 15 and SSMCTrBurstWT0 to 15 are defined in Ssmc.h.
  */
  SSMCTrBurstWTData = BWtMask_ON | Beat15 | SSMCTrBurstWT15;
  ConfigureBurstWT(SSMCTrBurstWTData);

  /*
      Programming the SSMCTrWTCNCL register. The constant SMWTCNCLDI/EN
      disables or Enables the SMCANCELWait signal. The constant SMWAITIGNORE_0/1
      enables or disables the SMWAITIGNORE respectively and the constants
      WTCNCL0 to 63 are used to load the CANCEL WAIT count.
  */
  WTCNCLData = SMWTCNCLDI | SMWAITIGNORE_1 | WTCNCL10 ;
  HSA(SSMCTrWTCNCL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,WTCNCLData);

  /** Configuring the system to LITTLE endian mode by setting ENDIANNESS = 0 **/
  ENDIANNESS = 0;
  HSA(SSMCTrEndian, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ENDIANNESS);
  HSEN(LITTLE);

  /*
      Programming the SSMCTrExtMuxWT register.The constant ExtMuxDI/EN disables
      or enables the  External Mux. The constants ExtMuxAss0 to 15 and
      ExtMuxDAss0 to 15 define the Assertion and Deassertion counts.
  */
  ExtMuxData = ExtMuxAss5 | ExtMuxDAss5 | ExtMuxDI;
  HSA(SSMCTrExtMux, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,ExtMuxData);

  /** Programming the SSMCTrSMBLSPOL register **/
  SMBLSPOLData = SMBLSPOL_0;
  HSA(SSMCTrSMBLSPOL, NSEQ, INCR, , WRD, , 0x1, , , , ,);
  HSW( ,SMBLSPOLData);

  /** Set Bank 0 Memory Type as SRAM (32 bits width) **/
  /** RBLE Enabled, ExtWait Disabled **/
  SSMCTrMEMBData[0] = 0x00007FFF;

  SMBCRData[0] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN |
                 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        | 
                 CRWAITEN_DI      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW32           |  RBLE_1          | SMBLSPOL_0;

  SSMCTrCS2WTRData[0] = TRWAITEN_DI | TRWAITPOL_0 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK0, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[0],
               SSMCTrCS2WTRData[0], WSTBRD2);

  ConfigureMemory(BANK0, SSMCTrMEMBData[0]);

  /** Set Bank 1 Memory Type as SRAM (8 bits width) **/
  /** RBLE Disabled, ExtWait Disabled **/
  SSMCTrMEMBData[1] = 0x00000000;

  SMBCRData[1] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI 	  | WRAPRD_DI 	     | 
		 CRWAITEN_DI      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW8            | RBLE_0           | SMBLSPOL_0;

  SSMCTrCS2WTRData[1] = TRWAITEN_DI | TRWAITPOL_0 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK1, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[1],
               SSMCTrCS2WTRData[1], WSTBRD2);

  ConfigureMemory(BANK1, SSMCTrMEMBData[1]);

  /** Set Bank 2 Memory Type as SRAM (16 bits width) **/
  SSMCTrMEMBData[2] = 0x00007FFF;
  /** RBLE Enabled, ExtWait Enabled **/

  SMBCRData[2] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        | 
		 CRWAITEN_EN      | CRWAITPOL_1      |
                 BIWRITE_DI       | BIREAD_DI        |
		 CRMW16           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[2] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK2, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[2],
               SSMCTrCS2WTRData[2], WSTBRD2);

  ConfigureMemory(BANK2, SSMCTrMEMBData[2]);

  /** Set Bank 3 Memory Type as SRAM (8 bits width) **/
  /** RBLE Disabled, ExtWait Enabled **/
  SSMCTrMEMBData[3] = 0x00000000;

  SMBCRData[3] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI 	  | WRAPRD_DI        | 
		 CRWAITEN_EN      | CRWAITPOL_1      |
                 BIWRITE_DI       | BIREAD_DI        |
                 CRMW8            | RBLE_0 	     | SMBLSPOL_0;

  SSMCTrCS2WTRData[3] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK3, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[3],
               SSMCTrCS2WTRData[3], WSTBRD2);

  ConfigureMemory(BANK3, SSMCTrMEMBData[3]);

  /** Set Bank 4 Memory Type as SRAM (16 bits width) **/
  SSMCTrMEMBData[4] = 0x00007FFF;
  /** RBLE Enabled, ExtWait Enabled **/

  SMBCRData[4] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI          | WRAPRD_DI        | 
		 CRWAITEN_EN      | CRWAITPOL_1      |
                 BIWRITE_DI       | BIREAD_DI        |
     		 CRMW16           | RBLE_1           | SMBLSPOL_0;

  SSMCTrCS2WTRData[4] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK4, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[4],
               SSMCTrCS2WTRData[4], WSTBRD2);

  ConfigureMemory(BANK4, SSMCTrMEMBData[4]);

  /** Set Bank 5 Memory Type as ROM (8 bits width) **/
  /** RBLE Disabled, ExtWait Enabled **/
  SSMCTrMEMBData[5] = 0x00000000;

  SMBCRData[5] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI 	  | WRAPRD_DI  	     | 
		 CRWAITEN_EN      | CRWAITPOL_1      |
                 BIWRITE_DI       | BIREAD_DI        |
		 CRMW8            | RBLE_0           | SMBLSPOL_0;
        
  SSMCTrCS2WTRData[5] = TRWAITEN_EN | TRWAITPOL_1 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK5, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[5],
               SSMCTrCS2WTRData[5], WSTBRD2);

  ConfigureMemory(BANK5, SSMCTrMEMBData[5]);

  /** Set Bank 6 Memory Type as BROM (32 bits width) **/
  SSMCTrMEMBData[6] = 0x00007FFF;
  /** RBLE Enabled, ExtWait Disabled **/

  SMBCRData[6] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN |
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI 	  | WRAPRD_DI 	     | 
		 CRWAITEN_DI      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
		 CRMW32	 	  | RBLE_1 	     | SMBLSPOL_0;

  SSMCTrCS2WTRData[6] = TRWAITEN_DI | TRWAITPOL_0 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK6, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[6],
               SSMCTrCS2WTRData[6], WSTBRD2);

  ConfigureMemory(BANK6, SSMCTrMEMBData[6]);

  /** Set Bank 7 Memory Type as BROM (8 bits width) **/
  /** RBLE Disabled, ExtWait Disabled **/
  SSMCTrMEMBData[7] = 0x00000000;

  SMBCRData[7] = CRADDRVALIDWR_EN | CRADDRVALIDRD_EN | 
		 CRSYNCENWR_SY    | CRSYNCENRD_SY    |
                 CRBURSTLENWR4    | CRBURSTLENRD4    |
                 CRBMWRITE_EN     | CRBMREAD_EN      |
                 CRWP_DI 	  | WRAPRD_DI        | 
		 CRWAITEN_DI      | CRWAITPOL_0      |
                 BIWRITE_DI       | BIREAD_DI        |
		 CRMW8            | RBLE_0           | SMBLSPOL_0;

  SSMCTrCS2WTRData[7] = TRWAITEN_DI | TRWAITPOL_0 | TRCS2WTR2 | TRWT2DEWT2;

  ConfigureUUT(BANK7, WSTIDCY1, WSTRD2, WSTWR3, WSTOEN1, WSTWEN1, SMBCRData[7],
               SSMCTrCS2WTRData[7], WSTBRD2);

  ConfigureMemory(BANK7, SSMCTrMEMBData[7]);

  while (TestCases->CaseNumber != "ENDOFTEST")
  {
    sprintf(report,"TEST NO : %s", TestCases->CaseNumber);
    C(report);

    SyWrRdParams = TestCases->TestParams;
   while (SyWrRdParams->BANKNO != 9)
    {

  /* Set the ofset for the memory to zero.The offset can be given a new value 
     by changing the value of the variable SSMCTrMEMBData */ 
  
  SSMCTrMEMBData[SyWrRdParams -> BANKNO ] = 0x00000000;
  
  /* the control register fields are configured as per the requirement */
  BCRData     =   CRADDRVALIDWR_EN | 
                  CRADDRVALIDRD_EN |
                  CRSYNCENWR_SY    | 
                  CRSYNCENRD_SY    |
                  CRBMWRITE_EN     |     
                  CRBMREAD_EN      |    
                  CRWP_DI          |
                  WRAPRD_DI        |
                  CRWAITEN_DI      |     
                  CRWAITPOL_0      |
                  SyWrRdParams -> BURSTLENWR | 
                  SyWrRdParams -> BURSTLENRD |
                  BIWRITE_DI       | 
                  BIREAD_DI        |
                  SMBLSPOL_0       |
                  SyWrRdParams -> RBLE       |
		  SyWrRdParams -> MSIZE;

  SSMCTrCS2WTRData[SyWrRdParams -> BANKNO] = TRWAITEN_DI | TRWAITPOL_0 | 
                                             TRCS2WTR2 | TRWT2DEWT2; 

  ConfigureUUT(SyWrRdParams -> BANKNO, 
               SyWrRdParams -> WSTIDCY, 
               SyWrRdParams -> WSTRD,
               SyWrRdParams -> WSTWR, 
               SyWrRdParams -> WSTOEN, 
               SyWrRdParams -> WSTWEN,
               BCRData,
               SSMCTrCS2WTRData[SyWrRdParams -> BANKNO],
               WSTBRD2 );

  ConfigureMemory(SyWrRdParams -> BANKNO,
                  SSMCTrMEMBData[SyWrRdParams -> BANKNO ]); 

  /* Generate TestData depending on the HSIZE   */
  switch(SyWrRdParams -> HSIZE)
  {
    case 8 : TestData = ~(SyWrRdParams -> BANKNO) & UnMask[0];
             break;

    case 16 : TestData = ~(SyWrRdParams -> BANKNO) & UnMask[1];
              break;

    case 32 : TestData = ~(SyWrRdParams -> BANKNO) & UnMask[2];
              break;
  } 

    /* Assign values to Hsize  depending on the HSIZE values in testcases */
    /* Hsize = 0,1,2 when HSIZE = 8,16.32 respectively */
  switch(SyWrRdParams -> HSIZE)
  {
    case  8 : Hsize = 0;
              break;

    case 16 : Hsize = 1;
              break;

    case 32 : Hsize = 2;
              break;
  }

  /* Assign values to Msize  depending on the MSIZE values in testcases */
  /* Msize = 0,1,2 when MSIZE = 8,16.32 respectively                    */
  switch(SyWrRdParams -> MSIZE)
  {
    case MW8 : Msize = 0;
               break;

    case MW16 : Msize = 1;
                break;
    
    case MW32 : Msize = 2;
                break;
  }

  /* Perform BurstWrite followed by BurstRead on the selected Bank for the */
  /* given set of parameters values as listed in the SyWriteRead in the    */ 
  /* verification plan.Also verify the data form the AHB side              */ 
     BurstWriteRead(SyWrRdParams -> BANKNO,
                    SyWrRdParams -> HBURST,
                    0x00,
                    Hsize,
                    Msize, 
                    TestData);
     
     SyWrRdParams++;
    }
  TestCases++;
  }
}

/********************************* END ****************************************/
