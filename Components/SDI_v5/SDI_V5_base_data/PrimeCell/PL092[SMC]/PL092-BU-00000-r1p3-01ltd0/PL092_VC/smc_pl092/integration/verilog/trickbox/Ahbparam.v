// --=========================================================================--
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from ARM Limited
//   (C) COPYRIGHT 2000-2001 ARM Limited
//       ALL RIGHTS RESERVED
// The entire notice above must be reproduced on all authorised
// copies and copies may only be made to the extent permitted
// by a licensing agreement from ARM Limited.
//
// -----------------------------------------------------------------------------
// Version and Release Control Information:
//
// File Name              : Ahbparam.v.rca
// File Revision          : 1.11
//
// Release Information    : PrimeCell(TM)-PL092-r1p3-01ltd0
//
// -----------------------------------------------------------------------------
// Purpose :
//           This module introduces proper delays to all signals 
//
// --=========================================================================--

`timescale 1ns/1ps
`include "../chip/timing.v" 

// -----------------------------------------------------------------------------

module  Ahbparam (
                  HCLK,
                  HADDR,
                  HTRANS,
                  HSIZE,
                  HBURST,
                  DelayEn,
                  HWRITE,
                  HSEL,
                  HMASTER,
                  HMASTLOCK,
                  HREADYOut,
                  HWDATA,
                  HSPLITOut,
                  HRDATAOut,
                  HRESPOut,
                  HSELdly,
                  HMASTLOCKdly ,
                  HADDRdly ,
                  HTRANSdly,
                  HSIZEdly,
                  HBURSTdly ,
                  HWRITEdly,
                  HREADYdly,
                  HWDATAdly,
                  HRDATAdly,
                  HSPLITdly,
                  HMASTERdly,
                  HRESPdly
                 );

input           HCLK;        // AHB Clock
input  [31:0]   HADDR;       // AHB Address Bus
input   [1:0]   HTRANS;      // AHB Transfer type
input   [2:0]   HSIZE;       // AHB Transfer size
input   [2:0]   HBURST;      // AHB Burst Control
input           DelayEn;     // Delay Enable bit
input           HWRITE;      // AHB Read/Write Signal
input           HSEL;        // Slave Selected
input   [3:0]   HMASTER;     // Master owning AHB
input           HMASTLOCK;   // Master locks Slave for current transaction
input           HREADYOut;   // AHB Ready signal generated by slave
input  [63:0]   HWDATA;      // AHB Write Data Bus
input  [15:0]   HSPLITOut;   // SPLIT Reply to MASTER
input  [63:0]   HRDATAOut;   // Internal Read Data Bus
input  [1:0]    HRESPOut;    // Internal HRESP signal
output          HSELdly;     // Delayed HSEL signal
output          HMASTLOCKdly;// Delayed HMASTLOCK signal
output [31:0]   HADDRdly;    // Delayed AHB Address bus
output  [1:0]   HTRANSdly;   // Delayed AHB Transfer
output  [2:0]   HSIZEdly;    // Delayed AHB size signal
output  [2:0]   HBURSTdly;   // Delayed AHB Burst
output          HWRITEdly;   // Delayed AHB Read/Write signal
output          HREADYdly;   // AHB Ready signal ouput from slave
output [63:0]   HWDATAdly;   // Delayed AHB Write Data
output [63:0]   HRDATAdly;   // AHB Read Data Bus
output [15:0]   HSPLITdly;   // Delayed HSPLIT lines
output  [3:0]   HMASTERdly;  // Delayed HMASTER
output  [1:0]   HRESPdly;    // AHB response signal
 
// -----------------------------------------------------------------------------
//
//                             Ahbparam 
//                             ========
//
// -----------------------------------------------------------------------------
//
// Overview
// ========
//
// This module introduces delays to AHB signals. 
// -----------------------------------------------------------------------------
// Constant declarations
// -----------------------------------------------------------------------------
//`define Tclkl            50
// AHB Clock Low phase period
 
//`define Tclkh            50
// AHB Clock HIGH  phase period
 
//`define Tovrd            50
//  By default make it tclkh;
//`define Tohdr             4
// Timing parameters for HRDATA
 
`define Tovresp            50
//  By default make it tclkl;
`define Tohresp             4
// Timing parameters for HRESP
 
//`define Tovrdy           50
//  By default make it tclkl;
//`define Tohrdy            4
// Timing parameters for HREADY
 
`define Tovsplit           50
//  By default make it tclkl;
`define Tohsplit            4
// Timing parameters for HSPLITx
 
`define HADDR_DLY_VALUE     0
// Delay time for HADDR signal
 
`define HSEL_DLY_VALUE      0
// Delay time for HSEL signal
 
`define HMASTLOCK_DLY_VALUE 0
// Delay time for HMASTLOCK signal
 
`define HTRANS_DLY_VALUE    0
// Delay time for HTRANS signal
 
`define HSIZE_DLY_VALUE     0
// Delay time for HSIZE signal
 
`define HBURST_DLY_VALUE    0
// Delay time for HBURST signal

`define HWRITE_DLY_VALUE    0
// Delay time for HWRITE signal
 
`define HREADY_DLY_VALUE    3
// Delay time for HREADY signal
 
`define HWDATA_DLY_VALUE    0
// Delay time for HWDATA signal
 
`define HRDATA_DLY_VALUE    3
// Delay time for HRDATA signal
 
`define HRESP_DLY_VALUE     3
// Delay time for HRESP signal
 
`define HSPLIT_DLY_VALUE    3
// Delay time for HSPLIT signal
    
`define HMASTER_DLY_VALUE   0
// Delay time for HMASTER signal
 

// -----------------------------------------------------------------------------
// Signal declarations
// -----------------------------------------------------------------------------
reg         HREADYX;
// For timing protocol checks of HREADY signal, this signal is paased out 
// after making it unknown for a certain duration
  
reg  [1:0]  HRESPX;
//For timing protocol checks of HRESP signal, this signal is paased out 
// after making it unknown for a certain duration

reg  [15:0] HSPLITX; 
//For timing protocol checks of HSPLITx signal, this signal is paased out 
// after making it unknown for a certain duration

// -----------------------------------------------------------------------------
// Wire declarations
// -----------------------------------------------------------------------------
wire        HREADYOutDel;
// Delayed version of Actual Response signals coming from slave 
wire [1:0]  HRESPOutDel;
// Delayed version of Actual Response signals coming from slave 
wire [15:0] HSPLITOutDel;
// Delayed version of Actual Response signals coming from slave 

// -----------------------------------------------------------------------------
//
// Main body of code
// =================
//
// -----------------------------------------------------------------------------
// Introducing delays 
// ----------------------------------------------------------------------------
assign  # `HREADY_DLY_VALUE        HREADYOutDel  = HREADYOut;
assign  # `HRESP_DLY_VALUE         HRESPOutDel   = HRESPOut;
assign  # `HSPLIT_DLY_VALUE        HSPLITOutDel  = HSPLITOut;
assign  # `HADDR_DLY_VALUE         HADDRdly      = HADDR;
assign  # `HSEL_DLY_VALUE          HSELdly       = HSEL;
assign  # `HTRANS_DLY_VALUE        HTRANSdly     = HTRANS;
assign  # `HSIZE_DLY_VALUE         HSIZEdly      = HSIZE;
assign  # `HBURST_DLY_VALUE        HBURSTdly     = HBURST;
assign  # `HWRITE_DLY_VALUE        HWRITEdly     = HWRITE;
assign  # `HWDATA_DLY_VALUE        HWDATAdly     = HWDATA;
assign  # `HMASTER_DLY_VALUE       HMASTERdly    = HMASTER;
assign  # `HMASTLOCK_DLY_VALUE     HMASTLOCKdly  = HMASTLOCK;
assign  # `HRDATA_DLY_VALUE        HRDATAdly     = HRDATAOut;
assign     HREADYdly = (DelayEn == 1'b1 ) ? HREADYX : HREADYOutDel;
 
assign     HRESPdly  = (DelayEn == 1'b1 ) ? HRESPX  : HRESPOutDel;
 
assign     HSPLITdly = (DelayEn == 1'b1)  ? HSPLITX : HSPLITOutDel;

// ----------------------------------------------------------------------------
// For timing violation checking of Slave's  Output Signals, this signal is 
// made to go to an unknown state for a predetermined duration and then passed
// out as the actual output signal.  
// ----------------------------------------------------------------------------
always @(posedge HCLK)
begin : p_SlaveSeq 
  if (DelayEn === 1'b1) 
  begin      
    # 0.0005                   HREADYX <= 1'bX;
    # (32 * `HREADY_DLY_VALUE) HREADYX <= HREADYOut;

    # 0.0005                   HRESPX  <= 2'bXX;
    # (32 * `HRESP_DLY_VALUE)  HRESPX  <= HRESPOut;

    # 0.0005                   HSPLITX <= 16'bXXXXXXXXXXXXXXXX;
    # (32 * `HSPLIT_DLY_VALUE) HSPLITX <= HSPLITOut;
  end
  else
  begin
    HREADYX <= # `HREADY_DLY_VALUE  HREADYOut;

    HRESPX  <= # `HRESP_DLY_VALUE   HRESPOut;

    HSPLITX <= # `HSPLIT_DLY_VALUE  HSPLITOut;
  end
end // p_SlaveSeq;
 
endmodule
 
// --================================ END ====================================--
