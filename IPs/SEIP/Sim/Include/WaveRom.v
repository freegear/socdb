
always @(posedge MCK) begin
						WEMDO <= 8'h00;
if (WEMA == 24'h000000) WEMDO <= 8'h00;
if (WEMA == 24'h000010)	WEMDO <= 8'h28;
if (WEMA == 24'h000011)	WEMDO <= 8'h5C;
if (WEMA == 24'h000012)	WEMDO <= 8'h55;
if (WEMA == 24'h000013)	WEMDO <= 8'h04;
if (WEMA == 24'h000014)	WEMDO <= 8'hC3;
if (WEMA == 24'h000015)	WEMDO <= 8'hEC;
if (WEMA == 24'h111100)	WEMDO <= 8'h4A;
if (WEMA == 24'h111101)	WEMDO <= 8'hBE;	
if (WEMA == 24'h111102)	WEMDO <= 8'hEF;
if (WEMA == 24'h111103)	WEMDO <= 8'h26;
if (WEMA == 24'h111104)	WEMDO <= 8'h33;
if (WEMA == 24'h111105)	WEMDO <= 8'h68; 
if (WEMA == 24'h111106)	WEMDO <= 8'hF2;
if (WEMA == 24'h111107)	WEMDO <= 8'hDD;
if (WEMA == 24'h111108)	WEMDO <= 8'h96;
if (WEMA == 24'h111109)	WEMDO <= 8'hC7;
if (WEMA == 24'h11110A)	WEMDO <= 8'h30;
if (WEMA == 24'h222218)	WEMDO <= 8'h44;
if (WEMA == 24'h222219)	WEMDO <= 8'h45;
if (WEMA == 24'h22221A)	WEMDO <= 8'hAB;
if (WEMA == 24'h22221B) WEMDO <= 8'hC8;
if (WEMA == 24'h22221C)	WEMDO <= 8'h38;
if (WEMA == 24'h22221D)	WEMDO <= 8'h6D;
if (WEMA == 24'h333330)	WEMDO <= 8'hC6;
if (WEMA == 24'h333331)	WEMDO <= 8'h4B;
if (WEMA == 24'h333332)	WEMDO <= 8'h33;
if (WEMA == 24'h333333)	WEMDO <= 8'hFD;
if (WEMA == 24'h444440)	WEMDO <= 8'h26;
if (WEMA == 24'h444441) WEMDO <= 8'h47;	
if (WEMA == 24'h444442)	WEMDO <= 8'h63;
if (WEMA == 24'h444443)	WEMDO <= 8'hCF;
if (WEMA == 24'h555550)	WEMDO <= 8'h92;
if (WEMA == 24'h555551)	WEMDO <= 8'hA3;
if (WEMA == 24'h555552)	WEMDO <= 8'hE8;
if (WEMA == 24'h555553)	WEMDO <= 8'h3D;
if (WEMA == 24'h555554)	WEMDO <= 8'h5E;
if (WEMA == 24'h555555)	WEMDO <= 8'h78;
if (WEMA == 24'h555556)	WEMDO <= 8'h2A;
if (WEMA == 24'h555557)	WEMDO <= 8'hE7;
if (WEMA == 24'h555558)	WEMDO <= 8'hF9;
if (WEMA == 24'h6665F4)	WEMDO <= 8'h44;
if (WEMA == 24'h6665F5)	WEMDO <= 8'h27;
if (WEMA == 24'h6665F6)	WEMDO <= 8'h71;
if (WEMA == 24'h6665F7)	WEMDO <= 8'h38;
if (WEMA == 24'h6665F8)	WEMDO <= 8'hCB;
if (WEMA == 24'h6665F9)	WEMDO <= 8'hAE;
if (WEMA == 24'h6665FA)	WEMDO <= 8'hEF;
if (WEMA == 24'h6665FB)	WEMDO <= 8'h18;
if (WEMA == 24'h6665FC)	WEMDO <= 8'h3C;
if (WEMA == 24'h6665FD)	WEMDO <= 8'h6A;
if (WEMA == 24'h6665FE)	WEMDO <= 8'h27;
if (WEMA == 24'h6665FF)	WEMDO <= 8'hC7;
if (WEMA == 24'h666600)	WEMDO <= 8'h84;
if (WEMA == 24'h777772)	WEMDO <= 8'hA2;
if (WEMA == 24'h777773)	WEMDO <= 8'h16;
if (WEMA == 24'h777774)	WEMDO <= 8'h5B;
if (WEMA == 24'h777775)	WEMDO <= 8'h77;
end
