//
// Module UART_lib.UartTop.struct
//
// Created:
//          by - jylim.UNKNOWN (GUNDAM)
//          at - 11:49:50 2006-12-12
//
// Version : 3.0 CT500(TSMC)
// Generated by Mentor Graphics' HDL Designer(TM) 2004.1 (Build 41)
//

`resetall
`timescale 1ns/10ps
module UartTop(
   PADDR, 
   PENABLE, 
   PSEL, 
   PWDATA, 
   PWRITE, 
   clk, 
   rstb, 
   rxd, 
   PRDATA, 
   int, 
   rxdmareq, 
   txd, 
   txdmareq
);

// aloowed value 3'b000(NO FIFO), 3'b001(8 depth), 3'b010(16 depth), 3'b011(32 depth)
parameter UART_FIFO_CONFIG = 3'b011;

parameter UART_FIFO_WIDTH = (UART_FIFO_CONFIG == 3'b011) ? 5 : ((UART_FIFO_CONFIG == 3'b010) ? 4 : ((UART_FIFO_CONFIG == 3'b001) ? 3 : 0));

// Internal Declarations
input  [4:2]  PADDR;
input         PENABLE;
input         PSEL;
input  [31:0] PWDATA;
input         PWRITE;
input         clk;
input         rstb;
input         rxd;
output [31:0] PRDATA;
output        int;
output        rxdmareq;
output        txd;
output        txdmareq;


wire [4:2]   PADDR;
wire         PENABLE;
wire         PSEL;
wire [31:0]  PWDATA;
wire         PWRITE;
wire         clk;
wire         rstb;
wire         rxd;
wire [31:0]  PRDATA;
wire         int;
wire         rxdmareq;
wire         txd;
wire         txdmareq;

// Local declarations

// Internal signal declarations
wire       baudx16clk;
wire       bytereceivedb;
wire       databit;
wire [7:0] fifodata_rx;
wire [7:0] fifodata_tx;
wire       fifordb;
wire       fifowrb;
wire       frameerror;
wire       loopbacken;
wire       overrunerror;
wire [1:0] parity;
wire       parityerror;
wire       rxbusy;
wire [UART_FIFO_WIDTH:0] rxfifocnt;
wire       rxfifoempty;
wire       stopbit;
wire       swrst;
wire       txbusy;
wire       txfifo_emptyb;
wire       txfifo_fillb;
wire       txfifo_fullb;
wire [UART_FIFO_WIDTH:0] txfifocnt;
wire       uarten;
wire       frameerr_clear;
wire       parityerr_clear;
wire       overrunerr_clear;


// Instances 
RegBlk #(UART_FIFO_CONFIG, UART_FIFO_WIDTH) RegBlock( 
   .PADDR         (PADDR), 
   .PENABLE       (PENABLE), 
   .PSEL          (PSEL), 
   .PWDATA        (PWDATA), 
   .PWRITE        (PWRITE), 
   .bytereceivedb (bytereceivedb), 
   .clk           (clk), 
   .fifodata_rx   (fifodata_rx), 
   .frameerror    (frameerror), 
   .overrunerror  (overrunerror), 
   .parityerror   (parityerror), 
   .rstb          (rstb), 
   .rxbusy        (rxbusy), 
   .rxfifocnt     (rxfifocnt), 
   .rxfifoempty   (rxfifoempty), 
   .txbusy        (txbusy), 
   .txfifo_emptyb (txfifo_emptyb), 
   .txfifo_fillb  (txfifo_fillb), 
   .txfifo_fullb  (txfifo_fullb), 
   .txfifocnt     (txfifocnt), 
   .PRDATA        (PRDATA), 
   .baudx16clk    (baudx16clk), 
   .databit       (databit), 
   .fifodata_tx   (fifodata_tx), 
   .fifordb       (fifordb), 
   .fifowrb       (fifowrb), 
   .int           (int), 
   .loopbacken    (loopbacken), 
   .parity        (parity[1:0]), 
   .rxdmareq      (rxdmareq), 
   .stopbit       (stopbit), 
   .swrst         (swrst), 
   .txdmareq      (txdmareq), 
   .uarten        (uarten),
   .frameerr_clear(frameerr_clear),
   .parityerr_clear(parityerr_clear),
   .overrunerr_clear(overrunerr_clear)
); 

RxBlock #(UART_FIFO_WIDTH) RxBLK( 
   .baudx16clk    (baudx16clk), 
   .clk           (clk), 
   .databit       (databit), 
   .fifordb       (fifordb), 
   .loopbacken    (loopbacken), 
   .parity        (parity[1:0]), 
   .rstb          (rstb), 
   .rxd           (rxd), 
   .stopbit       (stopbit), 
   .swrst         (swrst), 
   .txd           (txd), 
   .uarten        (uarten), 
   .bytereceivedb (bytereceivedb), 
   .fifodata_rx   (fifodata_rx), 
   .frameerror    (frameerror), 
   .overrunerror  (overrunerror), 
   .parityerror   (parityerror), 
   .rxbusy        (rxbusy), 
   .rxfifocnt     (rxfifocnt),
   .rxfifoempty   (rxfifoempty),
   .frameerr_clear(frameerr_clear),
   .parityerr_clear(parityerr_clear),
   .overrunerr_clear(overrunerr_clear)
); 

TxBlock #(UART_FIFO_WIDTH) TxBLK( 
   .baudx16clk    (baudx16clk), 
   .clk           (clk), 
   .databit       (databit), 
   .fifodata_tx   (fifodata_tx), 
   .fifowrb       (fifowrb), 
   .parity        (parity[1:0]), 
   .rstb          (rstb), 
   .stopbit       (stopbit), 
   .swrst         (swrst), 
   .uarten        (uarten), 
   .txbusy        (txbusy), 
   .txd           (txd), 
   .txfifo_emptyb (txfifo_emptyb), 
   .txfifo_fillb  (txfifo_fillb), 
   .txfifo_fullb  (txfifo_fullb), 
   .txfifocnt     (txfifocnt)
); 


endmodule // UartTop

