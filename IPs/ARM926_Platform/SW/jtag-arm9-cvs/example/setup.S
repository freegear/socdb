start:
	mov 	r13, #0x300
	b	main
