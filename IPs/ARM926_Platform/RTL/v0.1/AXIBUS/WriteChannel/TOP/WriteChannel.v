// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannel.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code

`timescale 1 ns/ 10ps
module  WriteChannel(


 
    //_______________________________________________________________
    //For Master 1
    //Write address channel
//Disalbe_id_port
    AWADDRm12si1  ,
    AWLENm12si1   ,
    AWSIZEm12si1  ,
    AWBURSTm12si1 ,
    AWLOCKm12si1  ,
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDm12si1 ,
    AWREADYsi12m1 ,

    //Write data channel
//Disalbe_id_port
    WDATAm12si1   ,
    WSTRBm12si1   ,
    WLASTm12si1   ,
    WVALIDm12si1  ,
    WREADYsi12m1  ,

    //Write response channel
//Disalbe_id_port
    BRESPsi12m1   ,
    BVALIDsi12m1  ,
    BREADYm12si1  ,

 
 
    //_______________________________________________________________
    //For Master 3
    //Write address channel
    AWIDm32si3    ,
    AWADDRm32si3  ,
    AWLENm32si3   ,
    AWSIZEm32si3  ,
    AWBURSTm32si3 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDm32si3 ,
    AWREADYsi32m3 ,

    //Write data channel
    WIDm32si3     ,
    WDATAm32si3   ,
    WSTRBm32si3   ,
    WLASTm32si3   ,
    WVALIDm32si3  ,
    WREADYsi32m3  ,

    //Write response channel
    BIDsi32m3     ,
    BRESPsi32m3   ,
    BVALIDsi32m3  ,
    BREADYm32si3  ,

 
    //_______________________________________________________________
    //For Master 4
    //Write address channel
//Disalbe_id_port
    AWADDRm42si4  ,
    AWLENm42si4   ,
    AWSIZEm42si4  ,
    AWBURSTm42si4 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDm42si4 ,
    AWREADYsi42m4 ,

    //Write data channel
//Disalbe_id_port
    WDATAm42si4   ,
    WSTRBm42si4   ,
    WLASTm42si4   ,
    WVALIDm42si4  ,
    WREADYsi42m4  ,

    //Write response channel
//Disalbe_id_port
    BRESPsi42m4   ,
    BVALIDsi42m4  ,
    BREADYm42si4  ,

 

    
    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    AWIDmi02s0    ,
    AWADDRmi02s0  ,
    AWLENmi02s0   ,
    AWSIZEmi02s0  ,
    AWBURSTmi02s0 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi02s0 ,
    AWREADYs02mi0 ,

    //Write data channel
    WIDmi02s0     ,
    WDATAmi02s0   ,
    WSTRBmi02s0   ,
    WLASTmi02s0   ,
    WVALIDmi02s0  ,
    WREADYs02mi0  ,

    //Write response channel
    BIDs02mi0     ,
    BRESPs02mi0   ,
    BVALIDs02mi0  ,
    BREADYmi02s0  ,
    
    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    AWIDmi12s1    ,
    AWADDRmi12s1  ,
    AWLENmi12s1   ,
    AWSIZEmi12s1  ,
    AWBURSTmi12s1 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi12s1 ,
    AWREADYs12mi1 ,

    //Write data channel
    WIDmi12s1     ,
    WDATAmi12s1   ,
//Disalbe_WSTRB_port
    WLASTmi12s1   ,
    WVALIDmi12s1  ,
    WREADYs12mi1  ,

    //Write response channel
    BIDs12mi1     ,
    BRESPs12mi1   ,
    BVALIDs12mi1  ,
    BREADYmi12s1  ,
    
    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    AWIDmi22s2    ,
    AWADDRmi22s2  ,
    AWLENmi22s2   ,
    AWSIZEmi22s2  ,
    AWBURSTmi22s2 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi22s2 ,
    AWREADYs22mi2 ,

    //Write data channel
    WIDmi22s2     ,
    WDATAmi22s2   ,
//Disalbe_WSTRB_port
    WLASTmi22s2   ,
    WVALIDmi22s2  ,
    WREADYs22mi2  ,

    //Write response channel
    BIDs22mi2     ,
    BRESPs22mi2   ,
    BVALIDs22mi2  ,
    BREADYmi22s2  ,
    
    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    AWIDmi32s3    ,
    AWADDRmi32s3  ,
    AWLENmi32s3   ,
    AWSIZEmi32s3  ,
    AWBURSTmi32s3 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi32s3 ,
    AWREADYs32mi3 ,

    //Write data channel
    WIDmi32s3     ,
    WDATAmi32s3   ,
    WSTRBmi32s3   ,
    WLASTmi32s3   ,
    WVALIDmi32s3  ,
    WREADYs32mi3  ,

    //Write response channel
    BIDs32mi3     ,
    BRESPs32mi3   ,
    BVALIDs32mi3  ,
    BREADYmi32s3  ,
    
    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    AWIDmi42s4    ,
    AWADDRmi42s4  ,
    AWLENmi42s4   ,
    AWSIZEmi42s4  ,
    AWBURSTmi42s4 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi42s4 ,
    AWREADYs42mi4 ,

    //Write data channel
    WIDmi42s4     ,
    WDATAmi42s4   ,
    WSTRBmi42s4   ,
    WLASTmi42s4   ,
    WVALIDmi42s4  ,
    WREADYs42mi4  ,

    //Write response channel
    BIDs42mi4     ,
    BRESPs42mi4   ,
    BVALIDs42mi4  ,
    BREADYmi42s4  ,
    
    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    AWIDmi52s5    ,
    AWADDRmi52s5  ,
    AWLENmi52s5   ,
    AWSIZEmi52s5  ,
    AWBURSTmi52s5 ,
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    AWVALIDmi52s5 ,
    AWREADYs52mi5 ,

    //Write data channel
    WIDmi52s5     ,
    WDATAmi52s5   ,
    WSTRBmi52s5   ,
    WLASTmi52s5   ,
    WVALIDmi52s5  ,
    WREADYs52mi5  ,

    //Write response channel
    BIDs52mi5     ,
    BRESPs52mi5   ,
    BVALIDs52mi5  ,
    BREADYmi52s5  ,


    //Lock Access
    //_______________________________________________________________

    Lock2wrmi0,
    Lock2wrmi1,
    Lock2wrmi2,
    Lock2wrmi3,
    Lock2wrmi4,
    Lock2wrmi5,

    Lock2rdmi0,
    Lock2rdmi1,
    Lock2rdmi2,
    Lock2rdmi3,
    Lock2rdmi4,
    Lock2rdmi5,

    UnLock2wrmi0,
    UnLock2wrmi1,
    UnLock2wrmi2,
    UnLock2wrmi3,
    UnLock2wrmi4,
    UnLock2wrmi5,

    UnLock2rdmi0,
    UnLock2rdmi1,
    UnLock2rdmi2,
    UnLock2rdmi3,
    UnLock2rdmi4,
    UnLock2rdmi5,

    ARVALIDmi02s0,
    ARVALIDmi12s1,
    ARVALIDmi22s2,
    ARVALIDmi32s3,
    ARVALIDmi42s4,
    ARVALIDmi52s5,

    LockPort2wrmi0,
    LockPort2wrmi1,
    LockPort2wrmi2,
    LockPort2wrmi3,
    LockPort2wrmi4,
    LockPort2wrmi5,

    ReadIntEmptyWrmi02Rdmi0,
    ReadIntEmptyWrmi12Rdmi1,
    ReadIntEmptyWrmi22Rdmi2,
    ReadIntEmptyWrmi32Rdmi3,
    ReadIntEmptyWrmi42Rdmi4,
    ReadIntEmptyWrmi52Rdmi5,

    DataCntEmptyRdmi02Wrmi0,
    DataCntEmptyRdmi12Wrmi1,
    DataCntEmptyRdmi22Wrmi2,
    DataCntEmptyRdmi32Wrmi3,
    DataCntEmptyRdmi42Wrmi4,
    DataCntEmptyRdmi52Wrmi5,

    CtlDataWrite2Lock0,
    CtlDataWrite2Lock1,
    CtlDataWrite2Lock2,
    CtlDataWrite2Lock3,
    CtlDataWrite2Lock4,
    CtlDataWrite2Lock5,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 3;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 5;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 2;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter MASTERID0_WID = 1 ;
parameter MASTERID1_WID = 1 ;
parameter MASTERID2_WID = 2 ;
parameter MASTERID3_WID = 1 ;
parameter MASTERID4_WID = 1 ;
parameter MAXMASTERID_WID = 2 ;
parameter BLANKMASTERID0_WID = 1 ;
parameter BLANKMASTERID1_WID = 1 ;
parameter BLANKMASTERID2_WID = 0 ;
parameter BLANKMASTERID3_WID = 1 ;
parameter BLANKMASTERID4_WID = 1 ;
parameter SLAVEID0_WID = 3 ;
parameter SLAVEID1_WID = 2 ;
parameter SLAVEID2_WID = 2 ;
parameter SLAVEID3_WID = 3 ;
parameter SLAVEID4_WID = 3 ;
parameter SLAVEID5_WID = 3 ;
parameter SELMASTER0_WID = 2 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 2 ;
parameter SELMASTER4_WID = 2 ;
parameter SELMASTER5_WID = 2 ;
parameter SLAVE_MASTERID0_WID = 1 ;
parameter SLAVE_MASTERID1_WID = 1 ;
parameter SLAVE_MASTERID2_WID = 1 ;
parameter SLAVE_MASTERID3_WID = 1 ;
parameter SLAVE_MASTERID4_WID = 1 ;
parameter SLAVE_MASTERID5_WID = 1 ;
    


  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   ACLK;
    input   ARESETn;  

    //Lock Access
    //_______________________________________________________________


    //Slave 0
    //_____________________________________
    input   Lock2wrmi0;
    input   UnLock2wrmi0;
    output  Lock2rdmi0;
    output  UnLock2rdmi0;
    input   ARVALIDmi02s0;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER0_WID-1:0]LockPort2wrmi0;
    input   [SELMASTER0_WID:0]LockPort2wrmi0;

    output  ReadIntEmptyWrmi02Rdmi0;
    input   DataCntEmptyRdmi02Wrmi0;
    output  [SELMASTER0_WID-1:0]CtlDataWrite2Lock0;

    //Slave 1
    //_____________________________________
    input   Lock2wrmi1;
    input   UnLock2wrmi1;
    output  Lock2rdmi1;
    output  UnLock2rdmi1;
    input   ARVALIDmi12s1;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER1_WID-1:0]LockPort2wrmi1;
    input   [SELMASTER1_WID:0]LockPort2wrmi1;

    output  ReadIntEmptyWrmi12Rdmi1;
    input   DataCntEmptyRdmi12Wrmi1;
    output  [SELMASTER1_WID-1:0]CtlDataWrite2Lock1;

    //Slave 2
    //_____________________________________
    input   Lock2wrmi2;
    input   UnLock2wrmi2;
    output  Lock2rdmi2;
    output  UnLock2rdmi2;
    input   ARVALIDmi22s2;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER2_WID-1:0]LockPort2wrmi2;
    input   [SELMASTER2_WID:0]LockPort2wrmi2;

    output  ReadIntEmptyWrmi22Rdmi2;
    input   DataCntEmptyRdmi22Wrmi2;
    output  [SELMASTER2_WID-1:0]CtlDataWrite2Lock2;

    //Slave 3
    //_____________________________________
    input   Lock2wrmi3;
    input   UnLock2wrmi3;
    output  Lock2rdmi3;
    output  UnLock2rdmi3;
    input   ARVALIDmi32s3;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER3_WID-1:0]LockPort2wrmi3;
    input   [SELMASTER3_WID:0]LockPort2wrmi3;

    output  ReadIntEmptyWrmi32Rdmi3;
    input   DataCntEmptyRdmi32Wrmi3;
    output  [SELMASTER3_WID-1:0]CtlDataWrite2Lock3;

    //Slave 4
    //_____________________________________
    input   Lock2wrmi4;
    input   UnLock2wrmi4;
    output  Lock2rdmi4;
    output  UnLock2rdmi4;
    input   ARVALIDmi42s4;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER4_WID-1:0]LockPort2wrmi4;
    input   [SELMASTER4_WID:0]LockPort2wrmi4;

    output  ReadIntEmptyWrmi42Rdmi4;
    input   DataCntEmptyRdmi42Wrmi4;
    output  [SELMASTER4_WID-1:0]CtlDataWrite2Lock4;

    //Slave 5
    //_____________________________________
    input   Lock2wrmi5;
    input   UnLock2wrmi5;
    output  Lock2rdmi5;
    output  UnLock2rdmi5;
    input   ARVALIDmi52s5;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER5_WID-1:0]LockPort2wrmi5;
    input   [SELMASTER5_WID:0]LockPort2wrmi5;

    output  ReadIntEmptyWrmi52Rdmi5;
    input   DataCntEmptyRdmi52Wrmi5;
    output  [SELMASTER5_WID-1:0]CtlDataWrite2Lock5;
    //_______________________________________________________________

    //SlaveInterface
    //_______________________________________________________________

 
    //For Master 1
    //Write address channel
//Disalbe_id_port
    input   [ADDR_WID-1:0]          AWADDRm12si1;
    input   [AWLEN_WID-1:0]         AWLENm12si1;
    input   [AWSIZE_WID-1:0]        AWSIZEm12si1;  
    input   [AWBURST_WID-1:0]       AWBURSTm12si1; 
    input   [AWLOCK_WID-1:0]        AWLOCKm12si1;  
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALIDm12si1; 
    output  AWREADYsi12m1; 

    //Write data channel
//Disalbe_id_port
    input   [BUS_WID-1:0]           WDATAm12si1;   
    input   [WSTRB_WID-1:0]         WSTRBm12si1;   
    input   WLASTm12si1;   
    input   WVALIDm12si1;  
    output  WREADYsi12m1;  

    //Write response channel
//Disalbe_id_port
    output   [BRESP_WID-1:0]        BRESPsi12m1;   
    output   BVALIDsi12m1;  
    input    BREADYm12si1;  
 
 
    //For Master 3
    //Write address channel
    input   [MASTERID3_WID-1:0]    AWIDm32si3;    
    input   [ADDR_WID-1:0]          AWADDRm32si3;
    input   [AWLEN_WID-1:0]         AWLENm32si3;
    input   [AWSIZE_WID-1:0]        AWSIZEm32si3;  
    input   [AWBURST_WID-1:0]       AWBURSTm32si3; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALIDm32si3; 
    output  AWREADYsi32m3; 

    //Write data channel
    input   [MASTERID3_WID-1:0]   WIDm32si3;     
    input   [BUS_WID-1:0]           WDATAm32si3;   
    input   [WSTRB_WID-1:0]         WSTRBm32si3;   
    input   WLASTm32si3;   
    input   WVALIDm32si3;  
    output  WREADYsi32m3;  

    //Write response channel
    output   [MASTERID3_WID-1:0]  BIDsi32m3;     
    output   [BRESP_WID-1:0]        BRESPsi32m3;   
    output   BVALIDsi32m3;  
    input    BREADYm32si3;  
 
    //For Master 4
    //Write address channel
//Disalbe_id_port
    input   [ADDR_WID-1:0]          AWADDRm42si4;
    input   [AWLEN_WID-1:0]         AWLENm42si4;
    input   [AWSIZE_WID-1:0]        AWSIZEm42si4;  
    input   [AWBURST_WID-1:0]       AWBURSTm42si4; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    input   AWVALIDm42si4; 
    output  AWREADYsi42m4; 

    //Write data channel
//Disalbe_id_port
    input   [BUS_WID-1:0]           WDATAm42si4;   
    input   [WSTRB_WID-1:0]         WSTRBm42si4;   
    input   WLASTm42si4;   
    input   WVALIDm42si4;  
    output  WREADYsi42m4;  

    //Write response channel
//Disalbe_id_port
    output   [BRESP_WID-1:0]        BRESPsi42m4;   
    output   BVALIDsi42m4;  
    input    BREADYm42si4;  
 


    //MasterInterface
    //_______________________________________________________________

    // For slave 0
    //__________________________________________________
    //Write address channel
    output   [SLAVEID0_WID-1:0]AWIDmi02s0;    
    output   [ADDR_WID-1:0]     AWADDRmi02s0;
    output   [AWLEN_WID-1:0]    AWLENmi02s0;
    output   [AWSIZE_WID-1:0]   AWSIZEmi02s0;  
    output   [AWBURST_WID-1:0]  AWBURSTmi02s0; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi02s0; 
    input    AWREADYs02mi0; 
    
    //Write data channel
    output   [SLAVEID0_WID-1:0]WIDmi02s0;     
    output   [BUS_WID-1:0]      WDATAmi02s0;   
    output   [WSTRB_WID-1:0]    WSTRBmi02s0;   
    output   WLASTmi02s0;   
    output   WVALIDmi02s0;  
    input    WREADYs02mi0; 

    //Write response channel
    input   [SLAVEID0_WID-1:0] BIDs02mi0;     
    input   [BRESP_WID-1:0]     BRESPs02mi0;   
    input   BVALIDs02mi0;  
    output  BREADYmi02s0;  

    // For slave 1
    //__________________________________________________
    //Write address channel
    output   [SLAVEID1_WID-1:0]AWIDmi12s1;    
    output   [ADDR_WID-1:0]     AWADDRmi12s1;
    output   [AWLEN_WID-1:0]    AWLENmi12s1;
    output   [AWSIZE_WID-1:0]   AWSIZEmi12s1;  
    output   [AWBURST_WID-1:0]  AWBURSTmi12s1; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi12s1; 
    input    AWREADYs12mi1; 
    
    //Write data channel
    output   [SLAVEID1_WID-1:0]WIDmi12s1;     
    output   [BUS_WID-1:0]      WDATAmi12s1;   
//Disalbe_WSTRB_port
    output   WLASTmi12s1;   
    output   WVALIDmi12s1;  
    input    WREADYs12mi1; 

    //Write response channel
    input   [SLAVEID1_WID-1:0] BIDs12mi1;     
    input   [BRESP_WID-1:0]     BRESPs12mi1;   
    input   BVALIDs12mi1;  
    output  BREADYmi12s1;  

    // For slave 2
    //__________________________________________________
    //Write address channel
    output   [SLAVEID2_WID-1:0]AWIDmi22s2;    
    output   [ADDR_WID-1:0]     AWADDRmi22s2;
    output   [AWLEN_WID-1:0]    AWLENmi22s2;
    output   [AWSIZE_WID-1:0]   AWSIZEmi22s2;  
    output   [AWBURST_WID-1:0]  AWBURSTmi22s2; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi22s2; 
    input    AWREADYs22mi2; 
    
    //Write data channel
    output   [SLAVEID2_WID-1:0]WIDmi22s2;     
    output   [BUS_WID-1:0]      WDATAmi22s2;   
//Disalbe_WSTRB_port
    output   WLASTmi22s2;   
    output   WVALIDmi22s2;  
    input    WREADYs22mi2; 

    //Write response channel
    input   [SLAVEID2_WID-1:0] BIDs22mi2;     
    input   [BRESP_WID-1:0]     BRESPs22mi2;   
    input   BVALIDs22mi2;  
    output  BREADYmi22s2;  

    // For slave 3
    //__________________________________________________
    //Write address channel
    output   [SLAVEID3_WID-1:0]AWIDmi32s3;    
    output   [ADDR_WID-1:0]     AWADDRmi32s3;
    output   [AWLEN_WID-1:0]    AWLENmi32s3;
    output   [AWSIZE_WID-1:0]   AWSIZEmi32s3;  
    output   [AWBURST_WID-1:0]  AWBURSTmi32s3; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi32s3; 
    input    AWREADYs32mi3; 
    
    //Write data channel
    output   [SLAVEID3_WID-1:0]WIDmi32s3;     
    output   [BUS_WID-1:0]      WDATAmi32s3;   
    output   [WSTRB_WID-1:0]    WSTRBmi32s3;   
    output   WLASTmi32s3;   
    output   WVALIDmi32s3;  
    input    WREADYs32mi3; 

    //Write response channel
    input   [SLAVEID3_WID-1:0] BIDs32mi3;     
    input   [BRESP_WID-1:0]     BRESPs32mi3;   
    input   BVALIDs32mi3;  
    output  BREADYmi32s3;  

    // For slave 4
    //__________________________________________________
    //Write address channel
    output   [SLAVEID4_WID-1:0]AWIDmi42s4;    
    output   [ADDR_WID-1:0]     AWADDRmi42s4;
    output   [AWLEN_WID-1:0]    AWLENmi42s4;
    output   [AWSIZE_WID-1:0]   AWSIZEmi42s4;  
    output   [AWBURST_WID-1:0]  AWBURSTmi42s4; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi42s4; 
    input    AWREADYs42mi4; 
    
    //Write data channel
    output   [SLAVEID4_WID-1:0]WIDmi42s4;     
    output   [BUS_WID-1:0]      WDATAmi42s4;   
    output   [WSTRB_WID-1:0]    WSTRBmi42s4;   
    output   WLASTmi42s4;   
    output   WVALIDmi42s4;  
    input    WREADYs42mi4; 

    //Write response channel
    input   [SLAVEID4_WID-1:0] BIDs42mi4;     
    input   [BRESP_WID-1:0]     BRESPs42mi4;   
    input   BVALIDs42mi4;  
    output  BREADYmi42s4;  

    // For slave 5
    //__________________________________________________
    //Write address channel
    output   [SLAVEID5_WID-1:0]AWIDmi52s5;    
    output   [ADDR_WID-1:0]     AWADDRmi52s5;
    output   [AWLEN_WID-1:0]    AWLENmi52s5;
    output   [AWSIZE_WID-1:0]   AWSIZEmi52s5;  
    output   [AWBURST_WID-1:0]  AWBURSTmi52s5; 
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    output   AWVALIDmi52s5; 
    input    AWREADYs52mi5; 
    
    //Write data channel
    output   [SLAVEID5_WID-1:0]WIDmi52s5;     
    output   [BUS_WID-1:0]      WDATAmi52s5;   
    output   [WSTRB_WID-1:0]    WSTRBmi52s5;   
    output   WLASTmi52s5;   
    output   WVALIDmi52s5;  
    input    WREADYs52mi5; 

    //Write response channel
    input   [SLAVEID5_WID-1:0] BIDs52mi5;     
    input   [BRESP_WID-1:0]     BRESPs52mi5;   
    input   BVALIDs52mi5;  
    output  BREADYmi52s5;  



//Master module wire were generated
//Master module 1 - 0
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi0 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi0;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi0 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi0};    
    wire  [BUS_WID-1:0]         WDATAsi12mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi0;  

//Master module wire were generated
//Master module 1 - 1
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi1 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi1;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi1 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi1};    
    wire  [BUS_WID-1:0]         WDATAsi12mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi1;  

//Master module wire were generated
//Master module 1 - 2
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi2 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi2;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi2 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi2};    
    wire  [BUS_WID-1:0]         WDATAsi12mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi2;  

//Master module wire were generated
//Master module 1 - 3
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi3 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi3;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi3 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi3};    
    wire  [BUS_WID-1:0]         WDATAsi12mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi3;  

//Master module wire were generated
//Master module 1 - 4
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi4 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi4;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi4 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi4};    
    wire  [BUS_WID-1:0]         WDATAsi12mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi4;  

//Master module wire were generated
//Master module 1 - 5
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi5 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi5;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi5 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi5};    
    wire  [BUS_WID-1:0]         WDATAsi12mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi5;  

//Master module wire were generated
//Master module 3 - 0
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi0 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi0;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi0 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi0};    
    wire  [BUS_WID-1:0]         WDATAsi32mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi0;  

//Master module wire were generated
//Master module 3 - 1
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi1 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi1;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi1 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi1};    
    wire  [BUS_WID-1:0]         WDATAsi32mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi1;  

//Master module wire were generated
//Master module 3 - 2
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi2 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi2;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi2 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi2};    
    wire  [BUS_WID-1:0]         WDATAsi32mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi2;  

//Master module wire were generated
//Master module 3 - 3
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi3 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi3;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi3 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi3};    
    wire  [BUS_WID-1:0]         WDATAsi32mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi3;  

//Master module wire were generated
//Master module 3 - 4
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi4 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi4;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi4 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi4};    
    wire  [BUS_WID-1:0]         WDATAsi32mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi4;  

//Master module wire were generated
//Master module 3 - 5
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi5 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi5;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi5 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi5};    
    wire  [BUS_WID-1:0]         WDATAsi32mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi5;  

//Master module wire were generated
//Master module 4 - 0
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi0 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi0;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi0 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi0};    
    wire  [BUS_WID-1:0]         WDATAsi42mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi0;  

//Master module wire were generated
//Master module 4 - 3
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi3 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi3;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi3 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi3};    
    wire  [BUS_WID-1:0]         WDATAsi42mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi3;  

//Master module wire were generated
//Master module 4 - 4
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi4 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi4;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi4 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi4};    
    wire  [BUS_WID-1:0]         WDATAsi42mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi4;  

//Master module wire were generated
//Master module 4 - 5
//_____________________________________________________________________

    wire  [MASTERID4_WID-1:0]  AWIDsi42mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi42mi5 = 
             {{BLANKMASTERID4_WID{1'b0}},AWIDsi42mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi42mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi42mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi42mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi42mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi42mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi42mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi42mi5;
    
    wire  [MASTERID4_WID-1:0]  WIDsi42mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi42mi5 =
             {{BLANKMASTERID4_WID{1'b0}},WIDsi42mi5};    
    wire  [BUS_WID-1:0]         WDATAsi42mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi42mi5;  



    wire    [SLAVE_NUM-1:0]     AWVALIDsi12mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si1;
    wire    [SLAVE_NUM-1:0]     WLASTsi12mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi12mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si1;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si1;
    wire    [SLAVE_NUM-1:0]     BREADYsi12mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     WLASTsi32mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si3;
    wire    [SLAVE_NUM-1:0]     BREADYsi32mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi42mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si4;
    wire    [SLAVE_NUM-1:0]     WLASTsi42mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi42mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si4;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si4;
    wire    [SLAVE_NUM-1:0]     BREADYsi42mi;
//_____________________________________________________________________

    //Slave Number 0(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si1;     
    wire   [BRESP_WID-1:0]               BRESPmi02si1; 
    //Slave Number 0(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si3;     
    wire   [BRESP_WID-1:0]               BRESPmi02si3; 
    //Slave Number 0(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si4;     
    wire   [BRESP_WID-1:0]               BRESPmi02si4; 
    //Slave Number 1(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si1;     
    wire   [BRESP_WID-1:0]               BRESPmi12si1; 
    //Slave Number 1(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si3;     
    wire   [BRESP_WID-1:0]               BRESPmi12si3; 
    //Slave Number 2(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si1;     
    wire   [BRESP_WID-1:0]               BRESPmi22si1; 
    //Slave Number 2(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si3;     
    wire   [BRESP_WID-1:0]               BRESPmi22si3; 
    //Slave Number 3(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si1;     
    wire   [BRESP_WID-1:0]               BRESPmi32si1; 
    //Slave Number 3(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si3;     
    wire   [BRESP_WID-1:0]               BRESPmi32si3; 
    //Slave Number 3(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si4;     
    wire   [BRESP_WID-1:0]               BRESPmi32si4; 
    //Slave Number 4(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si1;     
    wire   [BRESP_WID-1:0]               BRESPmi42si1; 
    //Slave Number 4(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si3;     
    wire   [BRESP_WID-1:0]               BRESPmi42si3; 
    //Slave Number 4(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si4;     
    wire   [BRESP_WID-1:0]               BRESPmi42si4; 
    //Slave Number 5(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si1;     
    wire   [BRESP_WID-1:0]               BRESPmi52si1; 
    //Slave Number 5(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si3;     
    wire   [BRESP_WID-1:0]               BRESPmi52si3; 
    //Slave Number 5(slave interface) to 4 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si4;     
    wire   [BRESP_WID-1:0]               BRESPmi52si4; 

//Slave module wire were generated
//Slave module 0    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi02si;
    wire  [MASTER_NUM-1:0]    WREADYmi02si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi02si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi0;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi0;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi02si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi02si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi02si;

//Slave module wire were generated
//Slave module 1    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi12si;
    wire  [MASTER_NUM-1:0]    WREADYmi12si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi12si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi1;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi1;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi12si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi12si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi12si;

//Slave module wire were generated
//Slave module 2    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi22si;
    wire  [MASTER_NUM-1:0]    WREADYmi22si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi22si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi2;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi2;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi22si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi22si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi22si;

//Slave module wire were generated
//Slave module 3    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi32si;
    wire  [MASTER_NUM-1:0]    WREADYmi32si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi32si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi3;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi3;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi32si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi32si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi32si;

//Slave module wire were generated
//Slave module 4    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi42si;
    wire  [MASTER_NUM-1:0]    WREADYmi42si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi42si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi4;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi4;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi42si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi42si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi42si;

//Slave module wire were generated
//Slave module 5    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi52si;
    wire  [MASTER_NUM-1:0]    WREADYmi52si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi52si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi5;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi5;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi52si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi52si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi52si;


//MaserInterface to SlaveInterface Setting
//_____________________________________________________________________
//SlaveNum  [0]
/////////////////////////////
    assign SetAWREADYmi02si[0] = 1'b0;
    assign SetAWREADYmi02si[1] = AWREADYmi02si[0]; 
    assign SetAWREADYmi02si[2] = 1'b0;
    assign SetAWREADYmi02si[3] = AWREADYmi02si[1]; 
    assign SetAWREADYmi02si[4] = AWREADYmi02si[2]; 
//SlaveNum  [1]
/////////////////////////////
    assign SetAWREADYmi12si[0] = 1'b0;
    assign SetAWREADYmi12si[1] = AWREADYmi12si[0]; 
    assign SetAWREADYmi12si[2] = 1'b0;
    assign SetAWREADYmi12si[3] = AWREADYmi12si[1]; 
    assign SetAWREADYmi12si[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetAWREADYmi22si[0] = 1'b0;
    assign SetAWREADYmi22si[1] = AWREADYmi22si[0]; 
    assign SetAWREADYmi22si[2] = 1'b0;
    assign SetAWREADYmi22si[3] = AWREADYmi22si[1]; 
    assign SetAWREADYmi22si[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetAWREADYmi32si[0] = 1'b0;
    assign SetAWREADYmi32si[1] = AWREADYmi32si[0]; 
    assign SetAWREADYmi32si[2] = 1'b0;
    assign SetAWREADYmi32si[3] = AWREADYmi32si[1]; 
    assign SetAWREADYmi32si[4] = AWREADYmi32si[2]; 
//SlaveNum  [4]
/////////////////////////////
    assign SetAWREADYmi42si[0] = 1'b0;
    assign SetAWREADYmi42si[1] = AWREADYmi42si[0]; 
    assign SetAWREADYmi42si[2] = 1'b0;
    assign SetAWREADYmi42si[3] = AWREADYmi42si[1]; 
    assign SetAWREADYmi42si[4] = AWREADYmi42si[2]; 
//SlaveNum  [5]
/////////////////////////////
    assign SetAWREADYmi52si[0] = 1'b0;
    assign SetAWREADYmi52si[1] = AWREADYmi52si[0]; 
    assign SetAWREADYmi52si[2] = 1'b0;
    assign SetAWREADYmi52si[3] = AWREADYmi52si[1]; 
    assign SetAWREADYmi52si[4] = AWREADYmi52si[2]; 

//SlaveNum  [0]
/////////////////////////////
    assign  SetWREADYmi02si[0] = 1'b0;
    assign  SetWREADYmi02si[1] = WREADYmi02si[0];   
    assign  SetWREADYmi02si[2] = 1'b0;
    assign  SetWREADYmi02si[3] = WREADYmi02si[1];   
    assign  SetWREADYmi02si[4] = WREADYmi02si[2];   
//SlaveNum  [1]
/////////////////////////////
    assign  SetWREADYmi12si[0] = 1'b0;
    assign  SetWREADYmi12si[1] = WREADYmi12si[0];   
    assign  SetWREADYmi12si[2] = 1'b0;
    assign  SetWREADYmi12si[3] = WREADYmi12si[1];   
    assign  SetWREADYmi12si[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  SetWREADYmi22si[0] = 1'b0;
    assign  SetWREADYmi22si[1] = WREADYmi22si[0];   
    assign  SetWREADYmi22si[2] = 1'b0;
    assign  SetWREADYmi22si[3] = WREADYmi22si[1];   
    assign  SetWREADYmi22si[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  SetWREADYmi32si[0] = 1'b0;
    assign  SetWREADYmi32si[1] = WREADYmi32si[0];   
    assign  SetWREADYmi32si[2] = 1'b0;
    assign  SetWREADYmi32si[3] = WREADYmi32si[1];   
    assign  SetWREADYmi32si[4] = WREADYmi32si[2];   
//SlaveNum  [4]
/////////////////////////////
    assign  SetWREADYmi42si[0] = 1'b0;
    assign  SetWREADYmi42si[1] = WREADYmi42si[0];   
    assign  SetWREADYmi42si[2] = 1'b0;
    assign  SetWREADYmi42si[3] = WREADYmi42si[1];   
    assign  SetWREADYmi42si[4] = WREADYmi42si[2];   
//SlaveNum  [5]
/////////////////////////////
    assign  SetWREADYmi52si[0] = 1'b0;
    assign  SetWREADYmi52si[1] = WREADYmi52si[0];   
    assign  SetWREADYmi52si[2] = 1'b0;
    assign  SetWREADYmi52si[3] = WREADYmi52si[1];   
    assign  SetWREADYmi52si[4] = WREADYmi52si[2];   

//SlaveNum  [0]
/////////////////////////////
    assign SetBVALIDmi02si[0]  = 1'b0;
    assign SetBVALIDmi02si[1]  = BVALIDmi02si[0];
    assign SetBVALIDmi02si[2]  = 1'b0;
    assign SetBVALIDmi02si[3]  = BVALIDmi02si[1];
    assign SetBVALIDmi02si[4]  = BVALIDmi02si[2];
//SlaveNum  [1]
/////////////////////////////
    assign SetBVALIDmi12si[0]  = 1'b0;
    assign SetBVALIDmi12si[1]  = BVALIDmi12si[0];
    assign SetBVALIDmi12si[2]  = 1'b0;
    assign SetBVALIDmi12si[3]  = BVALIDmi12si[1];
    assign SetBVALIDmi12si[4]  = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetBVALIDmi22si[0]  = 1'b0;
    assign SetBVALIDmi22si[1]  = BVALIDmi22si[0];
    assign SetBVALIDmi22si[2]  = 1'b0;
    assign SetBVALIDmi22si[3]  = BVALIDmi22si[1];
    assign SetBVALIDmi22si[4]  = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetBVALIDmi32si[0]  = 1'b0;
    assign SetBVALIDmi32si[1]  = BVALIDmi32si[0];
    assign SetBVALIDmi32si[2]  = 1'b0;
    assign SetBVALIDmi32si[3]  = BVALIDmi32si[1];
    assign SetBVALIDmi32si[4]  = BVALIDmi32si[2];
//SlaveNum  [4]
/////////////////////////////
    assign SetBVALIDmi42si[0]  = 1'b0;
    assign SetBVALIDmi42si[1]  = BVALIDmi42si[0];
    assign SetBVALIDmi42si[2]  = 1'b0;
    assign SetBVALIDmi42si[3]  = BVALIDmi42si[1];
    assign SetBVALIDmi42si[4]  = BVALIDmi42si[2];
//SlaveNum  [5]
/////////////////////////////
    assign SetBVALIDmi52si[0]  = 1'b0;
    assign SetBVALIDmi52si[1]  = BVALIDmi52si[0];
    assign SetBVALIDmi52si[2]  = 1'b0;
    assign SetBVALIDmi52si[3]  = BVALIDmi52si[1];
    assign SetBVALIDmi52si[4]  = BVALIDmi52si[2];

//AWREADYmi2si///////////////////////
//MasterNum  [1]
/////////////////////////////
    assign  AWREADYmi2si1[0] = SetAWREADYmi02si[1];
    assign  AWREADYmi2si1[1] = SetAWREADYmi12si[1];
    assign  AWREADYmi2si1[2] = SetAWREADYmi22si[1];
    assign  AWREADYmi2si1[3] = SetAWREADYmi32si[1];
    assign  AWREADYmi2si1[4] = SetAWREADYmi42si[1];
    assign  AWREADYmi2si1[5] = SetAWREADYmi52si[1];
//MasterNum  [3]
/////////////////////////////
    assign  AWREADYmi2si3[0] = SetAWREADYmi02si[3];
    assign  AWREADYmi2si3[1] = SetAWREADYmi12si[3];
    assign  AWREADYmi2si3[2] = SetAWREADYmi22si[3];
    assign  AWREADYmi2si3[3] = SetAWREADYmi32si[3];
    assign  AWREADYmi2si3[4] = SetAWREADYmi42si[3];
    assign  AWREADYmi2si3[5] = SetAWREADYmi52si[3];
//MasterNum  [4]
/////////////////////////////
    assign  AWREADYmi2si4[0] = SetAWREADYmi02si[4];
    assign  AWREADYmi2si4[1] = SetAWREADYmi12si[4];
    assign  AWREADYmi2si4[2] = SetAWREADYmi22si[4];
    assign  AWREADYmi2si4[3] = SetAWREADYmi32si[4];
    assign  AWREADYmi2si4[4] = SetAWREADYmi42si[4];
    assign  AWREADYmi2si4[5] = SetAWREADYmi52si[4];

//BVALIDmi2si////////////////////////
//MasterNum  [1]
/////////////////////////////
    assign  BVALIDmi2si1[0] = SetBVALIDmi02si[1];
    assign  BVALIDmi2si1[1] = SetBVALIDmi12si[1];
    assign  BVALIDmi2si1[2] = SetBVALIDmi22si[1];
    assign  BVALIDmi2si1[3] = SetBVALIDmi32si[1];
    assign  BVALIDmi2si1[4] = SetBVALIDmi42si[1];
    assign  BVALIDmi2si1[5] = SetBVALIDmi52si[1];
//MasterNum  [3]
/////////////////////////////
    assign  BVALIDmi2si3[0] = SetBVALIDmi02si[3];
    assign  BVALIDmi2si3[1] = SetBVALIDmi12si[3];
    assign  BVALIDmi2si3[2] = SetBVALIDmi22si[3];
    assign  BVALIDmi2si3[3] = SetBVALIDmi32si[3];
    assign  BVALIDmi2si3[4] = SetBVALIDmi42si[3];
    assign  BVALIDmi2si3[5] = SetBVALIDmi52si[3];
//MasterNum  [4]
/////////////////////////////
    assign  BVALIDmi2si4[0] = SetBVALIDmi02si[4];
    assign  BVALIDmi2si4[1] = SetBVALIDmi12si[4];
    assign  BVALIDmi2si4[2] = SetBVALIDmi22si[4];
    assign  BVALIDmi2si4[3] = SetBVALIDmi32si[4];
    assign  BVALIDmi2si4[4] = SetBVALIDmi42si[4];
    assign  BVALIDmi2si4[5] = SetBVALIDmi52si[4];

//WREADYmi2si////////////////////////
//MasterNum  [1]
/////////////////////////////
    assign  WREADYmi2si1[0] = SetWREADYmi02si[1];
    assign  WREADYmi2si1[1] = SetWREADYmi12si[1];
    assign  WREADYmi2si1[2] = SetWREADYmi22si[1];
    assign  WREADYmi2si1[3] = SetWREADYmi32si[1];
    assign  WREADYmi2si1[4] = SetWREADYmi42si[1];
    assign  WREADYmi2si1[5] = SetWREADYmi52si[1];
//MasterNum  [3]
/////////////////////////////
    assign  WREADYmi2si3[0] = SetWREADYmi02si[3];
    assign  WREADYmi2si3[1] = SetWREADYmi12si[3];
    assign  WREADYmi2si3[2] = SetWREADYmi22si[3];
    assign  WREADYmi2si3[3] = SetWREADYmi32si[3];
    assign  WREADYmi2si3[4] = SetWREADYmi42si[3];
    assign  WREADYmi2si3[5] = SetWREADYmi52si[3];
//MasterNum  [4]
/////////////////////////////
    assign  WREADYmi2si4[0] = SetWREADYmi02si[4];
    assign  WREADYmi2si4[1] = SetWREADYmi12si[4];
    assign  WREADYmi2si4[2] = SetWREADYmi22si[4];
    assign  WREADYmi2si4[3] = SetWREADYmi32si[4];
    assign  WREADYmi2si4[4] = SetWREADYmi42si[4];
    assign  WREADYmi2si4[5] = SetWREADYmi52si[4];

//_____________________________________________________________________


//SlaveInterface to MasterInterface Setting
//_____________________________________________________________________

//AWVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  AWVALIDsi2mi0[0] = AWVALIDsi12mi[0];
    assign  AWVALIDsi2mi0[1] = AWVALIDsi32mi[0];
    assign  AWVALIDsi2mi0[2] = AWVALIDsi42mi[0];
    assign  AWVALIDsi2mi0[3] = 1'b0;
    assign  AWVALIDsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  AWVALIDsi2mi1[0] = AWVALIDsi12mi[1];
    assign  AWVALIDsi2mi1[1] = AWVALIDsi32mi[1];
    assign  AWVALIDsi2mi1[2] = 1'b0;
    assign  AWVALIDsi2mi1[3] = 1'b0;
    assign  AWVALIDsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  AWVALIDsi2mi2[0] = AWVALIDsi12mi[2];
    assign  AWVALIDsi2mi2[1] = AWVALIDsi32mi[2];
    assign  AWVALIDsi2mi2[2] = 1'b0;
    assign  AWVALIDsi2mi2[3] = 1'b0;
    assign  AWVALIDsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  AWVALIDsi2mi3[0] = AWVALIDsi12mi[3];
    assign  AWVALIDsi2mi3[1] = AWVALIDsi32mi[3];
    assign  AWVALIDsi2mi3[2] = AWVALIDsi42mi[3];
    assign  AWVALIDsi2mi3[3] = 1'b0;
    assign  AWVALIDsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  AWVALIDsi2mi4[0] = AWVALIDsi12mi[4];
    assign  AWVALIDsi2mi4[1] = AWVALIDsi32mi[4];
    assign  AWVALIDsi2mi4[2] = AWVALIDsi42mi[4];
    assign  AWVALIDsi2mi4[3] = 1'b0;
    assign  AWVALIDsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  AWVALIDsi2mi5[0] = AWVALIDsi12mi[5];
    assign  AWVALIDsi2mi5[1] = AWVALIDsi32mi[5];
    assign  AWVALIDsi2mi5[2] = AWVALIDsi42mi[5];
    assign  AWVALIDsi2mi5[3] = 1'b0;
    assign  AWVALIDsi2mi5[4] = 1'b0;

//WVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WVALIDsi2mi0[0] = WVALIDsi12mi[0];
    assign  WVALIDsi2mi0[1] = WVALIDsi32mi[0];
    assign  WVALIDsi2mi0[2] = WVALIDsi42mi[0];
    assign  WVALIDsi2mi0[3] = 1'b0;
    assign  WVALIDsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WVALIDsi2mi1[0] = WVALIDsi12mi[1];
    assign  WVALIDsi2mi1[1] = WVALIDsi32mi[1];
    assign  WVALIDsi2mi1[2] = 1'b0;
    assign  WVALIDsi2mi1[3] = 1'b0;
    assign  WVALIDsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WVALIDsi2mi2[0] = WVALIDsi12mi[2];
    assign  WVALIDsi2mi2[1] = WVALIDsi32mi[2];
    assign  WVALIDsi2mi2[2] = 1'b0;
    assign  WVALIDsi2mi2[3] = 1'b0;
    assign  WVALIDsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WVALIDsi2mi3[0] = WVALIDsi12mi[3];
    assign  WVALIDsi2mi3[1] = WVALIDsi32mi[3];
    assign  WVALIDsi2mi3[2] = WVALIDsi42mi[3];
    assign  WVALIDsi2mi3[3] = 1'b0;
    assign  WVALIDsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WVALIDsi2mi4[0] = WVALIDsi12mi[4];
    assign  WVALIDsi2mi4[1] = WVALIDsi32mi[4];
    assign  WVALIDsi2mi4[2] = WVALIDsi42mi[4];
    assign  WVALIDsi2mi4[3] = 1'b0;
    assign  WVALIDsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WVALIDsi2mi5[0] = WVALIDsi12mi[5];
    assign  WVALIDsi2mi5[1] = WVALIDsi32mi[5];
    assign  WVALIDsi2mi5[2] = WVALIDsi42mi[5];
    assign  WVALIDsi2mi5[3] = 1'b0;
    assign  WVALIDsi2mi5[4] = 1'b0;

//WLASTsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WLASTsi2mi0[0] = WLASTsi12mi[0];
    assign  WLASTsi2mi0[1] = WLASTsi32mi[0];
    assign  WLASTsi2mi0[2] = WLASTsi42mi[0];
    assign  WLASTsi2mi0[3] = 1'b0;
    assign  WLASTsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WLASTsi2mi1[0] = WLASTsi12mi[1];
    assign  WLASTsi2mi1[1] = WLASTsi32mi[1];
    assign  WLASTsi2mi1[2] = 1'b0;
    assign  WLASTsi2mi1[3] = 1'b0;
    assign  WLASTsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WLASTsi2mi2[0] = WLASTsi12mi[2];
    assign  WLASTsi2mi2[1] = WLASTsi32mi[2];
    assign  WLASTsi2mi2[2] = 1'b0;
    assign  WLASTsi2mi2[3] = 1'b0;
    assign  WLASTsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WLASTsi2mi3[0] = WLASTsi12mi[3];
    assign  WLASTsi2mi3[1] = WLASTsi32mi[3];
    assign  WLASTsi2mi3[2] = WLASTsi42mi[3];
    assign  WLASTsi2mi3[3] = 1'b0;
    assign  WLASTsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WLASTsi2mi4[0] = WLASTsi12mi[4];
    assign  WLASTsi2mi4[1] = WLASTsi32mi[4];
    assign  WLASTsi2mi4[2] = WLASTsi42mi[4];
    assign  WLASTsi2mi4[3] = 1'b0;
    assign  WLASTsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WLASTsi2mi5[0] = WLASTsi12mi[5];
    assign  WLASTsi2mi5[1] = WLASTsi32mi[5];
    assign  WLASTsi2mi5[2] = WLASTsi42mi[5];
    assign  WLASTsi2mi5[3] = 1'b0;
    assign  WLASTsi2mi5[4] = 1'b0;

//BREADYsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  BREADYsi2mi0[0] = BREADYsi12mi[0];
    assign  BREADYsi2mi0[1] = BREADYsi32mi[0];
    assign  BREADYsi2mi0[2] = BREADYsi42mi[0];
    assign  BREADYsi2mi0[3] = 1'b0;
    assign  BREADYsi2mi0[4] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  BREADYsi2mi1[0] = BREADYsi12mi[1];
    assign  BREADYsi2mi1[1] = BREADYsi32mi[1];
    assign  BREADYsi2mi1[2] = 1'b0;
    assign  BREADYsi2mi1[3] = 1'b0;
    assign  BREADYsi2mi1[4] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  BREADYsi2mi2[0] = BREADYsi12mi[2];
    assign  BREADYsi2mi2[1] = BREADYsi32mi[2];
    assign  BREADYsi2mi2[2] = 1'b0;
    assign  BREADYsi2mi2[3] = 1'b0;
    assign  BREADYsi2mi2[4] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  BREADYsi2mi3[0] = BREADYsi12mi[3];
    assign  BREADYsi2mi3[1] = BREADYsi32mi[3];
    assign  BREADYsi2mi3[2] = BREADYsi42mi[3];
    assign  BREADYsi2mi3[3] = 1'b0;
    assign  BREADYsi2mi3[4] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  BREADYsi2mi4[0] = BREADYsi12mi[4];
    assign  BREADYsi2mi4[1] = BREADYsi32mi[4];
    assign  BREADYsi2mi4[2] = BREADYsi42mi[4];
    assign  BREADYsi2mi4[3] = 1'b0;
    assign  BREADYsi2mi4[4] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  BREADYsi2mi5[0] = BREADYsi12mi[5];
    assign  BREADYsi2mi5[1] = BREADYsi32mi[5];
    assign  BREADYsi2mi5[2] = BREADYsi42mi[5];
    assign  BREADYsi2mi5[3] = 1'b0;
    assign  BREADYsi2mi5[4] = 1'b0;

//_____________________________________________________________________



//Master module 1    
//________________________________________________________________________

ARMD_RS_WriteChannelsi
ARMD_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disalbe_id_port
    .AWADDRm2si  (AWADDRm12si1),
    .AWLENm2si   (AWLENm12si1),
    .AWSIZEm2si  (AWSIZEm12si1),
    .AWBURSTm2si (AWBURSTm12si1),
    .AWLOCKm2si  (AWLOCKm12si1),
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm2si (AWVALIDm12si1),
    .AWREADYsi2m (AWREADYsi12m1),

    //Write data channel
//Disalbe_id_port
    .WDATAm2si   (WDATAm12si1),
    .WSTRBm2si   (WSTRBm12si1),
    .WLASTm2si   (WLASTm12si1),
    .WVALIDm2si  (WVALIDm12si1),
    .WREADYsi2m  (WREADYsi12m1),

    //Write response channel
//Disalbe_id_port
    .BRESPsi2m   (BRESPsi12m1),
    .BVALIDsi2m  (BVALIDsi12m1),
    .BREADYm2si  (BREADYm12si1),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi12mi0),
    .AWADDRsi2mi0  (AWADDRsi12mi0),
    .AWLENsi2mi0   (AWLENsi12mi0),
    .AWSIZEsi2mi0  (AWSIZEsi12mi0),
    .AWBURSTsi2mi0 (AWBURSTsi12mi0),
    .AWLOCKsi2mi0  (AWLOCKsi12mi0),
    .AWCACHEsi2mi0 (AWCACHEsi12mi0),
    .AWPROTsi2mi0  (AWPROTsi12mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi12mi0),
    .WDATAsi2mi0   (WDATAsi12mi0),
    .WSTRBsi2mi0   (WSTRBsi12mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si1[MASTERID1_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi12mi1),
    .AWADDRsi2mi1  (AWADDRsi12mi1),
    .AWLENsi2mi1   (AWLENsi12mi1),
    .AWSIZEsi2mi1  (AWSIZEsi12mi1),
    .AWBURSTsi2mi1 (AWBURSTsi12mi1),
    .AWLOCKsi2mi1  (AWLOCKsi12mi1),
    .AWCACHEsi2mi1 (AWCACHEsi12mi1),
    .AWPROTsi2mi1  (AWPROTsi12mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi12mi1),
    .WDATAsi2mi1   (WDATAsi12mi1),
    .WSTRBsi2mi1   (WSTRBsi12mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si1[MASTERID1_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi12mi2),
    .AWADDRsi2mi2  (AWADDRsi12mi2),
    .AWLENsi2mi2   (AWLENsi12mi2),
    .AWSIZEsi2mi2  (AWSIZEsi12mi2),
    .AWBURSTsi2mi2 (AWBURSTsi12mi2),
    .AWLOCKsi2mi2  (AWLOCKsi12mi2),
    .AWCACHEsi2mi2 (AWCACHEsi12mi2),
    .AWPROTsi2mi2  (AWPROTsi12mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi12mi2),
    .WDATAsi2mi2   (WDATAsi12mi2),
    .WSTRBsi2mi2   (WSTRBsi12mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si1[MASTERID1_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi12mi3),
    .AWADDRsi2mi3  (AWADDRsi12mi3),
    .AWLENsi2mi3   (AWLENsi12mi3),
    .AWSIZEsi2mi3  (AWSIZEsi12mi3),
    .AWBURSTsi2mi3 (AWBURSTsi12mi3),
    .AWLOCKsi2mi3  (AWLOCKsi12mi3),
    .AWCACHEsi2mi3 (AWCACHEsi12mi3),
    .AWPROTsi2mi3  (AWPROTsi12mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi12mi3),
    .WDATAsi2mi3   (WDATAsi12mi3),
    .WSTRBsi2mi3   (WSTRBsi12mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si1[MASTERID1_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi12mi4),
    .AWADDRsi2mi4  (AWADDRsi12mi4),
    .AWLENsi2mi4   (AWLENsi12mi4),
    .AWSIZEsi2mi4  (AWSIZEsi12mi4),
    .AWBURSTsi2mi4 (AWBURSTsi12mi4),
    .AWLOCKsi2mi4  (AWLOCKsi12mi4),
    .AWCACHEsi2mi4 (AWCACHEsi12mi4),
    .AWPROTsi2mi4  (AWPROTsi12mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi12mi4),
    .WDATAsi2mi4   (WDATAsi12mi4),
    .WSTRBsi2mi4   (WSTRBsi12mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si1[MASTERID1_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi12mi5),
    .AWADDRsi2mi5  (AWADDRsi12mi5),
    .AWLENsi2mi5   (AWLENsi12mi5),
    .AWSIZEsi2mi5  (AWSIZEsi12mi5),
    .AWBURSTsi2mi5 (AWBURSTsi12mi5),
    .AWLOCKsi2mi5  (AWLOCKsi12mi5),
    .AWCACHEsi2mi5 (AWCACHEsi12mi5),
    .AWPROTsi2mi5  (AWPROTsi12mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi12mi5),
    .WDATAsi2mi5   (WDATAsi12mi5),
    .WSTRBsi2mi5   (WSTRBsi12mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si1[MASTERID1_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si1),

    .AWVALIDsi2mi (AWVALIDsi12mi),
    .AWREADYmi2si (AWREADYmi2si1),

    .WLASTsi2mi   (WLASTsi12mi),
    .WVALIDsi2mi  (WVALIDsi12mi),
    .WREADYmi2si  (WREADYmi2si1),

    .BVALIDmi2si    (BVALIDmi2si1),
    .BREADYsi2mi    (BREADYsi12mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 3    
//________________________________________________________________________

DMACtrl_RS_WriteChannelsi
DMACtrl_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm32si3),
    .AWADDRm2si  (AWADDRm32si3),
    .AWLENm2si   (AWLENm32si3),
    .AWSIZEm2si  (AWSIZEm32si3),
    .AWBURSTm2si (AWBURSTm32si3),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm2si (AWVALIDm32si3),
    .AWREADYsi2m (AWREADYsi32m3),

    //Write data channel
    .WIDm2si     (WIDm32si3),
    .WDATAm2si   (WDATAm32si3),
    .WSTRBm2si   (WSTRBm32si3),
    .WLASTm2si   (WLASTm32si3),
    .WVALIDm2si  (WVALIDm32si3),
    .WREADYsi2m  (WREADYsi32m3),

    //Write response channel
    .BIDsi2m     (BIDsi32m3),
    .BRESPsi2m   (BRESPsi32m3),
    .BVALIDsi2m  (BVALIDsi32m3),
    .BREADYm2si  (BREADYm32si3),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi32mi0),
    .AWADDRsi2mi0  (AWADDRsi32mi0),
    .AWLENsi2mi0   (AWLENsi32mi0),
    .AWSIZEsi2mi0  (AWSIZEsi32mi0),
    .AWBURSTsi2mi0 (AWBURSTsi32mi0),
    .AWLOCKsi2mi0  (AWLOCKsi32mi0),
    .AWCACHEsi2mi0 (AWCACHEsi32mi0),
    .AWPROTsi2mi0  (AWPROTsi32mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi32mi0),
    .WDATAsi2mi0   (WDATAsi32mi0),
    .WSTRBsi2mi0   (WSTRBsi32mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si3[MASTERID3_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi32mi1),
    .AWADDRsi2mi1  (AWADDRsi32mi1),
    .AWLENsi2mi1   (AWLENsi32mi1),
    .AWSIZEsi2mi1  (AWSIZEsi32mi1),
    .AWBURSTsi2mi1 (AWBURSTsi32mi1),
    .AWLOCKsi2mi1  (AWLOCKsi32mi1),
    .AWCACHEsi2mi1 (AWCACHEsi32mi1),
    .AWPROTsi2mi1  (AWPROTsi32mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi32mi1),
    .WDATAsi2mi1   (WDATAsi32mi1),
    .WSTRBsi2mi1   (WSTRBsi32mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si3[MASTERID3_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi32mi2),
    .AWADDRsi2mi2  (AWADDRsi32mi2),
    .AWLENsi2mi2   (AWLENsi32mi2),
    .AWSIZEsi2mi2  (AWSIZEsi32mi2),
    .AWBURSTsi2mi2 (AWBURSTsi32mi2),
    .AWLOCKsi2mi2  (AWLOCKsi32mi2),
    .AWCACHEsi2mi2 (AWCACHEsi32mi2),
    .AWPROTsi2mi2  (AWPROTsi32mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi32mi2),
    .WDATAsi2mi2   (WDATAsi32mi2),
    .WSTRBsi2mi2   (WSTRBsi32mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si3[MASTERID3_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi32mi3),
    .AWADDRsi2mi3  (AWADDRsi32mi3),
    .AWLENsi2mi3   (AWLENsi32mi3),
    .AWSIZEsi2mi3  (AWSIZEsi32mi3),
    .AWBURSTsi2mi3 (AWBURSTsi32mi3),
    .AWLOCKsi2mi3  (AWLOCKsi32mi3),
    .AWCACHEsi2mi3 (AWCACHEsi32mi3),
    .AWPROTsi2mi3  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi32mi3),
    .WDATAsi2mi3   (WDATAsi32mi3),
    .WSTRBsi2mi3   (WSTRBsi32mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si3[MASTERID3_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi32mi4),
    .AWADDRsi2mi4  (AWADDRsi32mi4),
    .AWLENsi2mi4   (AWLENsi32mi4),
    .AWSIZEsi2mi4  (AWSIZEsi32mi4),
    .AWBURSTsi2mi4 (AWBURSTsi32mi4),
    .AWLOCKsi2mi4  (AWLOCKsi32mi4),
    .AWCACHEsi2mi4 (AWCACHEsi32mi4),
    .AWPROTsi2mi4  (AWPROTsi32mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi32mi4),
    .WDATAsi2mi4   (WDATAsi32mi4),
    .WSTRBsi2mi4   (WSTRBsi32mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si3[MASTERID3_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi32mi5),
    .AWADDRsi2mi5  (AWADDRsi32mi5),
    .AWLENsi2mi5   (AWLENsi32mi5),
    .AWSIZEsi2mi5  (AWSIZEsi32mi5),
    .AWBURSTsi2mi5 (AWBURSTsi32mi5),
    .AWLOCKsi2mi5  (AWLOCKsi32mi5),
    .AWCACHEsi2mi5 (AWCACHEsi32mi5),
    .AWPROTsi2mi5  (AWPROTsi32mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi32mi5),
    .WDATAsi2mi5   (WDATAsi32mi5),
    .WSTRBsi2mi5   (WSTRBsi32mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si3[MASTERID3_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si3),

    .AWVALIDsi2mi (AWVALIDsi32mi),
    .AWREADYmi2si (AWREADYmi2si3),

    .WLASTsi2mi   (WLASTsi32mi),
    .WVALIDsi2mi  (WVALIDsi32mi),
    .WREADYmi2si  (WREADYmi2si3),

    .BVALIDmi2si    (BVALIDmi2si3),
    .BREADYsi2mi    (BREADYsi32mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 4    
//________________________________________________________________________

VideoIn_RS_WriteChannelsi
VideoIn_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disalbe_id_port
    .AWADDRm2si  (AWADDRm42si4),
    .AWLENm2si   (AWLENm42si4),
    .AWSIZEm2si  (AWSIZEm42si4),
    .AWBURSTm2si (AWBURSTm42si4),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDm2si (AWVALIDm42si4),
    .AWREADYsi2m (AWREADYsi42m4),

    //Write data channel
//Disalbe_id_port
    .WDATAm2si   (WDATAm42si4),
    .WSTRBm2si   (WSTRBm42si4),
    .WLASTm2si   (WLASTm42si4),
    .WVALIDm2si  (WVALIDm42si4),
    .WREADYsi2m  (WREADYsi42m4),

    //Write response channel
//Disalbe_id_port
    .BRESPsi2m   (BRESPsi42m4),
    .BVALIDsi2m  (BVALIDsi42m4),
    .BREADYm2si  (BREADYm42si4),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi42mi0),
    .AWADDRsi2mi0  (AWADDRsi42mi0),
    .AWLENsi2mi0   (AWLENsi42mi0),
    .AWSIZEsi2mi0  (AWSIZEsi42mi0),
    .AWBURSTsi2mi0 (AWBURSTsi42mi0),
    .AWLOCKsi2mi0  (AWLOCKsi42mi0),
    .AWCACHEsi2mi0 (AWCACHEsi42mi0),
    .AWPROTsi2mi0  (AWPROTsi42mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi42mi0),
    .WDATAsi2mi0   (WDATAsi42mi0),
    .WSTRBsi2mi0   (WSTRBsi42mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si4[MASTERID4_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi42mi3),
    .AWADDRsi2mi3  (AWADDRsi42mi3),
    .AWLENsi2mi3   (AWLENsi42mi3),
    .AWSIZEsi2mi3  (AWSIZEsi42mi3),
    .AWBURSTsi2mi3 (AWBURSTsi42mi3),
    .AWLOCKsi2mi3  (AWLOCKsi42mi3),
    .AWCACHEsi2mi3 (AWCACHEsi42mi3),
    .AWPROTsi2mi3  (AWPROTsi42mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi42mi3),
    .WDATAsi2mi3   (WDATAsi42mi3),
    .WSTRBsi2mi3   (WSTRBsi42mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si4[MASTERID4_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi42mi4),
    .AWADDRsi2mi4  (AWADDRsi42mi4),
    .AWLENsi2mi4   (AWLENsi42mi4),
    .AWSIZEsi2mi4  (AWSIZEsi42mi4),
    .AWBURSTsi2mi4 (AWBURSTsi42mi4),
    .AWLOCKsi2mi4  (AWLOCKsi42mi4),
    .AWCACHEsi2mi4 (AWCACHEsi42mi4),
    .AWPROTsi2mi4  (AWPROTsi42mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi42mi4),
    .WDATAsi2mi4   (WDATAsi42mi4),
    .WSTRBsi2mi4   (WSTRBsi42mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si4[MASTERID4_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si4),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi42mi5),
    .AWADDRsi2mi5  (AWADDRsi42mi5),
    .AWLENsi2mi5   (AWLENsi42mi5),
    .AWSIZEsi2mi5  (AWSIZEsi42mi5),
    .AWBURSTsi2mi5 (AWBURSTsi42mi5),
    .AWLOCKsi2mi5  (AWLOCKsi42mi5),
    .AWCACHEsi2mi5 (AWCACHEsi42mi5),
    .AWPROTsi2mi5  (AWPROTsi42mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi42mi5),
    .WDATAsi2mi5   (WDATAsi42mi5),
    .WSTRBsi2mi5   (WSTRBsi42mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si4[MASTERID4_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si4),

    .AWVALIDsi2mi (AWVALIDsi42mi),
    .AWREADYmi2si (AWREADYmi2si4),

    .WLASTsi2mi   (WLASTsi42mi),
    .WVALIDsi2mi  (WVALIDsi42mi),
    .WREADYmi2si  (WREADYmi2si4),

    .BVALIDmi2si    (BVALIDmi2si4),
    .BREADYsi2mi    (BREADYsi42mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Slave module 0    
//___________________________________________________________________________

DDRCtrl_RS_WriteChannelmi
DDRCtrl_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi02s0),
    .AWADDRmi2s  (AWADDRmi02s0),
    .AWLENmi2s   (AWLENmi02s0),
    .AWSIZEmi2s  (AWSIZEmi02s0),
    .AWBURSTmi2s (AWBURSTmi02s0),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi02s0),
    .AWREADYs2mi (AWREADYs02mi0),

    //Write data channel
    .WIDmi2s     (WIDmi02s0),
    .WDATAmi2s   (WDATAmi02s0),
    .WSTRBmi2s   (WSTRBmi02s0),
    .WLASTmi2s   (WLASTmi02s0),
    .WVALIDmi2s  (WVALIDmi02s0),
    .WREADYs2mi  (WREADYs02mi0),

    //Write response channel
    .BIDs2mi     (BIDs02mi0),
    .BRESPs2mi   (BRESPs02mi0),
    .BVALIDs2mi  (BVALIDs02mi0),
    .BREADYmi2s  (BREADYmi02s0),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi0),
    .AWLENsi02mi   (AWLENsi12mi0),
    .AWSIZEsi02mi  (AWSIZEsi12mi0),
    .AWBURSTsi02mi (AWBURSTsi12mi0),
    .AWLOCKsi02mi  (AWLOCKsi12mi0),
    .AWCACHEsi02mi (AWCACHEsi12mi0),
    .AWPROTsi02mi  (AWPROTsi12mi0),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi0),   
    .WSTRBsi02mi (WSTRBsi12mi0),   

    //Write response channel
    .BIDmi2si0     (BIDmi02si1),
    .BRESPmi2si0   (BRESPmi02si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi0),
    .AWLENsi12mi   (AWLENsi32mi0),
    .AWSIZEsi12mi  (AWSIZEsi32mi0),
    .AWBURSTsi12mi (AWBURSTsi32mi0),
    .AWLOCKsi12mi  (AWLOCKsi32mi0),
    .AWCACHEsi12mi (AWCACHEsi32mi0),
    .AWPROTsi12mi  (AWPROTsi32mi0),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi0),   
    .WSTRBsi12mi (WSTRBsi32mi0),   

    //Write response channel
    .BIDmi2si1     (BIDmi02si3),
    .BRESPmi2si1   (BRESPmi02si3),
    //Master Number 4
    //Write address channel
    .AWIDsi22mi    (wAWIDsi42mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi42mi0),
    .AWLENsi22mi   (AWLENsi42mi0),
    .AWSIZEsi22mi  (AWSIZEsi42mi0),
    .AWBURSTsi22mi (AWBURSTsi42mi0),
    .AWLOCKsi22mi  (AWLOCKsi42mi0),
    .AWCACHEsi22mi (AWCACHEsi42mi0),
    .AWPROTsi22mi  (AWPROTsi42mi0),

    //Write data channel
    .WIDsi22mi   (wWIDsi42mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi22mi (WDATAsi42mi0),   
    .WSTRBsi22mi (WSTRBsi42mi0),   

    //Write response channel
    .BIDmi2si2     (BIDmi02si4),
    .BRESPmi2si2   (BRESPmi02si4),

    .BVALIDmi2si  (BVALIDmi02si),
    .BREADYsi2mi   (BREADYsi2mi0),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi0),
    .AWREADYmi2si  (AWREADYmi02si),
    .WLASTsi2mi    (WLASTsi2mi0),
    .WVALIDsi2mi   (WVALIDsi2mi0),
    .WREADYmi2si   (WREADYmi02si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi0),
    .UnLock2Wrmi(UnLock2wrmi0),

    .Lock2Rdmi(Lock2rdmi0),
    .UnLock2Rdmi(UnLock2rdmi0),

    .ARVALID(ARVALIDmi02s0),
    .LockPort(LockPort2wrmi0),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi02Rdmi0),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi02Wrmi0),
    .CtlDataWrite2Lock(CtlDataWrite2Lock0)
    ////////////////////////////////////////

    );

//Slave module 1    
//___________________________________________________________________________

APB0_RS_WriteChannelmi
APB0_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi12s1),
    .AWADDRmi2s  (AWADDRmi12s1),
    .AWLENmi2s   (AWLENmi12s1),
    .AWSIZEmi2s  (AWSIZEmi12s1),
    .AWBURSTmi2s (AWBURSTmi12s1),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi12s1),
    .AWREADYs2mi (AWREADYs12mi1),

    //Write data channel
    .WIDmi2s     (WIDmi12s1),
    .WDATAmi2s   (WDATAmi12s1),
//Disalbe_WSTRB_port
    .WLASTmi2s   (WLASTmi12s1),
    .WVALIDmi2s  (WVALIDmi12s1),
    .WREADYs2mi  (WREADYs12mi1),

    //Write response channel
    .BIDs2mi     (BIDs12mi1),
    .BRESPs2mi   (BRESPs12mi1),
    .BVALIDs2mi  (BVALIDs12mi1),
    .BREADYmi2s  (BREADYmi12s1),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi1),
    .AWLENsi02mi   (AWLENsi12mi1),
    .AWSIZEsi02mi  (AWSIZEsi12mi1),
    .AWBURSTsi02mi (AWBURSTsi12mi1),
    .AWLOCKsi02mi  (AWLOCKsi12mi1),
    .AWCACHEsi02mi (AWCACHEsi12mi1),
    .AWPROTsi02mi  (AWPROTsi12mi1),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi1),   
    .WSTRBsi02mi (WSTRBsi12mi1),   

    //Write response channel
    .BIDmi2si0     (BIDmi12si1),
    .BRESPmi2si0   (BRESPmi12si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi1),
    .AWLENsi12mi   (AWLENsi32mi1),
    .AWSIZEsi12mi  (AWSIZEsi32mi1),
    .AWBURSTsi12mi (AWBURSTsi32mi1),
    .AWLOCKsi12mi  (AWLOCKsi32mi1),
    .AWCACHEsi12mi (AWCACHEsi32mi1),
    .AWPROTsi12mi  (AWPROTsi32mi1),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi1),   
    .WSTRBsi12mi (WSTRBsi32mi1),   

    //Write response channel
    .BIDmi2si1     (BIDmi12si3),
    .BRESPmi2si1   (BRESPmi12si3),

    .BVALIDmi2si  (BVALIDmi12si),
    .BREADYsi2mi   (BREADYsi2mi1),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi1),
    .AWREADYmi2si  (AWREADYmi12si),
    .WLASTsi2mi    (WLASTsi2mi1),
    .WVALIDsi2mi   (WVALIDsi2mi1),
    .WREADYmi2si   (WREADYmi12si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi1),
    .UnLock2Wrmi(UnLock2wrmi1),

    .Lock2Rdmi(Lock2rdmi1),
    .UnLock2Rdmi(UnLock2rdmi1),

    .ARVALID(ARVALIDmi12s1),
    .LockPort(LockPort2wrmi1),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi12Rdmi1),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi12Wrmi1),
    .CtlDataWrite2Lock(CtlDataWrite2Lock1)
    ////////////////////////////////////////

    );

//Slave module 2    
//___________________________________________________________________________

APB1_RS_WriteChannelmi
APB1_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi22s2),
    .AWADDRmi2s  (AWADDRmi22s2),
    .AWLENmi2s   (AWLENmi22s2),
    .AWSIZEmi2s  (AWSIZEmi22s2),
    .AWBURSTmi2s (AWBURSTmi22s2),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi22s2),
    .AWREADYs2mi (AWREADYs22mi2),

    //Write data channel
    .WIDmi2s     (WIDmi22s2),
    .WDATAmi2s   (WDATAmi22s2),
//Disalbe_WSTRB_port
    .WLASTmi2s   (WLASTmi22s2),
    .WVALIDmi2s  (WVALIDmi22s2),
    .WREADYs2mi  (WREADYs22mi2),

    //Write response channel
    .BIDs2mi     (BIDs22mi2),
    .BRESPs2mi   (BRESPs22mi2),
    .BVALIDs2mi  (BVALIDs22mi2),
    .BREADYmi2s  (BREADYmi22s2),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi2),
    .AWLENsi02mi   (AWLENsi12mi2),
    .AWSIZEsi02mi  (AWSIZEsi12mi2),
    .AWBURSTsi02mi (AWBURSTsi12mi2),
    .AWLOCKsi02mi  (AWLOCKsi12mi2),
    .AWCACHEsi02mi (AWCACHEsi12mi2),
    .AWPROTsi02mi  (AWPROTsi12mi2),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi2),   
    .WSTRBsi02mi (WSTRBsi12mi2),   

    //Write response channel
    .BIDmi2si0     (BIDmi22si1),
    .BRESPmi2si0   (BRESPmi22si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi2),
    .AWLENsi12mi   (AWLENsi32mi2),
    .AWSIZEsi12mi  (AWSIZEsi32mi2),
    .AWBURSTsi12mi (AWBURSTsi32mi2),
    .AWLOCKsi12mi  (AWLOCKsi32mi2),
    .AWCACHEsi12mi (AWCACHEsi32mi2),
    .AWPROTsi12mi  (AWPROTsi32mi2),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi2),   
    .WSTRBsi12mi (WSTRBsi32mi2),   

    //Write response channel
    .BIDmi2si1     (BIDmi22si3),
    .BRESPmi2si1   (BRESPmi22si3),

    .BVALIDmi2si  (BVALIDmi22si),
    .BREADYsi2mi   (BREADYsi2mi2),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi2),
    .AWREADYmi2si  (AWREADYmi22si),
    .WLASTsi2mi    (WLASTsi2mi2),
    .WVALIDsi2mi   (WVALIDsi2mi2),
    .WREADYmi2si   (WREADYmi22si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi2),
    .UnLock2Wrmi(UnLock2wrmi2),

    .Lock2Rdmi(Lock2rdmi2),
    .UnLock2Rdmi(UnLock2rdmi2),

    .ARVALID(ARVALIDmi22s2),
    .LockPort(LockPort2wrmi2),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi22Rdmi2),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi22Wrmi2),
    .CtlDataWrite2Lock(CtlDataWrite2Lock2)
    ////////////////////////////////////////

    );

//Slave module 3    
//___________________________________________________________________________

SMC_RS_WriteChannelmi
SMC_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi32s3),
    .AWADDRmi2s  (AWADDRmi32s3),
    .AWLENmi2s   (AWLENmi32s3),
    .AWSIZEmi2s  (AWSIZEmi32s3),
    .AWBURSTmi2s (AWBURSTmi32s3),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi32s3),
    .AWREADYs2mi (AWREADYs32mi3),

    //Write data channel
    .WIDmi2s     (WIDmi32s3),
    .WDATAmi2s   (WDATAmi32s3),
    .WSTRBmi2s   (WSTRBmi32s3),
    .WLASTmi2s   (WLASTmi32s3),
    .WVALIDmi2s  (WVALIDmi32s3),
    .WREADYs2mi  (WREADYs32mi3),

    //Write response channel
    .BIDs2mi     (BIDs32mi3),
    .BRESPs2mi   (BRESPs32mi3),
    .BVALIDs2mi  (BVALIDs32mi3),
    .BREADYmi2s  (BREADYmi32s3),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi3),
    .AWLENsi02mi   (AWLENsi12mi3),
    .AWSIZEsi02mi  (AWSIZEsi12mi3),
    .AWBURSTsi02mi (AWBURSTsi12mi3),
    .AWLOCKsi02mi  (AWLOCKsi12mi3),
    .AWCACHEsi02mi (AWCACHEsi12mi3),
    .AWPROTsi02mi  (AWPROTsi12mi3),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi3),   
    .WSTRBsi02mi (WSTRBsi12mi3),   

    //Write response channel
    .BIDmi2si0     (BIDmi32si1),
    .BRESPmi2si0   (BRESPmi32si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi3),
    .AWLENsi12mi   (AWLENsi32mi3),
    .AWSIZEsi12mi  (AWSIZEsi32mi3),
    .AWBURSTsi12mi (AWBURSTsi32mi3),
    .AWLOCKsi12mi  (AWLOCKsi32mi3),
    .AWCACHEsi12mi (AWCACHEsi32mi3),
    .AWPROTsi12mi  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi3),   
    .WSTRBsi12mi (WSTRBsi32mi3),   

    //Write response channel
    .BIDmi2si1     (BIDmi32si3),
    .BRESPmi2si1   (BRESPmi32si3),
    //Master Number 4
    //Write address channel
    .AWIDsi22mi    (wAWIDsi42mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi42mi3),
    .AWLENsi22mi   (AWLENsi42mi3),
    .AWSIZEsi22mi  (AWSIZEsi42mi3),
    .AWBURSTsi22mi (AWBURSTsi42mi3),
    .AWLOCKsi22mi  (AWLOCKsi42mi3),
    .AWCACHEsi22mi (AWCACHEsi42mi3),
    .AWPROTsi22mi  (AWPROTsi42mi3),

    //Write data channel
    .WIDsi22mi   (wWIDsi42mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi22mi (WDATAsi42mi3),   
    .WSTRBsi22mi (WSTRBsi42mi3),   

    //Write response channel
    .BIDmi2si2     (BIDmi32si4),
    .BRESPmi2si2   (BRESPmi32si4),

    .BVALIDmi2si  (BVALIDmi32si),
    .BREADYsi2mi   (BREADYsi2mi3),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi3),
    .AWREADYmi2si  (AWREADYmi32si),
    .WLASTsi2mi    (WLASTsi2mi3),
    .WVALIDsi2mi   (WVALIDsi2mi3),
    .WREADYmi2si   (WREADYmi32si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi3),
    .UnLock2Wrmi(UnLock2wrmi3),

    .Lock2Rdmi(Lock2rdmi3),
    .UnLock2Rdmi(UnLock2rdmi3),

    .ARVALID(ARVALIDmi32s3),
    .LockPort(LockPort2wrmi3),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi32Rdmi3),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi32Wrmi3),
    .CtlDataWrite2Lock(CtlDataWrite2Lock3)
    ////////////////////////////////////////

    );

//Slave module 4    
//___________________________________________________________________________

IntSRAM_RS_WriteChannelmi
IntSRAM_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi42s4),
    .AWADDRmi2s  (AWADDRmi42s4),
    .AWLENmi2s   (AWLENmi42s4),
    .AWSIZEmi2s  (AWSIZEmi42s4),
    .AWBURSTmi2s (AWBURSTmi42s4),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi42s4),
    .AWREADYs2mi (AWREADYs42mi4),

    //Write data channel
    .WIDmi2s     (WIDmi42s4),
    .WDATAmi2s   (WDATAmi42s4),
    .WSTRBmi2s   (WSTRBmi42s4),
    .WLASTmi2s   (WLASTmi42s4),
    .WVALIDmi2s  (WVALIDmi42s4),
    .WREADYs2mi  (WREADYs42mi4),

    //Write response channel
    .BIDs2mi     (BIDs42mi4),
    .BRESPs2mi   (BRESPs42mi4),
    .BVALIDs2mi  (BVALIDs42mi4),
    .BREADYmi2s  (BREADYmi42s4),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi4),
    .AWLENsi02mi   (AWLENsi12mi4),
    .AWSIZEsi02mi  (AWSIZEsi12mi4),
    .AWBURSTsi02mi (AWBURSTsi12mi4),
    .AWLOCKsi02mi  (AWLOCKsi12mi4),
    .AWCACHEsi02mi (AWCACHEsi12mi4),
    .AWPROTsi02mi  (AWPROTsi12mi4),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi4),   
    .WSTRBsi02mi (WSTRBsi12mi4),   

    //Write response channel
    .BIDmi2si0     (BIDmi42si1),
    .BRESPmi2si0   (BRESPmi42si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi4),
    .AWLENsi12mi   (AWLENsi32mi4),
    .AWSIZEsi12mi  (AWSIZEsi32mi4),
    .AWBURSTsi12mi (AWBURSTsi32mi4),
    .AWLOCKsi12mi  (AWLOCKsi32mi4),
    .AWCACHEsi12mi (AWCACHEsi32mi4),
    .AWPROTsi12mi  (AWPROTsi32mi4),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi4),   
    .WSTRBsi12mi (WSTRBsi32mi4),   

    //Write response channel
    .BIDmi2si1     (BIDmi42si3),
    .BRESPmi2si1   (BRESPmi42si3),
    //Master Number 4
    //Write address channel
    .AWIDsi22mi    (wAWIDsi42mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi42mi4),
    .AWLENsi22mi   (AWLENsi42mi4),
    .AWSIZEsi22mi  (AWSIZEsi42mi4),
    .AWBURSTsi22mi (AWBURSTsi42mi4),
    .AWLOCKsi22mi  (AWLOCKsi42mi4),
    .AWCACHEsi22mi (AWCACHEsi42mi4),
    .AWPROTsi22mi  (AWPROTsi42mi4),

    //Write data channel
    .WIDsi22mi   (wWIDsi42mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi22mi (WDATAsi42mi4),   
    .WSTRBsi22mi (WSTRBsi42mi4),   

    //Write response channel
    .BIDmi2si2     (BIDmi42si4),
    .BRESPmi2si2   (BRESPmi42si4),

    .BVALIDmi2si  (BVALIDmi42si),
    .BREADYsi2mi   (BREADYsi2mi4),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi4),
    .AWREADYmi2si  (AWREADYmi42si),
    .WLASTsi2mi    (WLASTsi2mi4),
    .WVALIDsi2mi   (WVALIDsi2mi4),
    .WREADYmi2si   (WREADYmi42si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi4),
    .UnLock2Wrmi(UnLock2wrmi4),

    .Lock2Rdmi(Lock2rdmi4),
    .UnLock2Rdmi(UnLock2rdmi4),

    .ARVALID(ARVALIDmi42s4),
    .LockPort(LockPort2wrmi4),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi42Rdmi4),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi42Wrmi4),
    .CtlDataWrite2Lock(CtlDataWrite2Lock4)
    ////////////////////////////////////////

    );

//Slave module 5    
//___________________________________________________________________________

default_RS_WriteChannelmi
default_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi52s5),
    .AWADDRmi2s  (AWADDRmi52s5),
    .AWLENmi2s   (AWLENmi52s5),
    .AWSIZEmi2s  (AWSIZEmi52s5),
    .AWBURSTmi2s (AWBURSTmi52s5),
//Disalbe_lock_port
//Disalbe_cache_port
//Disalbe_protect_port

    .AWVALIDmi2s (AWVALIDmi52s5),
    .AWREADYs2mi (AWREADYs52mi5),

    //Write data channel
    .WIDmi2s     (WIDmi52s5),
    .WDATAmi2s   (WDATAmi52s5),
    .WSTRBmi2s   (WSTRBmi52s5),
    .WLASTmi2s   (WLASTmi52s5),
    .WVALIDmi2s  (WVALIDmi52s5),
    .WREADYs2mi  (WREADYs52mi5),

    //Write response channel
    .BIDs2mi     (BIDs52mi5),
    .BRESPs2mi   (BRESPs52mi5),
    .BVALIDs2mi  (BVALIDs52mi5),
    .BREADYmi2s  (BREADYmi52s5),

    //////////////////////////////////////////////

    //Master Number 1
    //Write address channel
    .AWIDsi02mi    (wAWIDsi12mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi12mi5),
    .AWLENsi02mi   (AWLENsi12mi5),
    .AWSIZEsi02mi  (AWSIZEsi12mi5),
    .AWBURSTsi02mi (AWBURSTsi12mi5),
    .AWLOCKsi02mi  (AWLOCKsi12mi5),
    .AWCACHEsi02mi (AWCACHEsi12mi5),
    .AWPROTsi02mi  (AWPROTsi12mi5),

    //Write data channel
    .WIDsi02mi   (wWIDsi12mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi02mi (WDATAsi12mi5),   
    .WSTRBsi02mi (WSTRBsi12mi5),   

    //Write response channel
    .BIDmi2si0     (BIDmi52si1),
    .BRESPmi2si0   (BRESPmi52si1),
    //Master Number 3
    //Write address channel
    .AWIDsi12mi    (wAWIDsi32mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi32mi5),
    .AWLENsi12mi   (AWLENsi32mi5),
    .AWSIZEsi12mi  (AWSIZEsi32mi5),
    .AWBURSTsi12mi (AWBURSTsi32mi5),
    .AWLOCKsi12mi  (AWLOCKsi32mi5),
    .AWCACHEsi12mi (AWCACHEsi32mi5),
    .AWPROTsi12mi  (AWPROTsi32mi5),

    //Write data channel
    .WIDsi12mi   (wWIDsi32mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi12mi (WDATAsi32mi5),   
    .WSTRBsi12mi (WSTRBsi32mi5),   

    //Write response channel
    .BIDmi2si1     (BIDmi52si3),
    .BRESPmi2si1   (BRESPmi52si3),
    //Master Number 4
    //Write address channel
    .AWIDsi22mi    (wAWIDsi42mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi42mi5),
    .AWLENsi22mi   (AWLENsi42mi5),
    .AWSIZEsi22mi  (AWSIZEsi42mi5),
    .AWBURSTsi22mi (AWBURSTsi42mi5),
    .AWLOCKsi22mi  (AWLOCKsi42mi5),
    .AWCACHEsi22mi (AWCACHEsi42mi5),
    .AWPROTsi22mi  (AWPROTsi42mi5),

    //Write data channel
    .WIDsi22mi   (wWIDsi42mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi22mi (WDATAsi42mi5),   
    .WSTRBsi22mi (WSTRBsi42mi5),   

    //Write response channel
    .BIDmi2si2     (BIDmi52si4),
    .BRESPmi2si2   (BRESPmi52si4),

    .BVALIDmi2si  (BVALIDmi52si),
    .BREADYsi2mi   (BREADYsi2mi5),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi5),
    .AWREADYmi2si  (AWREADYmi52si),
    .WLASTsi2mi    (WLASTsi2mi5),
    .WVALIDsi2mi   (WVALIDsi2mi5),
    .WREADYmi2si   (WREADYmi52si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi5),
    .UnLock2Wrmi(UnLock2wrmi5),

    .Lock2Rdmi(Lock2rdmi5),
    .UnLock2Rdmi(UnLock2rdmi5),

    .ARVALID(ARVALIDmi52s5),
    .LockPort(LockPort2wrmi5),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi52Rdmi5),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi52Wrmi5),
    .CtlDataWrite2Lock(CtlDataWrite2Lock5)
    ////////////////////////////////////////

    );

endmodule
