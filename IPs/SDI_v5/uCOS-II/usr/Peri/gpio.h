/*----------------------------------------------------------
    File Name   : gpio.h
    Description : External SMC Test SDI v5
-----------------------------------------------------------*/
#ifndef	__GPIO_H__
#define	__GPIO_H__

/*/////////////////////////////////////////////////////////
        INCLUDE
///////////////////////////////////////////////////////// */

#include "sysinc.h"

/*/////////////////////////////////////////////////////////
        FUNCTION DECLARATION
///////////////////////////////////////////////////////// */

static smtUint32 GPIO01Test(void);
static smtUint32 GPIO23Test(void);

#endif /* __GPIO_H__ */

