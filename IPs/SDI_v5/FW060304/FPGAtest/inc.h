#include "adc.c"
#include "einttest.c"
#include "esmc.c"
#include "fmc.c"
#include "lib.c"
#include "gpio.c"
#include "i2c.c"
#include "init.c"
#include "timerpwm.c"
#include "uart.c"
#include "uarttest.c"
#include "uarttst.c"
#include "wdt.c"
#include "pwrmanage.c"
#include "registercheck.c"
