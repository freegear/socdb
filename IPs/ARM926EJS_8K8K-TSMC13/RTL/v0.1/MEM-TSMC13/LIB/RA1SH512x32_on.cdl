* 
* Copyright 2006 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.3f
* Version: 2004Q2V1
* Name: SRAM-SP-HS-HC SRAM Generator|TSMC CL013G Process
* Comment: 
* Configuration:  -instname "RA1SH512x32_on" -words 512 -bits 32 -f\
* Configuration: requency 100 -ring_width 4 -mux 8 -drive 6 -write_\
* Configuration: mask on -wp_size 8 -redundancy off -redundancy_bit\
* Configuration: s 1 -top_layer met6 -power_type rings -horiz met3 \
* Configuration: -vert met2 -cust_comment "" -left_bus_delim "[" -r\
* Configuration: ight_bus_delim "]" -pwr_gnd_rename "VDD:VDD,GND:VS\
* Configuration: S" -prefix "" -pin_space 0.0 -name_case upper -che\
* Configuration: ck_instname on -diodes on -inside_ring_type GND -f\
* Configuration: use_encoding encoded -insert_fuse yes -fusebox_nam\
* Configuration: e FUSE -rtl_style mux
* Codefile: 
* 
*
** begin lvs.header
** $Revision: 1.1 $
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA1SH512x32_onFCIO8 DPU2 DW DW_ GTP WE WESA VSS VDD
** RA1SH512x32_onFCIO8: 2 flat devices **
D0 VSS WE DN 0.2116P 1.84U
D1 VSS GTP DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCIO8
****
.SUBCKT RA1SH512x32_onFCSA8 GTP YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onFCSA8: 1 flat devices **
D0 VSS GTP DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCSA8
****
.SUBCKT RA1SH512x32_onLEFT_CAP A0 A0_ DPU2 DW DW_ GTP GTP_0 GTP_1 WE WESA WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0
+  YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onLEFT_CAP: 3 flat devices **
XI0_0 DPU2 DW DW_ GTP WE WESA VSS VDD RA1SH512x32_onFCIO8
XI0_1 GTP_0 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32_onFCSA8
.ENDS RA1SH512x32_onLEFT_CAP
****
.SUBCKT RA1SH512x32_onFCBWRO8 BWEN D Q VSS VDD
** RA1SH512x32_onFCBWRO8: 2 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS Q DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCBWRO8
****
.SUBCKT RA1SH512x32_onIO8 BWE BWEN D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4
+  DW DW_ GTP Q STUBDPN1I STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW
+  STUBDWI STUBDWI_ STUBDW_ STUBWE STUBWEI STUBWESA STUBWESAI WE WESA VSS VDD
** RA1SH512x32_onIO8: 68 flat devices **
M0 NET0302 NET37 QPD VDD P W=1.27U L=0.13U M=1
M1 NET0302 GTPND VDD VDD P W=1.27U L=0.13U M=1
M10 NET60 GGTPBUF VSS VSS N W=1.62U L=0.13U M=1
M11 QPD DW NET60 VSS N W=1.62U L=0.13U M=1
M12 DILATCH GTPND DI VSS N W=0.19U L=0.13U M=1
M13 QPD DPU4 VSS VSS N W=1.69U L=0.13U M=1
M14 QPD DPU2 VSS VSS N W=1.69U L=0.13U M=1
M15 QPD DPU3 VSS VSS N W=1.69U L=0.13U M=1
M16 QPD DPU1 VSS VSS N W=1.69U L=0.13U M=1
M17 WEIBLATCH GTPND WEIB VSS N W=0.19U L=0.13U M=1
M18 GWE_FB-NET7 WESA VSS VSS N W=0.15U L=0.13U M=1
M19 WEIBLATCH GGTPBUF GWE_FB-NET7 VSS N W=0.15U L=0.13U M=1
M2 NET39 GTPND VDD VDD P W=1.27U L=0.13U M=1
M20 GWE_FB-NET15 GTPND WEIBLATCH VDD P W=0.15U L=0.13U M=1
M21 VDD WESA GWE_FB-NET15 VDD P W=0.15U L=0.13U M=1
M22 GDW_FB-NET7 DIN VSS VSS N W=0.15U L=0.13U M=1
M23 DILATCH GGTPBUF GDW_FB-NET7 VSS N W=0.15U L=0.13U M=1
M24 GDW_FB-NET15 GTPND DILATCH VDD P W=0.15U L=0.13U M=1
M25 VDD DIN GDW_FB-NET15 VDD P W=0.15U L=0.13U M=1
M26 GDWU-NET8 WESA VSS VSS N W=0.46U L=0.13U M=1
M27 NET37 NET90 GDWU-NET8 VSS N W=0.46U L=0.13U M=1
M28 VDD WESA NET37 VDD P W=0.46U L=0.13U M=1
M29 VDD NET90 NET37 VDD P W=0.46U L=0.13U M=1
M3 NET39 NET37 QPD VDD P W=1.27U L=0.13U M=1
M30 GDW-NET8 WESA VSS VSS N W=0.46U L=0.13U M=1
M31 NET101 DIN GDW-NET8 VSS N W=0.46U L=0.13U M=1
M32 VDD WESA NET101 VDD P W=0.46U L=0.13U M=1
M33 VDD DIN NET101 VDD P W=0.46U L=0.13U M=1
M34 VDD WE WEIB VDD P W=0.62U L=0.13U M=1
M35 WEIB WE VSS VSS N W=0.37U L=0.13U M=1
M36 VDD NET37 DW_ VDD P W=1U L=0.13U M=1
M37 DW_ NET37 VSS VSS N W=0.5U L=0.13U M=1
M38 VDD NET101 DW VDD P W=1U L=0.13U M=1
M39 DW NET101 VSS VSS N W=0.5U L=0.13U M=1
M4 DILATCH GGTPBUF DI VDD P W=0.22U L=0.13U M=1
M40 VDD QPD Q VDD P W=6U L=0.13U M=1
M41 Q QPD VSS VSS N W=6U L=0.13U M=1
M42 VDD QPU QPD VDD P W=0.3U L=0.26U M=1
M43 QPD QPU VSS VSS N W=0.3U L=0.26U M=1
M44 VDD QPD QPU VDD P W=0.3U L=0.13U M=1
M45 QPU QPD VSS VSS N W=0.3U L=0.13U M=1
M46 VDD GTP GTPND VDD P W=0.27U L=0.13U M=1
M47 GTPND GTP VSS VSS N W=0.25U L=0.13U M=1
M48 VDD GTPND GGTPBUF VDD P W=0.57U L=0.13U M=1
M49 GGTPBUF GTPND VSS VSS N W=0.37U L=0.13U M=1
M5 QPD DPN4 VDD VDD P W=3.4U L=0.13U M=1
M50 VDD DILATCH DIN VDD P W=0.36U L=0.13U M=1
M51 DIN DILATCH VSS VSS N W=0.23U L=0.13U M=1
M52 VDD WEIBLATCH WESA VDD P W=0.4U L=0.13U M=1
M53 WESA WEIBLATCH VSS VSS N W=0.39U L=0.13U M=1
M54 VDD NET122 NET116 VDD P W=0.23U L=0.13U M=1
M55 NET116 NET122 VSS VSS N W=0.15U L=0.13U M=1
M56 VDD DIN NET90 VDD P W=0.23U L=0.13U M=1
M57 NET90 DIN VSS VSS N W=0.15U L=0.13U M=1
M58 VDD NET116 DI VDD P W=0.23U L=0.13U M=1
M59 DI NET116 VSS VSS N W=0.15U L=0.13U M=1
M6 QPD DPN3 VDD VDD P W=3.4U L=0.13U M=1
M60 VDD D NET122 VDD P W=0.23U L=0.13U M=1
M61 NET122 D VSS VSS N W=0.15U L=0.13U M=1
M62 VDD NET128 NET124 VDD P W=0.23U L=0.13U M=1
M63 NET124 NET128 VSS VSS N W=0.15U L=0.13U M=1
M64 VDD NET124 BWE VDD P W=0.47U L=0.13U M=1
M65 BWE NET124 VSS VSS N W=0.3U L=0.13U M=1
M66 VDD BWEN NET128 VDD P W=0.23U L=0.13U M=1
M67 NET128 BWEN VSS VSS N W=0.15U L=0.13U M=1
M7 QPD DPN2 VDD VDD P W=3.4U L=0.13U M=1
M8 QPD DPN1 VDD VDD P W=3.4U L=0.13U M=1
M9 WEIBLATCH GGTPBUF WEIB VDD P W=0.22U L=0.13U M=1
.ENDS RA1SH512x32_onIO8
****
.SUBCKT RA1SH512x32_onIOX BWE BWEN D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4
+  DW DW_ GTP Q STUBDPN1I STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW
+  STUBDWI STUBDWI_ STUBDW_ STUBWESA STUBWESAI WESA VSS VDD
** RA1SH512x32_onIOX: 68 flat devices **
XI0_0 BWE BWEN D DPN1 DPN2 DPN3 DPN4 DPU1 DPU2 DPU3 DPU4 DW DW_ GTP Q
+  STUBDPN1I STUBDPN2I STUBDPN4 STUBDPU1 STUBDPU2 STUBDPU4 STUBDW STUBDWI
+  STUBDWI_ STUBDW_ VSS VSS STUBWESA STUBWESAI BWE WESA VSS VDD
+  RA1SH512x32_onIO8
.ENDS RA1SH512x32_onIOX
****
.SUBCKT RA1SH512x32_onSA8 DPN DPU DR DR_ DW DWCD DWCD_ DW_ G1 GTP WESA YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onSA8: 55 flat devices **
M0 SRCDB GTP2D VDD VDD P W=1.4U L=0.13U M=1
M1 SRCDB WESAB VDD VDD P W=0.15U L=0.13U M=1
M10 DW_ NET42 DWCD_ VDD P W=0.99U L=0.13U M=1
M11 DW NET42 DWCD VDD P W=0.99U L=0.13U M=1
M12 DR DRP VDD VDD P W=2U L=0.13U M=1
M13 DR DRP DR_ VDD P W=2U L=0.13U M=1
M14 SD SP DR VDD P W=1.65U L=0.13U M=1
M15 SD_ SP DR_ VDD P W=1.65U L=0.13U M=1
M16 SD SD_ VDD VDD P W=0.34U L=0.13U M=1
M17 SD_ SDPCH VDD VDD P W=0.3U L=0.13U M=1
M18 DR_ DRP VDD VDD P W=2U L=0.13U M=1
M19 SRC GTPN NET89 VSS N W=1.76U L=0.13U M=1
M2 DRP SRCDB VDD VDD P W=0.5U L=0.13U M=1
M20 NET82 GTP2D VSS VSS N W=1.09U L=0.13U M=1
M21 SRCDB WESAB NET82 VSS N W=0.3U L=0.13U M=1
M22 DRP SRCDB NET104 VSS N W=1U L=0.13U M=1
M23 NET89 SRCD VSS VSS N W=1.6U L=0.13U M=1
M24 SD_ SD SRC VSS N W=2.7U L=0.19U M=1
M25 SDPCH SP VSS VSS N W=0.15U L=0.13U M=1
M26 DRP WESAB SDPCH VSS N W=0.3U L=0.13U M=1
M27 NET44 G1 GTP VSS N W=0.3U L=0.13U M=1
M28 NET104 GTPN VSS VSS N W=0.3U L=0.13U M=1
M29 DWCD NET42 VSS VSS N W=0.15U L=0.13U M=1
M3 SD_ SD VDD VDD P W=0.34U L=0.13U M=1
M30 DWCD_ NET42 VSS VSS N W=0.15U L=0.13U M=1
M31 SRC GTPN NET125 VSS N W=1.76U L=0.13U M=1
M32 SD_ SD SRC VSS N W=2.7U L=0.19U M=1
M33 SD SD_ SRC VSS N W=2.7U L=0.19U M=1
M34 SD SD_ SRC VSS N W=2.7U L=0.19U M=1
M35 NET125 SRCD VSS VSS N W=1.6U L=0.13U M=1
M36 NET44 NET42 VSS VSS N W=0.15U L=0.13U M=1
M37 VDD G1 NET42 VDD P W=0.15U L=0.13U M=1
M38 NET42 G1 VSS VSS N W=0.15U L=0.13U M=1
M39 VDD WESA WESAB VDD P W=0.23U L=0.13U M=1
M4 SD SDPCH VDD VDD P W=0.3U L=0.13U M=1
M40 WESAB WESA VSS VSS N W=0.15U L=0.13U M=1
M41 VDD SRCDB SRCD VDD P W=0.36U L=0.13U M=1
M42 SRCD SRCDB VSS VSS N W=0.15U L=0.13U M=1
M43 VDD WESAB SP VDD P W=0.6U L=0.13U M=1
M44 SP WESAB VSS VSS N W=0.5U L=0.13U M=1
M45 VDD SD SDN VDD P W=0.7U L=0.13U M=1
M46 SDN SD VSS VSS N W=0.24U L=0.13U M=1
M47 VDD GTPN GTP2D VDD P W=0.46U L=0.13U M=1
M48 GTP2D GTPN VSS VSS N W=0.3U L=0.13U M=1
M49 VDD NET44 GTPN VDD P W=2U L=0.13U M=1
M5 SD SDPCH SD_ VDD P W=0.3U L=0.13U M=1
M50 GTPN NET44 VSS VSS N W=0.5U L=0.13U M=1
M51 VDD SDN DPN VDD P W=0.35U L=0.13U M=1
M52 DPN SDN VSS VSS N W=0.94U L=0.13U M=1
M53 VDD SD_ DPU VDD P W=0.7U L=0.13U M=1
M54 DPU SD_ VSS VSS N W=0.24U L=0.13U M=1
M6 DRP SP SDPCH VDD P W=0.3U L=0.13U M=1
M7 SD_ VDD SD VDD P W=0.34U L=0.13U M=1
M8 NET44 NET42 GTP VDD P W=0.3U L=0.13U M=1
M9 DRP GTPN VDD VDD P W=1.5U L=0.13U M=1
.ENDS RA1SH512x32_onSA8
****
.SUBCKT RA1SH512x32_onCD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0
+  G1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onCD: 43 flat devices **
M0 BL0PD CS0 DW_ VDD P W=0.99U L=0.13U M=1
M1 NET85 YCDSEL_ GTP VDD P W=0.3U L=0.13U M=1
M10 BL1_ CS1 DR_ VDD P W=2.28U L=0.13U M=1
M11 BL0_ CS0 DR_ VDD P W=2.28U L=0.13U M=1
M12 BL0_ YI VDD VDD P W=4.64U L=0.13U M=1
M13 BL1 YI VDD VDD P W=4.64U L=0.13U M=1
M14 BL1_ YI VDD VDD P W=4.64U L=0.13U M=1
M15 BL0PD CS0 VSS VSS N W=0.68U L=0.13U M=1
M16 BL0 BL0PD VSS VSS N W=5.21U L=0.13U M=1
M17 NET85 YCDSEL_ VSS VSS N W=0.3U L=0.13U M=1
M18 NET85 YCDSEL GTP VSS N W=0.3U L=0.13U M=1
M19 BL1_PD CS1 VSS VSS N W=0.68U L=0.13U M=1
M2 BL0 CS0 DR VDD P W=2.28U L=0.13U M=1
M20 BL1PD CS1 VSS VSS N W=0.68U L=0.13U M=1
M21 BL0_PD CS0 VSS VSS N W=0.68U L=0.13U M=1
M22 BL1 BL1_PD VSS VSS N W=5.21U L=0.13U M=1
M23 BL1_ BL1PD VSS VSS N W=5.21U L=0.13U M=1
M24 BL0_ BL0_PD VSS VSS N W=5.21U L=0.13U M=1
M25 VDD NET85 WL1_EN_ VDD P W=1.64U L=0.13U M=1
M26 WL1_EN_ NET85 VSS VSS N W=1.04U L=0.13U M=1
M27 VDD WL1_EN_ YI VDD P W=4.08U L=0.13U M=1
M28 YI WL1_EN_ VSS VSS N W=3.24U L=0.13U M=1
M29 VDD YCDSEL_ YCDSEL VDD P W=0.15U L=0.13U M=1
M3 BL0 YI VDD VDD P W=4.64U L=0.13U M=1
M30 YCDSEL YCDSEL_ VSS VSS N W=0.15U L=0.13U M=1
M31 SC_NAND_C0_I0-NET8 G0 VSS VSS N W=0.19U L=0.13U M=1
M32 YCDSEL_ G1 SC_NAND_C0_I0-NET8 VSS N W=0.19U L=0.13U M=1
M33 VDD G0 YCDSEL_ VDD P W=0.15U L=0.13U M=1
M34 VDD G1 YCDSEL_ VDD P W=0.15U L=0.13U M=1
M35 GCSR-NET8 A0 VSS VSS N W=1.57U L=0.13U M=1
M36 CS1 YI GCSR-NET8 VSS N W=1.57U L=0.13U M=1
M37 VDD A0 CS1 VDD P W=1.14U L=0.13U M=1
M38 VDD YI CS1 VDD P W=1.14U L=0.13U M=1
M39 GCS-NET8 A0_ VSS VSS N W=1.57U L=0.13U M=1
M4 BL0 YI BL0_ VDD P W=4.64U L=0.13U M=1
M40 CS0 YI GCS-NET8 VSS N W=1.57U L=0.13U M=1
M41 VDD A0_ CS0 VDD P W=1.14U L=0.13U M=1
M42 VDD YI CS0 VDD P W=1.14U L=0.13U M=1
M5 BL1_ YI BL1 VDD P W=4.64U L=0.13U M=1
M6 BL1_PD CS1 DW_ VDD P W=0.99U L=0.13U M=1
M7 BL1PD CS1 DW VDD P W=0.99U L=0.13U M=1
M8 BL0_PD CS0 DW VDD P W=0.99U L=0.13U M=1
M9 BL1 CS1 DR VDD P W=2.28U L=0.13U M=1
.ENDS RA1SH512x32_onCD
****
.SUBCKT RA1SH512x32_onMUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onMUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0__0 BL0_0 DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_3
+  VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32_onCD
XI2_0 A0 A0_ BL0_2 BL0__2 BL0__1 BL0_1 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
XI4_0 A0 A0_ BL0_3 BL0__3 BL0__4 BL0_4 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
XI6_0 A0 A0_ BL0_6 BL0__6 BL0__5 BL0_5 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
.ENDS RA1SH512x32_onMUX_CD_ODD
****
.SUBCKT RA1SH512x32_onCCG BL BL_ WL WP VSS VDD
** RA1SH512x32_onCCG: 6 flat devices **
M0 BL WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BL_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS RA1SH512x32_onCCG
****
.SUBCKT RA1SH512x32_onCCP BL BL_ WL WP VSS VDD
** RA1SH512x32_onCCP: 6 flat devices **
M0 BL WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BL_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS RA1SH512x32_onCCP
****
.SUBCKT RA1SH512x32_onBIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SH512x32_onBIT_MUX_1: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SH512x32_onCCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SH512x32_onCCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SH512x32_onCCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SH512x32_onCCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SH512x32_onCCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SH512x32_onCCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SH512x32_onCCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SH512x32_onCCG
.ENDS RA1SH512x32_onBIT_MUX_1
****
.SUBCKT RA1SH512x32_onBIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6
+  BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SH512x32_onBIT_MUX_0: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SH512x32_onCCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SH512x32_onCCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SH512x32_onCCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SH512x32_onCCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SH512x32_onCCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SH512x32_onCCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SH512x32_onCCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SH512x32_onCCG
.ENDS RA1SH512x32_onBIT_MUX_0
****
.SUBCKT RA1SH512x32_onBIT_COL BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD
** RA1SH512x32_onBIT_COL: 3072 flat devices **
XI0_0 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL WP VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_0 WP_0 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_10 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_9 WP_9 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_11 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_10 WP_10 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_12 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_11 WP_11 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_13 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_12 WP_12 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_14 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_13 WP_13 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_15 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_14 WP_14 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_16 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_15 WP_15 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_17 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_16 WP_16 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_18 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_17 WP_17 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_19 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_18 WP_18 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_2 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_1 WP_1 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_20 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_19 WP_19 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_21 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_20 WP_20 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_22 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_21 WP_21 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_23 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_22 WP_22 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_24 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_23 WP_23 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_25 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_24 WP_24 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_26 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_25 WP_25 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_27 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_26 WP_26 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_28 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_27 WP_27 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_29 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_28 WP_28 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_3 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_2 WP_2 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_30 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_29 WP_29 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_31 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_30 WP_30 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_32 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_31 WP_31 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_33 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_32 WP_32 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_34 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_33 WP_33 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_35 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_34 WP_34 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_36 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_35 WP_35 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_37 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_36 WP_36 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_38 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_37 WP_37 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_39 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_38 WP_38 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_4 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_3 WP_3 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_40 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_39 WP_39 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_41 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_40 WP_40 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_42 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_41 WP_41 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_43 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_42 WP_42 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_44 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_43 WP_43 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_45 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_44 WP_44 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_46 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_45 WP_45 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_47 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_46 WP_46 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_48 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_47 WP_47 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_49 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_48 WP_48 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_5 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_4 WP_4 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_50 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_49 WP_49 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_51 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_50 WP_50 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_52 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_51 WP_51 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_53 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_52 WP_52 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_54 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_53 WP_53 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_55 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_54 WP_54 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_56 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_55 WP_55 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_57 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_56 WP_56 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_58 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_57 WP_57 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_59 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_58 WP_58 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_6 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_5 WP_5 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_60 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_59 WP_59 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_61 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_60 WP_60 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_62 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_61 WP_61 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_63 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_62 WP_62 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_7 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_6 WP_6 VSS VDD RA1SH512x32_onBIT_MUX_1
XI0_8 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_7 WP_7 VSS VDD RA1SH512x32_onBIT_MUX_0
XI0_9 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_8 WP_8 VSS VDD RA1SH512x32_onBIT_MUX_1
.ENDS RA1SH512x32_onBIT_COL
****
.SUBCKT RA1SH512x32_onMCOL_ODD_RO8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 Q WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onMCOL_ODD_RO8: 3369 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SH512x32_onFCBWRO8
XI0_1 BWE BWEN D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS WESA VSS VDD RA1SH512x32_onIOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32_onSA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD
+  RA1SH512x32_onMUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32_onBIT_COL
.ENDS RA1SH512x32_onMCOL_ODD_RO8
****
.SUBCKT RA1SH512x32_onFCBWM8 BWEN D Q VSS VDD
** RA1SH512x32_onFCBWM8: 2 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS Q DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCBWM8
****
.SUBCKT RA1SH512x32_onMUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3
+  BL0_4 BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA
+  DRSA_0 DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onMUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0__0 BL0_0 DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_0
+  VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32_onCD
XI2_0 A0 A0_ BL0_2 BL0__2 BL0__1 BL0_1 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
XI4_0 A0 A0_ BL0_3 BL0__3 BL0__4 BL0_4 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
XI6_0 A0 A0_ BL0_6 BL0__6 BL0__5 BL0_5 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_3 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32_onCD
.ENDS RA1SH512x32_onMUX_CD_EVEN
****
.SUBCKT RA1SH512x32_onMCOL_EVEN_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 Q WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onMCOL_EVEN_M8: 3369 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SH512x32_onFCBWM8
XI0_1 BWE BWEN D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS WESA VSS VDD RA1SH512x32_onIOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32_onSA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD
+  RA1SH512x32_onMUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32_onBIT_COL
.ENDS RA1SH512x32_onMCOL_EVEN_M8
****
.SUBCKT RA1SH512x32_onMCOL_ODD_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 Q WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35
+  WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47
+  WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59
+  WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onMCOL_ODD_M8: 3369 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SH512x32_onFCBWM8
XI0_1 BWE BWEN D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS WESA VSS VDD RA1SH512x32_onIOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32_onSA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD
+  RA1SH512x32_onMUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32_onBIT_COL
.ENDS RA1SH512x32_onMCOL_ODD_M8
****
.SUBCKT RA1SH512x32_onFCBWLE8 BWEN D Q VSS VDD
** RA1SH512x32_onFCBWLE8: 3 flat devices **
D0 VSS D DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D2 VSS Q DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCBWLE8
****
.SUBCKT RA1SH512x32_onMCOL_EVEN_LE8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1
+  Q WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onMCOL_EVEN_LE8: 3370 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SH512x32_onFCBWLE8
XI0_1 BWE BWEN D VDD VDD DPN3 VDD VSS VSS DPU3 VSS DW DW_ GTP Q VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS WESA VSS VDD RA1SH512x32_onIOX
XI0_2 DPN3 DPU3 DR DR_ DW DWCD DWCD_ DW_ VDD GTP_0 WESA YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32_onSA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS DR DR_ VSS VSS DWCD DWCD_ VSS GTP_1 YP0_0 YP0_1
+  YP0_2 YP0_3 YP1_0_0 YP1_1_0 YP1_2_0 YP1_3_0 VSS VDD
+  RA1SH512x32_onMUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32_onBIT_COL
.ENDS RA1SH512x32_onMCOL_EVEN_LE8
****
.SUBCKT RA1SH512x32_onWING_16_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11
+  D_12 D_13 D_14 GTP GTP_0 GTP_1 Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9
+  Q_10 Q_11 Q_12 Q_13 Q_14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onWING_16_LEFT: 53906 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 Q WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_ODD_RO8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BWEN_0 D_7 GTP GTP_0 GTP_1 Q_7 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_RO8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 BWEN_0 D_8 GTP GTP_0 GTP_1 Q_8 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BWEN_0 D_9 GTP GTP_0 GTP_1 Q_9 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 BWEN_0 D_10 GTP GTP_0 GTP_1 Q_10
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BWEN_0 D_11 GTP GTP_0 GTP_1
+  Q_11 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 BWEN_0 D_12 GTP
+  GTP_0 GTP_1 Q_12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_EVEN_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BWEN_0 D_13 GTP
+  GTP_0 GTP_1 Q_13 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 BWEN_0 D_14 GTP
+  GTP_0 GTP_1 Q_14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_EVEN_LE8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BWEN D_0 GTP GTP_0 GTP_1 Q_0 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3
+  YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BWEN D_1 GTP GTP_0 GTP_1 Q_1 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BWEN D_2 GTP GTP_0 GTP_1 Q_2 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BWEN D_3 GTP GTP_0 GTP_1 Q_3 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 BWEN D_4 GTP GTP_0 GTP_1 Q_4 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BWEN D_5 GTP GTP_0 GTP_1 Q_5 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 BWEN D_6 GTP GTP_0 GTP_1 Q_6 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_LE8
.ENDS RA1SH512x32_onWING_16_LEFT
****
.SUBCKT RA1SH512x32_onHXP38L A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32_onHXP38L: 192 flat devices **
D0 VSS A2 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D16 VSS A0 DN 0.2116P 1.84U
D17 VSS BWEN DN 0.2116P 1.84U
D8 VSS A1 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A1 NET189 VDD P W=3.06U L=0.13U M=1
M100 VDD AP_3-APN1 XP_5 VDD P W=18U L=0.13U M=1
M101 XP_5 AP_3-APN1 VSS VSS N W=12.66U L=0.13U M=1
M102 VDD NET187 AP_3-AIN21 VDD P W=2.71U L=0.13U M=1
M103 AP_3-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M104 VDD NET190 AP_3-NET55 VDD P W=2.71U L=0.13U M=1
M105 AP_3-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M106 VDD NET171 AP_3-NET57 VDD P W=2.71U L=0.13U M=1
M107 AP_3-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M108 AP_4-APN1 AGTPT AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M109 AP_4-APN0 AGTPB AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M11 NET189 A1 VSS VSS N W=2.05U L=0.13U M=1
M110 AP_4-APN1 AP_4-NET47 AP_4-AIND1 VSS N W=4.38U L=0.13U M=1
M111 AP_4-APN0 AP_4-NET41 AP_4-AIND0 VSS N W=4.38U L=0.13U M=1
M112 AP_4-SC_NAND_C0_I14-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M113 AP_4-SC_NAND_C0_I14-NET12 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M114 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M115 AP_4-SC_NAND_C0_I14-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M116 AP_4-SC_NAND_C0_I14-NET21 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M117 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M118 VDD AP_4-NET55 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M119 VDD AP_4-NET57 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M12 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M120 VDD AP_4-AIN20 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M121 AP_4-GAPND-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M122 AP_4-GAPND-NET12 AP_4-NET57 AP_4-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M123 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M124 AP_4-GAPND-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M125 AP_4-GAPND-NET21 AP_4-NET57 AP_4-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M126 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M127 VDD AP_4-NET55 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M128 VDD AP_4-NET57 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M129 VDD AP_4-AIN21 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M13 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M130 VDD AP_4-APN0 XP_6 VDD P W=18U L=0.13U M=1
M131 XP_6 AP_4-APN0 VSS VSS N W=12.66U L=0.13U M=1
M132 VDD AGTPB AP_4-NET41 VDD P W=0.77U L=0.13U M=1
M133 AP_4-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M134 VDD NET188 AP_4-AIN20 VDD P W=2.71U L=0.13U M=1
M135 AP_4-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M136 VDD XP_6 AP_4-APN0 VDD P W=0.15U L=0.2U M=1
M137 AP_4-APN0 XP_6 VSS VSS N W=0.15U L=0.39U M=1
M138 VDD AGTPT AP_4-NET47 VDD P W=0.77U L=0.13U M=1
M139 AP_4-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M14 VDD AI_2-NET28 NET171 VDD P W=3.06U L=0.13U M=1
M140 VDD XP_7 AP_4-APN1 VDD P W=0.15U L=0.2U M=1
M141 AP_4-APN1 XP_7 VSS VSS N W=0.15U L=0.39U M=1
M142 VDD AP_4-APN1 XP_7 VDD P W=18U L=0.13U M=1
M143 XP_7 AP_4-APN1 VSS VSS N W=12.66U L=0.13U M=1
M144 VDD NET187 AP_4-AIN21 VDD P W=2.71U L=0.13U M=1
M145 AP_4-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M146 VDD NET190 AP_4-NET55 VDD P W=2.71U L=0.13U M=1
M147 AP_4-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M148 VDD NET189 AP_4-NET57 VDD P W=2.71U L=0.13U M=1
M149 AP_4-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M15 NET171 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M150 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M151 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M152 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M153 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M154 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M155 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M156 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M157 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M158 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M159 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M160 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M161 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M162 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M163 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M164 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M165 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M166 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M167 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M168 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M169 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M170 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M171 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M172 VDD AP_1-APN0 XP_0 VDD P W=18U L=0.13U M=1
M173 XP_0 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M174 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M175 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M176 VDD NET188 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M177 AP_1-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M178 VDD XP_0 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M179 AP_1-APN0 XP_0 VSS VSS N W=0.15U L=0.39U M=1
M18 VDD A0 NET187 VDD P W=3.06U L=0.13U M=1
M180 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M181 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M182 VDD XP_1 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M183 AP_1-APN1 XP_1 VSS VSS N W=0.15U L=0.39U M=1
M184 VDD AP_1-APN1 XP_1 VDD P W=18U L=0.13U M=1
M185 XP_1 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M186 VDD NET187 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M187 AP_1-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M188 VDD NET127 AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M189 AP_1-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M19 NET187 A0 VSS VSS N W=2.05U L=0.13U M=1
M190 VDD NET171 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M191 AP_1-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M2 VDD A2 NET190 VDD P W=3.06U L=0.13U M=1
M20 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M21 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M22 VDD AI_1-NET28 NET188 VDD P W=3.06U L=0.13U M=1
M23 NET188 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M24 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M25 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M26 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M27 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M28 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M29 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M3 NET190 A2 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M31 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M32 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M33 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M34 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M35 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M37 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M38 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M39 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M4 VDD A2 AI_3-NET28 VDD P W=2.45U L=0.13U M=1
M40 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M41 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M42 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M43 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M44 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M45 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M46 VDD AP_2-APN0 XP_2 VDD P W=18U L=0.13U M=1
M47 XP_2 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M48 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M49 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M5 AI_3-NET28 A2 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD NET188 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M51 AP_2-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M52 VDD XP_2 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M53 AP_2-APN0 XP_2 VSS VSS N W=0.15U L=0.39U M=1
M54 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M55 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M56 VDD XP_3 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M57 AP_2-APN1 XP_3 VSS VSS N W=0.15U L=0.39U M=1
M58 VDD AP_2-APN1 XP_3 VDD P W=18U L=0.13U M=1
M59 XP_3 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M6 VDD AI_3-NET28 NET127 VDD P W=3.06U L=0.13U M=1
M60 VDD NET187 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M61 AP_2-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M62 VDD NET127 AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M63 AP_2-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M64 VDD NET189 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M65 AP_2-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M66 AP_3-APN1 AGTPT AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M67 AP_3-APN0 AGTPB AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M68 AP_3-APN1 AP_3-NET47 AP_3-AIND1 VSS N W=4.38U L=0.13U M=1
M69 AP_3-APN0 AP_3-NET41 AP_3-AIND0 VSS N W=4.38U L=0.13U M=1
M7 NET127 AI_3-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 AP_3-SC_NAND_C0_I14-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M71 AP_3-SC_NAND_C0_I14-NET12 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M72 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M73 AP_3-SC_NAND_C0_I14-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M74 AP_3-SC_NAND_C0_I14-NET21 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M75 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M76 VDD AP_3-NET55 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M77 VDD AP_3-NET57 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_3-AIN20 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M79 AP_3-GAPND-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M80 AP_3-GAPND-NET12 AP_3-NET57 AP_3-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M81 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M82 AP_3-GAPND-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M83 AP_3-GAPND-NET21 AP_3-NET57 AP_3-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M84 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M85 VDD AP_3-NET55 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M86 VDD AP_3-NET57 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M87 VDD AP_3-AIN21 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M88 VDD AP_3-APN0 XP_4 VDD P W=18U L=0.13U M=1
M89 XP_4 AP_3-APN0 VSS VSS N W=12.66U L=0.13U M=1
M90 VDD AGTPB AP_3-NET41 VDD P W=0.77U L=0.13U M=1
M91 AP_3-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M92 VDD NET188 AP_3-AIN20 VDD P W=2.71U L=0.13U M=1
M93 AP_3-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M94 VDD XP_4 AP_3-APN0 VDD P W=0.15U L=0.2U M=1
M95 AP_3-APN0 XP_4 VSS VSS N W=0.15U L=0.39U M=1
M96 VDD AGTPT AP_3-NET47 VDD P W=0.77U L=0.13U M=1
M97 AP_3-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M98 VDD XP_5 AP_3-APN1 VDD P W=0.15U L=0.2U M=1
M99 AP_3-APN1 XP_5 VSS VSS N W=0.15U L=0.39U M=1
.ENDS RA1SH512x32_onHXP38L
****
.SUBCKT RA1SH512x32_onHXP38LX A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32_onHXP38LX: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32_onHXP38L
.ENDS RA1SH512x32_onHXP38LX
****
.SUBCKT RA1SH512x32_onHXP38 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32_onHXP38: 192 flat devices **
D0 VSS A2 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D16 VSS A0 DN 0.2116P 1.84U
D17 VSS BWEN DN 0.2116P 1.84U
D8 VSS A1 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A1 NET189 VDD P W=3.06U L=0.13U M=1
M100 VDD AP_3-APN1 XP_5 VDD P W=18U L=0.13U M=1
M101 XP_5 AP_3-APN1 VSS VSS N W=12.66U L=0.13U M=1
M102 VDD NET187 AP_3-AIN21 VDD P W=2.71U L=0.13U M=1
M103 AP_3-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M104 VDD NET190 AP_3-NET55 VDD P W=2.71U L=0.13U M=1
M105 AP_3-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M106 VDD NET171 AP_3-NET57 VDD P W=2.71U L=0.13U M=1
M107 AP_3-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M108 AP_4-APN1 AGTPT AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M109 AP_4-APN0 AGTPB AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M11 NET189 A1 VSS VSS N W=2.05U L=0.13U M=1
M110 AP_4-APN1 AP_4-NET47 AP_4-AIND1 VSS N W=4.38U L=0.13U M=1
M111 AP_4-APN0 AP_4-NET41 AP_4-AIND0 VSS N W=4.38U L=0.13U M=1
M112 AP_4-SC_NAND_C0_I14-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M113 AP_4-SC_NAND_C0_I14-NET12 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M114 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M115 AP_4-SC_NAND_C0_I14-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M116 AP_4-SC_NAND_C0_I14-NET21 AP_4-NET57 AP_4-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M117 AP_4-AIND0 AP_4-AIN20 AP_4-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M118 VDD AP_4-NET55 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M119 VDD AP_4-NET57 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M12 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M120 VDD AP_4-AIN20 AP_4-AIND0 VDD P W=5.52U L=0.13U M=1
M121 AP_4-GAPND-NET9 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M122 AP_4-GAPND-NET12 AP_4-NET57 AP_4-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M123 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M124 AP_4-GAPND-NET18 AP_4-NET55 VSS VSS N W=4.38U L=0.13U M=1
M125 AP_4-GAPND-NET21 AP_4-NET57 AP_4-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M126 AP_4-AIND1 AP_4-AIN21 AP_4-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M127 VDD AP_4-NET55 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M128 VDD AP_4-NET57 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M129 VDD AP_4-AIN21 AP_4-AIND1 VDD P W=5.52U L=0.13U M=1
M13 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M130 VDD AP_4-APN0 XP_6 VDD P W=18U L=0.13U M=1
M131 XP_6 AP_4-APN0 VSS VSS N W=12.66U L=0.13U M=1
M132 VDD AGTPB AP_4-NET41 VDD P W=0.77U L=0.13U M=1
M133 AP_4-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M134 VDD NET188 AP_4-AIN20 VDD P W=2.71U L=0.13U M=1
M135 AP_4-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M136 VDD XP_6 AP_4-APN0 VDD P W=0.15U L=0.2U M=1
M137 AP_4-APN0 XP_6 VSS VSS N W=0.15U L=0.39U M=1
M138 VDD AGTPT AP_4-NET47 VDD P W=0.77U L=0.13U M=1
M139 AP_4-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M14 VDD AI_2-NET28 NET171 VDD P W=3.06U L=0.13U M=1
M140 VDD XP_7 AP_4-APN1 VDD P W=0.15U L=0.2U M=1
M141 AP_4-APN1 XP_7 VSS VSS N W=0.15U L=0.39U M=1
M142 VDD AP_4-APN1 XP_7 VDD P W=18U L=0.13U M=1
M143 XP_7 AP_4-APN1 VSS VSS N W=12.66U L=0.13U M=1
M144 VDD NET187 AP_4-AIN21 VDD P W=2.71U L=0.13U M=1
M145 AP_4-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M146 VDD NET190 AP_4-NET55 VDD P W=2.71U L=0.13U M=1
M147 AP_4-NET55 NET190 VSS VSS N W=1.78U L=0.13U M=1
M148 VDD NET189 AP_4-NET57 VDD P W=2.71U L=0.13U M=1
M149 AP_4-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M15 NET171 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M150 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M151 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M152 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M153 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M154 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M155 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M156 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M157 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M158 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M159 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M160 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M161 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M162 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M163 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M164 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M165 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M166 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M167 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M168 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M169 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M170 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M171 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M172 VDD AP_1-APN0 XP_0 VDD P W=18U L=0.13U M=1
M173 XP_0 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M174 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M175 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M176 VDD NET188 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M177 AP_1-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M178 VDD XP_0 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M179 AP_1-APN0 XP_0 VSS VSS N W=0.15U L=0.39U M=1
M18 VDD A0 NET187 VDD P W=3.06U L=0.13U M=1
M180 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M181 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M182 VDD XP_1 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M183 AP_1-APN1 XP_1 VSS VSS N W=0.15U L=0.39U M=1
M184 VDD AP_1-APN1 XP_1 VDD P W=18U L=0.13U M=1
M185 XP_1 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M186 VDD NET187 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M187 AP_1-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M188 VDD NET127 AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M189 AP_1-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M19 NET187 A0 VSS VSS N W=2.05U L=0.13U M=1
M190 VDD NET171 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M191 AP_1-NET57 NET171 VSS VSS N W=1.78U L=0.13U M=1
M2 VDD A2 NET190 VDD P W=3.06U L=0.13U M=1
M20 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M21 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M22 VDD AI_1-NET28 NET188 VDD P W=3.06U L=0.13U M=1
M23 NET188 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M24 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M25 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M26 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M27 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M28 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M29 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M3 NET190 A2 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M31 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M32 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M33 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M34 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M35 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M37 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M38 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M39 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M4 VDD A2 AI_3-NET28 VDD P W=2.45U L=0.13U M=1
M40 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M41 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M42 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M43 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M44 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M45 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M46 VDD AP_2-APN0 XP_2 VDD P W=18U L=0.13U M=1
M47 XP_2 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M48 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M49 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M5 AI_3-NET28 A2 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD NET188 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M51 AP_2-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M52 VDD XP_2 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M53 AP_2-APN0 XP_2 VSS VSS N W=0.15U L=0.39U M=1
M54 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M55 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M56 VDD XP_3 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M57 AP_2-APN1 XP_3 VSS VSS N W=0.15U L=0.39U M=1
M58 VDD AP_2-APN1 XP_3 VDD P W=18U L=0.13U M=1
M59 XP_3 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M6 VDD AI_3-NET28 NET127 VDD P W=3.06U L=0.13U M=1
M60 VDD NET187 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M61 AP_2-AIN21 NET187 VSS VSS N W=1.78U L=0.13U M=1
M62 VDD NET127 AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M63 AP_2-NET55 NET127 VSS VSS N W=1.78U L=0.13U M=1
M64 VDD NET189 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M65 AP_2-NET57 NET189 VSS VSS N W=1.78U L=0.13U M=1
M66 AP_3-APN1 AGTPT AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M67 AP_3-APN0 AGTPB AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M68 AP_3-APN1 AP_3-NET47 AP_3-AIND1 VSS N W=4.38U L=0.13U M=1
M69 AP_3-APN0 AP_3-NET41 AP_3-AIND0 VSS N W=4.38U L=0.13U M=1
M7 NET127 AI_3-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 AP_3-SC_NAND_C0_I14-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M71 AP_3-SC_NAND_C0_I14-NET12 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M72 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M73 AP_3-SC_NAND_C0_I14-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M74 AP_3-SC_NAND_C0_I14-NET21 AP_3-NET57 AP_3-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M75 AP_3-AIND0 AP_3-AIN20 AP_3-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M76 VDD AP_3-NET55 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M77 VDD AP_3-NET57 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_3-AIN20 AP_3-AIND0 VDD P W=5.52U L=0.13U M=1
M79 AP_3-GAPND-NET9 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M80 AP_3-GAPND-NET12 AP_3-NET57 AP_3-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M81 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M82 AP_3-GAPND-NET18 AP_3-NET55 VSS VSS N W=4.38U L=0.13U M=1
M83 AP_3-GAPND-NET21 AP_3-NET57 AP_3-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M84 AP_3-AIND1 AP_3-AIN21 AP_3-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M85 VDD AP_3-NET55 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M86 VDD AP_3-NET57 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M87 VDD AP_3-AIN21 AP_3-AIND1 VDD P W=5.52U L=0.13U M=1
M88 VDD AP_3-APN0 XP_4 VDD P W=18U L=0.13U M=1
M89 XP_4 AP_3-APN0 VSS VSS N W=12.66U L=0.13U M=1
M90 VDD AGTPB AP_3-NET41 VDD P W=0.77U L=0.13U M=1
M91 AP_3-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M92 VDD NET188 AP_3-AIN20 VDD P W=2.71U L=0.13U M=1
M93 AP_3-AIN20 NET188 VSS VSS N W=1.78U L=0.13U M=1
M94 VDD XP_4 AP_3-APN0 VDD P W=0.15U L=0.2U M=1
M95 AP_3-APN0 XP_4 VSS VSS N W=0.15U L=0.39U M=1
M96 VDD AGTPT AP_3-NET47 VDD P W=0.77U L=0.13U M=1
M97 AP_3-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M98 VDD XP_5 AP_3-APN1 VDD P W=0.15U L=0.2U M=1
M99 AP_3-APN1 XP_5 VSS VSS N W=0.15U L=0.39U M=1
.ENDS RA1SH512x32_onHXP38
****
.SUBCKT RA1SH512x32_onHXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32_onHXP38X: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32_onHXP38
.ENDS RA1SH512x32_onHXP38X
****
.SUBCKT RA1SH512x32_onX_PRE_DECODE A0 A0_0 A1 A1_0 A2 A2_0 AGTPB AGTPT AY0
+  AY0_ BWEN WEI XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_4_0
+  XP_5 XP_5_0 XP_6 XP_6_0 XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onX_PRE_DECODE: 384 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0 XP_1 XP_2 XP_3 XP_4 XP_5
+  XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32_onHXP38LX
XI1_0 A0_0 A1_0 A2_0 AGTPB AGTPT AY0 AY0_ BWEN WEI XP_0_0 XP_1_0 XP_2_0 XP_3_0
+  XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3
+  VSS VDD RA1SH512x32_onHXP38X
.ENDS RA1SH512x32_onX_PRE_DECODE
****
.SUBCKT RA1SH512x32_onHYP24 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** RA1SH512x32_onHYP24: 100 flat devices **
D0 VSS A1 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
D8 VSS A0 DN 0.2116P 1.84U
D9 VSS BWEN DN 0.2116P 1.84U
M10 VDD A0 NET106 VDD P W=3.06U L=0.13U M=1
M11 NET106 A0 VSS VSS N W=2.05U L=0.13U M=1
M12 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M13 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M14 VDD AI_1-NET28 NET105 VDD P W=3.06U L=0.13U M=1
M15 NET105 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M16 AP_2-APN1 AGTPT AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M17 AP_2-APN0 AGTPB AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M18 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M19 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M2 VDD A1 NET107 VDD P W=3.06U L=0.13U M=1
M20 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M21 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M22 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M23 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M24 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M25 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M26 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M27 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M28 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M29 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M3 NET107 A1 VSS VSS N W=2.05U L=0.13U M=1
M30 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M31 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M32 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M33 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M34 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M35 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M36 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M37 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M38 VDD AP_2-APN0 YP0_3 VDD P W=18U L=0.13U M=1
M39 YP0_3 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M4 VDD A1 AI_2-NET28 VDD P W=2.45U L=0.13U M=1
M40 VDD AGTPB AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M41 AP_2-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M42 VDD NET106 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M43 AP_2-AIN20 NET106 VSS VSS N W=1.78U L=0.13U M=1
M44 VDD YP0_3 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M45 AP_2-APN0 YP0_3 VSS VSS N W=0.15U L=0.39U M=1
M46 VDD AGTPT AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M47 AP_2-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M48 VDD YP0_2 AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M49 AP_2-APN1 YP0_2 VSS VSS N W=0.15U L=0.39U M=1
M5 AI_2-NET28 A1 VSS VSS N W=1.64U L=0.13U M=1
M50 VDD AP_2-APN1 YP0_2 VDD P W=18U L=0.13U M=1
M51 YP0_2 AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M52 VDD NET105 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M53 AP_2-AIN21 NET105 VSS VSS N W=1.78U L=0.13U M=1
M54 VDD VSS AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M55 AP_2-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M56 VDD NET107 AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M57 AP_2-NET57 NET107 VSS VSS N W=1.78U L=0.13U M=1
M58 AP_1-APN1 AGTPT AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M59 AP_1-APN0 AGTPB AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M6 VDD AI_2-NET28 NET86 VDD P W=3.06U L=0.13U M=1
M60 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M61 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M62 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M63 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M64 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M65 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M66 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M67 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M68 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M69 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M7 NET86 AI_2-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M71 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M72 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M73 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M74 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M75 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M76 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M77 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M78 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M79 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M80 VDD AP_1-APN0 YP0_1 VDD P W=18U L=0.13U M=1
M81 YP0_1 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M82 VDD AGTPB AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M83 AP_1-NET41 AGTPB VSS VSS N W=0.66U L=0.13U M=1
M84 VDD NET106 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M85 AP_1-AIN20 NET106 VSS VSS N W=1.78U L=0.13U M=1
M86 VDD YP0_1 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M87 AP_1-APN0 YP0_1 VSS VSS N W=0.15U L=0.39U M=1
M88 VDD AGTPT AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M89 AP_1-NET47 AGTPT VSS VSS N W=0.66U L=0.13U M=1
M90 VDD YP0_0 AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M91 AP_1-APN1 YP0_0 VSS VSS N W=0.15U L=0.39U M=1
M92 VDD AP_1-APN1 YP0_0 VDD P W=18U L=0.13U M=1
M93 YP0_0 AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M94 VDD NET105 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M95 AP_1-AIN21 NET105 VSS VSS N W=1.78U L=0.13U M=1
M96 VDD VSS AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M97 AP_1-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M98 VDD NET86 AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M99 AP_1-NET57 NET86 VSS VSS N W=1.78U L=0.13U M=1
.ENDS RA1SH512x32_onHYP24
****
.SUBCKT RA1SH512x32_onHYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** RA1SH512x32_onHYP24X: 100 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SH512x32_onHYP24
.ENDS RA1SH512x32_onHYP24X
****
.SUBCKT RA1SH512x32_onHYP12XR A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onHYP12XR: 92 flat devices **
D0 VSS A0 DN 0.2116P 1.84U
D1 VSS BWEN DN 0.2116P 1.84U
M10 AP_2-APN1 AP_2-NET47 AP_2-AIND1 VSS N W=4.38U L=0.13U M=1
M11 AP_2-APN0 AP_2-NET41 AP_2-AIND0 VSS N W=4.38U L=0.13U M=1
M12 AP_2-SC_NAND_C0_I14-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M13 AP_2-SC_NAND_C0_I14-NET12 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M14 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M15 AP_2-SC_NAND_C0_I14-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M16 AP_2-SC_NAND_C0_I14-NET21 AP_2-NET57 AP_2-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M17 AP_2-AIND0 AP_2-AIN20 AP_2-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M18 VDD AP_2-NET55 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M19 VDD AP_2-NET57 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M2 VDD A0 NET94 VDD P W=3.06U L=0.13U M=1
M20 VDD AP_2-AIN20 AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M21 AP_2-GAPND-NET9 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M22 AP_2-GAPND-NET12 AP_2-NET57 AP_2-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M23 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M24 AP_2-GAPND-NET18 AP_2-NET55 VSS VSS N W=4.38U L=0.13U M=1
M25 AP_2-GAPND-NET21 AP_2-NET57 AP_2-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M26 AP_2-AIND1 AP_2-AIN21 AP_2-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M27 VDD AP_2-NET55 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M28 VDD AP_2-NET57 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M29 VDD AP_2-AIN21 AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M3 NET94 A0 VSS VSS N W=2.05U L=0.13U M=1
M30 VDD AP_2-APN0 AY0 VDD P W=18U L=0.13U M=1
M31 AY0 AP_2-APN0 VSS VSS N W=12.66U L=0.13U M=1
M32 VDD AGTP AP_2-NET41 VDD P W=0.77U L=0.13U M=1
M33 AP_2-NET41 AGTP VSS VSS N W=0.66U L=0.13U M=1
M34 VDD NET94 AP_2-AIN20 VDD P W=2.71U L=0.13U M=1
M35 AP_2-AIN20 NET94 VSS VSS N W=1.78U L=0.13U M=1
M36 VDD AY0 AP_2-APN0 VDD P W=0.15U L=0.2U M=1
M37 AP_2-APN0 AY0 VSS VSS N W=0.15U L=0.39U M=1
M38 VDD AGTP AP_2-NET47 VDD P W=0.77U L=0.13U M=1
M39 AP_2-NET47 AGTP VSS VSS N W=0.66U L=0.13U M=1
M4 VDD A0 AI_1-NET28 VDD P W=2.45U L=0.13U M=1
M40 VDD AY0_ AP_2-APN1 VDD P W=0.15U L=0.2U M=1
M41 AP_2-APN1 AY0_ VSS VSS N W=0.15U L=0.39U M=1
M42 VDD AP_2-APN1 AY0_ VDD P W=18U L=0.13U M=1
M43 AY0_ AP_2-APN1 VSS VSS N W=12.66U L=0.13U M=1
M44 VDD NET93 AP_2-AIN21 VDD P W=2.71U L=0.13U M=1
M45 AP_2-AIN21 NET93 VSS VSS N W=1.78U L=0.13U M=1
M46 VDD VSS AP_2-NET55 VDD P W=2.71U L=0.13U M=1
M47 AP_2-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M48 VDD VSS AP_2-NET57 VDD P W=2.71U L=0.13U M=1
M49 AP_2-NET57 VSS VSS VSS N W=1.78U L=0.13U M=1
M5 AI_1-NET28 A0 VSS VSS N W=1.64U L=0.13U M=1
M50 AP_1-APN1 AGTP AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M51 AP_1-APN0 AGTP AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M52 AP_1-APN1 AP_1-NET47 AP_1-AIND1 VSS N W=4.38U L=0.13U M=1
M53 AP_1-APN0 AP_1-NET41 AP_1-AIND0 VSS N W=4.38U L=0.13U M=1
M54 AP_1-SC_NAND_C0_I14-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M55 AP_1-SC_NAND_C0_I14-NET12 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET9 VSS N
+  W=4.38U L=0.13U M=1
M56 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET12 VSS N W=4.38U L=0.13U M=1
M57 AP_1-SC_NAND_C0_I14-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M58 AP_1-SC_NAND_C0_I14-NET21 AP_1-NET57 AP_1-SC_NAND_C0_I14-NET18 VSS N
+  W=4.38U L=0.13U M=1
M59 AP_1-AIND0 AP_1-AIN20 AP_1-SC_NAND_C0_I14-NET21 VSS N W=4.38U L=0.13U M=1
M6 VDD AI_1-NET28 NET93 VDD P W=3.06U L=0.13U M=1
M60 VDD AP_1-NET55 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M61 VDD AP_1-NET57 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M62 VDD AP_1-AIN20 AP_1-AIND0 VDD P W=5.52U L=0.13U M=1
M63 AP_1-GAPND-NET9 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M64 AP_1-GAPND-NET12 AP_1-NET57 AP_1-GAPND-NET9 VSS N W=4.38U L=0.13U M=1
M65 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET12 VSS N W=4.38U L=0.13U M=1
M66 AP_1-GAPND-NET18 AP_1-NET55 VSS VSS N W=4.38U L=0.13U M=1
M67 AP_1-GAPND-NET21 AP_1-NET57 AP_1-GAPND-NET18 VSS N W=4.38U L=0.13U M=1
M68 AP_1-AIND1 AP_1-AIN21 AP_1-GAPND-NET21 VSS N W=4.38U L=0.13U M=1
M69 VDD AP_1-NET55 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M7 NET93 AI_1-NET28 VSS VSS N W=2.05U L=0.13U M=1
M70 VDD AP_1-NET57 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M71 VDD AP_1-AIN21 AP_1-AIND1 VDD P W=5.52U L=0.13U M=1
M72 VDD AP_1-APN0 AY0 VDD P W=18U L=0.13U M=1
M73 AY0 AP_1-APN0 VSS VSS N W=12.66U L=0.13U M=1
M74 VDD AGTP AP_1-NET41 VDD P W=0.77U L=0.13U M=1
M75 AP_1-NET41 AGTP VSS VSS N W=0.66U L=0.13U M=1
M76 VDD NET94 AP_1-AIN20 VDD P W=2.71U L=0.13U M=1
M77 AP_1-AIN20 NET94 VSS VSS N W=1.78U L=0.13U M=1
M78 VDD AY0 AP_1-APN0 VDD P W=0.15U L=0.2U M=1
M79 AP_1-APN0 AY0 VSS VSS N W=0.15U L=0.39U M=1
M8 AP_2-APN1 AGTP AP_2-AIND1 VDD P W=5.52U L=0.13U M=1
M80 VDD AGTP AP_1-NET47 VDD P W=0.77U L=0.13U M=1
M81 AP_1-NET47 AGTP VSS VSS N W=0.66U L=0.13U M=1
M82 VDD AY0_ AP_1-APN1 VDD P W=0.15U L=0.2U M=1
M83 AP_1-APN1 AY0_ VSS VSS N W=0.15U L=0.39U M=1
M84 VDD AP_1-APN1 AY0_ VDD P W=18U L=0.13U M=1
M85 AY0_ AP_1-APN1 VSS VSS N W=12.66U L=0.13U M=1
M86 VDD NET93 AP_1-AIN21 VDD P W=2.71U L=0.13U M=1
M87 AP_1-AIN21 NET93 VSS VSS N W=1.78U L=0.13U M=1
M88 VDD VSS AP_1-NET55 VDD P W=2.71U L=0.13U M=1
M89 AP_1-NET55 VSS VSS VSS N W=1.78U L=0.13U M=1
M9 AP_2-APN0 AGTP AP_2-AIND0 VDD P W=5.52U L=0.13U M=1
M90 VDD VSS AP_1-NET57 VDD P W=2.71U L=0.13U M=1
M91 AP_1-NET57 VSS VSS VSS N W=1.78U L=0.13U M=1
.ENDS RA1SH512x32_onHYP12XR
****
.SUBCKT RA1SH512x32_onHYP12XRX A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onHYP12XRX: 92 flat devices **
XI0_0 A0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32_onHYP12XR
.ENDS RA1SH512x32_onHYP12XRX
****
.SUBCKT RA1SH512x32_onY_DECODE A0 A0_0 A1 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN
+  RST WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SH512x32_onY_DECODE: 192 flat devices **
XI0_0 A0 A1 AGTP AGTP AY0 AY0_ BWEN WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SH512x32_onHYP24X
XI1_0 A0_0 AGTP AY0 AY0_ BWEN CLKB GSRCN GTPN RST WEI YP0_0 YP0_1 YP0_2 YP0_3
+  VSS VSS VSS VSS VSS VDD RA1SH512x32_onHYP12XRX
.ENDS RA1SH512x32_onY_DECODE
****
.SUBCKT RA1SH512x32_onHBF8 CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL
+  RST STOV STUBWE TMS WE WEI WEN WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onHBF8: 79 flat devices **
D0 VSS WEN DN 0.2116P 1.84U
D1 VSS TMS DN 0.2116P 1.84U
D2 VSS CLK DN 0.2116P 1.84U
D3 VSS STOV DN 0.2116P 1.84U
D4 VSS CEN DN 0.2116P 1.84U
M10 BF-CENMML CLK BF-SC_TRIINV_C8_I0-NET7 VSS N W=0.15U L=0.13U M=1
M11 BF-SC_TRIINV_C8_I0-NET15 CLKB BF-CENMML VDD P W=0.15U L=0.13U M=1
M12 VDD BF-CEL BF-SC_TRIINV_C8_I0-NET15 VDD P W=0.15U L=0.13U M=1
M13 RST BF-RSTSRC VDD VDD P W=10.55U L=0.13U M=1
M14 RST BF-MBLN VDD VDD P W=2.25U L=0.13U M=1
M15 BF-CENMML BF-NET223 BF-NET113 VDD P W=0.15U L=0.13U M=1
M16 BF-MBLN MBL VDD VDD P W=0.88U L=0.13U M=1
M17 BF-NET113 TMS BF-NET123 VDD P W=0.15U L=0.13U M=1
M18 BF-NET123 CLK VDD VDD P W=0.15U L=0.13U M=1
M19 BF-NET128 CLKB VSS VSS N W=0.15U L=0.13U M=1
M20 BF-CENMML BF-NET223 BF-NET128 VSS N W=0.15U L=0.13U M=1
M21 BF-MBLN MBL VSS VSS N W=0.4U L=0.13U M=1
M22 BF-NET135 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M23 BF-NET138 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M24 BF-NET141 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M25 BF-NET144 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M26 BF-NET147 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M27 BF-NET150 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M28 BF-NET153 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M29 BF-NET156 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M30 BF-NET159 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M31 RST BF-MBLN BF-NET135 VSS N W=1.74U L=0.13U M=1
M32 RST BF-MBLN BF-NET138 VSS N W=1.74U L=0.13U M=1
M33 RST BF-MBLN BF-NET141 VSS N W=1.74U L=0.13U M=1
M34 RST BF-MBLN BF-NET144 VSS N W=1.74U L=0.13U M=1
M35 RST BF-MBLN BF-NET147 VSS N W=1.74U L=0.13U M=1
M36 RST BF-MBLN BF-NET150 VSS N W=1.74U L=0.13U M=1
M37 RST BF-MBLN BF-NET153 VSS N W=1.74U L=0.13U M=1
M38 RST BF-MBLN BF-NET156 VSS N W=1.74U L=0.13U M=1
M39 RST BF-MBLN BF-NET159 VSS N W=1.74U L=0.13U M=1
M40 BF-CENMML TMS BF-NET128 VSS N W=0.15U L=0.13U M=1
M41 RST BF-MBLN BF-NET195 VSS N W=1.74U L=0.13U M=1
M42 BF-NET195 BF-RSTSRC VSS VSS N W=2.26U L=0.13U M=1
M43 BF-GGSRCND-NET9 GTPN VSS VSS N W=0.28U L=0.13U M=1
M44 BF-GGSRCND-NET12 CLKB BF-GGSRCND-NET9 VSS N W=0.28U L=0.13U M=1
M45 BF-NET212 BF-CEL BF-GGSRCND-NET12 VSS N W=0.28U L=0.13U M=1
M46 VDD GTPN BF-NET212 VDD P W=0.15U L=0.13U M=1
M47 VDD CLKB BF-NET212 VDD P W=0.15U L=0.13U M=1
M48 VDD BF-CEL BF-NET212 VDD P W=0.15U L=0.13U M=1
M49 BF-GRSRC-NET8 GTP VSS VSS N W=0.48U L=0.13U M=1
M5 BF-GCKSTOV-NET8 STOV VSS VSS N W=0.41U L=0.13U M=1
M50 BF-RSRCN BF-CKSTOV BF-GRSRC-NET8 VSS N W=0.48U L=0.13U M=1
M51 BF-GRSRC-NET12 GTP VSS VSS N W=0.48U L=0.13U M=1
M52 BF-RSRCN BF-CKSTOV BF-GRSRC-NET12 VSS N W=0.48U L=0.13U M=1
M53 VDD GTP BF-RSRCN VDD P W=0.76U L=0.13U M=1
M54 VDD BF-CKSTOV BF-RSRCN VDD P W=0.76U L=0.13U M=1
M55 VDD BF-NET205 BF-NET203 VDD P W=3.16U L=0.13U M=1
M56 BF-NET203 BF-NET205 VSS VSS N W=2.01U L=0.13U M=1
M57 VDD WEN BF-NET205 VDD P W=1.12U L=0.13U M=1
M58 BF-NET205 WEN VSS VSS N W=0.74U L=0.13U M=1
M59 VDD BF-NET203 WE VDD P W=10.76U L=0.13U M=1
M6 BF-CKSTOV CLK BF-GCKSTOV-NET8 VSS N W=0.41U L=0.13U M=1
M60 WE BF-NET203 VSS VSS N W=7.5U L=0.13U M=1
M61 VDD BF-RSRCN BF-RSTSRC VDD P W=2.3U L=0.13U M=1
M62 BF-RSTSRC BF-RSRCN VSS VSS N W=1.46U L=0.13U M=1
M63 VDD BF-NET212 BF-NET211 VDD P W=0.4U L=0.13U M=1
M64 BF-NET211 BF-NET212 VSS VSS N W=0.26U L=0.13U M=1
M65 VDD BF-NET211 BF-NET216 VDD P W=2.21U L=0.13U M=1
M66 BF-NET216 BF-NET211 VSS VSS N W=1.4U L=0.13U M=1
M67 VDD BF-NET216 GSRCN VDD P W=12U L=0.13U M=1
M68 GSRCN BF-NET216 VSS VSS N W=7.65U L=0.13U M=1
M69 VDD BF-GTPI GTPN VDD P W=0.15U L=0.13U M=1
M7 VDD STOV BF-CKSTOV VDD P W=0.31U L=0.13U M=1
M70 GTPN BF-GTPI VSS VSS N W=0.15U L=0.13U M=1
M71 VDD GTPN BF-GTPI VDD P W=0.15U L=0.13U M=1
M72 BF-GTPI GTPN VSS VSS N W=0.15U L=0.13U M=1
M73 VDD CLK CLKB VDD P W=6.68U L=0.13U M=1
M74 CLKB CLK VSS VSS N W=26.73U L=0.13U M=1
M75 VDD CEN BF-NET223 VDD P W=0.15U L=0.13U M=1
M76 BF-NET223 CEN VSS VSS N W=0.15U L=0.13U M=1
M77 VDD BF-CENMML BF-CEL VDD P W=0.15U L=0.13U M=1
M78 BF-CEL BF-CENMML VSS VSS N W=0.15U L=0.13U M=1
M8 VDD CLK BF-CKSTOV VDD P W=0.31U L=0.13U M=1
M9 BF-SC_TRIINV_C8_I0-NET7 BF-CEL VSS VSS N W=0.15U L=0.13U M=1
.ENDS RA1SH512x32_onHBF8
****
.SUBCKT RA1SH512x32_onHBFX CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL
+  RST STUBWE WE WEI WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onHBFX: 79 flat devices **
XI0_0 CEN CLK CLKB DPN4 DPU4 DW DW_ GSRCN GTP GTPN MBL RST VSS STUBWE VSS WE
+  WEI VSS WESA YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32_onHBF8
.ENDS RA1SH512x32_onHBFX
****
.SUBCKT RA1SH512x32_onCCMWP BL BLD BLD_ BL_ WL WP VSS VDD
** RA1SH512x32_onCCMWP: 6 flat devices **
M0 BLD WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BLD_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS RA1SH512x32_onCCMWP
****
.SUBCKT RA1SH512x32_onCCMWG BL BLD BLD_ BL_ WL WP VSS VDD
** RA1SH512x32_onCCMWG: 6 flat devices **
M0 BLD WP CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 BLD_ WP CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M2 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M3 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M4 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M5 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS RA1SH512x32_onCCMWG
****
.SUBCKT RA1SH512x32_onFLMWG BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** RA1SH512x32_onFLMWG: 24 flat devices **
M0 NET25 WP1 CORED VSS NCH_SRAM W=0.23U L=0.145U M=1
M1 NET34 WP3 CORED_ VSS NCH_SRAM W=0.23U L=0.145U M=1
M10 VDD NODE5 NODE4 VDD PCH_SRAM W=0.165U L=0.14U M=1
M11 NODE4 NODE5 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M12 VDD NODE2 NODE1 VDD PCH_SRAM W=0.165U L=0.14U M=1
M13 NODE1 NODE2 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M14 VDD NODE3 NODE0 VDD PCH_SRAM W=0.165U L=0.14U M=1
M15 NODE0 NODE3 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M16 VDD NODE4 NODE5 VDD PCH_SRAM W=0.165U L=0.14U M=1
M17 NODE5 NODE4 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M18 VDD NODE1 NODE2 VDD PCH_SRAM W=0.165U L=0.14U M=1
M19 NODE2 NODE1 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M2 NET19 WP2 NODE4 VSS NCH_SRAM W=0.23U L=0.145U M=1
M20 VDD NODE0 NODE3 VDD PCH_SRAM W=0.165U L=0.14U M=1
M21 NODE3 NODE0 VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M22 VDD CORED_ CORED VDD PCH_SRAM W=0.165U L=0.14U M=1
M23 CORED CORED_ VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
M3 NET19 WP3 NODE1 VSS NCH_SRAM W=0.23U L=0.145U M=1
M4 NET25 WP0 NODE0 VSS NCH_SRAM W=0.23U L=0.145U M=1
M5 NET28 WP2 NODE5 VSS NCH_SRAM W=0.23U L=0.145U M=1
M6 NET28 WP3 NODE2 VSS NCH_SRAM W=0.23U L=0.145U M=1
M7 NET34 WP2 NODE3 VSS NCH_SRAM W=0.23U L=0.145U M=1
M8 VDD CORED CORED_ VDD PCH_SRAM W=0.165U L=0.14U M=1
M9 CORED_ CORED VSS VSS NCH_SRAM W=0.39U L=0.13U M=1
.ENDS RA1SH512x32_onFLMWG
****
.SUBCKT RA1SH512x32_onMODEL_ROW_16 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2
+  BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15
+  BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27
+  BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51
+  BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63
+  BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75
+  BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87
+  BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99
+  BL_100 BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109
+  BL_110 BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119
+  BL_120 BL_121 BL_122 BL_123 BL_124 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 WL VSS VDD
** RA1SH512x32_onMODEL_ROW_16: 1536 flat devices **
XI0_0 BL BLD_214 BLD__216 BL_ WL WL VSS VDD RA1SH512x32_onCCMWG
XI0_1 BL_ BLD__216 BLD_214 BL WL WL VSS VDD RA1SH512x32_onCCMWG
XI100_0 BL_94 BLD_274 BLD__276 BL__94 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI100_1 BL__94 BLD__276 BLD_274 BL_94 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI101_0 BL_95 BLD_406 BLD__408 BL__95 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI101_1 BL__95 BLD__408 BLD_406 BL_95 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI102_0 BL_96 BLD_30 BLD__32 BL__96 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI102_1 BL__96 BLD__32 BLD_30 BL_96 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI103_0 BL_97 BLD_154 BLD__156 BL__97 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI103_1 BL__97 BLD__156 BLD_154 BL_97 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI104_0 BL_98 BLD_282 BLD__284 BL__98 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI104_1 BL__98 BLD__284 BLD_282 BL_98 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI105_0 BL_99 BLD_414 BLD__416 BL__99 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI105_1 BL__99 BLD__416 BLD_414 BL_99 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI106_0 BL_100 BLD_38 BLD__40 BL__100 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI106_1 BL__100 BLD__40 BLD_38 BL_100 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI107_0 BL_101 BLD_162 BLD__164 BL__101 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI107_1 BL__101 BLD__164 BLD_162 BL_101 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI108_0 BL_102 BLD_290 BLD__292 BL__102 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI108_1 BL__102 BLD__292 BLD_290 BL_102 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI109_0 BL_103 BLD_422 BLD__424 BL__103 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI109_1 BL__103 BLD__424 BLD_422 BL_103 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI10_0 BL_9 BLD_46 BLD__48 BL__9 WL WL VSS VDD RA1SH512x32_onCCMWP
XI10_1 BL__9 BLD__48 BLD_46 BL_9 WL WL VSS VDD RA1SH512x32_onCCMWP
XI110_0 BL_104 BLD_478 BLD__480 BL__104 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI110_1 BL__104 BLD__480 BLD_478 BL_104 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI111_0 BL_105 BLD_94 BLD__96 BL__105 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI111_1 BL__105 BLD__96 BLD_94 BL_105 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI112_0 BL_106 BLD_226 BLD__228 BL__106 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI112_1 BL__106 BLD__228 BLD_226 BL_106 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI113_0 BL_107 BLD_354 BLD__356 BL__107 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI113_1 BL__107 BLD__356 BLD_354 BL_107 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI114_0 BL_108 BLD_486 BLD__488 BL__108 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI114_1 BL__108 BLD__488 BLD_486 BL_108 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI115_0 BL_109 BLD_102 BLD__104 BL__109 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI115_1 BL__109 BLD__104 BLD_102 BL_109 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI116_0 BL_110 BLD_234 BLD__236 BL__110 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI116_1 BL__110 BLD__236 BLD_234 BL_110 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI117_0 BL_111 BLD_362 BLD__364 BL__111 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI117_1 BL__111 BLD__364 BLD_362 BL_111 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI118_0 BL_112 BLD_490 BLD__492 BL__112 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI118_1 BL__112 BLD__492 BLD_490 BL_112 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI119_0 BL_113 BLD_110 BLD__112 BL__113 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI119_1 BL__113 BLD__112 BLD_110 BL_113 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI11_0 BL_10 BLD_170 BLD__172 BL__10 WL WL VSS VDD RA1SH512x32_onCCMWG
XI11_1 BL__10 BLD__172 BLD_170 BL_10 WL WL VSS VDD RA1SH512x32_onCCMWG
XI120_0 BL_114 BLD_150 BLD__152 BL__114 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI120_1 BL__114 BLD__152 BLD_150 BL_114 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI121_0 BL_115 BLD_278 BLD__280 BL__115 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI121_1 BL__115 BLD__280 BLD_278 BL_115 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI122_0 BL_116 BLD_410 BLD__412 BL__116 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI122_1 BL__116 BLD__412 BLD_410 BL_116 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI123_0 BL_117 BLD_34 BLD__36 BL__117 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI123_1 BL__117 BLD__36 BLD_34 BL_117 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI124_0 BL_118 BLD_158 BLD__160 BL__118 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI124_1 BL__118 BLD__160 BLD_158 BL_118 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI125_0 BL_119 BLD_286 BLD__288 BL__119 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI125_1 BL__119 BLD__288 BLD_286 BL_119 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI126_0 BL_120 BLD_418 BLD__420 BL__120 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI126_1 BL__120 BLD__420 BLD_418 BL_120 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI127_0 BL_121 BLD_42 BLD__44 BL__121 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI127_1 BL__121 BLD__44 BLD_42 BL_121 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI128_0 BL_122 BLD_166 BLD__168 BL__122 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI128_1 BL__122 BLD__168 BLD_166 BL_122 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI129_0 BL_123 BLD_294 BLD__296 BL__123 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI129_1 BL__123 BLD__296 BLD_294 BL_123 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI12_0 BL_11 BLD_298 BLD__300 BL__11 WL WL VSS VDD RA1SH512x32_onCCMWG
XI12_1 BL__11 BLD__300 BLD_298 BL_11 WL WL VSS VDD RA1SH512x32_onCCMWG
XI130_0 BL_124 BLD_350 BLD__352 BL__124 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI130_1 BL__124 BLD__352 BLD_350 BL_124 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI13_0 BL_12 BLD_430 BLD__432 BL__12 WL WL VSS VDD RA1SH512x32_onCCMWP
XI13_1 BL__12 BLD__432 BLD_430 BL_12 WL WL VSS VDD RA1SH512x32_onCCMWP
XI14_0 BL_13 BLD_54 BLD__56 BL__13 WL WL VSS VDD RA1SH512x32_onCCMWP
XI14_1 BL__13 BLD__56 BLD_54 BL_13 WL WL VSS VDD RA1SH512x32_onCCMWP
XI15_0 BL_14 BLD_174 BLD__176 BL__14 WL WL VSS VDD RA1SH512x32_onCCMWG
XI15_1 BL__14 BLD__176 BLD_174 BL_14 WL WL VSS VDD RA1SH512x32_onCCMWG
XI16_0 BL_15 BLD_310 BLD__312 BL__15 WL WL VSS VDD RA1SH512x32_onCCMWG
XI16_1 BL__15 BLD__312 BLD_310 BL_15 WL WL VSS VDD RA1SH512x32_onCCMWG
XI17_0 BL_16 BLD_442 BLD__444 BL__16 WL WL VSS VDD RA1SH512x32_onCCMWP
XI17_1 BL__16 BLD__444 BLD_442 BL_16 WL WL VSS VDD RA1SH512x32_onCCMWP
XI18_0 BL_17 BLD_70 BLD__72 BL__17 WL WL VSS VDD RA1SH512x32_onCCMWP
XI18_1 BL__17 BLD__72 BLD_70 BL_17 WL WL VSS VDD RA1SH512x32_onCCMWP
XI19_0 BL_18 BLD_190 BLD__192 BL__18 WL WL VSS VDD RA1SH512x32_onCCMWG
XI19_1 BL__18 BLD__192 BLD_190 BL_18 WL WL VSS VDD RA1SH512x32_onCCMWG
XI1_0 BL_0 BLD_346 BLD__348 BL__0 WL WL VSS VDD RA1SH512x32_onCCMWP
XI1_1 BL__0 BLD__348 BLD_346 BL_0 WL WL VSS VDD RA1SH512x32_onCCMWP
XI20_0 BL_19 BLD_238 BLD__240 BL__19 WL WL VSS VDD RA1SH512x32_onCCMWG
XI20_1 BL__19 BLD__240 BLD_238 BL_19 WL WL VSS VDD RA1SH512x32_onCCMWG
XI21_0 BL_20 BLD_370 BLD__372 BL__20 WL WL VSS VDD RA1SH512x32_onCCMWP
XI21_1 BL__20 BLD__372 BLD_370 BL_20 WL WL VSS VDD RA1SH512x32_onCCMWP
XI22_0 BL_21 BLD_494 BLD__496 BL__21 WL WL VSS VDD RA1SH512x32_onCCMWP
XI22_1 BL__21 BLD__496 BLD_494 BL_21 WL WL VSS VDD RA1SH512x32_onCCMWP
XI23_0 BL_22 BLD_118 BLD__120 BL__22 WL WL VSS VDD RA1SH512x32_onCCMWG
XI23_1 BL__22 BLD__120 BLD_118 BL_22 WL WL VSS VDD RA1SH512x32_onCCMWG
XI24_0 BL_23 BLD_246 BLD__248 BL__23 WL WL VSS VDD RA1SH512x32_onCCMWG
XI24_1 BL__23 BLD__248 BLD_246 BL_23 WL WL VSS VDD RA1SH512x32_onCCMWG
XI25_0 BL_24 BLD_378 BLD__380 BL__24 WL WL VSS VDD RA1SH512x32_onCCMWP
XI25_1 BL__24 BLD__380 BLD_378 BL_24 WL WL VSS VDD RA1SH512x32_onCCMWP
XI26_0 BL_25 BLD_2 BLD__4 BL__25 WL WL VSS VDD RA1SH512x32_onCCMWP
XI26_1 BL__25 BLD__4 BLD_2 BL_25 WL WL VSS VDD RA1SH512x32_onCCMWP
XI27_0 BL_26 BLD_130 BLD__132 BL__26 WL WL VSS VDD RA1SH512x32_onCCMWG
XI27_1 BL__26 BLD__132 BLD_130 BL_26 WL WL VSS VDD RA1SH512x32_onCCMWG
XI28_0 BL_27 BLD_258 BLD__260 BL__27 WL WL VSS VDD RA1SH512x32_onCCMWG
XI28_1 BL__27 BLD__260 BLD_258 BL_27 WL WL VSS VDD RA1SH512x32_onCCMWG
XI29_0 BL_28 BLD_394 BLD__396 BL__28 WL WL VSS VDD RA1SH512x32_onCCMWP
XI29_1 BL__28 BLD__396 BLD_394 BL_28 WL WL VSS VDD RA1SH512x32_onCCMWP
XI2_0 BL_1 BLD_474 BLD__476 BL__1 WL WL VSS VDD RA1SH512x32_onCCMWP
XI2_1 BL__1 BLD__476 BLD_474 BL_1 WL WL VSS VDD RA1SH512x32_onCCMWP
XI30_0 BL_29 BLD_426 BLD__428 BL__29 WL WL VSS VDD RA1SH512x32_onCCMWP
XI30_1 BL__29 BLD__428 BLD_426 BL_29 WL WL VSS VDD RA1SH512x32_onCCMWP
XI31_0 BL_30 BLD_50 BLD__52 BL__30 WL WL VSS VDD RA1SH512x32_onCCMWG
XI31_1 BL__30 BLD__52 BLD_50 BL_30 WL WL VSS VDD RA1SH512x32_onCCMWG
XI33_0 BL_31 BLD_306 BLD__308 BL__31 WL WL VSS VDD RA1SH512x32_onCCMWG
XI33_1 BL__31 BLD__308 BLD_306 BL_31 WL WL VSS VDD RA1SH512x32_onCCMWG
XI34_0 BL_32 BLD_438 BLD__440 BL__32 WL WL VSS VDD RA1SH512x32_onCCMWP
XI34_1 BL__32 BLD__440 BLD_438 BL_32 WL WL VSS VDD RA1SH512x32_onCCMWP
XI35_0 BL_33 BLD_62 BLD__64 BL__33 WL WL VSS VDD RA1SH512x32_onCCMWP
XI35_1 BL__33 BLD__64 BLD_62 BL_33 WL WL VSS VDD RA1SH512x32_onCCMWP
XI36_0 BL_34 BLD_186 BLD__188 BL__34 WL WL VSS VDD RA1SH512x32_onCCMWG
XI36_1 BL__34 BLD__188 BLD_186 BL_34 WL WL VSS VDD RA1SH512x32_onCCMWG
XI37_0 BL_35 BLD_322 BLD__324 BL__35 WL WL VSS VDD RA1SH512x32_onCCMWG
XI37_1 BL__35 BLD__324 BLD_322 BL_35 WL WL VSS VDD RA1SH512x32_onCCMWG
XI38_0 BL_36 BLD_454 BLD__456 BL__36 WL WL VSS VDD RA1SH512x32_onCCMWP
XI38_1 BL__36 BLD__456 BLD_454 BL_36 WL WL VSS VDD RA1SH512x32_onCCMWP
XI39_0 BL_37 BLD_82 BLD__84 BL__37 WL WL VSS VDD RA1SH512x32_onCCMWP
XI39_1 BL__37 BLD__84 BLD_82 BL_37 WL WL VSS VDD RA1SH512x32_onCCMWP
XI3_0 BL_2 BLD_98 BLD__100 BL__2 WL WL VSS VDD RA1SH512x32_onCCMWG
XI3_1 BL__2 BLD__100 BLD_98 BL_2 WL WL VSS VDD RA1SH512x32_onCCMWG
XI40_0 BL_38 BLD_114 BLD__116 BL__38 WL WL VSS VDD RA1SH512x32_onCCMWG
XI40_1 BL__38 BLD__116 BLD_114 BL_38 WL WL VSS VDD RA1SH512x32_onCCMWG
XI41_0 BL_39 BLD_242 BLD__244 BL__39 WL WL VSS VDD RA1SH512x32_onCCMWG
XI41_1 BL__39 BLD__244 BLD_242 BL_39 WL WL VSS VDD RA1SH512x32_onCCMWG
XI42_0 BL_40 BLD_374 BLD__376 BL__40 WL WL VSS VDD RA1SH512x32_onCCMWP
XI42_1 BL__40 BLD__376 BLD_374 BL_40 WL WL VSS VDD RA1SH512x32_onCCMWP
XI43_0 BL_41 BLD_ BLD BL__41 WL WL VSS VDD RA1SH512x32_onCCMWP
XI43_1 BL__41 BLD BLD_ BL_41 WL WL VSS VDD RA1SH512x32_onCCMWP
XI44_0 BL_42 BLD_126 BLD__128 BL__42 WL WL VSS VDD RA1SH512x32_onCCMWG
XI44_1 BL__42 BLD__128 BLD_126 BL_42 WL WL VSS VDD RA1SH512x32_onCCMWG
XI45_0 BL_43 BLD_254 BLD__256 BL__43 WL WL VSS VDD RA1SH512x32_onCCMWG
XI45_1 BL__43 BLD__256 BLD_254 BL_43 WL WL VSS VDD RA1SH512x32_onCCMWG
XI46_0 BL_44 BLD_390 BLD__392 BL__44 WL WL VSS VDD RA1SH512x32_onCCMWP
XI46_1 BL__44 BLD__392 BLD_390 BL_44 WL WL VSS VDD RA1SH512x32_onCCMWP
XI47_0 BL_45 BLD_14 BLD__16 BL__45 WL WL VSS VDD RA1SH512x32_onCCMWP
XI47_1 BL__45 BLD__16 BLD_14 BL_45 WL WL VSS VDD RA1SH512x32_onCCMWP
XI48_0 BL_46 BLD_138 BLD__140 BL__46 WL WL VSS VDD RA1SH512x32_onCCMWG
XI48_1 BL__46 BLD__140 BLD_138 BL_46 WL WL VSS VDD RA1SH512x32_onCCMWG
XI49_0 BL_47 BLD_266 BLD__268 BL__47 WL WL VSS VDD RA1SH512x32_onCCMWG
XI49_1 BL__47 BLD__268 BLD_266 BL_47 WL WL VSS VDD RA1SH512x32_onCCMWG
XI4_0 BL_3 BLD_222 BLD__224 BL__3 WL WL VSS VDD RA1SH512x32_onCCMWG
XI4_1 BL__3 BLD__224 BLD_222 BL_3 WL WL VSS VDD RA1SH512x32_onCCMWG
XI50_0 BL_48 BLD_302 BLD__304 BL__48 WL WL VSS VDD RA1SH512x32_onCCMWP
XI50_1 BL__48 BLD__304 BLD_302 BL_48 WL WL VSS VDD RA1SH512x32_onCCMWP
XI51_0 BL_49 BLD_434 BLD__436 BL__49 WL WL VSS VDD RA1SH512x32_onCCMWP
XI51_1 BL__49 BLD__436 BLD_434 BL_49 WL WL VSS VDD RA1SH512x32_onCCMWP
XI52_0 BL_50 BLD_58 BLD__60 BL__50 WL WL VSS VDD RA1SH512x32_onCCMWG
XI52_1 BL__50 BLD__60 BLD_58 BL_50 WL WL VSS VDD RA1SH512x32_onCCMWG
XI53_0 BL_51 BLD_182 BLD__184 BL__51 WL WL VSS VDD RA1SH512x32_onCCMWG
XI53_1 BL__51 BLD__184 BLD_182 BL_51 WL WL VSS VDD RA1SH512x32_onCCMWG
XI54_0 BL_52 BLD_318 BLD__320 BL__52 WL WL VSS VDD RA1SH512x32_onCCMWP
XI54_1 BL__52 BLD__320 BLD_318 BL_52 WL WL VSS VDD RA1SH512x32_onCCMWP
XI55_0 BL_53 BLD_450 BLD__452 BL__53 WL WL VSS VDD RA1SH512x32_onCCMWP
XI55_1 BL__53 BLD__452 BLD_450 BL_53 WL WL VSS VDD RA1SH512x32_onCCMWP
XI56_0 BL_54 BLD_78 BLD__80 BL__54 WL WL VSS VDD RA1SH512x32_onCCMWG
XI56_1 BL__54 BLD__80 BLD_78 BL_54 WL WL VSS VDD RA1SH512x32_onCCMWG
XI57_0 BL_55 BLD_202 BLD__204 BL__55 WL WL VSS VDD RA1SH512x32_onCCMWG
XI57_1 BL__55 BLD__204 BLD_202 BL_55 WL WL VSS VDD RA1SH512x32_onCCMWG
XI58_0 BL_56 BLD_334 BLD__336 BL__56 WL WL VSS VDD RA1SH512x32_onCCMWP
XI58_1 BL__56 BLD__336 BLD_334 BL_56 WL WL VSS VDD RA1SH512x32_onCCMWP
XI59_0 BL_57 BLD_466 BLD__468 BL__57 WL WL VSS VDD RA1SH512x32_onCCMWP
XI59_1 BL__57 BLD__468 BLD_466 BL_57 WL WL VSS VDD RA1SH512x32_onCCMWP
XI5_0 BL_4 BLD_358 BLD__360 BL__4 WL WL VSS VDD RA1SH512x32_onCCMWP
XI5_1 BL__4 BLD__360 BLD_358 BL_4 WL WL VSS VDD RA1SH512x32_onCCMWP
XI60_0 BL_58 BLD_498 BLD__500 BL__58 WL WL VSS VDD RA1SH512x32_onCCMWG
XI60_1 BL__58 BLD__500 BLD_498 BL_58 WL WL VSS VDD RA1SH512x32_onCCMWG
XI61_0 BL_59 BLD_122 BLD__124 BL__59 WL WL VSS VDD RA1SH512x32_onCCMWG
XI61_1 BL__59 BLD__124 BLD_122 BL_59 WL WL VSS VDD RA1SH512x32_onCCMWG
XI62_0 BL_60 BLD_250 BLD__252 BL__60 WL WL VSS VDD RA1SH512x32_onCCMWP
XI62_1 BL__60 BLD__252 BLD_250 BL_60 WL WL VSS VDD RA1SH512x32_onCCMWP
XI63_0 BL_61 BLD_386 BLD__388 BL__61 WL WL VSS VDD RA1SH512x32_onCCMWP
XI63_1 BL__61 BLD__388 BLD_386 BL_61 WL WL VSS VDD RA1SH512x32_onCCMWP
XI64_0 BL_62 BLD_10 BLD__12 BL__62 WL WL VSS VDD RA1SH512x32_onCCMWG
XI64_1 BL__62 BLD__12 BLD_10 BL_62 WL WL VSS VDD RA1SH512x32_onCCMWG
XI66_0 BL0 BL0_ BL1 BL1_ WL WL WL VSS VSS VSS VDD RA1SH512x32_onFLMWG
XI68_0 BL_63 BLD_22 BLD__24 BL__63 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI68_1 BL__63 BLD__24 BLD_22 BL_63 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI69_0 BL_64 BLD_146 BLD__148 BL__64 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI69_1 BL__64 BLD__148 BLD_146 BL_64 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI6_0 BL_5 BLD_482 BLD__484 BL__5 WL WL VSS VDD RA1SH512x32_onCCMWP
XI6_1 BL__5 BLD__484 BLD_482 BL_5 WL WL VSS VDD RA1SH512x32_onCCMWP
XI70_0 BL_65 BLD_178 BLD__180 BL__65 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI70_1 BL__65 BLD__180 BLD_178 BL_65 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI71_0 BL_66 BLD_314 BLD__316 BL__66 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI71_1 BL__66 BLD__316 BLD_314 BL_66 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI72_0 BL_67 BLD_446 BLD__448 BL__67 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI72_1 BL__67 BLD__448 BLD_446 BL_67 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI73_0 BL_68 BLD_74 BLD__76 BL__68 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI73_1 BL__68 BLD__76 BLD_74 BL_68 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI74_0 BL_69 BLD_198 BLD__200 BL__69 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI74_1 BL__69 BLD__200 BLD_198 BL_69 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI75_0 BL_70 BLD_330 BLD__332 BL__70 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI75_1 BL__70 BLD__332 BLD_330 BL_70 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI76_0 BL_71 BLD_462 BLD__464 BL__71 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI76_1 BL__71 BLD__464 BLD_462 BL_71 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI77_0 BL_72 BLD_90 BLD__92 BL__72 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI77_1 BL__72 BLD__92 BLD_90 BL_72 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI78_0 BL_73 BLD_210 BLD__212 BL__73 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI78_1 BL__73 BLD__212 BLD_210 BL_73 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI79_0 BL_74 BLD_342 BLD__344 BL__74 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI79_1 BL__74 BLD__344 BLD_342 BL_74 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI7_0 BL_6 BLD_106 BLD__108 BL__6 WL WL VSS VDD RA1SH512x32_onCCMWG
XI7_1 BL__6 BLD__108 BLD_106 BL_6 WL WL VSS VDD RA1SH512x32_onCCMWG
XI80_0 BL_75 BLD_382 BLD__384 BL__75 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI80_1 BL__75 BLD__384 BLD_382 BL_75 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI81_0 BL_76 BLD_6 BLD__8 BL__76 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI81_1 BL__76 BLD__8 BLD_6 BL_76 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI82_0 BL_77 BLD_134 BLD__136 BL__77 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI82_1 BL__77 BLD__136 BLD_134 BL_77 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI83_0 BL_78 BLD_262 BLD__264 BL__78 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI83_1 BL__78 BLD__264 BLD_262 BL_78 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI84_0 BL_79 BLD_398 BLD__400 BL__79 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI84_1 BL__79 BLD__400 BLD_398 BL_79 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI85_0 BL_80 BLD_18 BLD__20 BL__80 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI85_1 BL__80 BLD__20 BLD_18 BL_80 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI86_0 BL_81 BLD_142 BLD__144 BL__81 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI86_1 BL__81 BLD__144 BLD_142 BL_81 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI87_0 BL_82 BLD_270 BLD__272 BL__82 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI87_1 BL__82 BLD__272 BLD_270 BL_82 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI88_0 BL_83 BLD_402 BLD__404 BL__83 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI88_1 BL__83 BLD__404 BLD_402 BL_83 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI89_0 BL_84 BLD_26 BLD__28 BL__84 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI89_1 BL__84 BLD__28 BLD_26 BL_84 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI8_0 BL_7 BLD_230 BLD__232 BL__7 WL WL VSS VDD RA1SH512x32_onCCMWG
XI8_1 BL__7 BLD__232 BLD_230 BL_7 WL WL VSS VDD RA1SH512x32_onCCMWG
XI90_0 BL_85 BLD_66 BLD__68 BL__85 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI90_1 BL__85 BLD__68 BLD_66 BL_85 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI91_0 BL_86 BLD_194 BLD__196 BL__86 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI91_1 BL__86 BLD__196 BLD_194 BL_86 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI92_0 BL_87 BLD_326 BLD__328 BL__87 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI92_1 BL__87 BLD__328 BLD_326 BL_87 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI93_0 BL_88 BLD_458 BLD__460 BL__88 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI93_1 BL__88 BLD__460 BLD_458 BL_88 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI94_0 BL_89 BLD_86 BLD__88 BL__89 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI94_1 BL__89 BLD__88 BLD_86 BL_89 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI95_0 BL_90 BLD_206 BLD__208 BL__90 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI95_1 BL__90 BLD__208 BLD_206 BL_90 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI96_0 BL_91 BLD_338 BLD__340 BL__91 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI96_1 BL__91 BLD__340 BLD_338 BL_91 VSS VSS VSS VDD RA1SH512x32_onCCMWP
XI97_0 BL_92 BLD_470 BLD__472 BL__92 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI97_1 BL__92 BLD__472 BLD_470 BL_92 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI99_0 BL_93 BLD_218 BLD__220 BL__93 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI99_1 BL__93 BLD__220 BLD_218 BL_93 VSS VSS VSS VDD RA1SH512x32_onCCMWG
XI9_0 BL_8 BLD_366 BLD__368 BL__8 WL WL VSS VDD RA1SH512x32_onCCMWP
XI9_1 BL__8 BLD__368 BLD_366 BL_8 WL WL VSS VDD RA1SH512x32_onCCMWP
.ENDS RA1SH512x32_onMODEL_ROW_16
****
.SUBCKT RA1SH512x32_onWD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWD: 30 flat devices **
M0 NET120 RSWN1 GTP VDD P W=1.61U L=0.13U M=1
M1 NET123 RSWN0 GTP VDD P W=1.61U L=0.13U M=1
M10 NET123 WLI0 GTP VSS N W=1.61U L=0.13U M=1
M11 RSWN0 G2_W0 NET129 VSS N W=0.86U L=0.13U M=1
M12 NET129 G1 NET132 VSS N W=0.86U L=0.13U M=1
M13 NET132 G0 VSS VSS N W=0.86U L=0.13U M=1
M14 RSWN1 G2_W1 NET134 VSS N W=0.86U L=0.13U M=1
M15 NET134 G1 NET137 VSS N W=0.86U L=0.13U M=1
M16 NET137 G0 VSS VSS N W=0.86U L=0.13U M=1
M17 NET120 RSWN1 VSS VSS N W=0.3U L=0.13U M=1
M18 VDD WL1_EN_ WL1 VDD P W=27.12U L=0.13U M=1
M19 WL1 WL1_EN_ VSS VSS N W=16.68U L=0.13U M=1
M2 RSWN0 G2_W0 VDD VDD P W=0.49U L=0.13U M=1
M20 VDD NET120 WL1_EN_ VDD P W=9.85U L=0.13U M=1
M21 WL1_EN_ NET120 VSS VSS N W=6.26U L=0.13U M=1
M22 VDD NET123 WL0_EN_ VDD P W=9.85U L=0.13U M=1
M23 WL0_EN_ NET123 VSS VSS N W=6.26U L=0.13U M=1
M24 VDD WL0_EN_ WL0 VDD P W=27.12U L=0.13U M=1
M25 WL0 WL0_EN_ VSS VSS N W=16.68U L=0.13U M=1
M26 VDD RSWN0 WLI0 VDD P W=0.36U L=0.13U M=1
M27 WLI0 RSWN0 VSS VSS N W=0.23U L=0.13U M=1
M28 VDD RSWN1 WLI1 VDD P W=0.36U L=0.13U M=1
M29 WLI1 RSWN1 VSS VSS N W=0.23U L=0.13U M=1
M3 RSWN0 G1 VDD VDD P W=0.49U L=0.13U M=1
M4 RSWN0 G0 VDD VDD P W=0.49U L=0.13U M=1
M5 RSWN1 G0 VDD VDD P W=0.49U L=0.13U M=1
M6 RSWN1 G1 VDD VDD P W=0.49U L=0.13U M=1
M7 RSWN1 G2_W1 VDD VDD P W=0.49U L=0.13U M=1
M8 NET123 RSWN0 VSS VSS N W=0.3U L=0.13U M=1
M9 NET120 WLI1 GTP VSS N W=1.61U L=0.13U M=1
.ENDS RA1SH512x32_onWD
****
.SUBCKT RA1SH512x32_onWD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32_onWD
.ENDS RA1SH512x32_onWD1
****
.SUBCKT RA1SH512x32_onROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1
+  XP1F XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onROW_FILLER1: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32_onWD1
.ENDS RA1SH512x32_onROW_FILLER1
****
.SUBCKT RA1SH512x32_onWD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32_onWD
.ENDS RA1SH512x32_onWD2
****
.SUBCKT RA1SH512x32_onROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1
+  XP1F XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onROW_FILLER2: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32_onWD2
.ENDS RA1SH512x32_onROW_FILLER2
****
.SUBCKT RA1SH512x32_onWD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32_onWD
.ENDS RA1SH512x32_onWD3
****
.SUBCKT RA1SH512x32_onROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1
+  XP1F XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onROW_FILLER3: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32_onWD3
.ENDS RA1SH512x32_onROW_FILLER3
****
.SUBCKT RA1SH512x32_onWD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32_onWD
.ENDS RA1SH512x32_onWD0
****
.SUBCKT RA1SH512x32_onROW_8 G0 G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP1F XP1F_0 XP1F_1 XP1F_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SH512x32_onROW_8: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32_onWD0
.ENDS RA1SH512x32_onROW_8
****
.SUBCKT RA1SH512x32_onHWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2
+  XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onHWDB: 30 flat devices **
M0 I0-NET120 I0-RSWN1 GTP VDD P W=1.61U L=0.13U M=1
M1 I0-NET123 I0-RSWN0 GTP VDD P W=1.61U L=0.13U M=1
M10 I0-NET123 I0-WLI0 GTP VSS N W=1.61U L=0.13U M=1
M11 I0-RSWN0 G2_W0 I0-NET129 VSS N W=0.86U L=0.13U M=1
M12 I0-NET129 G1 I0-NET132 VSS N W=0.86U L=0.13U M=1
M13 I0-NET132 G0 VSS VSS N W=0.86U L=0.13U M=1
M14 I0-RSWN1 G2_W1 I0-NET134 VSS N W=0.86U L=0.13U M=1
M15 I0-NET134 G1 I0-NET137 VSS N W=0.86U L=0.13U M=1
M16 I0-NET137 G0 VSS VSS N W=0.86U L=0.13U M=1
M17 I0-NET120 I0-RSWN1 VSS VSS N W=0.3U L=0.13U M=1
M18 VDD I0-WL1_EN_ WL1 VDD P W=27.12U L=0.13U M=1
M19 WL1 I0-WL1_EN_ VSS VSS N W=16.68U L=0.13U M=1
M2 I0-RSWN0 G2_W0 VDD VDD P W=0.49U L=0.13U M=1
M20 VDD I0-NET120 I0-WL1_EN_ VDD P W=9.85U L=0.13U M=1
M21 I0-WL1_EN_ I0-NET120 VSS VSS N W=6.26U L=0.13U M=1
M22 VDD I0-NET123 I0-WL0_EN_ VDD P W=9.85U L=0.13U M=1
M23 I0-WL0_EN_ I0-NET123 VSS VSS N W=6.26U L=0.13U M=1
M24 VDD I0-WL0_EN_ WL0 VDD P W=27.12U L=0.13U M=1
M25 WL0 I0-WL0_EN_ VSS VSS N W=16.68U L=0.13U M=1
M26 VDD I0-RSWN0 I0-WLI0 VDD P W=0.36U L=0.13U M=1
M27 I0-WLI0 I0-RSWN0 VSS VSS N W=0.23U L=0.13U M=1
M28 VDD I0-RSWN1 I0-WLI1 VDD P W=0.36U L=0.13U M=1
M29 I0-WLI1 I0-RSWN1 VSS VSS N W=0.23U L=0.13U M=1
M3 I0-RSWN0 G1 VDD VDD P W=0.49U L=0.13U M=1
M4 I0-RSWN0 G0 VDD VDD P W=0.49U L=0.13U M=1
M5 I0-RSWN1 G0 VDD VDD P W=0.49U L=0.13U M=1
M6 I0-RSWN1 G1 VDD VDD P W=0.49U L=0.13U M=1
M7 I0-RSWN1 G2_W1 VDD VDD P W=0.49U L=0.13U M=1
M8 I0-NET123 I0-RSWN0 VSS VSS N W=0.3U L=0.13U M=1
M9 I0-NET120 I0-WLI1 GTP VSS N W=1.61U L=0.13U M=1
.ENDS RA1SH512x32_onHWDB
****
.SUBCKT RA1SH512x32_onHWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onHWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32_onHWDB
.ENDS RA1SH512x32_onHWDB0
****
.SUBCKT RA1SH512x32_onROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2
+  XP1F XP1F_0 XP1F_1 XP1F_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SH512x32_onROW_BOTTOM: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32_onHWDB0
.ENDS RA1SH512x32_onROW_BOTTOM
****
.SUBCKT RA1SH512x32_onFCMWDX MWL XP0 XP1 VSS VDD
** RA1SH512x32_onFCMWDX: 2 flat devices **
D0 VSS XP1 DN 0.2116P 1.84U
D1 VSS XP0 DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCMWDX
****
.SUBCKT RA1SH512x32_onFCMWD G0F G1F MWL XP0F XP1F VSS VDD
** RA1SH512x32_onFCMWD: 2 flat devices **
D0 VSS XP1F DN 0.2116P 1.84U
D1 VSS XP0F DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFCMWD
****
.SUBCKT RA1SH512x32_onMWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7
+  MWG8 MWG9 MWG10 MWG11 MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** RA1SH512x32_onMWD: 35 flat devices **
M0 MBL GTP VDD VDD P W=6.04U L=0.13U M=1
M1 MBL GTP MBL_ VDD P W=6.64U L=0.13U M=1
M10 MBL MWG9 VSS VSS N W=0.3U L=0.2U M=1
M11 MBL MWG7 VSS VSS N W=0.3U L=0.2U M=1
M12 MBL MWG7 VSS VSS N W=0.3U L=0.2U M=1
M13 MBL MWG5 VSS VSS N W=0.3U L=0.2U M=1
M14 MBL MWG5 VSS VSS N W=0.3U L=0.2U M=1
M15 MBL MWG10 VSS VSS N W=0.3U L=0.2U M=1
M16 MBL MWG10 VSS VSS N W=0.3U L=0.2U M=1
M17 MBL MWG8 VSS VSS N W=0.3U L=0.2U M=1
M18 MBL MWG3 VSS VSS N W=0.3U L=0.2U M=1
M19 MBL MWG8 VSS VSS N W=0.3U L=0.2U M=1
M2 MBL_ GTP VDD VDD P W=6.04U L=0.13U M=1
M20 MBL MWG6 VSS VSS N W=0.3U L=0.2U M=1
M21 MBL MWG6 VSS VSS N W=0.3U L=0.2U M=1
M22 MBL MWG4 VSS VSS N W=0.3U L=0.2U M=1
M23 MBL MWG4 VSS VSS N W=0.3U L=0.2U M=1
M24 MBL MWG2 VSS VSS N W=0.3U L=0.2U M=1
M25 MBL MWG2 VSS VSS N W=0.3U L=0.2U M=1
M26 MBL MWG0 VSS VSS N W=0.3U L=0.2U M=1
M27 MBL MWG0 VSS VSS N W=0.3U L=0.2U M=1
M28 MBL MWG11 VSS VSS N W=0.3U L=0.2U M=1
M29 MBL MWG3 VSS VSS N W=0.3U L=0.2U M=1
M3 NET41 VSS GTP VDD P W=1.61U L=0.13U M=1
M30 MBL MWG1 VSS VSS N W=0.3U L=0.2U M=1
M31 VDD NET41 NET120 VDD P W=11.43U L=0.13U M=1
M32 NET120 NET41 VSS VSS N W=7.26U L=0.13U M=1
M33 VDD NET120 MWL VDD P W=27.13U L=0.13U M=1
M34 MWL NET120 VSS VSS N W=16.68U L=0.13U M=1
M4 NET41 VDD GTP VSS N W=1.61U L=0.13U M=1
M5 MBL MWG1 VSS VSS N W=0.3U L=0.2U M=1
M6 MBL MWLD VSS VSS N W=0.3U L=0.2U M=1
M7 MBL MWLD VSS VSS N W=0.3U L=0.2U M=1
M8 MBL MWG11 VSS VSS N W=0.3U L=0.2U M=1
M9 MBL MWG9 VSS VSS N W=0.3U L=0.2U M=1
.ENDS RA1SH512x32_onMWD
****
.SUBCKT RA1SH512x32_onMWDX GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onMWDX: 35 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD MWLD MWLD MWLD VSS VSS VSS VSS VSS VSS VSS MWL
+  MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onMWD
.ENDS RA1SH512x32_onMWDX
****
.SUBCKT RA1SH512x32_onROW_TOP G0F G1F GTP MBL MBL_ MWL MWLD XP0 XP0F XP0_0
+  XP0_1 XP1 XP1F XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD
** RA1SH512x32_onROW_TOP: 43 flat devices **
XI0_0 MWL XP0 XP1 VSS VDD RA1SH512x32_onFCMWDX
XI1_0 MWL XP0_0 XP1_0 VSS VDD RA1SH512x32_onFCMWDX
XI2_0 MWL XP0_1 XP1_1 VSS VDD RA1SH512x32_onFCMWDX
XI3_0 G0F G1F MWL XP0F XP1F VSS VDD RA1SH512x32_onFCMWD
XI4_0 GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD RA1SH512x32_onMWDX
.ENDS RA1SH512x32_onROW_TOP
****
.SUBCKT RA1SH512x32_onWORD_ROWS G0 GTP MBL MBL_ MWL MWLD WL0 WL0_0 WL0_1 WL0_2
+  WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13
+  WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23
+  WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL1 WL1_0 WL1_1 WL1_2
+  WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13
+  WL1_14 WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23
+  WL1_24 WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 XP0 XP0_0 XP0_1 XP0_2 XP1
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32_onWORD_ROWS: 1003 flat devices **
XI0_0 G0 XP0_2 GTP WL0 WL1 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1 XP1_2 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA1SH512x32_onROW_BOTTOM
XI0_1 G0 XP0_2 GTP WL0_0 WL1_0 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_10 G0 XP0_1 GTP WL0_9 WL1_9 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_11 G0 XP0_1 GTP WL0_10 WL1_10 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_12 G0 XP1_1 XP0_1 GTP WL0_11 WL1_11 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_13 G0 XP1_1 GTP WL0_12 WL1_12 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_14 G0 XP1_1 GTP WL0_13 WL1_13 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_15 G0 XP1_1 GTP WL0_14 WL1_14 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_16 G0 XP0_0 XP1_1 GTP WL0_15 WL1_15 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_17 G0 XP0_0 GTP WL0_16 WL1_16 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_18 G0 XP0_0 GTP WL0_17 WL1_17 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_19 G0 XP0_0 GTP WL0_18 WL1_18 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_2 G0 XP0_2 GTP WL0_1 WL1_1 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_20 G0 XP1_0 XP0_0 GTP WL0_19 WL1_19 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_21 G0 XP1_0 GTP WL0_20 WL1_20 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_22 G0 XP1_0 GTP WL0_21 WL1_21 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_23 G0 XP1_0 GTP WL0_22 WL1_22 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_24 G0 XP0 XP1_0 GTP WL0_23 WL1_23 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_25 G0 XP0 GTP WL0_24 WL1_24 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_26 G0 XP0 GTP WL0_25 WL1_25 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_27 G0 XP0 GTP WL0_26 WL1_26 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_28 G0 XP1 XP0 GTP WL0_27 WL1_27 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_29 G0 XP1 GTP WL0_28 WL1_28 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_3 G0 XP0_2 GTP WL0_2 WL1_2 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_30 G0 XP1 GTP WL0_29 WL1_29 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_31 G0 XP1 GTP WL0_30 WL1_30 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_32 G0 XP1 GTP MBL MBL_ MWL MWLD XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0
+  XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_TOP
XI0_4 G0 XP1_2 XP0_2 GTP WL0_3 WL1_3 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_5 G0 XP1_2 GTP WL0_4 WL1_4 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
XI0_6 G0 XP1_2 GTP WL0_5 WL1_5 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER2
XI0_7 G0 XP1_2 GTP WL0_6 WL1_6 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER3
XI0_8 G0 XP0_1 XP1_2 GTP WL0_7 WL1_7 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_8
XI0_9 G0 XP0_1 GTP WL0_8 WL1_8 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32_onROW_FILLER1
.ENDS RA1SH512x32_onWORD_ROWS
****
.SUBCKT RA1SH512x32_onHCKA A0 A0_ AGTP CLKB GSRCN GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onHCKA: 4 flat devices **
M0 GTPN RST VDD VDD P W=12.2U L=0.13U M=1
M1 GTPN GSRCN CLKB VSS N W=26.73U L=0.13U M=1
M2 VDD GTPN AGTP VDD P W=36.46U L=0.13U M=1
M3 AGTP GTPN VSS VSS N W=17.82U L=0.13U M=1
.ENDS RA1SH512x32_onHCKA
****
.SUBCKT RA1SH512x32_onCK A0 A0_ CLKB GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onCK: 4 flat devices **
M0 GTPN RST VDD VDD P W=12.2U L=0.13U M=1
M1 GTPN GSRCN CLKB VSS N W=26.73U L=0.13U M=1
M2 VDD GTPN GTP VDD P W=36.46U L=0.13U M=1
M3 GTP GTPN VSS VSS N W=17.82U L=0.13U M=1
.ENDS RA1SH512x32_onCK
****
.SUBCKT RA1SH512x32_onCLK_DRVS A0 A0_ AGTP CLKB GSRCN GTP GTPN GTP_0 GTP_1
+  GTP_2 RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onCLK_DRVS: 20 flat devices **
XI0_0 A0 A0_ AGTP CLKB GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32_onHCKA
XI1_0 A0 A0_ CLKB GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32_onCK
XI2_0 A0 A0_ CLKB GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32_onCK
XI3_0 A0 A0_ CLKB GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32_onCK
XI4_0 A0 A0_ CLKB GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32_onCK
.ENDS RA1SH512x32_onCLK_DRVS
****
.SUBCKT RA1SH512x32_onWING_16_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4
+  BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17
+  BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29
+  BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41
+  BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53
+  BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65
+  BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77
+  BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89
+  BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101
+  BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111
+  BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121
+  BL_122 BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26
+  BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36
+  BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46
+  BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56
+  BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66
+  BL__67 BL__68 BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76
+  BL__77 BL__78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105
+  BL__106 BL__107 BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114
+  BL__115 BL__116 BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123
+  BL__124 BL__125 BL__126 BWEN BWEN_0 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8
+  D_9 D_10 D_11 D_12 D_13 D_14 GTP GTP_0 GTP_1 Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6
+  Q_7 Q_8 Q_9 Q_10 Q_11 Q_12 Q_13 Q_14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onWING_16_RIGHT: 53906 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 BWEN D GTP GTP_0 GTP_1 Q WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_EVEN_LE8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BWEN_0 D_7 GTP GTP_0 GTP_1 Q_7 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_LE8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 BWEN_0 D_8 GTP GTP_0 GTP_1 Q_8 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BWEN_0 D_9 GTP GTP_0 GTP_1 Q_9 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 BWEN_0 D_10 GTP GTP_0 GTP_1 Q_10
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 BWEN_0 D_11 GTP GTP_0 GTP_1
+  Q_11 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0
+  YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 BWEN_0 D_12 GTP
+  GTP_0 GTP_1 Q_12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 BWEN_0 D_13 GTP
+  GTP_0 GTP_1 Q_13 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_EVEN_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 BWEN_0 D_14 GTP
+  GTP_0 GTP_1 Q_14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0
+  YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3 YP1_3_0 VSS VDD
+  RA1SH512x32_onMCOL_ODD_RO8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BWEN D_0 GTP GTP_0 GTP_1 Q_0 WL WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0 YP1_3
+  YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BWEN D_1 GTP GTP_0 GTP_1 Q_1 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BWEN D_2 GTP GTP_0 GTP_1 Q_2 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BWEN D_3 GTP GTP_0 GTP_1 Q_3 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 BWEN D_4 GTP GTP_0 GTP_1 Q_4 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BWEN D_5 GTP GTP_0 GTP_1 Q_5 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_EVEN_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 BWEN D_6 GTP GTP_0 GTP_1 Q_6 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35
+  WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47
+  WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59
+  WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2
+  YP1_2_0 YP1_3 YP1_3_0 VSS VDD RA1SH512x32_onMCOL_ODD_RO8
.ENDS RA1SH512x32_onWING_16_RIGHT
****
.SUBCKT RA1SH512x32_onFLCIO A0 A0_ CLKB GSRCN GTP GTPN MBL MBL_ RST YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onFLCIO: 11 flat devices **
D0 VSS YP1_0 DN 0.2116P 1.84U
D1 VSS YP1_1 DN 0.2116P 1.84U
D10 VSS A0 DN 0.2116P 1.84U
D2 VSS YP1_2 DN 0.2116P 1.84U
D3 VSS YP1_3 DN 0.2116P 1.84U
D4 VSS YP0_3 DN 0.2116P 1.84U
D5 VSS YP0_2 DN 0.2116P 1.84U
D6 VSS YP0_1 DN 0.2116P 1.84U
D7 VSS YP0_0 DN 0.2116P 1.84U
D8 VSS GTP DN 0.2116P 1.84U
D9 VSS A0_ DN 0.2116P 1.84U
.ENDS RA1SH512x32_onFLCIO
****
.SUBCKT RA1SH512x32_onFLCIOX A0 A0_ BL0 BL0_ CLKB GSRCN GTP GTPN RST YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32_onFLCIOX: 11 flat devices **
XI0_0 A0 A0_ CLKB GSRCN GTP GTPN BL0_ BL0 RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32_onFLCIO
.ENDS RA1SH512x32_onFLCIOX
****
.SUBCKT RA1SH512x32_onRIGHT_CAP A0 A0_ DPU2 DW DW_ GTP GTP_0 GTP_1 WE WESA WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_0_0 YP1_1 YP1_1_0 YP1_2 YP1_2_0
+  YP1_3 YP1_3_0 VSS VDD
** RA1SH512x32_onRIGHT_CAP: 3 flat devices **
XI0_0 DPU2 DW DW_ GTP WE WESA VSS VDD RA1SH512x32_onFCIO8
XI0_1 GTP_0 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32_onFCSA8
.ENDS RA1SH512x32_onRIGHT_CAP
****
.SUBCKT RA1SH512x32_onMBLBASE MBL MBL_ MWLD MWLS VSS VDD
** RA1SH512x32_onMBLBASE: 1 flat devices **
M0 VDD VDD VDD VDD PCH_SRAM W=0.33U L=0.14U M=1
.ENDS RA1SH512x32_onMBLBASE
****
.SUBCKT RA1SH512x32_onMODEL_COL BL BL_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15
+  WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27
+  WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39
+  WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51
+  WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD
** RA1SH512x32_onMODEL_COL: 385 flat devices **
XI0_64 BL_ BL WL_64 WL_63 VSS VDD RA1SH512x32_onMBLBASE
XI1_0 BL BL_ WL WP VSS VDD RA1SH512x32_onCCP
XI1_1 BL_ BL WL_0 WP_0 VSS VDD RA1SH512x32_onCCP
XI1_10 BL BL_ WL_9 WP_9 VSS VDD RA1SH512x32_onCCP
XI1_11 BL_ BL WL_10 WP_10 VSS VDD RA1SH512x32_onCCP
XI1_12 BL BL_ WL_11 WP_11 VSS VDD RA1SH512x32_onCCP
XI1_13 BL_ BL WL_12 WP_12 VSS VDD RA1SH512x32_onCCP
XI1_14 BL BL_ WL_13 WP_13 VSS VDD RA1SH512x32_onCCP
XI1_15 BL_ BL WL_14 WP_14 VSS VDD RA1SH512x32_onCCP
XI1_16 BL BL_ WL_15 WP_15 VSS VDD RA1SH512x32_onCCP
XI1_17 BL_ BL WL_16 WP_16 VSS VDD RA1SH512x32_onCCP
XI1_18 BL BL_ WL_17 WP_17 VSS VDD RA1SH512x32_onCCP
XI1_19 BL_ BL WL_18 WP_18 VSS VDD RA1SH512x32_onCCP
XI1_2 BL BL_ WL_1 WP_1 VSS VDD RA1SH512x32_onCCP
XI1_20 BL BL_ WL_19 WP_19 VSS VDD RA1SH512x32_onCCP
XI1_21 BL_ BL WL_20 WP_20 VSS VDD RA1SH512x32_onCCP
XI1_22 BL BL_ WL_21 WP_21 VSS VDD RA1SH512x32_onCCP
XI1_23 BL_ BL WL_22 WP_22 VSS VDD RA1SH512x32_onCCP
XI1_24 BL BL_ WL_23 WP_23 VSS VDD RA1SH512x32_onCCP
XI1_25 BL_ BL WL_24 WP_24 VSS VDD RA1SH512x32_onCCP
XI1_26 BL BL_ WL_25 WP_25 VSS VDD RA1SH512x32_onCCP
XI1_27 BL_ BL WL_26 WP_26 VSS VDD RA1SH512x32_onCCP
XI1_28 BL BL_ WL_27 WP_27 VSS VDD RA1SH512x32_onCCP
XI1_29 BL_ BL WL_28 WP_28 VSS VDD RA1SH512x32_onCCP
XI1_3 BL_ BL WL_2 WP_2 VSS VDD RA1SH512x32_onCCP
XI1_30 BL BL_ WL_29 WP_29 VSS VDD RA1SH512x32_onCCP
XI1_31 BL_ BL WL_30 WP_30 VSS VDD RA1SH512x32_onCCP
XI1_32 BL BL_ WL_31 WP_31 VSS VDD RA1SH512x32_onCCP
XI1_33 BL_ BL WL_32 WP_32 VSS VDD RA1SH512x32_onCCP
XI1_34 BL BL_ WL_33 WP_33 VSS VDD RA1SH512x32_onCCP
XI1_35 BL_ BL WL_34 WP_34 VSS VDD RA1SH512x32_onCCP
XI1_36 BL BL_ WL_35 WP_35 VSS VDD RA1SH512x32_onCCP
XI1_37 BL_ BL WL_36 WP_36 VSS VDD RA1SH512x32_onCCP
XI1_38 BL BL_ WL_37 WP_37 VSS VDD RA1SH512x32_onCCP
XI1_39 BL_ BL WL_38 WP_38 VSS VDD RA1SH512x32_onCCP
XI1_4 BL BL_ WL_3 WP_3 VSS VDD RA1SH512x32_onCCP
XI1_40 BL BL_ WL_39 WP_39 VSS VDD RA1SH512x32_onCCP
XI1_41 BL_ BL WL_40 WP_40 VSS VDD RA1SH512x32_onCCP
XI1_42 BL BL_ WL_41 WP_41 VSS VDD RA1SH512x32_onCCP
XI1_43 BL_ BL WL_42 WP_42 VSS VDD RA1SH512x32_onCCP
XI1_44 BL BL_ WL_43 WP_43 VSS VDD RA1SH512x32_onCCP
XI1_45 BL_ BL WL_44 WP_44 VSS VDD RA1SH512x32_onCCP
XI1_46 BL BL_ WL_45 WP_45 VSS VDD RA1SH512x32_onCCP
XI1_47 BL_ BL WL_46 WP_46 VSS VDD RA1SH512x32_onCCP
XI1_48 BL BL_ WL_47 WP_47 VSS VDD RA1SH512x32_onCCP
XI1_49 BL_ BL WL_48 WP_48 VSS VDD RA1SH512x32_onCCP
XI1_5 BL_ BL WL_4 WP_4 VSS VDD RA1SH512x32_onCCP
XI1_50 BL BL_ WL_49 WP_49 VSS VDD RA1SH512x32_onCCP
XI1_51 BL_ BL WL_50 WP_50 VSS VDD RA1SH512x32_onCCP
XI1_52 BL BL_ WL_51 WP_51 VSS VDD RA1SH512x32_onCCP
XI1_53 BL_ BL WL_52 WP_52 VSS VDD RA1SH512x32_onCCP
XI1_54 BL BL_ WL_53 WP_53 VSS VDD RA1SH512x32_onCCP
XI1_55 BL_ BL WL_54 WP_54 VSS VDD RA1SH512x32_onCCP
XI1_56 BL BL_ WL_55 WP_55 VSS VDD RA1SH512x32_onCCP
XI1_57 BL_ BL WL_56 WP_56 VSS VDD RA1SH512x32_onCCP
XI1_58 BL BL_ WL_57 WP_57 VSS VDD RA1SH512x32_onCCP
XI1_59 BL_ BL WL_58 WP_58 VSS VDD RA1SH512x32_onCCP
XI1_6 BL BL_ WL_5 WP_5 VSS VDD RA1SH512x32_onCCP
XI1_60 BL BL_ WL_59 WP_59 VSS VDD RA1SH512x32_onCCP
XI1_61 BL_ BL WL_60 WP_60 VSS VDD RA1SH512x32_onCCP
XI1_62 BL BL_ WL_61 WP_61 VSS VDD RA1SH512x32_onCCP
XI1_63 BL_ BL WL_62 WP_62 VSS VDD RA1SH512x32_onCCP
XI1_7 BL_ BL WL_6 WP_6 VSS VDD RA1SH512x32_onCCP
XI1_8 BL BL_ WL_7 WP_7 VSS VDD RA1SH512x32_onCCP
XI1_9 BL_ BL WL_8 WP_8 VSS VDD RA1SH512x32_onCCP
.ENDS RA1SH512x32_onMODEL_COL
****
.SUBCKT RA1SH512x32_on A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] CEN CLK
+  D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13]
+  D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25]
+  D[26] D[27] D[28] D[29] D[30] D[31] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7]
+  Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20]
+  Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] WEN[0]
+  WEN[1] WEN[2] WEN[3] VSS VDD
** RA1SH512x32_on: 112964 flat devices **
XI0_0 A0 A0_ VSS VSS VSS GTP_1 GTP_1 GTP_1 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD RA1SH512x32_onLEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34
+  BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46
+  BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58
+  BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70
+  BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94
+  BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105
+  BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125
+  BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 WEN[1]
+  WEN[0] D[15] D[14] D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4]
+  D[3] D[2] D[1] D[0] GTP_1 GTP_1 GTP_1 Q[15] Q[14] Q[13] Q[12] Q[11] Q[10]
+  Q[9] Q[8] Q[7] Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD
+  RA1SH512x32_onWING_16_LEFT
XI1_5 BL_ BL__63 BL_63 BL__64 BL_64 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__15 BL__16 BL__17
+  BL__18 BL__19 BL__20 BL__21 BL__22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL_71 BL_72 BL_73 BL_74 BL_75
+  BL_76 BL_77 BL_78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108
+  BL_109 BL_110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_0 BL_1
+  BL_2 BL_3 BL_4 BL_5 BL_6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL_47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__71
+  BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__103 BL__104
+  BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124
+  BL__125 BL__126 MWLB VSS VDD RA1SH512x32_onMODEL_ROW_16
XI3_0 A[6] A[3] A[7] A[4] A[8] A[5] AGTPT AGTPT A0 A0_ VSS VSS XP_0 XP_0_0
+  XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_4_0 XP_5 XP_5_0 XP_6 XP_6_0
+  XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SH512x32_onX_PRE_DECODE
XI3_3 VDD GTP_1 MBL MBL_ MWLB MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14
+  WL_15 WL_18 WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_31 WL_34 WL_35 WL_38
+  WL_39 WL_42 WL_43 WL_46 WL_47 WL_50 WL_51 WL_54 WL_55 WL_58 WL_59 WL_62
+  WL_0 WL_1 WL_4 WL_5 WL_8 WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24
+  WL_25 WL_28 WL_29 WL_32 WL_33 WL_36 WL_37 WL_40 WL_41 WL_44 WL_45 WL_48
+  WL_49 WL_52 WL_53 WL_56 WL_57 WL_60 WL_61 XP_6 XP_4 XP_2 XP_0 XP_7 XP_5
+  XP_3 XP_1 XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 VSS VDD
+  RA1SH512x32_onWORD_ROWS
XI4_0 A[1] A[0] A[2] AGTPT A0 A0_ VSS CLKB GSRCN GTPN RST VSS YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD RA1SH512x32_onY_DECODE
XI5_0 CEN CLK CLKB VSS VSS VSS VSS GSRCN GTP_1 GTPN MBL RST VSS WE VSS VSS VSS
+  VSS VSS VSS VSS VDD RA1SH512x32_onHBFX
XI5_2 A0 A0_ AGTPT CLKB GSRCN GTP_1 GTPN GTP_1 GTP_1 GTP_1 RST YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SH512x32_onCLK_DRVS
XI6_2 A0 A0_ MBL_ MBL CLKB GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 VSS
+  VSS VSS VSS VSS VDD RA1SH512x32_onFLCIOX
XI6_4 MBL_ MBL WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 MWLB MWLB VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD
+  RA1SH512x32_onMODEL_COL
XI7_0 A0 A0_ BL_860 BL__862 BL_0_856 BL_1_852 BL_2_848 BL_3_844 BL_4_840
+  BL_5_836 BL_6_832 BL_7_830 BL_8_826 BL_9_822 BL_10_818 BL_11_814 BL_12_810
+  BL_13_806 BL_14_802 BL_15_796 BL_16_792 BL_17_788 BL_18_784 BL_19_780
+  BL_20_776 BL_21_772 BL_22_768 BL_23_766 BL_24_762 BL_25_758 BL_26_754
+  BL_27_750 BL_28_746 BL_29_742 BL_30_738 BL_31_732 BL_32_728 BL_33_724
+  BL_34_720 BL_35_716 BL_36_712 BL_37_708 BL_38_704 BL_39_702 BL_40_698
+  BL_41_694 BL_42_690 BL_43_686 BL_44_682 BL_45_678 BL_46_674 BL_47_668
+  BL_48_664 BL_49_660 BL_50_656 BL_51_652 BL_52_648 BL_53_644 BL_54_640
+  BL_55_638 BL_56_634 BL_57_630 BL_58_626 BL_59_622 BL_60_618 BL_61_614
+  BL_62_610 BL_63_604 BL_64_600 BL_65_596 BL_66_592 BL_67_588 BL_68_584
+  BL_69_580 BL_70_576 BL_71_574 BL_72_570 BL_73_566 BL_74_562 BL_75_558
+  BL_76_554 BL_77_550 BL_78_546 BL_79_540 BL_80_536 BL_81_532 BL_82_528
+  BL_83_524 BL_84_520 BL_85_516 BL_86_512 BL_87_510 BL_88_506 BL_89_502
+  BL_90_498 BL_91_494 BL_92_490 BL_93_486 BL_94_482 BL_95_476 BL_96_472
+  BL_97_468 BL_98_464 BL_99_460 BL_100_456 BL_101_452 BL_102_448 BL_103_446
+  BL_104_442 BL_105_438 BL_106_434 BL_107_430 BL_108_426 BL_109_422
+  BL_110_418 BL_111_412 BL_112_408 BL_113_404 BL_114_400 BL_115_396
+  BL_116_392 BL_117_388 BL_118_384 BL_119_382 BL_120_378 BL_121_374
+  BL_122_370 BL_123_366 BL_124_362 BL_125_358 BL_126_354 BL__0_858 BL__1_854
+  BL__2_850 BL__3_846 BL__4_842 BL__5_838 BL__6_834 BL__7_828 BL__8_824
+  BL__9_820 BL__10_816 BL__11_812 BL__12_808 BL__13_804 BL__14_800 BL__15_798
+  BL__16_794 BL__17_790 BL__18_786 BL__19_782 BL__20_778 BL__21_774
+  BL__22_770 BL__23_764 BL__24_760 BL__25_756 BL__26_752 BL__27_748
+  BL__28_744 BL__29_740 BL__30_736 BL__31_734 BL__32_730 BL__33_726
+  BL__34_722 BL__35_718 BL__36_714 BL__37_710 BL__38_706 BL__39_700
+  BL__40_696 BL__41_692 BL__42_688 BL__43_684 BL__44_680 BL__45_676
+  BL__46_672 BL__47_670 BL__48_666 BL__49_662 BL__50_658 BL__51_654
+  BL__52_650 BL__53_646 BL__54_642 BL__55_636 BL__56_632 BL__57_628
+  BL__58_624 BL__59_620 BL__60_616 BL__61_612 BL__62_608 BL__63_606
+  BL__64_602 BL__65_598 BL__66_594 BL__67_590 BL__68_586 BL__69_582
+  BL__70_578 BL__71_572 BL__72_568 BL__73_564 BL__74_560 BL__75_556
+  BL__76_552 BL__77_548 BL__78_544 BL__79_542 BL__80_538 BL__81_534
+  BL__82_530 BL__83_526 BL__84_522 BL__85_518 BL__86_514 BL__87_508
+  BL__88_504 BL__89_500 BL__90_496 BL__91_492 BL__92_488 BL__93_484
+  BL__94_480 BL__95_478 BL__96_474 BL__97_470 BL__98_466 BL__99_462
+  BL__100_458 BL__101_454 BL__102_450 BL__103_444 BL__104_440 BL__105_436
+  BL__106_432 BL__107_428 BL__108_424 BL__109_420 BL__110_416 BL__111_414
+  BL__112_410 BL__113_406 BL__114_402 BL__115_398 BL__116_394 BL__117_390
+  BL__118_386 BL__119_380 BL__120_376 BL__121_372 BL__122_368 BL__123_364
+  BL__124_360 BL__125_356 BL__126_352 WEN[2] WEN[3] D[16] D[17] D[18] D[19]
+  D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31]
+  GTP_1 GTP_1 GTP_1 Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24]
+  Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VDD RA1SH512x32_onWING_16_RIGHT
XI7_5 BL__862 BL__63_606 BL_63_604 BL__64_602 BL_64_600 BL_860 BL__0_858
+  BL__1_854 BL__2_850 BL__3_846 BL__4_842 BL__5_838 BL__6_834 BL_7_830
+  BL_8_826 BL_9_822 BL_10_818 BL_11_814 BL_12_810 BL_13_806 BL_14_802
+  BL__15_798 BL__16_794 BL__17_790 BL__18_786 BL__19_782 BL__20_778
+  BL__21_774 BL__22_770 BL_23_766 BL_24_762 BL_25_758 BL_26_754 BL_27_750
+  BL_28_746 BL_29_742 BL_30_738 BL__31_734 BL__32_730 BL__33_726 BL__34_722
+  BL__35_718 BL__36_714 BL__37_710 BL__38_706 BL_39_702 BL_40_698 BL_41_694
+  BL_42_690 BL_43_686 BL_44_682 BL_45_678 BL_46_674 BL__47_670 BL__48_666
+  BL__49_662 BL__50_658 BL__51_654 BL__52_650 BL__53_646 BL__54_642 BL_55_638
+  BL_56_634 BL_57_630 BL_58_626 BL_59_622 BL_60_618 BL_61_614 BL_62_610
+  BL__65_598 BL__66_594 BL__67_590 BL__68_586 BL__69_582 BL__70_578 BL_71_574
+  BL_72_570 BL_73_566 BL_74_562 BL_75_558 BL_76_554 BL_77_550 BL_78_546
+  BL__79_542 BL__80_538 BL__81_534 BL__82_530 BL__83_526 BL__84_522
+  BL__85_518 BL__86_514 BL_87_510 BL_88_506 BL_89_502 BL_90_498 BL_91_494
+  BL_92_490 BL_93_486 BL_94_482 BL__95_478 BL__96_474 BL__97_470 BL__98_466
+  BL__99_462 BL__100_458 BL__101_454 BL__102_450 BL_103_446 BL_104_442
+  BL_105_438 BL_106_434 BL_107_430 BL_108_426 BL_109_422 BL_110_418
+  BL__111_414 BL__112_410 BL__113_406 BL__114_402 BL__115_398 BL__116_394
+  BL__117_390 BL__118_386 BL_119_382 BL_120_378 BL_121_374 BL_122_370
+  BL_123_366 BL_124_362 BL_125_358 BL_126_354 BL_0_856 BL_1_852 BL_2_848
+  BL_3_844 BL_4_840 BL_5_836 BL_6_832 BL__7_828 BL__8_824 BL__9_820
+  BL__10_816 BL__11_812 BL__12_808 BL__13_804 BL__14_800 BL_15_796 BL_16_792
+  BL_17_788 BL_18_784 BL_19_780 BL_20_776 BL_21_772 BL_22_768 BL__23_764
+  BL__24_760 BL__25_756 BL__26_752 BL__27_748 BL__28_744 BL__29_740
+  BL__30_736 BL_31_732 BL_32_728 BL_33_724 BL_34_720 BL_35_716 BL_36_712
+  BL_37_708 BL_38_704 BL__39_700 BL__40_696 BL__41_692 BL__42_688 BL__43_684
+  BL__44_680 BL__45_676 BL__46_672 BL_47_668 BL_48_664 BL_49_660 BL_50_656
+  BL_51_652 BL_52_648 BL_53_644 BL_54_640 BL__55_636 BL__56_632 BL__57_628
+  BL__58_624 BL__59_620 BL__60_616 BL__61_612 BL__62_608 BL_65_596 BL_66_592
+  BL_67_588 BL_68_584 BL_69_580 BL_70_576 BL__71_572 BL__72_568 BL__73_564
+  BL__74_560 BL__75_556 BL__76_552 BL__77_548 BL__78_544 BL_79_540 BL_80_536
+  BL_81_532 BL_82_528 BL_83_524 BL_84_520 BL_85_516 BL_86_512 BL__87_508
+  BL__88_504 BL__89_500 BL__90_496 BL__91_492 BL__92_488 BL__93_484
+  BL__94_480 BL_95_476 BL_96_472 BL_97_468 BL_98_464 BL_99_460 BL_100_456
+  BL_101_452 BL_102_448 BL__103_444 BL__104_440 BL__105_436 BL__106_432
+  BL__107_428 BL__108_424 BL__109_420 BL__110_416 BL_111_412 BL_112_408
+  BL_113_404 BL_114_400 BL_115_396 BL_116_392 BL_117_388 BL_118_384
+  BL__119_380 BL__120_376 BL__121_372 BL__122_368 BL__123_364 BL__124_360
+  BL__125_356 BL__126_352 MWLB VSS VDD RA1SH512x32_onMODEL_ROW_16
XI8_0 A0 A0_ VSS VSS VSS GTP_1 GTP_1 GTP_1 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD RA1SH512x32_onRIGHT_CAP
.ENDS RA1SH512x32_on
