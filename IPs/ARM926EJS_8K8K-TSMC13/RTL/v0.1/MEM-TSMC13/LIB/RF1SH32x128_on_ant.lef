MACRO RF1SH32x128_on
  PIN A[0]
    AntennaGateArea  0.039 ;
  END A[0]
  PIN A[1]
    AntennaGateArea  0.039 ;
  END A[1]
  PIN A[2]
    AntennaGateArea  0.039 ;
  END A[2]
  PIN A[3]
    AntennaGateArea  0.039 ;
  END A[3]
  PIN A[4]
    AntennaGateArea  0.039 ;
  END A[4]
  PIN CEN
    AntennaGateArea  0.039 ;
  END CEN
  PIN CLK
    AntennaGateArea  0.039 ;
  END CLK
  PIN D[0]
    AntennaGateArea  0.039 ;
  END D[0]
  PIN D[100]
    AntennaGateArea  0.039 ;
  END D[100]
  PIN D[101]
    AntennaGateArea  0.039 ;
  END D[101]
  PIN D[102]
    AntennaGateArea  0.039 ;
  END D[102]
  PIN D[103]
    AntennaGateArea  0.039 ;
  END D[103]
  PIN D[104]
    AntennaGateArea  0.039 ;
  END D[104]
  PIN D[105]
    AntennaGateArea  0.039 ;
  END D[105]
  PIN D[106]
    AntennaGateArea  0.039 ;
  END D[106]
  PIN D[107]
    AntennaGateArea  0.039 ;
  END D[107]
  PIN D[108]
    AntennaGateArea  0.039 ;
  END D[108]
  PIN D[109]
    AntennaGateArea  0.039 ;
  END D[109]
  PIN D[10]
    AntennaGateArea  0.039 ;
  END D[10]
  PIN D[110]
    AntennaGateArea  0.039 ;
  END D[110]
  PIN D[111]
    AntennaGateArea  0.039 ;
  END D[111]
  PIN D[112]
    AntennaGateArea  0.039 ;
  END D[112]
  PIN D[113]
    AntennaGateArea  0.039 ;
  END D[113]
  PIN D[114]
    AntennaGateArea  0.039 ;
  END D[114]
  PIN D[115]
    AntennaGateArea  0.039 ;
  END D[115]
  PIN D[116]
    AntennaGateArea  0.039 ;
  END D[116]
  PIN D[117]
    AntennaGateArea  0.039 ;
  END D[117]
  PIN D[118]
    AntennaGateArea  0.039 ;
  END D[118]
  PIN D[119]
    AntennaGateArea  0.039 ;
  END D[119]
  PIN D[11]
    AntennaGateArea  0.039 ;
  END D[11]
  PIN D[120]
    AntennaGateArea  0.039 ;
  END D[120]
  PIN D[121]
    AntennaGateArea  0.039 ;
  END D[121]
  PIN D[122]
    AntennaGateArea  0.039 ;
  END D[122]
  PIN D[123]
    AntennaGateArea  0.039 ;
  END D[123]
  PIN D[124]
    AntennaGateArea  0.039 ;
  END D[124]
  PIN D[125]
    AntennaGateArea  0.039 ;
  END D[125]
  PIN D[126]
    AntennaGateArea  0.039 ;
  END D[126]
  PIN D[127]
    AntennaGateArea  0.039 ;
  END D[127]
  PIN D[12]
    AntennaGateArea  0.039 ;
  END D[12]
  PIN D[13]
    AntennaGateArea  0.039 ;
  END D[13]
  PIN D[14]
    AntennaGateArea  0.039 ;
  END D[14]
  PIN D[15]
    AntennaGateArea  0.039 ;
  END D[15]
  PIN D[16]
    AntennaGateArea  0.039 ;
  END D[16]
  PIN D[17]
    AntennaGateArea  0.039 ;
  END D[17]
  PIN D[18]
    AntennaGateArea  0.039 ;
  END D[18]
  PIN D[19]
    AntennaGateArea  0.039 ;
  END D[19]
  PIN D[1]
    AntennaGateArea  0.039 ;
  END D[1]
  PIN D[20]
    AntennaGateArea  0.039 ;
  END D[20]
  PIN D[21]
    AntennaGateArea  0.039 ;
  END D[21]
  PIN D[22]
    AntennaGateArea  0.039 ;
  END D[22]
  PIN D[23]
    AntennaGateArea  0.039 ;
  END D[23]
  PIN D[24]
    AntennaGateArea  0.039 ;
  END D[24]
  PIN D[25]
    AntennaGateArea  0.039 ;
  END D[25]
  PIN D[26]
    AntennaGateArea  0.039 ;
  END D[26]
  PIN D[27]
    AntennaGateArea  0.039 ;
  END D[27]
  PIN D[28]
    AntennaGateArea  0.039 ;
  END D[28]
  PIN D[29]
    AntennaGateArea  0.039 ;
  END D[29]
  PIN D[2]
    AntennaGateArea  0.039 ;
  END D[2]
  PIN D[30]
    AntennaGateArea  0.039 ;
  END D[30]
  PIN D[31]
    AntennaGateArea  0.039 ;
  END D[31]
  PIN D[32]
    AntennaGateArea  0.039 ;
  END D[32]
  PIN D[33]
    AntennaGateArea  0.039 ;
  END D[33]
  PIN D[34]
    AntennaGateArea  0.039 ;
  END D[34]
  PIN D[35]
    AntennaGateArea  0.039 ;
  END D[35]
  PIN D[36]
    AntennaGateArea  0.039 ;
  END D[36]
  PIN D[37]
    AntennaGateArea  0.039 ;
  END D[37]
  PIN D[38]
    AntennaGateArea  0.039 ;
  END D[38]
  PIN D[39]
    AntennaGateArea  0.039 ;
  END D[39]
  PIN D[3]
    AntennaGateArea  0.039 ;
  END D[3]
  PIN D[40]
    AntennaGateArea  0.039 ;
  END D[40]
  PIN D[41]
    AntennaGateArea  0.039 ;
  END D[41]
  PIN D[42]
    AntennaGateArea  0.039 ;
  END D[42]
  PIN D[43]
    AntennaGateArea  0.039 ;
  END D[43]
  PIN D[44]
    AntennaGateArea  0.039 ;
  END D[44]
  PIN D[45]
    AntennaGateArea  0.039 ;
  END D[45]
  PIN D[46]
    AntennaGateArea  0.039 ;
  END D[46]
  PIN D[47]
    AntennaGateArea  0.039 ;
  END D[47]
  PIN D[48]
    AntennaGateArea  0.039 ;
  END D[48]
  PIN D[49]
    AntennaGateArea  0.039 ;
  END D[49]
  PIN D[4]
    AntennaGateArea  0.039 ;
  END D[4]
  PIN D[50]
    AntennaGateArea  0.039 ;
  END D[50]
  PIN D[51]
    AntennaGateArea  0.039 ;
  END D[51]
  PIN D[52]
    AntennaGateArea  0.039 ;
  END D[52]
  PIN D[53]
    AntennaGateArea  0.039 ;
  END D[53]
  PIN D[54]
    AntennaGateArea  0.039 ;
  END D[54]
  PIN D[55]
    AntennaGateArea  0.039 ;
  END D[55]
  PIN D[56]
    AntennaGateArea  0.039 ;
  END D[56]
  PIN D[57]
    AntennaGateArea  0.039 ;
  END D[57]
  PIN D[58]
    AntennaGateArea  0.039 ;
  END D[58]
  PIN D[59]
    AntennaGateArea  0.039 ;
  END D[59]
  PIN D[5]
    AntennaGateArea  0.039 ;
  END D[5]
  PIN D[60]
    AntennaGateArea  0.039 ;
  END D[60]
  PIN D[61]
    AntennaGateArea  0.039 ;
  END D[61]
  PIN D[62]
    AntennaGateArea  0.039 ;
  END D[62]
  PIN D[63]
    AntennaGateArea  0.039 ;
  END D[63]
  PIN D[64]
    AntennaGateArea  0.039 ;
  END D[64]
  PIN D[65]
    AntennaGateArea  0.039 ;
  END D[65]
  PIN D[66]
    AntennaGateArea  0.039 ;
  END D[66]
  PIN D[67]
    AntennaGateArea  0.039 ;
  END D[67]
  PIN D[68]
    AntennaGateArea  0.039 ;
  END D[68]
  PIN D[69]
    AntennaGateArea  0.039 ;
  END D[69]
  PIN D[6]
    AntennaGateArea  0.039 ;
  END D[6]
  PIN D[70]
    AntennaGateArea  0.039 ;
  END D[70]
  PIN D[71]
    AntennaGateArea  0.039 ;
  END D[71]
  PIN D[72]
    AntennaGateArea  0.039 ;
  END D[72]
  PIN D[73]
    AntennaGateArea  0.039 ;
  END D[73]
  PIN D[74]
    AntennaGateArea  0.039 ;
  END D[74]
  PIN D[75]
    AntennaGateArea  0.039 ;
  END D[75]
  PIN D[76]
    AntennaGateArea  0.039 ;
  END D[76]
  PIN D[77]
    AntennaGateArea  0.039 ;
  END D[77]
  PIN D[78]
    AntennaGateArea  0.039 ;
  END D[78]
  PIN D[79]
    AntennaGateArea  0.039 ;
  END D[79]
  PIN D[7]
    AntennaGateArea  0.039 ;
  END D[7]
  PIN D[80]
    AntennaGateArea  0.039 ;
  END D[80]
  PIN D[81]
    AntennaGateArea  0.039 ;
  END D[81]
  PIN D[82]
    AntennaGateArea  0.039 ;
  END D[82]
  PIN D[83]
    AntennaGateArea  0.039 ;
  END D[83]
  PIN D[84]
    AntennaGateArea  0.039 ;
  END D[84]
  PIN D[85]
    AntennaGateArea  0.039 ;
  END D[85]
  PIN D[86]
    AntennaGateArea  0.039 ;
  END D[86]
  PIN D[87]
    AntennaGateArea  0.039 ;
  END D[87]
  PIN D[88]
    AntennaGateArea  0.039 ;
  END D[88]
  PIN D[89]
    AntennaGateArea  0.039 ;
  END D[89]
  PIN D[8]
    AntennaGateArea  0.039 ;
  END D[8]
  PIN D[90]
    AntennaGateArea  0.039 ;
  END D[90]
  PIN D[91]
    AntennaGateArea  0.039 ;
  END D[91]
  PIN D[92]
    AntennaGateArea  0.039 ;
  END D[92]
  PIN D[93]
    AntennaGateArea  0.039 ;
  END D[93]
  PIN D[94]
    AntennaGateArea  0.039 ;
  END D[94]
  PIN D[95]
    AntennaGateArea  0.039 ;
  END D[95]
  PIN D[96]
    AntennaGateArea  0.039 ;
  END D[96]
  PIN D[97]
    AntennaGateArea  0.039 ;
  END D[97]
  PIN D[98]
    AntennaGateArea  0.039 ;
  END D[98]
  PIN D[99]
    AntennaGateArea  0.039 ;
  END D[99]
  PIN D[9]
    AntennaGateArea  0.039 ;
  END D[9]
  PIN WEN[0]
    AntennaGateArea  0.039 ;
  END WEN[0]
  PIN WEN[10]
    AntennaGateArea  0.039 ;
  END WEN[10]
  PIN WEN[11]
    AntennaGateArea  0.039 ;
  END WEN[11]
  PIN WEN[12]
    AntennaGateArea  0.039 ;
  END WEN[12]
  PIN WEN[13]
    AntennaGateArea  0.039 ;
  END WEN[13]
  PIN WEN[14]
    AntennaGateArea  0.039 ;
  END WEN[14]
  PIN WEN[15]
    AntennaGateArea  0.039 ;
  END WEN[15]
  PIN WEN[1]
    AntennaGateArea  0.039 ;
  END WEN[1]
  PIN WEN[2]
    AntennaGateArea  0.039 ;
  END WEN[2]
  PIN WEN[3]
    AntennaGateArea  0.039 ;
  END WEN[3]
  PIN WEN[4]
    AntennaGateArea  0.039 ;
  END WEN[4]
  PIN WEN[5]
    AntennaGateArea  0.039 ;
  END WEN[5]
  PIN WEN[6]
    AntennaGateArea  0.039 ;
  END WEN[6]
  PIN WEN[7]
    AntennaGateArea  0.039 ;
  END WEN[7]
  PIN WEN[8]
    AntennaGateArea  0.039 ;
  END WEN[8]
  PIN WEN[9]
    AntennaGateArea  0.039 ;
  END WEN[9]
END RF1SH32x128_on
