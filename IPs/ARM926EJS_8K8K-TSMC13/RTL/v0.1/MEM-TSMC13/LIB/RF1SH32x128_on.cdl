* 
* Copyright 2006 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.3c
* Version: 2003Q4V1
* Name: RF-SP-HS Register File Generator|TSMC CL013G-FSG Process
* Comment: 
* Configuration:  -instname "RF1SH32x128_on" -words 32 -bits 128 -f\
* Configuration: requency 100 -ring_width 2 -mux 1 -drive 4 -write_\
* Configuration: mask on -wp_size 8 -top_layer met6 -power_type rin\
* Configuration: gs -horiz met3 -vert met2 -cust_comment "" -left_b\
* Configuration: us_delim "[" -right_bus_delim "]" -pwr_gnd_rename \
* Configuration: "VDD:VDD,GND:VSS" -prefix "" -pin_space 0.0 -name_\
* Configuration: case upper -check_instname on -diodes on -inside_r\
* Configuration: ing_type GND
* Codefile: 
* 
*
** begin lvs.header
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RF1SH32x128_onFLCSA1 Q0 Q1 VSS VDD
** RF1SH32x128_onFLCSA1: 2 flat devices **
d1 VSS Q0 DN 0.2116P 1.84U
d2 VSS Q1 DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCSA1
****
.SUBCKT RF1SH32x128_onSA1B BL0 BL0_ GTPSA_ QB QT VSS VDD
** RF1SH32x128_onSA1B: 26 flat devices **
m1 SD GTPSAINV BL0 VDD P L=0.18U W=0.66U
m10 N22 SD_ VDD VDD P L=0.13U W=0.35U
m11 N22 SD_ VSS VSS N L=0.13U W=0.15U
m12 QI SI VSS VSS N L=0.13U W=0.62U
m13 QI SI_ VDD VDD P L=0.13U W=0.98U
m14 DLATKEEP QI VDD VDD P L=0.13U W=0.15U
m15 DLATKEEP QI VSS VSS N L=0.13U W=0.15U
m16 QI DLATKEEP VDD VDD P L=0.26U W=0.15U
m17 QI DLATKEEP VSS VSS N L=0.26U W=0.15U
m18 QB QI VDD VDD P L=0.13U W=2.64U
m19 QB QI VSS VSS N L=0.13U W=1.68U
m2 BL0_ GTPSAINV SD_ VDD P L=0.18U W=0.66U
m20 SD VSS SD_ VSS N L=0.13U W=2U
m21 VDD GTPSA_ SRC VSS N L=0.13U W=0.2U
m22 SI_ N22 VDD VDD P L=0.13U W=0.6U
m23 SI_ N22 VSS VSS N L=0.13U W=0.53U
m24 GTPSAINV GTPSA_ VDD VDD P L=0.13U W=0.6U
m25 GTPSAINV GTPSA_ VSS VSS N L=0.13U W=0.31U
m26 SD_ VDD SD VDD P L=0.13U W=0.96U
m3 SD SD_ VDD VDD P L=0.18U W=0.3U
m4 SD_ SD VDD VDD P L=0.18U W=0.3U
m5 SRC GTPSAINV VSS VSS N L=0.13U W=1.34U
m6 SD SD_ SRC VSS N L=0.2U W=2U
m7 SD_ SD SRC VSS N L=0.2U W=2U
m8 SI SD VDD VDD P L=0.13U W=0.35U
m9 SI SD VSS VSS N L=0.13U W=0.15U
.ENDS RF1SH32x128_onSA1B
****
.SUBCKT RF1SH32x128_onSA1T BL0 BL0_ BL1 BL1_ GLTWIST GRTWIST GTPSA_ GTPTWIST
+  QT VSS VDD
** RF1SH32x128_onSA1T: 26 flat devices **
m1 SD GTPSAINV BL1_ VDD P L=0.18U W=0.66U
m10 N26 SD_ VDD VDD P L=0.13U W=0.35U
m11 N26 SD_ VSS VSS N L=0.13U W=0.15U
m12 QI SI VSS VSS N L=0.13U W=0.62U
m13 QI SI_ VDD VDD P L=0.13U W=0.98U
m14 DLATKEEP QI VDD VDD P L=0.13U W=0.15U
m15 DLATKEEP QI VSS VSS N L=0.13U W=0.15U
m16 QI DLATKEEP VDD VDD P L=0.26U W=0.15U
m17 QI DLATKEEP VSS VSS N L=0.26U W=0.15U
m18 QT QI VDD VDD P L=0.13U W=2.64U
m19 QT QI VSS VSS N L=0.13U W=1.68U
m2 BL1 GTPSAINV SD_ VDD P L=0.18U W=0.66U
m20 GTPSAINV GTPSA_ VDD VDD P L=0.13U W=0.6U
m21 GTPSAINV GTPSA_ VSS VSS N L=0.13U W=0.32U
m22 VDD GTPSA_ SRC VSS N L=0.13U W=0.2U
m23 SI_ N26 VDD VDD P L=0.13U W=0.6U
m24 SI_ N26 VSS VSS N L=0.13U W=0.53U
m25 SD_ VDD SD VDD P L=0.13U W=0.96U
m26 SD VSS SD_ VSS N L=0.13U W=2U
m3 SD SD_ VDD VDD P L=0.18U W=0.3U
m4 SD_ SD VDD VDD P L=0.18U W=0.3U
m5 SRC GTPSAINV VSS VSS N L=0.13U W=1.34U
m6 SD SD_ SRC VSS N L=0.2U W=2U
m7 SD_ SD SRC VSS N L=0.2U W=2U
m8 SI SD VDD VDD P L=0.13U W=0.35U
m9 SI SD VSS VSS N L=0.13U W=0.15U
.ENDS RF1SH32x128_onSA1T
****
.SUBCKT RF1SH32x128_onCD1 BL0 BL0_ BL1 BL1_ GTP VSS VDD
** RF1SH32x128_onCD1: 10 flat devices **
m1 BL0 YI VDD VDD P L=0.13U W=1.6U
m10 BL1_ YI BL1 VDD P L=0.13U W=1.6U
m2 BL0_ YI VDD VDD P L=0.13U W=1.6U
m3 YI YIIN0 VDD VDD P L=0.13U W=2.1U
m4 YI YIIN0 VSS VSS N L=0.13U W=0.92U
m5 YIIN0 GTP VDD VDD P L=0.13U W=1.02U
m6 YIIN0 GTP VSS VSS N L=0.13U W=0.66U
m7 BL0 YI BL0_ VDD P L=0.13U W=1.6U
m8 BL1_ YI VDD VDD P L=0.13U W=1.6U
m9 BL1 YI VDD VDD P L=0.13U W=1.6U
.ENDS RF1SH32x128_onCD1
****
.SUBCKT RF1SH32x128_onMUX1CDSA210MY BL0 BL0_ BL1 BL1_ GRTWIST GTP GTPSA_
+  GTPSA__0 Q0 Q1 VSS VDD
** RF1SH32x128_onMUX1CDSA210MY: 64 flat devices **
XI0 Q0 Q1 VSS VDD RF1SH32x128_onFLCSA1
XI1 BL0 BL0_ GTPSA_ Q0 Q1 VSS VDD RF1SH32x128_onSA1B
XI2 BL0 BL0_ BL1 BL1_ GRTWIST GRTWIST GTPSA__0 GRTWIST Q1 VSS VDD
+  RF1SH32x128_onSA1T
XI3 BL0 BL0_ BL1 BL1_ GTP VSS VDD RF1SH32x128_onCD1
.ENDS RF1SH32x128_onMUX1CDSA210MY
****
.SUBCKT RF1SH32x128_onMUX1CDSA210R0 BL0 BL0_ BL1 BL1_ GRTWIST GTP GTPSA_
+  GTPSA__0 Q0 Q1 VSS VDD
** RF1SH32x128_onMUX1CDSA210R0: 64 flat devices **
XI0 Q0 Q1 VSS VDD RF1SH32x128_onFLCSA1
XI1 BL0 BL0_ GTPSA_ Q0 Q1 VSS VDD RF1SH32x128_onSA1B
XI2 BL0 BL0_ BL1 BL1_ GRTWIST GRTWIST GTPSA__0 GRTWIST Q1 VSS VDD
+  RF1SH32x128_onSA1T
XI3 BL0 BL0_ BL1 BL1_ GTP VSS VDD RF1SH32x128_onCD1
.ENDS RF1SH32x128_onMUX1CDSA210R0
****
.SUBCKT RF1SH32x128_onMUX1CDSAWING_L BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4
+  BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14
+  BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23
+  BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL1 BL1_ BL1_0
+  BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12
+  BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22
+  BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1__0 BL1__1
+  BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11
+  BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20
+  BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27 BL1__28 BL1__29
+  BL1__30 GLTWIST GTP GTPSA_ GTPSA__0 Q0 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6
+  Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19
+  Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q1 Q1_0
+  Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14
+  Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26
+  Q1_27 Q1_28 Q1_29 Q1_30 VSS VDD
** RF1SH32x128_onMUX1CDSAWING_L: 2048 flat devices **
XI0 BL0 BL0_ BL1 BL1_ GLTWIST GTP GTPSA_ GTPSA__0 Q0 Q1 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI1 BL0_0 BL0__0 BL1_0 BL1__0 GLTWIST GTP GTPSA_ GTPSA__0 Q0_0 Q1_0 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI10 BL0_8 BL0__8 BL1_8 BL1__8 GLTWIST GTP GTPSA_ GTPSA__0 Q0_8 Q1_8 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI11 BL0_9 BL0__9 BL1_9 BL1__9 GLTWIST GTP GTPSA_ GTPSA__0 Q0_9 Q1_9 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI12 BL0_10 BL0__10 BL1_10 BL1__10 GLTWIST GTP GTPSA_ GTPSA__0 Q0_10 Q1_10 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI13 BL0_11 BL0__11 BL1_11 BL1__11 GLTWIST GTP GTPSA_ GTPSA__0 Q0_11 Q1_11 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI14 BL0_12 BL0__12 BL1_12 BL1__12 GLTWIST GTP GTPSA_ GTPSA__0 Q0_12 Q1_12 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI15 BL0_13 BL0__13 BL1_13 BL1__13 GLTWIST GTP GTPSA_ GTPSA__0 Q0_13 Q1_13 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI16 BL0_14 BL0__14 BL1_14 BL1__14 GLTWIST GTP GTPSA_ GTPSA__0 Q0_14 Q1_14 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI18 BL0_15 BL0__15 BL1_15 BL1__15 GLTWIST GTP GTPSA_ GTPSA__0 Q0_15 Q1_15 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI19 BL0_16 BL0__16 BL1_16 BL1__16 GLTWIST GTP GTPSA_ GTPSA__0 Q0_16 Q1_16 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI2 BL0_1 BL0__1 BL1_1 BL1__1 GLTWIST GTP GTPSA_ GTPSA__0 Q0_1 Q1_1 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI20 BL0_17 BL0__17 BL1_17 BL1__17 GLTWIST GTP GTPSA_ GTPSA__0 Q0_17 Q1_17 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI21 BL0_18 BL0__18 BL1_18 BL1__18 GLTWIST GTP GTPSA_ GTPSA__0 Q0_18 Q1_18 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI22 BL0_19 BL0__19 BL1_19 BL1__19 GLTWIST GTP GTPSA_ GTPSA__0 Q0_19 Q1_19 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI23 BL0_20 BL0__20 BL1_20 BL1__20 GLTWIST GTP GTPSA_ GTPSA__0 Q0_20 Q1_20 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI24 BL0_21 BL0__21 BL1_21 BL1__21 GLTWIST GTP GTPSA_ GTPSA__0 Q0_21 Q1_21 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI25 BL0_22 BL0__22 BL1_22 BL1__22 GLTWIST GTP GTPSA_ GTPSA__0 Q0_22 Q1_22 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI27 BL0_23 BL0__23 BL1_23 BL1__23 GLTWIST GTP GTPSA_ GTPSA__0 Q0_23 Q1_23 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI28 BL0_24 BL0__24 BL1_24 BL1__24 GLTWIST GTP GTPSA_ GTPSA__0 Q0_24 Q1_24 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI29 BL0_25 BL0__25 BL1_25 BL1__25 GLTWIST GTP GTPSA_ GTPSA__0 Q0_25 Q1_25 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI3 BL0_2 BL0__2 BL1_2 BL1__2 GLTWIST GTP GTPSA_ GTPSA__0 Q0_2 Q1_2 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI30 BL0_26 BL0__26 BL1_26 BL1__26 GLTWIST GTP GTPSA_ GTPSA__0 Q0_26 Q1_26 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI31 BL0_27 BL0__27 BL1_27 BL1__27 GLTWIST GTP GTPSA_ GTPSA__0 Q0_27 Q1_27 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI32 BL0_28 BL0__28 BL1_28 BL1__28 GLTWIST GTP GTPSA_ GTPSA__0 Q0_28 Q1_28 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI33 BL0_29 BL0__29 BL1_29 BL1__29 GLTWIST GTP GTPSA_ GTPSA__0 Q0_29 Q1_29 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI34 BL0_30 BL0__30 BL1_30 BL1__30 GLTWIST GTP GTPSA_ GTPSA__0 Q0_30 Q1_30 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI4 BL0_3 BL0__3 BL1_3 BL1__3 GLTWIST GTP GTPSA_ GTPSA__0 Q0_3 Q1_3 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI5 BL0_4 BL0__4 BL1_4 BL1__4 GLTWIST GTP GTPSA_ GTPSA__0 Q0_4 Q1_4 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI6 BL0_5 BL0__5 BL1_5 BL1__5 GLTWIST GTP GTPSA_ GTPSA__0 Q0_5 Q1_5 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI7 BL0_6 BL0__6 BL1_6 BL1__6 GLTWIST GTP GTPSA_ GTPSA__0 Q0_6 Q1_6 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI9 BL0_7 BL0__7 BL1_7 BL1__7 GLTWIST GTP GTPSA_ GTPSA__0 Q0_7 Q1_7 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
.ENDS RF1SH32x128_onMUX1CDSAWING_L
****
.SUBCKT RF1SH32x128_onFLCHXP112 A0 WEI VSS VDD
** RF1SH32x128_onFLCHXP112: 1 flat devices **
d1 VSS A0 DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCHXP112
****
.SUBCKT RF1SH32x128_onHXP12 AGTPN AX0 GTP GTPSA XP0 XP1 YP0 YP1 YP2 YP3 VSS
+  VDD
** RF1SH32x128_onHXP12: 21 flat devices **
m1 N17 AX0 VDD VDD P L=0.13U W=1.55U
m10 N24 N17 VSS VSS N L=0.13U W=1.19U
m11 XP0 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m12 XP0 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m13 XP1 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m14 XP1 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m15 N29 VDD VSS VSS N L=0.13U W=2.22U
m16 VDD N12 AP0-APND0 VDD P L=0.13U W=1.29U
m17 VDD VDD AP0-APND0 VDD P L=0.13U W=1.29U
m18 N29 N12 AP0-APND0 VSS N L=0.13U W=1.65U
m19 VDD N13 AP0-AIND1 VDD P L=0.13U W=1.29U
m2 N17 AX0 VSS VSS N L=0.13U W=1.19U
m20 VDD VDD AP0-AIND1 VDD P L=0.13U W=1.29U
m21 N29 N13 AP0-AIND1 VSS N L=0.13U W=1.65U
m3 N13 N12 VDD VDD P L=0.13U W=0.7U
m4 N13 N12 VSS VSS N L=0.13U W=0.3U
m5 N12 N13 VDD VDD P L=0.13U W=0.7U
m6 N12 N13 VSS VSS N L=0.13U W=0.3U
m7 N13 AGTPN N17 VSS N L=0.13U W=1.19U
m8 N12 AGTPN N24 VSS N L=0.13U W=1.19U
m9 N24 N17 VDD VDD P L=0.13U W=1.19U
.ENDS RF1SH32x128_onHXP12
****
.SUBCKT RF1SH32x128_onFLCHXP124 A0 A1 WEI VSS VDD
** RF1SH32x128_onFLCHXP124: 2 flat devices **
d1 VSS A1 DN 0.2116P 1.84U
d2 VSS A0 DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCHXP124
****
.SUBCKT RF1SH32x128_onHXP24 AX0 AX1 GTP GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0 YP1
+  YP2 YP3 VSS VDD
** RF1SH32x128_onHXP24: 42 flat devices **
m1 N24 AX0 VDD VDD P L=0.13U W=1.55U
m10 N31 N24 VSS VSS N L=0.13U W=1.19U
m11 XPA0 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m12 XPA0 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m13 XPA1 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m14 XPA1 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m15 N36 IN1_ VSS VSS N L=0.13U W=2.22U
m16 VDD IN0 AP0-APND0 VDD P L=0.13U W=1.29U
m17 VDD IN1_ AP0-APND0 VDD P L=0.13U W=1.29U
m18 N36 IN0 AP0-APND0 VSS N L=0.13U W=1.65U
m19 VDD IN0_ AP0-AIND1 VDD P L=0.13U W=1.29U
m2 N24 AX0 VSS VSS N L=0.13U W=1.19U
m20 VDD IN1_ AP0-AIND1 VDD P L=0.13U W=1.29U
m21 N36 IN0_ AP0-AIND1 VSS N L=0.13U W=1.65U
m22 XPA3 AP1-AIND1 VDD VDD P L=0.13U W=5.07U
m23 XPA3 AP1-AIND1 VSS VSS N L=0.13U W=3.13U
m24 XPA2 AP1-APND0 VDD VDD P L=0.13U W=5.07U
m25 XPA2 AP1-APND0 VSS VSS N L=0.13U W=3.13U
m26 N43 IN1 VSS VSS N L=0.13U W=2.22U
m27 VDD IN0_ AP1-APND0 VDD P L=0.13U W=1.29U
m28 VDD IN1 AP1-APND0 VDD P L=0.13U W=1.29U
m29 N43 IN0_ AP1-APND0 VSS N L=0.13U W=1.65U
m3 IN0_ IN0 VDD VDD P L=0.13U W=0.7U
m30 VDD IN0 AP1-AIND1 VDD P L=0.13U W=1.29U
m31 VDD IN1 AP1-AIND1 VDD P L=0.13U W=1.29U
m32 N43 IN0 AP1-AIND1 VSS N L=0.13U W=1.65U
m33 N48 AX1 VDD VDD P L=0.13U W=1.55U
m34 N48 AX1 VSS VSS N L=0.13U W=1.19U
m35 IN1_ IN1 VDD VDD P L=0.13U W=0.7U
m36 IN1_ IN1 VSS VSS N L=0.13U W=0.3U
m37 IN1 IN1_ VDD VDD P L=0.13U W=0.7U
m38 IN1 IN1_ VSS VSS N L=0.13U W=0.3U
m39 IN1_ GTPN N48 VSS N L=0.13U W=1.19U
m4 IN0_ IN0 VSS VSS N L=0.13U W=0.3U
m40 IN1 GTPN N55 VSS N L=0.13U W=1.19U
m41 N55 N48 VDD VDD P L=0.13U W=1.19U
m42 N55 N48 VSS VSS N L=0.13U W=1.19U
m5 IN0 IN0_ VDD VDD P L=0.13U W=0.7U
m6 IN0 IN0_ VSS VSS N L=0.13U W=0.3U
m7 IN0_ GTPN N24 VSS N L=0.13U W=1.19U
m8 IN0 GTPN N31 VSS N L=0.13U W=1.19U
m9 N31 N24 VDD VDD P L=0.13U W=1.19U
.ENDS RF1SH32x128_onHXP24
****
.SUBCKT RF1SH32x128_onHXP24R AX0 AX1 GTP GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0
+  YP1 YP2 YP3 VSS VDD
** RF1SH32x128_onHXP24R: 42 flat devices **
m1 N25 AX0 VDD VDD P L=0.13U W=1.55U
m10 N32 N25 VSS VSS N L=0.13U W=1.19U
m11 XPA0 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m12 XPA0 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m13 XPA1 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m14 XPA1 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m15 N37 IN1_ VSS VSS N L=0.13U W=2.22U
m16 VDD IN0 AP0-APND0 VDD P L=0.13U W=1.29U
m17 VDD IN1_ AP0-APND0 VDD P L=0.13U W=1.29U
m18 N37 IN0 AP0-APND0 VSS N L=0.13U W=1.65U
m19 VDD IN0_ AP0-AIND1 VDD P L=0.13U W=1.29U
m2 N25 AX0 VSS VSS N L=0.13U W=1.19U
m20 VDD IN1_ AP0-AIND1 VDD P L=0.13U W=1.29U
m21 N37 IN0_ AP0-AIND1 VSS N L=0.13U W=1.65U
m22 XPA3 AP1-AIND1 VDD VDD P L=0.13U W=5.07U
m23 XPA3 AP1-AIND1 VSS VSS N L=0.13U W=3.13U
m24 XPA2 AP1-APND0 VDD VDD P L=0.13U W=5.07U
m25 XPA2 AP1-APND0 VSS VSS N L=0.13U W=3.13U
m26 N44 IN1 VSS VSS N L=0.13U W=2.22U
m27 VDD IN0_ AP1-APND0 VDD P L=0.13U W=1.29U
m28 VDD IN1 AP1-APND0 VDD P L=0.13U W=1.29U
m29 N44 IN0_ AP1-APND0 VSS N L=0.13U W=1.65U
m3 IN0_ IN0 VDD VDD P L=0.13U W=0.7U
m30 VDD IN0 AP1-AIND1 VDD P L=0.13U W=1.29U
m31 VDD IN1 AP1-AIND1 VDD P L=0.13U W=1.29U
m32 N44 IN0 AP1-AIND1 VSS N L=0.13U W=1.65U
m33 N49 AX1 VDD VDD P L=0.13U W=1.55U
m34 N49 AX1 VSS VSS N L=0.13U W=1.19U
m35 IN1_ IN1 VDD VDD P L=0.13U W=0.7U
m36 IN1_ IN1 VSS VSS N L=0.13U W=0.3U
m37 IN1 IN1_ VDD VDD P L=0.13U W=0.7U
m38 IN1 IN1_ VSS VSS N L=0.13U W=0.3U
m39 IN1_ GTPN N49 VSS N L=0.13U W=1.19U
m4 IN0_ IN0 VSS VSS N L=0.13U W=0.3U
m40 IN1 GTPN N56 VSS N L=0.13U W=1.19U
m41 N56 N49 VDD VDD P L=0.13U W=1.19U
m42 N56 N49 VSS VSS N L=0.13U W=1.19U
m5 IN0 IN0_ VDD VDD P L=0.13U W=0.7U
m6 IN0 IN0_ VSS VSS N L=0.13U W=0.3U
m7 IN0_ GTPN N25 VSS N L=0.13U W=1.19U
m8 IN0 GTPN N32 VSS N L=0.13U W=1.19U
m9 N32 N25 VDD VDD P L=0.13U W=1.19U
.ENDS RF1SH32x128_onHXP24R
****
.SUBCKT RF1SH32x128_onHXPS A0 A0_0 A0_1 A1 A1_0 GTP GTPN GTPSA WEI XP0 XP1
+  XPA0 XPA0_0 XPA1 XPA1_0 XPA2 XPA2_0 XPA3 XPA3_0 YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x128_onHXPS: 110 flat devices **
XI0_0 A0 WEI VSS VDD RF1SH32x128_onFLCHXP112
XI0_1 GTPN A0 GTP GTPSA XP0 XP1 YP0 YP1 YP2 YP3 VSS VDD RF1SH32x128_onHXP12
XI1_0 A0_0 A1 WEI VSS VDD RF1SH32x128_onFLCHXP124
XI1_1 A0_0 A1 GTP GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x128_onHXP24
XI2_0 A0_1 A1_0 WEI VSS VDD RF1SH32x128_onFLCHXP124
XI2_1 A0_1 A1_0 GTP GTPN GTPSA XPA0_0 XPA1_0 XPA2_0 XPA3_0 YP0 YP1 YP2 YP3 VSS
+  VDD RF1SH32x128_onHXP24R
.ENDS RF1SH32x128_onHXPS
****
.SUBCKT RF1SH32x128_onFLCCTRLSA1 CEN CLK STOV WEI VSS VDD
** RF1SH32x128_onFLCCTRLSA1: 3 flat devices **
d1 VSS CLK DN 0.2116P 1.84U
d2 VSS CEN DN 0.2116P 1.84U
d3 VSS STOV DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCCTRLSA1
****
.SUBCKT RF1SH32x128_onCK1 CEN CLK DLY3 DLY5 GTP GTPN GTPSA GTPSATW MBL MBL_
+  STOV VSS VDD
** RF1SH32x128_onCK1: 69 flat devices **
m1 GTP GTPN VDD VDD P L=0.13U W=42.24U
m10 GTPN GTPSATW VDD VDD P L=0.13U W=10.8U
m11 CLKB RST GTPN VSS N L=0.13U W=14.8U
m12 CLKB CLK VDD VDD P L=0.13U W=3.72U
m13 CLKB CLK VSS VSS N L=0.13U W=14.8U
m14 RST N37 VDD VDD P L=0.13U W=2.32U
m15 RST N37 VSS VSS N L=0.13U W=1.5U
m16 N37 N40 VDD VDD P L=0.13U W=0.6U
m17 N37 N40 VSS VSS N L=0.13U W=0.39U
m18 N40 N43 VDD VDD P L=0.13U W=0.24U
m19 N40 N43 VSS VSS N L=0.13U W=0.15U
m2 GTP GTPN VSS VSS N L=0.13U W=27.04U
m20 N43 CLKB VDD VDD P L=0.13U W=0.15U
m21 N90 CLKB VSS VSS N L=0.13U W=0.31U
m22 N43 GTPSATW VDD VDD P L=0.13U W=0.15U
m23 N89 GTPSATW N90 VSS N L=0.13U W=0.31U
m24 N43 N46 VDD VDD P L=0.13U W=0.15U
m25 N88 N46 N89 VSS N L=0.13U W=0.31U
m26 N43 GTPN VDD VDD P L=0.13U W=0.15U
m27 N43 GTPN N88 VSS N L=0.13U W=0.31U
m28 N46 CEN VDD VDD P L=0.13U W=0.24U
m29 N46 CEN VSS VSS N L=0.13U W=0.15U
m3 MBL_ YI VDD VDD P L=0.13U W=1.59U
m30 YI YIIN0 VDD VDD P L=0.13U W=1.06U
m31 YI YIIN0 VSS VSS N L=0.13U W=0.68U
m32 YIIN0 GTP VDD VDD P L=0.13U W=0.71U
m33 YIIN0 GTP VSS VSS N L=0.13U W=0.46U
m34 GTPSA GTPSANINV VDD VDD P L=0.13U W=27.28U
m35 GTPSA GTPSANINV VSS VSS N L=0.13U W=16.36U
m36 GTPKEEPSA GTPSANINV VDD VDD P L=0.13U W=0.15U
m37 GTPKEEPSA GTPSANINV VSS VSS N L=0.13U W=0.15U
m38 GTPSANINV GTPKEEPSA VDD VDD P L=0.13U W=0.15U
m39 GTPSANINV GTPKEEPSA VSS VSS N L=0.13U W=0.15U
m4 MBL YI VDD VDD P L=0.13U W=1.59U
m40 GTPSANINV SARST N61 VSS N L=0.13U W=4.37U
m41 N61 N23 VSS VSS N L=0.13U W=4.37U
m42 N62 N23 VDD VDD P L=0.13U W=6.82U
m43 N62 SASET GTPSANINV VDD P L=0.13U W=6.82U
m44 SASET MBLINV VDD VDD P L=0.13U W=3.05U
m45 N91 MBLINV VSS VSS N L=0.13U W=3.9U
m46 SASET CLKSTOV VDD VDD P L=0.13U W=3.05U
m47 SASET CLKSTOV N91 VSS N L=0.13U W=3.9U
m48 N23 GTP VDD VDD P L=0.13U W=1.95U
m49 N23 GTP VSS VSS N L=0.13U W=3.2U
m5 MBL_ YI MBL VDD P L=0.13U W=1.59U
m50 SARST N68 VDD VDD P L=0.13U W=1.95U
m51 SARST N68 VSS VSS N L=0.13U W=1.25U
m52 N68 N71 VDD VDD P L=0.13U W=0.72U
m53 N68 N71 VSS VSS N L=0.13U W=0.46U
m54 N71 DLY3 VDD VDD P L=0.13U W=0.17U
m55 N71 DLY3 VSS VSS N L=0.13U W=0.17U
m56 DLY5 N76 VDD VDD P L=0.13U W=0.24U
m57 DLY5 N76 VSS VSS N L=0.13U W=0.15U
m58 N76 GTPSATW VDD VDD P L=0.13U W=0.15U
m59 N76 GTPSATW VSS VSS N L=0.13U W=0.15U
m6 GTPKEEP GTPN VDD VDD P L=0.13U W=0.15U
m60 MBLINV MBL VDD VDD P L=0.13U W=1.57U
m61 MBLINV MBL VSS VSS N L=0.13U W=1.01U
m62 CLKSTOV CLK VDD VDD P L=0.13U W=1.55U
m63 N92 CLK VSS VSS N L=0.13U W=1.99U
m64 CLKSTOV STOV VDD VDD P L=0.13U W=1.55U
m65 CLKSTOV STOV N92 VSS N L=0.13U W=1.99U
m66 N85 N23 VDD VDD P L=0.13U W=6.82U
m67 N85 SASET GTPSANINV VDD P L=0.13U W=6.82U
m68 GTPSANINV SARST N87 VSS N L=0.13U W=4.37U
m69 N87 N23 VSS VSS N L=0.13U W=4.37U
m7 GTPKEEP GTPN VSS VSS N L=0.13U W=0.15U
m8 GTPN GTPKEEP VDD VDD P L=0.13U W=0.15U
m9 GTPN GTPKEEP VSS VSS N L=0.13U W=0.15U
.ENDS RF1SH32x128_onCK1
****
.SUBCKT RF1SH32x128_onMUX1BOTCTRL CEN CLK GTP GTPN GTPSA GTPSATW MBL MBL_ STOV
+  WEI VSS VDD
** RF1SH32x128_onMUX1BOTCTRL: 72 flat devices **
XI0 CEN CLK STOV WEI VSS VDD RF1SH32x128_onFLCCTRLSA1
XI1 CEN CLK DLY3 DLY3 GTP GTPN GTPSA GTPSATW MBL MBL_ STOV VSS VDD
+  RF1SH32x128_onCK1
.ENDS RF1SH32x128_onMUX1BOTCTRL
****
.SUBCKT RF1SH32x128_onMUX1CDSA20R0 BL0 BL0_ BL1 BL1_ GRTWIST GTP GTPSA_
+  GTPSA__0 Q0 Q1 VSS VDD
** RF1SH32x128_onMUX1CDSA20R0: 64 flat devices **
XI0 Q0 Q1 VSS VDD RF1SH32x128_onFLCSA1
XI1 BL0 BL0_ GTPSA_ Q0 Q1 VSS VDD RF1SH32x128_onSA1B
XI2 BL0 BL0_ BL1 BL1_ GTPSA__0 GRTWIST GTPSA__0 GTPSA__0 Q1 VSS VDD
+  RF1SH32x128_onSA1T
XI3 BL0 BL0_ BL1 BL1_ GTP VSS VDD RF1SH32x128_onCD1
.ENDS RF1SH32x128_onMUX1CDSA20R0
****
.SUBCKT RF1SH32x128_onMUX1CDSAWING_R BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4
+  BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14
+  BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23
+  BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL1 BL1_ BL1_0
+  BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12
+  BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22
+  BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1__0 BL1__1
+  BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11
+  BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20
+  BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27 BL1__28 BL1__29
+  BL1__30 GLTWIST GTP GTPSA_ GTPSA__0 Q0 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6
+  Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19
+  Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q1 Q1_0
+  Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9 Q1_10 Q1_11 Q1_12 Q1_13 Q1_14
+  Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21 Q1_22 Q1_23 Q1_24 Q1_25 Q1_26
+  Q1_27 Q1_28 Q1_29 Q1_30 VSS VDD
** RF1SH32x128_onMUX1CDSAWING_R: 2048 flat devices **
XI0 BL0 BL0_ BL1 BL1_ GTPSA__0 GTP GTPSA_ GTPSA__0 Q0 Q1 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI1 BL0_0 BL0__0 BL1_0 BL1__0 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_0 Q1_0 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI10 BL0_8 BL0__8 BL1_8 BL1__8 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_8 Q1_8 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI11 BL0_9 BL0__9 BL1_9 BL1__9 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_9 Q1_9 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI12 BL0_10 BL0__10 BL1_10 BL1__10 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_10 Q1_10
+  VSS VDD RF1SH32x128_onMUX1CDSA210MY
XI13 BL0_11 BL0__11 BL1_11 BL1__11 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_11 Q1_11
+  VSS VDD RF1SH32x128_onMUX1CDSA210R0
XI14 BL0_12 BL0__12 BL1_12 BL1__12 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_12 Q1_12
+  VSS VDD RF1SH32x128_onMUX1CDSA210MY
XI15 BL0_13 BL0__13 BL1_13 BL1__13 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_13 Q1_13
+  VSS VDD RF1SH32x128_onMUX1CDSA210R0
XI16 BL0_14 BL0__14 BL1_14 BL1__14 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_14 Q1_14
+  VSS VDD RF1SH32x128_onMUX1CDSA210MY
XI18 BL0_15 BL0__15 BL1_15 BL1__15 GLTWIST GTP GTPSA_ GTPSA__0 Q0_15 Q1_15 VSS
+  VDD RF1SH32x128_onMUX1CDSA20R0
XI19 BL0_16 BL0__16 BL1_16 BL1__16 GLTWIST GTP GTPSA_ GTPSA__0 Q0_16 Q1_16 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI2 BL0_1 BL0__1 BL1_1 BL1__1 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_1 Q1_1 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI20 BL0_17 BL0__17 BL1_17 BL1__17 GLTWIST GTP GTPSA_ GTPSA__0 Q0_17 Q1_17 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI21 BL0_18 BL0__18 BL1_18 BL1__18 GLTWIST GTP GTPSA_ GTPSA__0 Q0_18 Q1_18 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI22 BL0_19 BL0__19 BL1_19 BL1__19 GLTWIST GTP GTPSA_ GTPSA__0 Q0_19 Q1_19 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI23 BL0_20 BL0__20 BL1_20 BL1__20 GLTWIST GTP GTPSA_ GTPSA__0 Q0_20 Q1_20 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI24 BL0_21 BL0__21 BL1_21 BL1__21 GLTWIST GTP GTPSA_ GTPSA__0 Q0_21 Q1_21 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI25 BL0_22 BL0__22 BL1_22 BL1__22 GLTWIST GTP GTPSA_ GTPSA__0 Q0_22 Q1_22 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI27 BL0_23 BL0__23 BL1_23 BL1__23 GLTWIST GTP GTPSA_ GTPSA__0 Q0_23 Q1_23 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI28 BL0_24 BL0__24 BL1_24 BL1__24 GLTWIST GTP GTPSA_ GTPSA__0 Q0_24 Q1_24 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI29 BL0_25 BL0__25 BL1_25 BL1__25 GLTWIST GTP GTPSA_ GTPSA__0 Q0_25 Q1_25 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI3 BL0_2 BL0__2 BL1_2 BL1__2 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_2 Q1_2 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI30 BL0_26 BL0__26 BL1_26 BL1__26 GLTWIST GTP GTPSA_ GTPSA__0 Q0_26 Q1_26 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI31 BL0_27 BL0__27 BL1_27 BL1__27 GLTWIST GTP GTPSA_ GTPSA__0 Q0_27 Q1_27 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI32 BL0_28 BL0__28 BL1_28 BL1__28 GLTWIST GTP GTPSA_ GTPSA__0 Q0_28 Q1_28 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI33 BL0_29 BL0__29 BL1_29 BL1__29 GLTWIST GTP GTPSA_ GTPSA__0 Q0_29 Q1_29 VSS
+  VDD RF1SH32x128_onMUX1CDSA210R0
XI34 BL0_30 BL0__30 BL1_30 BL1__30 GLTWIST GTP GTPSA_ GTPSA__0 Q0_30 Q1_30 VSS
+  VDD RF1SH32x128_onMUX1CDSA210MY
XI4 BL0_3 BL0__3 BL1_3 BL1__3 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_3 Q1_3 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI5 BL0_4 BL0__4 BL1_4 BL1__4 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_4 Q1_4 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI6 BL0_5 BL0__5 BL1_5 BL1__5 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_5 Q1_5 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
XI7 BL0_6 BL0__6 BL1_6 BL1__6 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_6 Q1_6 VSS VDD
+  RF1SH32x128_onMUX1CDSA210MY
XI9 BL0_7 BL0__7 BL1_7 BL1__7 GTPSA__0 GTP GTPSA_ GTPSA__0 Q0_7 Q1_7 VSS VDD
+  RF1SH32x128_onMUX1CDSA210R0
.ENDS RF1SH32x128_onMUX1CDSAWING_R
****
.SUBCKT RF1SH32x128_onMUX1BOT A0 A0_0 A0_1 A1 A1_0 BL0 BL0_ BL0_0 BL0_1 BL0_2
+  BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13
+  BL0_14 BL0_15 BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23
+  BL0_24 BL0_25 BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33
+  BL0_34 BL0_35 BL0_36 BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43
+  BL0_44 BL0_45 BL0_46 BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53
+  BL0_54 BL0_55 BL0_56 BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0__0
+  BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10
+  BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19
+  BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28
+  BL0__29 BL0__30 BL0__31 BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37
+  BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46
+  BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55
+  BL0__56 BL0__57 BL0__58 BL0__59 BL0__60 BL0__61 BL0__62 BL1 BL1_ BL1_0
+  BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12
+  BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22
+  BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32
+  BL1_33 BL1_34 BL1_35 BL1_36 BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1_42
+  BL1_43 BL1_44 BL1_45 BL1_46 BL1_47 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52
+  BL1_53 BL1_54 BL1_55 BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62
+  BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9
+  BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18
+  BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27
+  BL1__28 BL1__29 BL1__30 BL1__31 BL1__32 BL1__33 BL1__34 BL1__35 BL1__36
+  BL1__37 BL1__38 BL1__39 BL1__40 BL1__41 BL1__42 BL1__43 BL1__44 BL1__45
+  BL1__46 BL1__47 BL1__48 BL1__49 BL1__50 BL1__51 BL1__52 BL1__53 BL1__54
+  BL1__55 BL1__56 BL1__57 BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 CEN CLK GTP
+  MBL MBL_ Q0 Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11
+  Q0_12 Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23
+  Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 Q0_29 Q0_30 Q0_31 Q0_32 Q0_33 Q0_34 Q0_35
+  Q0_36 Q0_37 Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44 Q0_45 Q0_46 Q0_47
+  Q0_48 Q0_49 Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56 Q0_57 Q0_58 Q0_59
+  Q0_60 Q0_61 Q0_62 Q1 Q1_0 Q1_1 Q1_2 Q1_3 Q1_4 Q1_5 Q1_6 Q1_7 Q1_8 Q1_9
+  Q1_10 Q1_11 Q1_12 Q1_13 Q1_14 Q1_15 Q1_16 Q1_17 Q1_18 Q1_19 Q1_20 Q1_21
+  Q1_22 Q1_23 Q1_24 Q1_25 Q1_26 Q1_27 Q1_28 Q1_29 Q1_30 Q1_31 Q1_32 Q1_33
+  Q1_34 Q1_35 Q1_36 Q1_37 Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45
+  Q1_46 Q1_47 Q1_48 Q1_49 Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57
+  Q1_58 Q1_59 Q1_60 Q1_61 Q1_62 STOV XP0 XP1 XPA0 XPA0_0 XPA1 XPA1_0 XPA2
+  XPA2_0 XPA3 XPA3_0 VSS VDD
** RF1SH32x128_onMUX1BOT: 4278 flat devices **
XI1 BL0_30 BL0__30 BL0_29 BL0_28 BL0_27 BL0_26 BL0_25 BL0_24 BL0_23 BL0_22
+  BL0_21 BL0_20 BL0_19 BL0_18 BL0_17 BL0_16 BL0_15 BL0_14 BL0_13 BL0_12
+  BL0_11 BL0_10 BL0_9 BL0_8 BL0_7 BL0_6 BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0
+  BL0 BL0__29 BL0__28 BL0__27 BL0__26 BL0__25 BL0__24 BL0__23 BL0__22 BL0__21
+  BL0__20 BL0__19 BL0__18 BL0__17 BL0__16 BL0__15 BL0__14 BL0__13 BL0__12
+  BL0__11 BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2
+  BL0__1 BL0__0 BL0_ BL1_30 BL1__30 BL1_29 BL1_28 BL1_27 BL1_26 BL1_25 BL1_24
+  BL1_23 BL1_22 BL1_21 BL1_20 BL1_19 BL1_18 BL1_17 BL1_16 BL1_15 BL1_14
+  BL1_13 BL1_12 BL1_11 BL1_10 BL1_9 BL1_8 BL1_7 BL1_6 BL1_5 BL1_4 BL1_3 BL1_2
+  BL1_1 BL1_0 BL1 BL1__29 BL1__28 BL1__27 BL1__26 BL1__25 BL1__24 BL1__23
+  BL1__22 BL1__21 BL1__20 BL1__19 BL1__18 BL1__17 BL1__16 BL1__15 BL1__14
+  BL1__13 BL1__12 BL1__11 BL1__10 BL1__9 BL1__8 BL1__7 BL1__6 BL1__5 BL1__4
+  BL1__3 BL1__2 BL1__1 BL1__0 BL1_ VSS GTP GTPSAB GTPSAB Q0_30 Q0_29 Q0_28
+  Q0_27 Q0_26 Q0_25 Q0_24 Q0_23 Q0_22 Q0_21 Q0_20 Q0_19 Q0_18 Q0_17 Q0_16
+  Q0_15 Q0_14 Q0_13 Q0_12 Q0_11 Q0_10 Q0_9 Q0_8 Q0_7 Q0_6 Q0_5 Q0_4 Q0_3 Q0_2
+  Q0_1 Q0_0 Q0 Q1_30 Q1_29 Q1_28 Q1_27 Q1_26 Q1_25 Q1_24 Q1_23 Q1_22 Q1_21
+  Q1_20 Q1_19 Q1_18 Q1_17 Q1_16 Q1_15 Q1_14 Q1_13 Q1_12 Q1_11 Q1_10 Q1_9 Q1_8
+  Q1_7 Q1_6 Q1_5 Q1_4 Q1_3 Q1_2 Q1_1 Q1_0 Q1 VSS VDD
+  RF1SH32x128_onMUX1CDSAWING_L
XI3 A0 A0_0 A0_1 A1 A1_0 GTP GTPN GTPSAB VSS XP0 XP1 XPA0 XPA0_0 XPA1 XPA1_0
+  XPA2 XPA2_0 XPA3 XPA3_0 VSS VSS VSS VSS VSS VDD RF1SH32x128_onHXPS
XI4 CEN CLK GTP GTPN GTPSAB GTPSAB MBL MBL_ STOV VSS VSS VDD
+  RF1SH32x128_onMUX1BOTCTRL
XI5 BL0_31 BL0__31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37 BL0_38 BL0_39
+  BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47 BL0_48 BL0_49
+  BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57 BL0_58 BL0_59
+  BL0_60 BL0_61 BL0_62 BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37
+  BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46
+  BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55
+  BL0__56 BL0__57 BL0__58 BL0__59 BL0__60 BL0__61 BL0__62 BL1_31 BL1__31
+  BL1_32 BL1_33 BL1_34 BL1_35 BL1_36 BL1_37 BL1_38 BL1_39 BL1_40 BL1_41
+  BL1_42 BL1_43 BL1_44 BL1_45 BL1_46 BL1_47 BL1_48 BL1_49 BL1_50 BL1_51
+  BL1_52 BL1_53 BL1_54 BL1_55 BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61
+  BL1_62 BL1__32 BL1__33 BL1__34 BL1__35 BL1__36 BL1__37 BL1__38 BL1__39
+  BL1__40 BL1__41 BL1__42 BL1__43 BL1__44 BL1__45 BL1__46 BL1__47 BL1__48
+  BL1__49 BL1__50 BL1__51 BL1__52 BL1__53 BL1__54 BL1__55 BL1__56 BL1__57
+  BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 VSS GTP GTPSAB GTPSAB Q0_31 Q0_32
+  Q0_33 Q0_34 Q0_35 Q0_36 Q0_37 Q0_38 Q0_39 Q0_40 Q0_41 Q0_42 Q0_43 Q0_44
+  Q0_45 Q0_46 Q0_47 Q0_48 Q0_49 Q0_50 Q0_51 Q0_52 Q0_53 Q0_54 Q0_55 Q0_56
+  Q0_57 Q0_58 Q0_59 Q0_60 Q0_61 Q0_62 Q1_31 Q1_32 Q1_33 Q1_34 Q1_35 Q1_36
+  Q1_37 Q1_38 Q1_39 Q1_40 Q1_41 Q1_42 Q1_43 Q1_44 Q1_45 Q1_46 Q1_47 Q1_48
+  Q1_49 Q1_50 Q1_51 Q1_52 Q1_53 Q1_54 Q1_55 Q1_56 Q1_57 Q1_58 Q1_59 Q1_60
+  Q1_61 Q1_62 VSS VDD RF1SH32x128_onMUX1CDSAWING_R
.ENDS RF1SH32x128_onMUX1BOT
****
.SUBCKT RF1SH32x128_onCC BL BL_ WL WP VSS VDD
** RF1SH32x128_onCC: 6 flat devices **
m1 BL WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BL_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RF1SH32x128_onCC
****
.SUBCKT RF1SH32x128_onCCMW BL BLD BLD_ BL_ WL WP VSS VDD
** RF1SH32x128_onCCMW: 6 flat devices **
m1 BLD WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BLD_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RF1SH32x128_onCCMW
****
.SUBCKT RF1SH32x128_onMCR_NO BL0 BL0_ BL0_0 BL0__0 WL WL_0 WP WP_0 VSS VDD
** RF1SH32x128_onMCR_NO: 24 flat devices **
XI0_0 BL0 BLD BLD_ BL0_ WL WP VSS VDD RF1SH32x128_onCCMW
XI0_1 BL0_ BLD_ BLD BL0 WL_0 WP_0 VSS VDD RF1SH32x128_onCCMW
XI1_0 BL0_0 BLD_4 BLD__2 BL0__0 WL WP VSS VDD RF1SH32x128_onCCMW
XI1_1 BL0__0 BLD__2 BLD_4 BL0_0 WL_0 WP_0 VSS VDD RF1SH32x128_onCCMW
.ENDS RF1SH32x128_onMCR_NO
****
.SUBCKT RF1SH32x128_onCCCOLNO BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 VSS
+  VDD
** RF1SH32x128_onCCCOLNO: 408 flat devices **
XI0_1 BL0_ BL0 WL WP VSS VDD RF1SH32x128_onCC
XI0_10 BL0 BL0_ WL_7 WP_7 VSS VDD RF1SH32x128_onCC
XI0_11 BL0_ BL0 WL_8 WP_8 VSS VDD RF1SH32x128_onCC
XI0_12 BL0 BL0_ WL_9 WP_9 VSS VDD RF1SH32x128_onCC
XI0_13 BL0_ BL0 WL_10 WP_10 VSS VDD RF1SH32x128_onCC
XI0_14 BL0 BL0_ WL_11 WP_11 VSS VDD RF1SH32x128_onCC
XI0_15 BL0_ BL0 WL_12 WP_12 VSS VDD RF1SH32x128_onCC
XI0_16 BL0 BL0_ WL_13 WP_13 VSS VDD RF1SH32x128_onCC
XI0_17 BL0_ BL0 WL_14 WP_14 VSS VDD RF1SH32x128_onCC
XI0_19 BL0_ BL0 WL_15 WP_15 VSS VDD RF1SH32x128_onCC
XI0_2 BL0 BL0_ WL_0 WP_0 VSS VDD RF1SH32x128_onCC
XI0_20 BL0 BL0_ WL_16 WP_16 VSS VDD RF1SH32x128_onCC
XI0_21 BL0_ BL0 WL_17 WP_17 VSS VDD RF1SH32x128_onCC
XI0_22 BL0 BL0_ WL_18 WP_18 VSS VDD RF1SH32x128_onCC
XI0_23 BL0_ BL0 WL_19 WP_19 VSS VDD RF1SH32x128_onCC
XI0_24 BL0 BL0_ WL_20 WP_20 VSS VDD RF1SH32x128_onCC
XI0_25 BL0_ BL0 WL_21 WP_21 VSS VDD RF1SH32x128_onCC
XI0_26 BL0 BL0_ WL_22 WP_22 VSS VDD RF1SH32x128_onCC
XI0_28 BL0 BL0_ WL_23 WP_23 VSS VDD RF1SH32x128_onCC
XI0_29 BL0_ BL0 WL_24 WP_24 VSS VDD RF1SH32x128_onCC
XI0_3 BL0_ BL0 WL_1 WP_1 VSS VDD RF1SH32x128_onCC
XI0_30 BL0 BL0_ WL_25 WP_25 VSS VDD RF1SH32x128_onCC
XI0_31 BL0_ BL0 WL_26 WP_26 VSS VDD RF1SH32x128_onCC
XI0_32 BL0 BL0_ WL_27 WP_27 VSS VDD RF1SH32x128_onCC
XI0_33 BL0_ BL0 WL_28 WP_28 VSS VDD RF1SH32x128_onCC
XI0_34 BL0 BL0_ WL_29 WP_29 VSS VDD RF1SH32x128_onCC
XI0_35 BL0_ BL0 WL_30 WP_30 VSS VDD RF1SH32x128_onCC
XI0_36 BL0 BL0_ BL0_0 BL0__0 WL_31 WL_32 WP_31 WP_32 VSS VDD
+  RF1SH32x128_onMCR_NO
XI0_4 BL0 BL0_ WL_2 WP_2 VSS VDD RF1SH32x128_onCC
XI0_5 BL0_ BL0 WL_3 WP_3 VSS VDD RF1SH32x128_onCC
XI0_6 BL0 BL0_ WL_4 WP_4 VSS VDD RF1SH32x128_onCC
XI0_7 BL0_ BL0 WL_5 WP_5 VSS VDD RF1SH32x128_onCC
XI0_8 BL0 BL0_ WL_6 WP_6 VSS VDD RF1SH32x128_onCC
XI1_1 BL0__0 BL0_0 WL WP VSS VDD RF1SH32x128_onCC
XI1_10 BL0__0 BL0_0 WL_7 WP_7 VSS VDD RF1SH32x128_onCC
XI1_11 BL0_0 BL0__0 WL_8 WP_8 VSS VDD RF1SH32x128_onCC
XI1_12 BL0__0 BL0_0 WL_9 WP_9 VSS VDD RF1SH32x128_onCC
XI1_13 BL0_0 BL0__0 WL_10 WP_10 VSS VDD RF1SH32x128_onCC
XI1_14 BL0__0 BL0_0 WL_11 WP_11 VSS VDD RF1SH32x128_onCC
XI1_15 BL0_0 BL0__0 WL_12 WP_12 VSS VDD RF1SH32x128_onCC
XI1_16 BL0__0 BL0_0 WL_13 WP_13 VSS VDD RF1SH32x128_onCC
XI1_17 BL0_0 BL0__0 WL_14 WP_14 VSS VDD RF1SH32x128_onCC
XI1_19 BL0_0 BL0__0 WL_15 WP_15 VSS VDD RF1SH32x128_onCC
XI1_2 BL0_0 BL0__0 WL_0 WP_0 VSS VDD RF1SH32x128_onCC
XI1_20 BL0__0 BL0_0 WL_16 WP_16 VSS VDD RF1SH32x128_onCC
XI1_21 BL0_0 BL0__0 WL_17 WP_17 VSS VDD RF1SH32x128_onCC
XI1_22 BL0__0 BL0_0 WL_18 WP_18 VSS VDD RF1SH32x128_onCC
XI1_23 BL0_0 BL0__0 WL_19 WP_19 VSS VDD RF1SH32x128_onCC
XI1_24 BL0__0 BL0_0 WL_20 WP_20 VSS VDD RF1SH32x128_onCC
XI1_25 BL0_0 BL0__0 WL_21 WP_21 VSS VDD RF1SH32x128_onCC
XI1_26 BL0__0 BL0_0 WL_22 WP_22 VSS VDD RF1SH32x128_onCC
XI1_28 BL0_0 BL0__0 WL_23 WP_23 VSS VDD RF1SH32x128_onCC
XI1_29 BL0__0 BL0_0 WL_24 WP_24 VSS VDD RF1SH32x128_onCC
XI1_3 BL0__0 BL0_0 WL_1 WP_1 VSS VDD RF1SH32x128_onCC
XI1_30 BL0_0 BL0__0 WL_25 WP_25 VSS VDD RF1SH32x128_onCC
XI1_31 BL0__0 BL0_0 WL_26 WP_26 VSS VDD RF1SH32x128_onCC
XI1_32 BL0_0 BL0__0 WL_27 WP_27 VSS VDD RF1SH32x128_onCC
XI1_33 BL0__0 BL0_0 WL_28 WP_28 VSS VDD RF1SH32x128_onCC
XI1_34 BL0_0 BL0__0 WL_29 WP_29 VSS VDD RF1SH32x128_onCC
XI1_35 BL0__0 BL0_0 WL_30 WP_30 VSS VDD RF1SH32x128_onCC
XI1_4 BL0_0 BL0__0 WL_2 WP_2 VSS VDD RF1SH32x128_onCC
XI1_5 BL0__0 BL0_0 WL_3 WP_3 VSS VDD RF1SH32x128_onCC
XI1_6 BL0_0 BL0__0 WL_4 WP_4 VSS VDD RF1SH32x128_onCC
XI1_7 BL0__0 BL0_0 WL_5 WP_5 VSS VDD RF1SH32x128_onCC
XI1_8 BL0_0 BL0__0 WL_6 WP_6 VSS VDD RF1SH32x128_onCC
.ENDS RF1SH32x128_onCCCOLNO
****
.SUBCKT RF1SH32x128_onFLCCMW BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** RF1SH32x128_onFLCCMW: 24 flat devices **
m1 N11 WP1 N19 VSS NCH_SRAM L=0.16U W=0.16U
m10 N13 N14 VSS VSS NCH_SRAM L=0.13U W=0.23U
m11 N18 WP3 N28 VSS NCH_SRAM L=0.16U W=0.16U
m12 N17 N18 VDD VDD PCH_SRAM L=0.145U W=0.16U
m13 N17 N18 VSS VSS NCH_SRAM L=0.13U W=0.23U
m14 N18 N17 VDD VDD PCH_SRAM L=0.145U W=0.16U
m15 N18 N17 VSS VSS NCH_SRAM L=0.13U W=0.23U
m16 N16 WP2 N28 VSS NCH_SRAM L=0.16U W=0.16U
m17 N15 N16 VDD VDD PCH_SRAM L=0.145U W=0.16U
m18 N15 N16 VSS VSS NCH_SRAM L=0.13U W=0.23U
m19 N16 N15 VDD VDD PCH_SRAM L=0.145U W=0.16U
m2 N12 N11 VDD VDD PCH_SRAM L=0.145U W=0.16U
m20 N16 N15 VSS VSS NCH_SRAM L=0.13U W=0.23U
m21 N12 WP3 N37 VSS NCH_SRAM L=0.16U W=0.16U
m22 N14 WP2 N37 VSS NCH_SRAM L=0.16U W=0.16U
m23 N17 WP3 N38 VSS NCH_SRAM L=0.16U W=0.16U
m24 N15 WP2 N38 VSS NCH_SRAM L=0.16U W=0.16U
m3 N12 N11 VSS VSS NCH_SRAM L=0.13U W=0.23U
m4 N11 N12 VDD VDD PCH_SRAM L=0.145U W=0.16U
m5 N11 N12 VSS VSS NCH_SRAM L=0.13U W=0.23U
m6 N13 WP0 N19 VSS NCH_SRAM L=0.16U W=0.16U
m7 N14 N13 VDD VDD PCH_SRAM L=0.145U W=0.16U
m8 N14 N13 VSS VSS NCH_SRAM L=0.13U W=0.23U
m9 N13 N14 VDD VDD PCH_SRAM L=0.145U W=0.16U
.ENDS RF1SH32x128_onFLCCMW
****
.SUBCKT RF1SH32x128_onMCR_TURN BL0 BL0_ BL0_0 BL0__0 WL WP0 WP1 WP2 WP3 VSS
+  VDD
** RF1SH32x128_onMCR_TURN: 24 flat devices **
XI0_0 BL0 BL0_ BL0__0 BL0_0 WL WP0 WP1 WP2 WP3 VSS VDD RF1SH32x128_onFLCCMW
.ENDS RF1SH32x128_onMCR_TURN
****
.SUBCKT RF1SH32x128_onCCCOLTURN BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WP WP0 WP1 WP2 WP3 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6
+  WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19
+  WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS VDD
** RF1SH32x128_onCCCOLTURN: 408 flat devices **
XI0_1 BL0_ BL0 WL WP VSS VDD RF1SH32x128_onCC
XI0_10 BL0 BL0_ WL_7 WP_7 VSS VDD RF1SH32x128_onCC
XI0_11 BL0_ BL0 WL_8 WP_8 VSS VDD RF1SH32x128_onCC
XI0_12 BL0 BL0_ WL_9 WP_9 VSS VDD RF1SH32x128_onCC
XI0_13 BL0_ BL0 WL_10 WP_10 VSS VDD RF1SH32x128_onCC
XI0_14 BL0 BL0_ WL_11 WP_11 VSS VDD RF1SH32x128_onCC
XI0_15 BL0_ BL0 WL_12 WP_12 VSS VDD RF1SH32x128_onCC
XI0_16 BL0 BL0_ WL_13 WP_13 VSS VDD RF1SH32x128_onCC
XI0_17 BL0_ BL0 WL_14 WP_14 VSS VDD RF1SH32x128_onCC
XI0_19 BL0_ BL0 WL_15 WP_15 VSS VDD RF1SH32x128_onCC
XI0_2 BL0 BL0_ WL_0 WP_0 VSS VDD RF1SH32x128_onCC
XI0_20 BL0 BL0_ WL_16 WP_16 VSS VDD RF1SH32x128_onCC
XI0_21 BL0_ BL0 WL_17 WP_17 VSS VDD RF1SH32x128_onCC
XI0_22 BL0 BL0_ WL_18 WP_18 VSS VDD RF1SH32x128_onCC
XI0_23 BL0_ BL0 WL_19 WP_19 VSS VDD RF1SH32x128_onCC
XI0_24 BL0 BL0_ WL_20 WP_20 VSS VDD RF1SH32x128_onCC
XI0_25 BL0_ BL0 WL_21 WP_21 VSS VDD RF1SH32x128_onCC
XI0_26 BL0 BL0_ WL_22 WP_22 VSS VDD RF1SH32x128_onCC
XI0_28 BL0 BL0_ WL_23 WP_23 VSS VDD RF1SH32x128_onCC
XI0_29 BL0_ BL0 WL_24 WP_24 VSS VDD RF1SH32x128_onCC
XI0_3 BL0_ BL0 WL_1 WP_1 VSS VDD RF1SH32x128_onCC
XI0_30 BL0 BL0_ WL_25 WP_25 VSS VDD RF1SH32x128_onCC
XI0_31 BL0_ BL0 WL_26 WP_26 VSS VDD RF1SH32x128_onCC
XI0_32 BL0 BL0_ WL_27 WP_27 VSS VDD RF1SH32x128_onCC
XI0_33 BL0_ BL0 WL_28 WP_28 VSS VDD RF1SH32x128_onCC
XI0_34 BL0 BL0_ WL_29 WP_29 VSS VDD RF1SH32x128_onCC
XI0_35 BL0_ BL0 WL_30 WP_30 VSS VDD RF1SH32x128_onCC
XI0_36 BL0 BL0_ BL0_0 BL0__0 WL_31 WP0 WP1 WP2 WP3 VSS VDD
+  RF1SH32x128_onMCR_TURN
XI0_4 BL0 BL0_ WL_2 WP_2 VSS VDD RF1SH32x128_onCC
XI0_5 BL0_ BL0 WL_3 WP_3 VSS VDD RF1SH32x128_onCC
XI0_6 BL0 BL0_ WL_4 WP_4 VSS VDD RF1SH32x128_onCC
XI0_7 BL0_ BL0 WL_5 WP_5 VSS VDD RF1SH32x128_onCC
XI0_8 BL0 BL0_ WL_6 WP_6 VSS VDD RF1SH32x128_onCC
XI1_1 BL0__0 BL0_0 WL WP VSS VDD RF1SH32x128_onCC
XI1_10 BL0__0 BL0_0 WL_7 WP_7 VSS VDD RF1SH32x128_onCC
XI1_11 BL0_0 BL0__0 WL_8 WP_8 VSS VDD RF1SH32x128_onCC
XI1_12 BL0__0 BL0_0 WL_9 WP_9 VSS VDD RF1SH32x128_onCC
XI1_13 BL0_0 BL0__0 WL_10 WP_10 VSS VDD RF1SH32x128_onCC
XI1_14 BL0__0 BL0_0 WL_11 WP_11 VSS VDD RF1SH32x128_onCC
XI1_15 BL0_0 BL0__0 WL_12 WP_12 VSS VDD RF1SH32x128_onCC
XI1_16 BL0__0 BL0_0 WL_13 WP_13 VSS VDD RF1SH32x128_onCC
XI1_17 BL0_0 BL0__0 WL_14 WP_14 VSS VDD RF1SH32x128_onCC
XI1_19 BL0_0 BL0__0 WL_15 WP_15 VSS VDD RF1SH32x128_onCC
XI1_2 BL0_0 BL0__0 WL_0 WP_0 VSS VDD RF1SH32x128_onCC
XI1_20 BL0__0 BL0_0 WL_16 WP_16 VSS VDD RF1SH32x128_onCC
XI1_21 BL0_0 BL0__0 WL_17 WP_17 VSS VDD RF1SH32x128_onCC
XI1_22 BL0__0 BL0_0 WL_18 WP_18 VSS VDD RF1SH32x128_onCC
XI1_23 BL0_0 BL0__0 WL_19 WP_19 VSS VDD RF1SH32x128_onCC
XI1_24 BL0__0 BL0_0 WL_20 WP_20 VSS VDD RF1SH32x128_onCC
XI1_25 BL0_0 BL0__0 WL_21 WP_21 VSS VDD RF1SH32x128_onCC
XI1_26 BL0__0 BL0_0 WL_22 WP_22 VSS VDD RF1SH32x128_onCC
XI1_28 BL0_0 BL0__0 WL_23 WP_23 VSS VDD RF1SH32x128_onCC
XI1_29 BL0__0 BL0_0 WL_24 WP_24 VSS VDD RF1SH32x128_onCC
XI1_3 BL0__0 BL0_0 WL_1 WP_1 VSS VDD RF1SH32x128_onCC
XI1_30 BL0_0 BL0__0 WL_25 WP_25 VSS VDD RF1SH32x128_onCC
XI1_31 BL0__0 BL0_0 WL_26 WP_26 VSS VDD RF1SH32x128_onCC
XI1_32 BL0_0 BL0__0 WL_27 WP_27 VSS VDD RF1SH32x128_onCC
XI1_33 BL0__0 BL0_0 WL_28 WP_28 VSS VDD RF1SH32x128_onCC
XI1_34 BL0_0 BL0__0 WL_29 WP_29 VSS VDD RF1SH32x128_onCC
XI1_35 BL0__0 BL0_0 WL_30 WP_30 VSS VDD RF1SH32x128_onCC
XI1_4 BL0_0 BL0__0 WL_2 WP_2 VSS VDD RF1SH32x128_onCC
XI1_5 BL0__0 BL0_0 WL_3 WP_3 VSS VDD RF1SH32x128_onCC
XI1_6 BL0_0 BL0__0 WL_4 WP_4 VSS VDD RF1SH32x128_onCC
XI1_7 BL0__0 BL0_0 WL_5 WP_5 VSS VDD RF1SH32x128_onCC
XI1_8 BL0_0 BL0__0 WL_6 WP_6 VSS VDD RF1SH32x128_onCC
.ENDS RF1SH32x128_onCCCOLTURN
****
.SUBCKT RF1SH32x128_onCCWING_L BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16
+  BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26
+  BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36
+  BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46
+  BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49
+  BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58
+  BL0__59 BL0__60 BL0__61 BL0__62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 VSS VDD
** RF1SH32x128_onCCWING_L: 13056 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI1 BL0_1 BL0__1 BL0_2 BL0__2 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI10 BL0_17 BL0__17 BL0_18 BL0__18 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI11 BL0_19 BL0__19 BL0_20 BL0__20 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI12 BL0_21 BL0__21 BL0_22 BL0__22 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI13 BL0_23 BL0__23 BL0_24 BL0__24 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI14 BL0_25 BL0__25 BL0_26 BL0__26 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI15 BL0_27 BL0__27 BL0_28 BL0__28 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI16 BL0_29 BL0__29 BL0_30 BL0__30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI18 BL0_31 BL0__31 BL0_32 BL0__32 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL WL_31
+  WL_31 VSS VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VDD RF1SH32x128_onCCCOLTURN
XI19 BL0_33 BL0__33 BL0_34 BL0__34 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI2 BL0_3 BL0__3 BL0_4 BL0__4 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI20 BL0_35 BL0__35 BL0_36 BL0__36 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI21 BL0_37 BL0__37 BL0_38 BL0__38 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI22 BL0_39 BL0__39 BL0_40 BL0__40 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI23 BL0_41 BL0__41 BL0_42 BL0__42 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI24 BL0_43 BL0__43 BL0_44 BL0__44 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI25 BL0_45 BL0__45 BL0_46 BL0__46 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI27 BL0_47 BL0__47 BL0_48 BL0__48 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI28 BL0_49 BL0__49 BL0_50 BL0__50 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI29 BL0_51 BL0__51 BL0_52 BL0__52 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI3 BL0_5 BL0__5 BL0_6 BL0__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI30 BL0_53 BL0__53 BL0_54 BL0__54 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI31 BL0_55 BL0__55 BL0_56 BL0__56 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI32 BL0_57 BL0__57 BL0_58 BL0__58 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI33 BL0_59 BL0__59 BL0_60 BL0__60 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI34 BL0_61 BL0__61 BL0_62 BL0__62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI4 BL0_7 BL0__7 BL0_8 BL0__8 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI5 BL0_9 BL0__9 BL0_10 BL0__10 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI6 BL0_11 BL0__11 BL0_12 BL0__12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI7 BL0_13 BL0__13 BL0_14 BL0__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI9 BL0_15 BL0__15 BL0_16 BL0__16 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
.ENDS RF1SH32x128_onCCWING_L
****
.SUBCKT RF1SH32x128_onWD G00 G01 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x128_onWD: 27 flat devices **
m1 WL1 WIN1 VDD VDD P L=0.13U W=5.18U
m10 GTPIN1 WL1 GTP VSS N L=0.13U W=0.33U
m11 GTPIN0 N27 GTP VDD P L=0.13U W=0.52U
m12 GTP WL0 GTPIN0 VSS N L=0.13U W=0.33U
m13 GTPIN1 N28 VSS VSS N L=0.13U W=0.15U
m14 GTPIN0 N27 VSS VSS N L=0.13U W=0.15U
m15 VDD G2 N28 VDD P L=0.13U W=0.15U
m16 VDD G3 N28 VDD P L=0.13U W=0.15U
m17 VDD G01 N28 VDD P L=0.13U W=0.15U
m18 N27 G2 VDD VDD P L=0.13U W=0.15U
m19 N27 G3 VDD VDD P L=0.13U W=0.15U
m2 WL1 WIN1 VSS VSS N L=0.13U W=2.68U
m20 N27 G00 VDD VDD P L=0.13U W=0.15U
m21 N27 G00 N29 VSS N L=0.13U W=0.38U
m22 N29 G01 N28 VSS N L=0.13U W=0.38U
m23 VDD G1 N28 VDD P L=0.13U W=0.15U
m24 N27 G1 VDD VDD P L=0.13U W=0.15U
m25 N29 G3 N40 VSS N L=0.13U W=0.38U
m26 N40 G2 N41 VSS N L=0.13U W=0.38U
m27 N41 G1 VSS VSS N L=0.13U W=0.38U
m3 WL0 WIN0 VDD VDD P L=0.13U W=5.18U
m4 WL0 WIN0 VSS VSS N L=0.13U W=2.68U
m5 WIN0 GTPIN0 VDD VDD P L=0.13U W=1.76U
m6 WIN0 GTPIN0 VSS VSS N L=0.13U W=1.12U
m7 WIN1 GTPIN1 VDD VDD P L=0.13U W=1.76U
m8 WIN1 GTPIN1 VSS VSS N L=0.13U W=1.12U
m9 GTP N28 GTPIN1 VDD P L=0.13U W=0.52U
.ENDS RF1SH32x128_onWD
****
.SUBCKT RF1SH32x128_onWDV_1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x128_onWDV_1: 27 flat devices **
XI0 XP3 XP2 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWD
.ENDS RF1SH32x128_onWDV_1
****
.SUBCKT RF1SH32x128_onWDV_0 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x128_onWDV_0: 27 flat devices **
XI0 XP0 XP1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWD
.ENDS RF1SH32x128_onWDV_0
****
.SUBCKT RF1SH32x128_onMWD GTP GTPIN GTPIN1 GTPIN2 GTPOUT0 GTPOUT1 GTPOUT2 MBL
+  MWL MWLLATE P1 P2 P3 P4 P5 P6 P7 P8 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x128_onMWD: 30 flat devices **
m1 MWL WINB1 VDD VDD P L=0.13U W=5.18U
m10 P6 MWLLATE VSS VSS N L=0.13U W=0.44U
m11 VSS MWLLATE P7 VSS N L=0.13U W=0.44U
m12 VSS MWLLATE P8 VSS N L=0.13U W=0.44U
m13 N26 VSS GTPAT VDD P L=0.13U W=0.52U
m14 GTPAT MWL N26 VSS N L=0.13U W=0.33U
m15 GTPOUT2 N32 VDD VDD P L=0.13U W=0.15U
m16 GTPOUT2 N32 VSS VSS N L=0.13U W=0.15U
m17 N32 GTPIN2 VDD VDD P L=0.13U W=0.15U
m18 N32 GTPIN2 VSS VSS N L=0.13U W=0.15U
m19 GTPOUT1 N37 VDD VDD P L=0.13U W=0.15U
m2 MWL WINB1 VSS VSS N L=0.13U W=2.68U
m20 GTPOUT1 N37 VSS VSS N L=0.13U W=0.15U
m21 N37 GTPIN1 VDD VDD P L=0.13U W=0.15U
m22 N37 GTPIN1 VSS VSS N L=0.13U W=0.15U
m23 GTPOUT0 N42 VDD VDD P L=0.13U W=0.15U
m24 GTPOUT0 N42 VSS VSS N L=0.13U W=0.15U
m25 N42 GTP VDD VDD P L=0.13U W=0.15U
m26 N42 GTP VSS VSS N L=0.13U W=0.15U
m27 N47 GTPIN VDD VDD P L=0.13U W=0.52U
m28 N47 GTPIN VSS VSS N L=0.13U W=0.33U
m29 N26 N47 VDD VDD P L=0.13U W=0.52U
m3 WINB1 GTPAT VDD VDD P L=0.13U W=1.76U
m30 N26 N47 VSS VSS N L=0.13U W=0.33U
m4 WINB1 GTPAT VSS VSS N L=0.13U W=1.12U
m5 P1 MWLLATE VSS VSS N L=0.13U W=0.44U
m6 P2 MWLLATE VSS VSS N L=0.13U W=0.44U
m7 P3 MWLLATE VSS VSS N L=0.13U W=0.44U
m8 P4 MWLLATE VSS VSS N L=0.13U W=0.44U
m9 P5 MWLLATE VSS VSS N L=0.13U W=0.44U
.ENDS RF1SH32x128_onMWD
****
.SUBCKT RF1SH32x128_onWDSTACK G1 G1_0 G1_1 G1_2 G1_3 G1_4 G1_5 G1_6 G1_7 G1_8
+  G1_9 G1_10 G1_11 G1_12 G1_13 G1_14 G2 G2_0 G2_1 G2_2 G2_3 G2_4 G2_5 G2_6
+  G2_7 G2_8 G2_9 G2_10 G2_11 G2_12 G2_13 G2_14 G3 G3_0 G3_1 G3_2 G3_3 G3_4
+  G3_5 G3_6 G3_7 G3_8 G3_9 G3_10 G3_11 G3_12 G3_13 G3_14 GTP MBL MWL MWLLATE
+  WL0 WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10
+  WL0_11 WL0_12 WL0_13 WL0_14 WL1 WL1_0 WL1_1 WL1_2 WL1_3 WL1_4 WL1_5 WL1_6
+  WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13 WL1_14 XP0 XP1 XP2 XP3 VSS
+  VDD
** RF1SH32x128_onWDSTACK: 462 flat devices **
XI1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_0
XI11 G1_7 G2_7 G3_7 GTP WL0_7 WL1_7 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_0
XI12 G1_8 G2_8 G3_8 GTP WL0_8 WL1_8 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_1
XI13 G1_9 G2_9 G3_9 GTP WL0_9 WL1_9 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_0
XI14 G1_10 G2_10 G3_10 GTP WL0_10 WL1_10 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_1
XI16 G1_11 G2_11 G3_11 GTP WL0_11 WL1_11 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_0
XI17 G1_12 G2_12 G3_12 GTP WL0_12 WL1_12 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_1
XI18 G1_13 G2_13 G3_13 GTP WL0_13 WL1_13 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_0
XI19 G1_14 G2_14 G3_14 GTP WL0_14 WL1_14 XP0 XP1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDV_1
XI2 G1_0 G2_0 G3_0 GTP WL0_0 WL1_0 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_1
XI20 GTP GTPIN GTP GTPIN2 GTPOUT0 GTPIN2 GTPIN MBL MWL MWLLATE P1 P2 P3 P4 P5
+  P6 P7 P8 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onMWD
XI3 G1_1 G2_1 G3_1 GTP WL0_1 WL1_1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_0
XI4 G1_2 G2_2 G3_2 GTP WL0_2 WL1_2 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_1
XI6 G1_3 G2_3 G3_3 GTP WL0_3 WL1_3 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_0
XI7 G1_4 G2_4 G3_4 GTP WL0_4 WL1_4 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_1
XI8 G1_5 G2_5 G3_5 GTP WL0_5 WL1_5 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_0
XI9 G1_6 G2_6 G3_6 GTP WL0_6 WL1_6 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x128_onWDV_1
.ENDS RF1SH32x128_onWDSTACK
****
.SUBCKT RF1SH32x128_onCCMBL2 BL BL_ WL WL_0 WP WP_0 VSS VDD
** RF1SH32x128_onCCMBL2: 12 flat devices **
XI1_0 BL_ BL WL WP VSS VDD RF1SH32x128_onCC
XI1_1 BL BL_ WL_0 WP_0 VSS VDD RF1SH32x128_onCC
.ENDS RF1SH32x128_onCCMBL2
****
.SUBCKT RF1SH32x128_onMBLBASE MBL MBL_ MWL MWLS VSS VDD
** RF1SH32x128_onMBLBASE: 4 flat devices **
m1 VSS MWL MBL VSS N L=0.13U W=0.15U
m2 VSS MWL MBL VSS N L=0.13U W=0.15U
m3 VDD VDD VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 VDD VDD VDD VDD PCH_SRAM L=0.145U W=0.16U
.ENDS RF1SH32x128_onMBLBASE
****
.SUBCKT RF1SH32x128_onMBLENDTOP MBL MBL_ WL WL_0 VSS VDD
** RF1SH32x128_onMBLENDTOP: 4 flat devices **
XI0_0 MBL MBL_ WL_0 WL VSS VDD RF1SH32x128_onMBLBASE
.ENDS RF1SH32x128_onMBLENDTOP
****
.SUBCKT RF1SH32x128_onMODEL_COL MBL MBL_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11
+  WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22 WP_23
+  WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 VSS VDD
** RF1SH32x128_onMODEL_COL: 196 flat devices **
XI1 MBL MBL_ WL WL_0 WP WP_0 VSS VDD RF1SH32x128_onCCMBL2
XI11 MBL MBL_ WL_15 WL_16 WP_15 WP_16 VSS VDD RF1SH32x128_onCCMBL2
XI12 MBL MBL_ WL_17 WL_18 WP_17 WP_18 VSS VDD RF1SH32x128_onCCMBL2
XI13 MBL MBL_ WL_19 WL_20 WP_19 WP_20 VSS VDD RF1SH32x128_onCCMBL2
XI14 MBL MBL_ WL_21 WL_22 WP_21 WP_22 VSS VDD RF1SH32x128_onCCMBL2
XI16 MBL_ MBL WL_23 WL_24 WP_23 WP_24 VSS VDD RF1SH32x128_onCCMBL2
XI17 MBL_ MBL WL_25 WL_26 WP_25 WP_26 VSS VDD RF1SH32x128_onCCMBL2
XI18 MBL_ MBL WL_27 WL_28 WP_27 WP_28 VSS VDD RF1SH32x128_onCCMBL2
XI19 MBL_ MBL WL_29 WL_30 WP_29 WP_30 VSS VDD RF1SH32x128_onCCMBL2
XI2 MBL MBL_ WL_1 WL_2 WP_1 WP_2 VSS VDD RF1SH32x128_onCCMBL2
XI20 MBL MBL_ WL_31 WL_32 VSS VDD RF1SH32x128_onMBLENDTOP
XI3 MBL MBL_ WL_3 WL_4 WP_3 WP_4 VSS VDD RF1SH32x128_onCCMBL2
XI4 MBL MBL_ WL_5 WL_6 WP_5 WP_6 VSS VDD RF1SH32x128_onCCMBL2
XI6 MBL_ MBL WL_7 WL_8 WP_7 WP_8 VSS VDD RF1SH32x128_onCCMBL2
XI7 MBL_ MBL WL_9 WL_10 WP_9 WP_10 VSS VDD RF1SH32x128_onCCMBL2
XI8 MBL_ MBL WL_11 WL_12 WP_11 WP_12 VSS VDD RF1SH32x128_onCCMBL2
XI9 MBL_ MBL WL_13 WL_14 WP_13 WP_14 VSS VDD RF1SH32x128_onCCMBL2
.ENDS RF1SH32x128_onMODEL_COL
****
.SUBCKT RF1SH32x128_onCCWING_R BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16
+  BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26
+  BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36
+  BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46
+  BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49
+  BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58
+  BL0__59 BL0__60 BL0__61 BL0__62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 VSS VDD
** RF1SH32x128_onCCWING_R: 13056 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI1 BL0_1 BL0__1 BL0_2 BL0__2 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI10 BL0_17 BL0__17 BL0_18 BL0__18 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI11 BL0_19 BL0__19 BL0_20 BL0__20 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI12 BL0_21 BL0__21 BL0_22 BL0__22 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI13 BL0_23 BL0__23 BL0_24 BL0__24 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI14 BL0_25 BL0__25 BL0_26 BL0__26 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI15 BL0_27 BL0__27 BL0_28 BL0__28 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI16 BL0_29 BL0__29 BL0_30 BL0__30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI18 BL0_31 BL0__31 BL0_32 BL0__32 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL WL_31
+  WL_31 VSS VSS WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VDD RF1SH32x128_onCCCOLTURN
XI19 BL0_33 BL0__33 BL0_34 BL0__34 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI2 BL0_3 BL0__3 BL0_4 BL0__4 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI20 BL0_35 BL0__35 BL0_36 BL0__36 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI21 BL0_37 BL0__37 BL0_38 BL0__38 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI22 BL0_39 BL0__39 BL0_40 BL0__40 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI23 BL0_41 BL0__41 BL0_42 BL0__42 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI24 BL0_43 BL0__43 BL0_44 BL0__44 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI25 BL0_45 BL0__45 BL0_46 BL0__46 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI27 BL0_47 BL0__47 BL0_48 BL0__48 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI28 BL0_49 BL0__49 BL0_50 BL0__50 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI29 BL0_51 BL0__51 BL0_52 BL0__52 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI3 BL0_5 BL0__5 BL0_6 BL0__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI30 BL0_53 BL0__53 BL0_54 BL0__54 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI31 BL0_55 BL0__55 BL0_56 BL0__56 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI32 BL0_57 BL0__57 BL0_58 BL0__58 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI33 BL0_59 BL0__59 BL0_60 BL0__60 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI34 BL0_61 BL0__61 BL0_62 BL0__62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 VSS VSS WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 VSS VSS VSS VDD RF1SH32x128_onCCCOLNO
XI4 BL0_7 BL0__7 BL0_8 BL0__8 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI5 BL0_9 BL0__9 BL0_10 BL0__10 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI6 BL0_11 BL0__11 BL0_12 BL0__12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI7 BL0_13 BL0__13 BL0_14 BL0__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
XI9 BL0_15 BL0__15 BL0_16 BL0__16 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VDD RF1SH32x128_onCCCOLNO
.ENDS RF1SH32x128_onCCWING_R
****
.SUBCKT RF1SH32x128_onMID BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17
+  BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27
+  BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37
+  BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47
+  BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57
+  BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0_63 BL0_64 BL0_65 BL0_66 BL0_67
+  BL0_68 BL0_69 BL0_70 BL0_71 BL0_72 BL0_73 BL0_74 BL0_75 BL0_76 BL0_77
+  BL0_78 BL0_79 BL0_80 BL0_81 BL0_82 BL0_83 BL0_84 BL0_85 BL0_86 BL0_87
+  BL0_88 BL0_89 BL0_90 BL0_91 BL0_92 BL0_93 BL0_94 BL0_95 BL0_96 BL0_97
+  BL0_98 BL0_99 BL0_100 BL0_101 BL0_102 BL0_103 BL0_104 BL0_105 BL0_106
+  BL0_107 BL0_108 BL0_109 BL0_110 BL0_111 BL0_112 BL0_113 BL0_114 BL0_115
+  BL0_116 BL0_117 BL0_118 BL0_119 BL0_120 BL0_121 BL0_122 BL0_123 BL0_124
+  BL0_125 BL0_126 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7
+  BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16
+  BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25
+  BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31 BL0__32 BL0__33 BL0__34
+  BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43
+  BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52
+  BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58 BL0__59 BL0__60 BL0__61
+  BL0__62 BL0__63 BL0__64 BL0__65 BL0__66 BL0__67 BL0__68 BL0__69 BL0__70
+  BL0__71 BL0__72 BL0__73 BL0__74 BL0__75 BL0__76 BL0__77 BL0__78 BL0__79
+  BL0__80 BL0__81 BL0__82 BL0__83 BL0__84 BL0__85 BL0__86 BL0__87 BL0__88
+  BL0__89 BL0__90 BL0__91 BL0__92 BL0__93 BL0__94 BL0__95 BL0__96 BL0__97
+  BL0__98 BL0__99 BL0__100 BL0__101 BL0__102 BL0__103 BL0__104 BL0__105
+  BL0__106 BL0__107 BL0__108 BL0__109 BL0__110 BL0__111 BL0__112 BL0__113
+  BL0__114 BL0__115 BL0__116 BL0__117 BL0__118 BL0__119 BL0__120 BL0__121
+  BL0__122 BL0__123 BL0__124 BL0__125 BL0__126 G2 G2_0 G3 GTP MBL MBL_ XP0
+  XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1 XP2 XP3 VSS VDD
** RF1SH32x128_onMID: 26770 flat devices **
XI1 BL0_62 BL0__62 BL0_61 BL0_60 BL0_59 BL0_58 BL0_57 BL0_56 BL0_55 BL0_54
+  BL0_53 BL0_52 BL0_51 BL0_50 BL0_49 BL0_48 BL0_47 BL0_46 BL0_45 BL0_44
+  BL0_43 BL0_42 BL0_41 BL0_40 BL0_39 BL0_38 BL0_37 BL0_36 BL0_35 BL0_34
+  BL0_33 BL0_32 BL0_31 BL0_30 BL0_29 BL0_28 BL0_27 BL0_26 BL0_25 BL0_24
+  BL0_23 BL0_22 BL0_21 BL0_20 BL0_19 BL0_18 BL0_17 BL0_16 BL0_15 BL0_14
+  BL0_13 BL0_12 BL0_11 BL0_10 BL0_9 BL0_8 BL0_7 BL0_6 BL0_5 BL0_4 BL0_3 BL0_2
+  BL0_1 BL0_0 BL0 BL0__61 BL0__60 BL0__59 BL0__58 BL0__57 BL0__56 BL0__55
+  BL0__54 BL0__53 BL0__52 BL0__51 BL0__50 BL0__49 BL0__48 BL0__47 BL0__46
+  BL0__45 BL0__44 BL0__43 BL0__42 BL0__41 BL0__40 BL0__39 BL0__38 BL0__37
+  BL0__36 BL0__35 BL0__34 BL0__33 BL0__32 BL0__31 BL0__30 BL0__29 BL0__28
+  BL0__27 BL0__26 BL0__25 BL0__24 BL0__23 BL0__22 BL0__21 BL0__20 BL0__19
+  BL0__18 BL0__17 BL0__16 BL0__15 BL0__14 BL0__13 BL0__12 BL0__11 BL0__10
+  BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2 BL0__1 BL0__0 BL0_
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 VSS VDD RF1SH32x128_onCCWING_L
XI3 XP0_1 XP0_1 XP1_0 XP1_0 XP0_0 XP0_0 XP1 XP1 XP0_1 XP0_1 XP1_0 XP1_0 XP0_0
+  XP0_0 XP1 XP1 XP0 XP0 XP0 XP0 XP0 XP0 XP0 XP0 G2 G2 G2 G2 G2 G2 G2 G2 VDD
+  VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD VDD GTP MBL WL_31
+  WL_31 WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14 WL_15 WL_18 WL_19 WL_22
+  WL_23 WL_26 WL_27 WL_30 WL_0 WL_1 WL_4 WL_5 WL_8 WL_9 WL_12 WL_13 WL_16
+  WL_17 WL_20 WL_21 WL_24 WL_25 WL_28 WL_29 XP0_2 XP1_1 XP2 XP3 VSS VDD
+  RF1SH32x128_onWDSTACK
XI4 MBL MBL_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_31 VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD RF1SH32x128_onMODEL_COL
XI5 BL0_63 BL0__63 BL0_64 BL0_65 BL0_66 BL0_67 BL0_68 BL0_69 BL0_70 BL0_71
+  BL0_72 BL0_73 BL0_74 BL0_75 BL0_76 BL0_77 BL0_78 BL0_79 BL0_80 BL0_81
+  BL0_82 BL0_83 BL0_84 BL0_85 BL0_86 BL0_87 BL0_88 BL0_89 BL0_90 BL0_91
+  BL0_92 BL0_93 BL0_94 BL0_95 BL0_96 BL0_97 BL0_98 BL0_99 BL0_100 BL0_101
+  BL0_102 BL0_103 BL0_104 BL0_105 BL0_106 BL0_107 BL0_108 BL0_109 BL0_110
+  BL0_111 BL0_112 BL0_113 BL0_114 BL0_115 BL0_116 BL0_117 BL0_118 BL0_119
+  BL0_120 BL0_121 BL0_122 BL0_123 BL0_124 BL0_125 BL0_126 BL0__64 BL0__65
+  BL0__66 BL0__67 BL0__68 BL0__69 BL0__70 BL0__71 BL0__72 BL0__73 BL0__74
+  BL0__75 BL0__76 BL0__77 BL0__78 BL0__79 BL0__80 BL0__81 BL0__82 BL0__83
+  BL0__84 BL0__85 BL0__86 BL0__87 BL0__88 BL0__89 BL0__90 BL0__91 BL0__92
+  BL0__93 BL0__94 BL0__95 BL0__96 BL0__97 BL0__98 BL0__99 BL0__100 BL0__101
+  BL0__102 BL0__103 BL0__104 BL0__105 BL0__106 BL0__107 BL0__108 BL0__109
+  BL0__110 BL0__111 BL0__112 BL0__113 BL0__114 BL0__115 BL0__116 BL0__117
+  BL0__118 BL0__119 BL0__120 BL0__121 BL0__122 BL0__123 BL0__124 BL0__125
+  BL0__126 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11
+  WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23
+  WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 VSS VDD
+  RF1SH32x128_onCCWING_R
.ENDS RF1SH32x128_onMID
****
.SUBCKT RF1SH32x128_onWR1T BL0 BL0_ BL1 BL_ D0 GTP WEI_ VSS VDD
** RF1SH32x128_onWR1T: 22 flat devices **
m1 DWIN GTPN DI_ VSS N L=0.13U W=0.64U
m10 N23 D0 VSS VSS N L=0.13U W=0.24U
m11 BL_ DWIN N16 VSS N L=0.13U W=2.2U
m12 BL1 DWINB N16 VSS N L=0.13U W=2.2U
m13 VSS GTPWEN N16 VSS N L=0.13U W=2.2U
m14 VDD GTPN N17 VDD P L=0.13U W=1U
m15 N17 DWIN DWINB VDD P L=0.13U W=1U
m16 N17 DWINB DWIN VDD P L=0.13U W=1U
m17 DWINB DWIN VSS VSS N L=0.13U W=0.3U
m18 DWIN DWINB VSS VSS N L=0.13U W=0.3U
m19 N30 GTPN VDD VDD P L=0.13U W=1U
m2 DWINB GTPN DI VSS N L=0.13U W=0.64U
m20 GTPWEN GTPN VSS VSS N L=0.13U W=0.32U
m21 GTPWEN WEI_ N30 VDD P L=0.13U W=1U
m22 GTPWEN WEI_ VSS VSS N L=0.13U W=0.32U
m3 GTPN GTP VDD VDD P L=0.13U W=0.58U
m4 GTPN GTP VSS VSS N L=0.13U W=0.37U
m5 DI_ DI VDD VDD P L=0.13U W=1U
m6 DI_ DI VSS VSS N L=0.13U W=0.64U
m7 DI N23 VDD VDD P L=0.13U W=1.4U
m8 DI N23 VSS VSS N L=0.13U W=0.64U
m9 N23 D0 VDD VDD P L=0.13U W=0.37U
.ENDS RF1SH32x128_onWR1T
****
.SUBCKT RF1SH32x128_onWR1B BL0 BL0_ D0 D1 GTP WE WEI VSS VDD
** RF1SH32x128_onWR1B: 36 flat devices **
m1 DWIN GTPN DI_ VSS N L=0.13U W=0.64U
m10 N23 D1 VSS VSS N L=0.13U W=0.24U
m11 BL0 DWIN N16 VSS N L=0.13U W=2.2U
m12 BL0_ DWINB N16 VSS N L=0.13U W=2.2U
m13 VSS GTPWEN N16 VSS N L=0.13U W=2.2U
m14 VDD GTPN N17 VDD P L=0.13U W=1U
m15 N17 DWIN DWINB VDD P L=0.13U W=1U
m16 N17 DWINB DWIN VDD P L=0.13U W=1U
m17 DWINB DWIN VSS VSS N L=0.13U W=0.3U
m18 DWIN DWINB VSS VSS N L=0.13U W=0.3U
m19 N43 GTPN VDD VDD P L=0.13U W=1U
m2 DWINB GTPN DI VSS N L=0.13U W=0.64U
m20 GTPWEN GTPN VSS VSS N L=0.13U W=0.32U
m21 GTPWEN WE N43 VDD P L=0.13U W=1U
m22 GTPWEN WE VSS VSS N L=0.13U W=0.32U
m23 WE N30 VDD VDD P L=0.13U W=0.59U
m24 WE N30 VSS VSS N L=0.13U W=0.38U
m25 N30 GTPN N45 VDD P L=0.13U W=0.3U
m26 N45 WE VDD VDD P L=0.13U W=0.3U
m27 N30 GTP N44 VSS N L=0.13U W=0.3U
m28 N44 WE VSS VSS N L=0.13U W=0.3U
m29 N30 GTP N47 VDD P L=0.13U W=0.43U
m3 GTPN GTP VDD VDD P L=0.13U W=0.58U
m30 N47 N35 VDD VDD P L=0.13U W=0.43U
m31 N30 GTPN N46 VSS N L=0.13U W=0.3U
m32 N46 N35 VSS VSS N L=0.13U W=0.3U
m33 N35 N38 VDD VDD P L=0.13U W=0.3U
m34 N35 N38 VSS VSS N L=0.13U W=0.15U
m35 N38 WEI VDD VDD P L=0.13U W=0.24U
m36 N38 WEI VSS VSS N L=0.13U W=0.15U
m4 GTPN GTP VSS VSS N L=0.13U W=0.37U
m5 DI_ DI VDD VDD P L=0.13U W=1U
m6 DI_ DI VSS VSS N L=0.13U W=0.64U
m7 DI N23 VDD VDD P L=0.13U W=1.4U
m8 DI N23 VSS VSS N L=0.13U W=0.64U
m9 N23 D1 VDD VDD P L=0.13U W=0.37U
.ENDS RF1SH32x128_onWR1B
****
.SUBCKT RF1SH32x128_onFLCWRM1 D0 D1 WBYTE VSS VDD
** RF1SH32x128_onFLCWRM1: 2 flat devices **
d1 VSS D0 DN 0.2116P 1.84U
d2 VSS D1 DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCWRM1
****
.SUBCKT RF1SH32x128_onMUX1WR4BW_M BL0 BL0_ BL0_0 BL0__0 BL1 BL1_0 BL_ BL__0 D0
+  D0_0 D1 D1_0 GTP GTP_0 WBYTE VSS VDD
** RF1SH32x128_onMUX1WR4BW_M: 120 flat devices **
XI0_0 BL0 BL0_ BL1 BL_ D1 GTP WEI_ VSS VDD RF1SH32x128_onWR1T
XI0_1 BL0 BL0_ D1 D0 GTP_0 WEI_ WBYTE VSS VDD RF1SH32x128_onWR1B
XI0_2 D0 D1 WBYTE VSS VDD RF1SH32x128_onFLCWRM1
XI1_0 BL0_0 BL0__0 BL1_0 BL__0 D1_0 GTP WEI__1 VSS VDD RF1SH32x128_onWR1T
XI1_1 BL0_0 BL0__0 D1_0 D0_0 GTP_0 WEI__1 WBYTE VSS VDD RF1SH32x128_onWR1B
XI1_2 D0_0 D1_0 WBYTE VSS VDD RF1SH32x128_onFLCWRM1
.ENDS RF1SH32x128_onMUX1WR4BW_M
****
.SUBCKT RF1SH32x128_onFLCWRR1 D0 D1 D2 D3 STUBWEI WBYTE VSS VDD
** RF1SH32x128_onFLCWRR1: 5 flat devices **
d1 VSS D0 DN 0.2116P 1.84U
d2 VSS D1 DN 0.2116P 1.84U
d3 VSS D2 DN 0.2116P 1.84U
d4 VSS D3 DN 0.2116P 1.84U
d5 VSS WBYTE DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCWRR1
****
.SUBCKT RF1SH32x128_onMUX1WR4BW_R BL0 BL0_ BL0_0 BL0__0 BL1 BL1_0 BL_ BL__0 D0
+  D1 D2 D3 GTP GTP_0 STUBWEI WBYTE VSS VDD
** RF1SH32x128_onMUX1WR4BW_R: 121 flat devices **
XI0_0 BL0 BL0_ BL1 BL_ D1 GTP WEI_ VSS VDD RF1SH32x128_onWR1T
XI0_1 BL0 BL0_ D1 D0 GTP_0 WEI_ WBYTE VSS VDD RF1SH32x128_onWR1B
XI0_2 D0 D1 D2 D3 STUBWEI WBYTE VSS VDD RF1SH32x128_onFLCWRR1
XI1_0 BL0_0 BL0__0 BL1_0 BL__0 D2 GTP WEI__1 VSS VDD RF1SH32x128_onWR1T
XI1_1 BL0_0 BL0__0 D2 D3 GTP_0 WEI__1 WBYTE VSS VDD RF1SH32x128_onWR1B
.ENDS RF1SH32x128_onMUX1WR4BW_R
****
.SUBCKT RF1SH32x128_onFCWR1 GTPB GTPT VSS VDD
** RF1SH32x128_onFCWR1: 2 flat devices **
d1 VSS GTPT DN 0.2116P 1.84U
d2 VSS GTPB DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFCWR1
****
.SUBCKT RF1SH32x128_onFCWR1XL GTPB GTPT VSS VDD
** RF1SH32x128_onFCWR1XL: 2 flat devices **
XI1 GTPB GTPT VSS VDD RF1SH32x128_onFCWR1
.ENDS RF1SH32x128_onFCWR1XL
****
.SUBCKT RF1SH32x128_onMUX1WRWING_L BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4
+  BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14
+  BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23
+  BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL1 BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13
+  BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23
+  BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL_ BL__0 BL__1 BL__2
+  BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23
+  BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D0 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D1 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6
+  D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19
+  D1_20 D1_21 D1_22 D2 D2_0 D2_1 D2_2 D2_3 D2_4 D2_5 D2_6 D3 D3_0 D3_1 D3_2
+  D3_3 D3_4 D3_5 D3_6 GTP GTP_0 WBYTE WBYTE_0 WBYTE_1 WBYTE_2 WBYTE_3 WBYTE_4
+  WBYTE_5 WBYTE_6 VSS VDD
** RF1SH32x128_onMUX1WRWING_L: 1930 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_0 BL_ BL__0 D0 D0_0 D1 D1_0 GTP GTP_0 WBYTE
+  VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI1 BL0_1 BL0__1 BL0_2 BL0__2 BL1_1 BL1_2 BL__1 BL__2 D0_1 D1_1 D2 D3 GTP
+  GTP_0 WBYTE_0 WBYTE VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI10 BL0_15 BL0__15 BL0_16 BL0__16 BL1_15 BL1_16 BL__15 BL__16 D0_11 D0_12
+  D1_11 D1_12 GTP GTP_0 WBYTE_3 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI11 BL0_17 BL0__17 BL0_18 BL0__18 BL1_17 BL1_18 BL__17 BL__18 D0_13 D1_13
+  D2_3 D3_3 GTP GTP_0 WBYTE_4 WBYTE_3 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI12 BL0_19 BL0__19 BL0_20 BL0__20 BL1_19 BL1_20 BL__19 BL__20 D0_14 D0_15
+  D1_14 D1_15 GTP GTP_0 WBYTE_4 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI13 BL0_21 BL0__21 BL0_22 BL0__22 BL1_21 BL1_22 BL__21 BL__22 D0_16 D1_16
+  D2_4 D3_4 GTP GTP_0 WBYTE_5 WBYTE_4 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI15 BL0_23 BL0__23 BL0_24 BL0__24 BL1_23 BL1_24 BL__23 BL__24 D0_17 D0_18
+  D1_17 D1_18 GTP GTP_0 WBYTE_5 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI16 BL0_25 BL0__25 BL0_26 BL0__26 BL1_25 BL1_26 BL__25 BL__26 D0_19 D1_19
+  D2_5 D3_5 GTP GTP_0 WBYTE_6 WBYTE_5 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI17 BL0_27 BL0__27 BL0_28 BL0__28 BL1_27 BL1_28 BL__27 BL__28 D0_20 D0_21
+  D1_20 D1_21 GTP GTP_0 WBYTE_6 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI18 BL0_29 BL0__29 BL0_30 BL0__30 BL1_29 BL1_30 BL__29 BL__30 D0_22 D1_22
+  D2_6 D3_6 GTP GTP_0 VSS WBYTE_6 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI19 GTP_0 GTP VSS VDD RF1SH32x128_onFCWR1XL
XI2 BL0_3 BL0__3 BL0_4 BL0__4 BL1_3 BL1_4 BL__3 BL__4 D0_2 D0_3 D1_2 D1_3 GTP
+  GTP_0 WBYTE_0 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI3 BL0_5 BL0__5 BL0_6 BL0__6 BL1_5 BL1_6 BL__5 BL__6 D0_4 D1_4 D2_0 D3_0 GTP
+  GTP_0 WBYTE_1 WBYTE_0 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI5 BL0_7 BL0__7 BL0_8 BL0__8 BL1_7 BL1_8 BL__7 BL__8 D0_5 D0_6 D1_5 D1_6 GTP
+  GTP_0 WBYTE_1 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI6 BL0_9 BL0__9 BL0_10 BL0__10 BL1_9 BL1_10 BL__9 BL__10 D0_7 D1_7 D2_1 D3_1
+  GTP GTP_0 WBYTE_2 WBYTE_1 VSS VDD RF1SH32x128_onMUX1WR4BW_R
XI7 BL0_11 BL0__11 BL0_12 BL0__12 BL1_11 BL1_12 BL__11 BL__12 D0_8 D0_9 D1_8
+  D1_9 GTP GTP_0 WBYTE_2 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI8 BL0_13 BL0__13 BL0_14 BL0__14 BL1_13 BL1_14 BL__13 BL__14 D0_10 D1_10 D2_2
+  D3_2 GTP GTP_0 WBYTE_3 WBYTE_2 VSS VDD RF1SH32x128_onMUX1WR4BW_R
.ENDS RF1SH32x128_onMUX1WRWING_L
****
.SUBCKT RF1SH32x128_onCTRLWR1 GTP MBL MBL_ WEI WEN VSS VDD
** RF1SH32x128_onCTRLWR1: 4 flat devices **
m1 WEI N6 VDD VDD P L=0.13U W=5.49U
m2 WEI N6 VSS VSS N L=0.13U W=3.51U
m3 N6 WEN VDD VDD P L=0.13U W=2.01U
m4 N6 WEN VSS VSS N L=0.13U W=1.29U
.ENDS RF1SH32x128_onCTRLWR1
****
.SUBCKT RF1SH32x128_onMUX1TOPCTRL GTP MBL MBL_ WEI VSS VDD
** RF1SH32x128_onMUX1TOPCTRL: 4 flat devices **
XI0 GTP MBL MBL_ WEI_0 VSS VSS VDD RF1SH32x128_onCTRLWR1
.ENDS RF1SH32x128_onMUX1TOPCTRL
****
.SUBCKT RF1SH32x128_onFLCWRL1 D0 D1 D2 D3 STUBWEI WBYTE VSS VDD
** RF1SH32x128_onFLCWRL1: 5 flat devices **
d1 VSS D0 DN 0.2116P 1.84U
d2 VSS D1 DN 0.2116P 1.84U
d3 VSS D2 DN 0.2116P 1.84U
d4 VSS D3 DN 0.2116P 1.84U
d5 VSS WBYTE DN 0.2116P 1.84U
.ENDS RF1SH32x128_onFLCWRL1
****
.SUBCKT RF1SH32x128_onMUX1WR4BW_L BL0 BL0_ BL0_0 BL0__0 BL1 BL1_0 BL_ BL__0 D0
+  D1 D2 D3 GTP GTP_0 STUBWEI WBYTE VSS VDD
** RF1SH32x128_onMUX1WR4BW_L: 121 flat devices **
XI0_0 BL0 BL0_ BL1 BL_ D1 GTP WEI_ VSS VDD RF1SH32x128_onWR1T
XI0_1 BL0 BL0_ D1 D0 GTP_0 WEI_ WBYTE VSS VDD RF1SH32x128_onWR1B
XI0_2 D0 D1 D2 D3 STUBWEI WBYTE VSS VDD RF1SH32x128_onFLCWRL1
XI1_0 BL0_0 BL0__0 BL1_0 BL__0 D2 GTP WEI__1 VSS VDD RF1SH32x128_onWR1T
XI1_1 BL0_0 BL0__0 D2 D3 GTP_0 WEI__1 WBYTE VSS VDD RF1SH32x128_onWR1B
.ENDS RF1SH32x128_onMUX1WR4BW_L
****
.SUBCKT RF1SH32x128_onFCWR1XR GTPB GTPT WE_ VSS VDD
** RF1SH32x128_onFCWR1XR: 2 flat devices **
XI1 GTPB GTPT VSS VDD RF1SH32x128_onFCWR1
.ENDS RF1SH32x128_onFCWR1XR
****
.SUBCKT RF1SH32x128_onMUX1WRWING_R BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15
+  BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25
+  BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4
+  BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14
+  BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23
+  BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL1 BL1_0 BL1_1
+  BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13
+  BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23
+  BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL_ BL__0 BL__1 BL__2
+  BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23
+  BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30 D0 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D1 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6
+  D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19
+  D1_20 D1_21 D1_22 D2 D2_0 D2_1 D2_2 D2_3 D2_4 D2_5 D2_6 D3 D3_0 D3_1 D3_2
+  D3_3 D3_4 D3_5 D3_6 GTP GTP_0 STUBWEI WBYTE WBYTE_0 WBYTE_1 WBYTE_2 WBYTE_3
+  WBYTE_4 WBYTE_5 WBYTE_6 VSS VDD
** RF1SH32x128_onMUX1WRWING_R: 1930 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_0 BL_ BL__0 D0 D1 D2 D3 GTP GTP_0 STUBWEI
+  WBYTE VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI1 BL0_1 BL0__1 BL0_2 BL0__2 BL1_1 BL1_2 BL__1 BL__2 D0_0 D0_1 D1_0 D1_1 GTP
+  GTP_0 WBYTE VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI10 BL0_15 BL0__15 BL0_16 BL0__16 BL1_15 BL1_16 BL__15 BL__16 D0_11 D1_11
+  D2_3 D3_3 GTP GTP_0 WBYTE_2 WBYTE_3 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI11 BL0_17 BL0__17 BL0_18 BL0__18 BL1_17 BL1_18 BL__17 BL__18 D0_12 D0_13
+  D1_12 D1_13 GTP GTP_0 WBYTE_3 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI12 BL0_19 BL0__19 BL0_20 BL0__20 BL1_19 BL1_20 BL__19 BL__20 D0_14 D1_14
+  D2_4 D3_4 GTP GTP_0 WBYTE_3 WBYTE_4 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI13 BL0_21 BL0__21 BL0_22 BL0__22 BL1_21 BL1_22 BL__21 BL__22 D0_15 D0_16
+  D1_15 D1_16 GTP GTP_0 WBYTE_4 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI15 BL0_23 BL0__23 BL0_24 BL0__24 BL1_23 BL1_24 BL__23 BL__24 D0_17 D1_17
+  D2_5 D3_5 GTP GTP_0 WBYTE_4 WBYTE_5 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI16 BL0_25 BL0__25 BL0_26 BL0__26 BL1_25 BL1_26 BL__25 BL__26 D0_18 D0_19
+  D1_18 D1_19 GTP GTP_0 WBYTE_5 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI17 BL0_27 BL0__27 BL0_28 BL0__28 BL1_27 BL1_28 BL__27 BL__28 D0_20 D1_20
+  D2_6 D3_6 GTP GTP_0 WBYTE_5 WBYTE_6 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI18 BL0_29 BL0__29 BL0_30 BL0__30 BL1_29 BL1_30 BL__29 BL__30 D0_21 D0_22
+  D1_21 D1_22 GTP GTP_0 WBYTE_6 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI19 GTP_0 GTP WBYTE_6 VSS VDD RF1SH32x128_onFCWR1XR
XI2 BL0_3 BL0__3 BL0_4 BL0__4 BL1_3 BL1_4 BL__3 BL__4 D0_2 D1_2 D2_0 D3_0 GTP
+  GTP_0 WBYTE WBYTE_0 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI3 BL0_5 BL0__5 BL0_6 BL0__6 BL1_5 BL1_6 BL__5 BL__6 D0_3 D0_4 D1_3 D1_4 GTP
+  GTP_0 WBYTE_0 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI5 BL0_7 BL0__7 BL0_8 BL0__8 BL1_7 BL1_8 BL__7 BL__8 D0_5 D1_5 D2_1 D3_1 GTP
+  GTP_0 WBYTE_0 WBYTE_1 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI6 BL0_9 BL0__9 BL0_10 BL0__10 BL1_9 BL1_10 BL__9 BL__10 D0_6 D0_7 D1_6 D1_7
+  GTP GTP_0 WBYTE_1 VSS VDD RF1SH32x128_onMUX1WR4BW_M
XI7 BL0_11 BL0__11 BL0_12 BL0__12 BL1_11 BL1_12 BL__11 BL__12 D0_8 D1_8 D2_2
+  D3_2 GTP GTP_0 WBYTE_1 WBYTE_2 VSS VDD RF1SH32x128_onMUX1WR4BW_L
XI8 BL0_13 BL0__13 BL0_14 BL0__14 BL1_13 BL1_14 BL__13 BL__14 D0_9 D0_10 D1_9
+  D1_10 GTP GTP_0 WBYTE_2 VSS VDD RF1SH32x128_onMUX1WR4BW_M
.ENDS RF1SH32x128_onMUX1WRWING_R
****
.SUBCKT RF1SH32x128_onMUX1TOP BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16
+  BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26
+  BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36
+  BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46
+  BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49
+  BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58
+  BL0__59 BL0__60 BL0__61 BL0__62 BL1 BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5
+  BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1_16
+  BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25 BL1_26
+  BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32 BL1_33 BL1_34 BL1_35 BL1_36
+  BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1_42 BL1_43 BL1_44 BL1_45 BL1_46
+  BL1_47 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52 BL1_53 BL1_54 BL1_55 BL1_56
+  BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62 BL_ BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15
+  BL__16 BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35
+  BL__36 BL__37 BL__38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45
+  BL__46 BL__47 BL__48 BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55
+  BL__56 BL__57 BL__58 BL__59 BL__60 BL__61 BL__62 D0 D0_0 D0_1 D0_2 D0_3
+  D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28
+  D0_29 D0_30 D0_31 D0_32 D0_33 D0_34 D0_35 D0_36 D0_37 D0_38 D0_39 D0_40
+  D0_41 D0_42 D0_43 D0_44 D0_45 D0_46 D1 D1_0 D1_1 D1_2 D1_3 D1_4 D1_5 D1_6
+  D1_7 D1_8 D1_9 D1_10 D1_11 D1_12 D1_13 D1_14 D1_15 D1_16 D1_17 D1_18 D1_19
+  D1_20 D1_21 D1_22 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31
+  D1_32 D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43
+  D1_44 D1_45 D1_46 D2 D2_0 D2_1 D2_2 D2_3 D2_4 D2_5 D2_6 D2_7 D2_8 D2_9
+  D2_10 D2_11 D2_12 D2_13 D2_14 D3 D3_0 D3_1 D3_2 D3_3 D3_4 D3_5 D3_6 D3_7
+  D3_8 D3_9 D3_10 D3_11 D3_12 D3_13 D3_14 GTP MBL MBL_ WBYTE WBYTE_0 WBYTE_1
+  WBYTE_2 WBYTE_3 WBYTE_4 WBYTE_5 WBYTE_6 WBYTE_7 WBYTE_8 WBYTE_9 WBYTE_10
+  WBYTE_11 WBYTE_12 WBYTE_13 WBYTE_14 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 VSS VDD
** RF1SH32x128_onMUX1TOP: 3864 flat devices **
XI0 BL0_30 BL0__30 BL0_29 BL0_28 BL0_27 BL0_26 BL0_25 BL0_24 BL0_23 BL0_22
+  BL0_21 BL0_20 BL0_19 BL0_18 BL0_17 BL0_16 BL0_15 BL0_14 BL0_13 BL0_12
+  BL0_11 BL0_10 BL0_9 BL0_8 BL0_7 BL0_6 BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0
+  BL0 BL0__29 BL0__28 BL0__27 BL0__26 BL0__25 BL0__24 BL0__23 BL0__22 BL0__21
+  BL0__20 BL0__19 BL0__18 BL0__17 BL0__16 BL0__15 BL0__14 BL0__13 BL0__12
+  BL0__11 BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4 BL0__3 BL0__2
+  BL0__1 BL0__0 BL0_ BL1_30 BL1_29 BL1_28 BL1_27 BL1_26 BL1_25 BL1_24 BL1_23
+  BL1_22 BL1_21 BL1_20 BL1_19 BL1_18 BL1_17 BL1_16 BL1_15 BL1_14 BL1_13
+  BL1_12 BL1_11 BL1_10 BL1_9 BL1_8 BL1_7 BL1_6 BL1_5 BL1_4 BL1_3 BL1_2 BL1_1
+  BL1_0 BL1 BL__30 BL__29 BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 BL__22
+  BL__21 BL__20 BL__19 BL__18 BL__17 BL__16 BL__15 BL__14 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 BL__6 BL__5 BL__4 BL__3 BL__2 BL__1 BL__0
+  BL_ D0_22 D0_21 D0_20 D0_19 D0_18 D0_17 D0_16 D0_15 D0_14 D0_13 D0_12 D0_11
+  D0_10 D0_9 D0_8 D0_7 D0_6 D0_5 D0_4 D0_3 D0_2 D0_1 D0_0 D0 D1_22 D1_21
+  D1_20 D1_19 D1_18 D1_17 D1_16 D1_15 D1_14 D1_13 D1_12 D1_11 D1_10 D1_9 D1_8
+  D1_7 D1_6 D1_5 D1_4 D1_3 D1_2 D1_1 D1_0 D1 D2_6 D2_5 D2_4 D2_3 D2_2 D2_1
+  D2_0 D2 D3_6 D3_5 D3_4 D3_3 D3_2 D3_1 D3_0 D3 GTP GTP WBYTE_6 WBYTE_5
+  WBYTE_4 WBYTE_3 WBYTE_2 WBYTE_1 WBYTE_0 WBYTE VSS VDD
+  RF1SH32x128_onMUX1WRWING_L
XI2 GTP MBL MBL_ WBYTE_6 VSS VDD RF1SH32x128_onMUX1TOPCTRL
XI3 BL0_31 BL0__31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37 BL0_38 BL0_39
+  BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47 BL0_48 BL0_49
+  BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57 BL0_58 BL0_59
+  BL0_60 BL0_61 BL0_62 BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37
+  BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46
+  BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55
+  BL0__56 BL0__57 BL0__58 BL0__59 BL0__60 BL0__61 BL0__62 BL1_31 BL1_32
+  BL1_33 BL1_34 BL1_35 BL1_36 BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1_42
+  BL1_43 BL1_44 BL1_45 BL1_46 BL1_47 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52
+  BL1_53 BL1_54 BL1_55 BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 D0_29 D0_30 D0_31 D0_32
+  D0_33 D0_34 D0_35 D0_36 D0_37 D0_38 D0_39 D0_40 D0_41 D0_42 D0_43 D0_44
+  D0_45 D0_46 D1_23 D1_24 D1_25 D1_26 D1_27 D1_28 D1_29 D1_30 D1_31 D1_32
+  D1_33 D1_34 D1_35 D1_36 D1_37 D1_38 D1_39 D1_40 D1_41 D1_42 D1_43 D1_44
+  D1_45 D1_46 D2_7 D2_8 D2_9 D2_10 D2_11 D2_12 D2_13 D2_14 D3_7 D3_8 D3_9
+  D3_10 D3_11 D3_12 D3_13 D3_14 GTP GTP WBYTE_6 WBYTE_7 WBYTE_8 WBYTE_9
+  WBYTE_10 WBYTE_11 WBYTE_12 WBYTE_13 WBYTE_14 VSS VDD
+  RF1SH32x128_onMUX1WRWING_R
.ENDS RF1SH32x128_onMUX1TOP
****
.SUBCKT RF1SH32x128_on A[0] A[1] A[2] A[3] A[4] CEN CLK D[0] D[1] D[2] D[3]
+  D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16]
+  D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28]
+  D[29] D[30] D[31] D[32] D[33] D[34] D[35] D[36] D[37] D[38] D[39] D[40]
+  D[41] D[42] D[43] D[44] D[45] D[46] D[47] D[48] D[49] D[50] D[51] D[52]
+  D[53] D[54] D[55] D[56] D[57] D[58] D[59] D[60] D[61] D[62] D[63] D[64]
+  D[65] D[66] D[67] D[68] D[69] D[70] D[71] D[72] D[73] D[74] D[75] D[76]
+  D[77] D[78] D[79] D[80] D[81] D[82] D[83] D[84] D[85] D[86] D[87] D[88]
+  D[89] D[90] D[91] D[92] D[93] D[94] D[95] D[96] D[97] D[98] D[99] D[100]
+  D[101] D[102] D[103] D[104] D[105] D[106] D[107] D[108] D[109] D[110]
+  D[111] D[112] D[113] D[114] D[115] D[116] D[117] D[118] D[119] D[120]
+  D[121] D[122] D[123] D[124] D[125] D[126] D[127] Q[0] Q[1] Q[2] Q[3] Q[4]
+  Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17]
+  Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29]
+  Q[30] Q[31] Q[32] Q[33] Q[34] Q[35] Q[36] Q[37] Q[38] Q[39] Q[40] Q[41]
+  Q[42] Q[43] Q[44] Q[45] Q[46] Q[47] Q[48] Q[49] Q[50] Q[51] Q[52] Q[53]
+  Q[54] Q[55] Q[56] Q[57] Q[58] Q[59] Q[60] Q[61] Q[62] Q[63] Q[64] Q[65]
+  Q[66] Q[67] Q[68] Q[69] Q[70] Q[71] Q[72] Q[73] Q[74] Q[75] Q[76] Q[77]
+  Q[78] Q[79] Q[80] Q[81] Q[82] Q[83] Q[84] Q[85] Q[86] Q[87] Q[88] Q[89]
+  Q[90] Q[91] Q[92] Q[93] Q[94] Q[95] Q[96] Q[97] Q[98] Q[99] Q[100] Q[101]
+  Q[102] Q[103] Q[104] Q[105] Q[106] Q[107] Q[108] Q[109] Q[110] Q[111]
+  Q[112] Q[113] Q[114] Q[115] Q[116] Q[117] Q[118] Q[119] Q[120] Q[121]
+  Q[122] Q[123] Q[124] Q[125] Q[126] Q[127] WEN[0] WEN[1] WEN[2] WEN[3]
+  WEN[4] WEN[5] WEN[6] WEN[7] WEN[8] WEN[9] WEN[10] WEN[11] WEN[12] WEN[13]
+  WEN[14] WEN[15] VSS VDD
** RF1SH32x128_on: 34912 flat devices **
XI0 A[4] A[2] A[0] A[3] A[1] BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16
+  BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26
+  BL0_27 BL0_28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36
+  BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46
+  BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0_60 BL0_61 BL0_62 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13
+  BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22
+  BL0__23 BL0__24 BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 BL0__31
+  BL0__32 BL0__33 BL0__34 BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40
+  BL0__41 BL0__42 BL0__43 BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49
+  BL0__50 BL0__51 BL0__52 BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58
+  BL0__59 BL0__60 BL0__61 BL0__62 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15
+  BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25
+  BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31 BL1_32 BL1_33 BL1_34 BL1_35
+  BL1_36 BL1_37 BL1_38 BL1_39 BL1_40 BL1_41 BL1_42 BL1_43 BL1_44 BL1_45
+  BL1_46 BL1_47 BL1_48 BL1_49 BL1_50 BL1_51 BL1_52 BL1_53 BL1_54 BL1_55
+  BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61 BL1_62 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21
+  BL1__22 BL1__23 BL1__24 BL1__25 BL1__26 BL1__27 BL1__28 BL1__29 BL1__30
+  BL1__31 BL1__32 BL1__33 BL1__34 BL1__35 BL1__36 BL1__37 BL1__38 BL1__39
+  BL1__40 BL1__41 BL1__42 BL1__43 BL1__44 BL1__45 BL1__46 BL1__47 BL1__48
+  BL1__49 BL1__50 BL1__51 BL1__52 BL1__53 BL1__54 BL1__55 BL1__56 BL1__57
+  BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 CEN CLK GTP MBL MBL_ Q[0] Q[3] Q[4]
+  Q[7] Q[8] Q[11] Q[12] Q[15] Q[16] Q[19] Q[20] Q[23] Q[24] Q[27] Q[28] Q[31]
+  Q[32] Q[35] Q[36] Q[39] Q[40] Q[43] Q[44] Q[47] Q[48] Q[51] Q[52] Q[55]
+  Q[56] Q[59] Q[60] Q[63] Q[64] Q[67] Q[68] Q[71] Q[72] Q[75] Q[76] Q[79]
+  Q[80] Q[83] Q[84] Q[87] Q[88] Q[91] Q[92] Q[95] Q[96] Q[99] Q[100] Q[103]
+  Q[104] Q[107] Q[108] Q[111] Q[112] Q[115] Q[116] Q[119] Q[120] Q[123]
+  Q[124] Q[127] Q[1] Q[2] Q[5] Q[6] Q[9] Q[10] Q[13] Q[14] Q[17] Q[18] Q[21]
+  Q[22] Q[25] Q[26] Q[29] Q[30] Q[33] Q[34] Q[37] Q[38] Q[41] Q[42] Q[45]
+  Q[46] Q[49] Q[50] Q[53] Q[54] Q[57] Q[58] Q[61] Q[62] Q[65] Q[66] Q[69]
+  Q[70] Q[73] Q[74] Q[77] Q[78] Q[81] Q[82] Q[85] Q[86] Q[89] Q[90] Q[93]
+  Q[94] Q[97] Q[98] Q[101] Q[102] Q[105] Q[106] Q[109] Q[110] Q[113] Q[114]
+  Q[117] Q[118] Q[121] Q[122] Q[125] Q[126] VSS XP0 XP1 XPA0 XPA0_0 XPA1
+  XPA1_0 XPA2 XPA2_0 XPA3 XPA3_0 VSS VDD RF1SH32x128_onMUX1BOT
XI1 BL0 BL0_ BL1_ BL1_0 BL0__0 BL0_1 BL1__1 BL1_2 BL0__2 BL0_3 BL1__3 BL1_4
+  BL0__4 BL0_5 BL1__5 BL1_6 BL0__6 BL0_7 BL1__7 BL1_8 BL0__8 BL0_9 BL1__9
+  BL1_10 BL0__10 BL0_11 BL1__11 BL1_12 BL0__12 BL0_13 BL1__13 BL1_14 BL0__14
+  BL0_15 BL1__15 BL1_16 BL0__16 BL0_17 BL1__17 BL1_18 BL0__18 BL0_19 BL1__19
+  BL1_20 BL0__20 BL0_21 BL1__21 BL1_22 BL0__22 BL0_23 BL1__23 BL1_24 BL0__24
+  BL0_25 BL1__25 BL1_26 BL0__26 BL0_27 BL1__27 BL1_28 BL0__28 BL0_29 BL1__29
+  BL1_30 BL0__30 BL0__31 BL1_31 BL1__32 BL0_32 BL0__33 BL1_33 BL1__34 BL0_34
+  BL0__35 BL1_35 BL1__36 BL0_36 BL0__37 BL1_37 BL1__38 BL0_38 BL0__39 BL1_39
+  BL1__40 BL0_40 BL0__41 BL1_41 BL1__42 BL0_42 BL0__43 BL1_43 BL1__44 BL0_44
+  BL0__45 BL1_45 BL1__46 BL0_46 BL0__47 BL1_47 BL1__48 BL0_48 BL0__49 BL1_49
+  BL1__50 BL0_50 BL0__51 BL1_51 BL1__52 BL0_52 BL0__53 BL1_53 BL1__54 BL0_54
+  BL0__55 BL1_55 BL1__56 BL0_56 BL0__57 BL1_57 BL1__58 BL0_58 BL0__59 BL1_59
+  BL1__60 BL0_60 BL0__61 BL1_61 BL1__62 BL0_62 BL1 BL1__0 BL0_0 BL0__1 BL1_1
+  BL1__2 BL0_2 BL0__3 BL1_3 BL1__4 BL0_4 BL0__5 BL1_5 BL1__6 BL0_6 BL0__7
+  BL1_7 BL1__8 BL0_8 BL0__9 BL1_9 BL1__10 BL0_10 BL0__11 BL1_11 BL1__12
+  BL0_12 BL0__13 BL1_13 BL1__14 BL0_14 BL0__15 BL1_15 BL1__16 BL0_16 BL0__17
+  BL1_17 BL1__18 BL0_18 BL0__19 BL1_19 BL1__20 BL0_20 BL0__21 BL1_21 BL1__22
+  BL0_22 BL0__23 BL1_23 BL1__24 BL0_24 BL0__25 BL1_25 BL1__26 BL0_26 BL0__27
+  BL1_27 BL1__28 BL0_28 BL0__29 BL1_29 BL1__30 BL0_30 BL0_31 BL1__31 BL1_32
+  BL0__32 BL0_33 BL1__33 BL1_34 BL0__34 BL0_35 BL1__35 BL1_36 BL0__36 BL0_37
+  BL1__37 BL1_38 BL0__38 BL0_39 BL1__39 BL1_40 BL0__40 BL0_41 BL1__41 BL1_42
+  BL0__42 BL0_43 BL1__43 BL1_44 BL0__44 BL0_45 BL1__45 BL1_46 BL0__46 BL0_47
+  BL1__47 BL1_48 BL0__48 BL0_49 BL1__49 BL1_50 BL0__50 BL0_51 BL1__51 BL1_52
+  BL0__52 BL0_53 BL1__53 BL1_54 BL0__54 BL0_55 BL1__55 BL1_56 BL0__56 BL0_57
+  BL1__57 BL1_58 BL0__58 BL0_59 BL1__59 BL1_60 BL0__60 BL0_61 BL1__61 BL1_62
+  BL0__62 XP1 VDD VDD GTP MBL MBL_ XP0 XPA2 XPA0 XPA0_0 XPA3 XPA1 XPA1_0
+  XPA2_0 XPA3_0 VSS VDD RF1SH32x128_onMID
XI2 BL0_ BL0 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8
+  BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16 BL0__17
+  BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26
+  BL0__27 BL0__28 BL0__29 BL0__30 BL0__31 BL0__32 BL0__33 BL0__34 BL0__35
+  BL0__36 BL0__37 BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43 BL0__44
+  BL0__45 BL0__46 BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52 BL0__53
+  BL0__54 BL0__55 BL0__56 BL0__57 BL0__58 BL0__59 BL0__60 BL0__61 BL0__62
+  BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11
+  BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21
+  BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27 BL0_28 BL0_29 BL0_30 BL0_31
+  BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37 BL0_38 BL0_39 BL0_40 BL0_41
+  BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47 BL0_48 BL0_49 BL0_50 BL0_51
+  BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57 BL0_58 BL0_59 BL0_60 BL0_61
+  BL0_62 BL1_ BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8
+  BL1__9 BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17
+  BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26
+  BL1__27 BL1__28 BL1__29 BL1__30 BL1__31 BL1__32 BL1__33 BL1__34 BL1__35
+  BL1__36 BL1__37 BL1__38 BL1__39 BL1__40 BL1__41 BL1__42 BL1__43 BL1__44
+  BL1__45 BL1__46 BL1__47 BL1__48 BL1__49 BL1__50 BL1__51 BL1__52 BL1__53
+  BL1__54 BL1__55 BL1__56 BL1__57 BL1__58 BL1__59 BL1__60 BL1__61 BL1__62 BL1
+  BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11
+  BL1_12 BL1_13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21
+  BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28 BL1_29 BL1_30 BL1_31
+  BL1_32 BL1_33 BL1_34 BL1_35 BL1_36 BL1_37 BL1_38 BL1_39 BL1_40 BL1_41
+  BL1_42 BL1_43 BL1_44 BL1_45 BL1_46 BL1_47 BL1_48 BL1_49 BL1_50 BL1_51
+  BL1_52 BL1_53 BL1_54 BL1_55 BL1_56 BL1_57 BL1_58 BL1_59 BL1_60 BL1_61
+  BL1_62 D[3] D[4] D[7] D[11] D[12] D[15] D[19] D[20] D[23] D[27] D[28] D[31]
+  D[35] D[36] D[39] D[43] D[44] D[47] D[51] D[52] D[55] D[59] D[60] D[63]
+  D[64] D[68] D[71] D[72] D[76] D[79] D[80] D[84] D[87] D[88] D[92] D[95]
+  D[96] D[100] D[103] D[104] D[108] D[111] D[112] D[116] D[119] D[120] D[124]
+  D[127] D[2] D[5] D[6] D[10] D[13] D[14] D[18] D[21] D[22] D[26] D[29] D[30]
+  D[34] D[37] D[38] D[42] D[45] D[46] D[50] D[53] D[54] D[58] D[61] D[62]
+  D[65] D[69] D[70] D[73] D[77] D[78] D[81] D[85] D[86] D[89] D[93] D[94]
+  D[97] D[101] D[102] D[105] D[109] D[110] D[113] D[117] D[118] D[121] D[125]
+  D[126] D[1] D[9] D[17] D[25] D[33] D[41] D[49] D[57] D[66] D[74] D[82]
+  D[90] D[98] D[106] D[114] D[122] D[0] D[8] D[16] D[24] D[32] D[40] D[48]
+  D[56] D[67] D[75] D[83] D[91] D[99] D[107] D[115] D[123] GTP MBL MBL_
+  WEN[0] WEN[1] WEN[2] WEN[3] WEN[4] WEN[5] WEN[6] WEN[7] WEN[8] WEN[9]
+  WEN[10] WEN[11] WEN[12] WEN[13] WEN[14] WEN[15] XP1 XPA3 XPA1 XP1 XP0 XPA2
+  XPA0 VDD VSS VDD RF1SH32x128_onMUX1TOP
.ENDS RF1SH32x128_on
