*
* Copyright 2006 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
*
* Generated by bif2cdl v3.3c
* Version: 2003Q4V1
* Name: RF-SP-HS Register File Generator|TSMC CL013G-FSG Process
* Comment:
* Configuration:  -instname RF1SH32x30 -words 32 -bits 30 -frequenc\
* Configuration: y 100 -ring_width 2 -mux 2 -drive 4 -write_mask of\
* Configuration: f -wp_size 8 -top_layer met6 -power_type rings -ho\
* Configuration: riz met3 -vert met2 -cust_comment "" -left_bus_del\
* Configuration: im "[" -right_bus_delim "]" -pwr_gnd_rename "VDD:V\
* Configuration: DD,GND:VSS" -prefix "" -pin_space 0.0 -name_case u\
* Configuration: pper -check_instname on -diodes on -inside_ring_ty\
* Configuration: pe GND
* Codefile:
*
*
** begin lvs.header
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RF1SH32x30FCWR2 GTP WE_ VSS VDD
** RF1SH32x30FCWR2: 1 flat devices **
d1 VSS GTP DN 0.2116P 1.84U
.ENDS RF1SH32x30FCWR2
****
.SUBCKT RF1SH32x30M24FCWRRIGHT GTP GTP_0 GTP_1 WE_ YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M24FCWRRIGHT: 1 flat devices **
XI0 GTP WE_ VSS VDD RF1SH32x30FCWR2
.ENDS RF1SH32x30M24FCWRRIGHT
****
.SUBCKT RF1SH32x30M24FCWRLEFT GTP GTP_0 GTP_1 WE_ YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M24FCWRLEFT: 1 flat devices **
XI0 GTP WE_ VSS VDD RF1SH32x30FCWR2
.ENDS RF1SH32x30M24FCWRLEFT
****
.SUBCKT RF1SH32x30FLCWRM2 D0 Q0 WBYTE VSS VDD
** RF1SH32x30FLCWRM2: 2 flat devices **
d1 VSS Q0 DN 0.2116P 1.84U
d2 VSS D0 DN 0.2116P 1.84U
.ENDS RF1SH32x30FLCWRM2
****
.SUBCKT RF1SH32x30WR2 D DW DW_ GTP Q WBYTE VSS VDD
** RF1SH32x30WR2: 44 flat devices **
m1 DW DWIN VDD VDD P L=0.13U W=0.82U
m10 N54 DWIN VDD VDD P L=0.13U W=0.3U
m11 DWPD N7 N53 VSS N L=0.13U W=0.3U
m12 N53 DWIN VSS VSS N L=0.13U W=0.3U
m13 DWPDB GTPND N56 VDD P L=0.13U W=0.3U
m14 N56 DWINB VDD VDD P L=0.13U W=0.3U
m15 DWPDB N7 N55 VSS N L=0.13U W=0.3U
m16 N55 DWINB VSS VSS N L=0.13U W=0.3U
m17 DWI DI VDD VDD P L=0.13U W=0.25U
m18 N57 DI VSS VSS N L=0.13U W=0.48U
m19 DWI N29 VDD VDD P L=0.13U W=0.25U
m2 DW DWIN VSS VSS N L=0.13U W=2.24U
m20 DWI N29 N57 VSS N L=0.13U W=0.48U
m21 DWIB DI_ VDD VDD P L=0.13U W=0.25U
m22 N58 DI_ VSS VSS N L=0.13U W=0.48U
m23 DWIB N29 VDD VDD P L=0.13U W=0.25U
m24 DWIB N29 N58 VSS N L=0.13U W=0.48U
m25 DWPD N7 DWI VDD P L=0.13U W=0.5U
m26 DWPDB N7 DWIB VDD P L=0.13U W=0.5U
m27 DWPD GTPND DWI VSS N L=0.13U W=0.32U
m28 DWPDB GTPND DWIB VSS N L=0.13U W=0.32U
m29 GTPND GTP VDD VDD P L=0.13U W=0.24U
m3 DW_ DWINB VDD VDD P L=0.13U W=0.82U
m30 GTPND GTP VSS VSS N L=0.13U W=0.15U
m31 DI_ DI VDD VDD P L=0.13U W=0.24U
m32 DI_ DI VSS VSS N L=0.13U W=0.15U
m33 N29 N38 VDD VDD P L=0.13U W=0.24U
m34 N29 N38 VSS VSS N L=0.13U W=0.15U
m35 DI N41 VDD VDD P L=0.13U W=0.24U
m36 DI N41 VSS VSS N L=0.13U W=0.15U
m37 N41 D VDD VDD P L=0.13U W=0.24U
m38 N41 D VSS VSS N L=0.13U W=0.15U
m39 N7 GTPND VDD VDD P L=0.13U W=0.36U
m4 DW_ DWINB VSS VSS N L=0.13U W=2.24U
m40 N7 GTPND VSS VSS N L=0.13U W=0.3U
m41 N38 N48 VDD VDD P L=0.13U W=0.24U
m42 N38 N48 VSS VSS N L=0.13U W=0.15U
m43 N48 WBYTE VDD VDD P L=0.13U W=0.24U
m44 N48 WBYTE VSS VSS N L=0.13U W=0.15U
m5 DWIN DWPD VDD VDD P L=0.13U W=0.68U
m6 DWIN DWPD VSS VSS N L=0.13U W=0.44U
m7 DWINB DWPDB VDD VDD P L=0.13U W=0.68U
m8 DWINB DWPDB VSS VSS N L=0.13U W=0.44U
m9 DWPD GTPND N54 VDD P L=0.13U W=0.3U
.ENDS RF1SH32x30WR2
****
.SUBCKT RF1SH32x30SA2 DR DR_ DW DW_ GLTWIST GRTWIST GTPSA_ GTPTOSA GTPTWIST Q
+  VSS VDD
** RF1SH32x30SA2: 33 flat devices **
m1 SD GTPSAINV DR VDD P L=0.13U W=0.8U
m10 N27 SD_ VDD VDD P L=0.13U W=0.5U
m11 N27 SD_ VSS VSS N L=0.13U W=0.15U
m12 QI SI VSS VSS N L=0.13U W=0.54U
m13 QI SI_ VDD VDD P L=0.13U W=0.97U
m14 DLATKEEP QI VDD VDD P L=0.13U W=0.15U
m15 DLATKEEP QI VSS VSS N L=0.13U W=0.15U
m16 QI DLATKEEP VDD VDD P L=0.26U W=0.15U
m17 QI DLATKEEP VSS VSS N L=0.26U W=0.15U
m18 Q QI VDD VDD P L=0.13U W=2.64U
m19 Q QI VSS VSS N L=0.13U W=1.68U
m2 DR_ GTPSAINV SD_ VDD P L=0.13U W=0.8U
m20 GTPSAINV GTPSA_ VDD VDD P L=0.13U W=0.49U
m21 GTPSAINV GTPSA_ VSS VSS N L=0.13U W=0.31U
m22 VDD GTPSA_ SRC VSS N L=0.13U W=0.2U
m23 SI_ N27 VDD VDD P L=0.13U W=0.24U
m24 SI_ N27 VSS VSS N L=0.13U W=0.55U
m25 N42 GTPTOSA VDD VDD P L=0.13U W=0.24U
m26 N42 GTPTOSA VSS VSS N L=0.13U W=0.15U
m27 N45 N42 VDD VDD P L=0.13U W=0.54U
m28 N45 N42 VSS VSS N L=0.13U W=0.35U
m29 SD_ N45 VDD VDD P L=0.13U W=0.81U
m3 SD SD_ VDD VDD P L=0.18U W=0.3U
m30 SD N45 VDD VDD P L=0.13U W=0.81U
m31 SD N45 SD_ VDD P L=0.13U W=0.81U
m32 SD_ VDD SD VDD P L=0.13U W=1.1U
m33 SD VSS SD_ VSS N L=0.13U W=2U
m4 SD_ SD VDD VDD P L=0.18U W=0.3U
m5 SRC GTPSAINV VSS VSS N L=0.13U W=1.34U
m6 SD SD_ SRC VSS N L=0.2U W=2U
m7 SD_ SD SRC VSS N L=0.2U W=2U
m8 SI SD VDD VDD P L=0.13U W=0.5U
m9 SI SD VSS VSS N L=0.13U W=0.15U
.ENDS RF1SH32x30SA2
****
.SUBCKT RF1SH32x30CD24 BL0 BL0_ BL1 BL1_ DR DRSA DRSA_ DR_ DW DWSA DWSA_ DW_
+  G0 GTP GTPTOSA H0 YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30CD24: 32 flat devices **
m1 BL0 YI0 VDD VDD P L=0.13U W=1.6U
m10 GTPIN0 YPBUF0 GTP VDD P L=0.13U W=0.23U
m11 GTPIN0 YI0 GTP VSS N L=0.13U W=0.23U
m12 BL0_ YI0 DW_ VSS N L=0.13U W=2.24U
m13 BL0 YI0 DW VSS N L=0.13U W=2.24U
m14 GTPIN0 YPBUF0 VSS VSS N L=0.13U W=0.19U
m15 BL1_ YI1 VDD VDD P L=0.13U W=1.6U
m16 BL1 YI1 VDD VDD P L=0.13U W=1.6U
m17 BL1_ YI1 BL1 VDD P L=0.13U W=1.6U
m18 BL1 YI1 DW VSS N L=0.13U W=2.24U
m19 BL1_ YI1 DW_ VSS N L=0.13U W=2.24U
m2 BL0_ YI0 VDD VDD P L=0.13U W=1.6U
m20 DR_ YIIN1 BL1_ VDD P L=0.13U W=0.72U
m21 DR YIIN1 BL1 VDD P L=0.13U W=0.72U
m22 YI1 YIIN1 VDD VDD P L=0.13U W=2.06U
m23 YI1 YIIN1 VSS VSS N L=0.13U W=0.94U
m24 YIIN1 GTPIN1 VDD VDD P L=0.13U W=1U
m25 YIIN1 GTPIN1 VSS VSS N L=0.13U W=0.64U
m26 GTPIN1 N26 VSS VSS N L=0.13U W=0.19U
m27 GTPIN1 N26 GTP VDD P L=0.13U W=0.23U
m28 GTPIN1 YI1 GTP VSS N L=0.13U W=0.23U
m29 N26 H0 VDD VDD P L=0.13U W=0.24U
m3 YI0 YIIN0 VDD VDD P L=0.13U W=2.06U
m30 N26 H0 VSS VSS N L=0.13U W=0.15U
m31 YPBUF0 G0 VDD VDD P L=0.13U W=0.24U
m32 YPBUF0 G0 VSS VSS N L=0.13U W=0.15U
m4 YI0 YIIN0 VSS VSS N L=0.13U W=0.94U
m5 YIIN0 GTPIN0 VDD VDD P L=0.13U W=1U
m6 YIIN0 GTPIN0 VSS VSS N L=0.13U W=0.64U
m7 BL0 YI0 BL0_ VDD P L=0.13U W=1.6U
m8 DR YIIN0 BL0 VDD P L=0.13U W=0.72U
m9 DR_ YIIN0 BL0_ VDD P L=0.13U W=0.72U
.ENDS RF1SH32x30CD24
****
.SUBCKT RF1SH32x30M2WRSACD_UP1R0 BL0 BL0_ BL1 BL1_ D GRTWIST GTP GTPSA_ GTP_0
+  Q WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2WRSACD_UP1R0: 109 flat devices **
XI0 D DW DW_ GTP Q WBYTE VSS VDD RF1SH32x30WR2
XI1 DR DR_ DW DW_ GRTWIST GRTWIST GTPSA_ GTP_0 GRTWIST Q VSS VDD RF1SH32x30SA2
XI2 BL0 BL0_ BL1 BL1_ DR DR DR_ DR_ DW DW DW_ DW_ YP1 GTP_0 GTP_0 YP0 YP0 YP1
+  YP2 YP3 VSS VDD RF1SH32x30CD24
.ENDS RF1SH32x30M2WRSACD_UP1R0
****
.SUBCKT RF1SH32x30M2WRSACD_DN1MY BL0 BL0_ BL1 BL1_ D GRTWIST GTP GTPSA_ GTP_0
+  Q WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2WRSACD_DN1MY: 109 flat devices **
XI0 D DW DW_ GTP Q WBYTE VSS VDD RF1SH32x30WR2
XI1 DR DR_ DW DW_ GRTWIST GRTWIST GTPSA_ GTP_0 GRTWIST Q VSS VDD RF1SH32x30SA2
XI2 BL0 BL0_ BL1 BL1_ DR DR DR_ DR_ DW DW DW_ DW_ YP0 GTP_0 GTP_0 YP1 YP0 YP1
+  YP2 YP3 VSS VDD RF1SH32x30CD24
.ENDS RF1SH32x30M2WRSACD_DN1MY
****
.SUBCKT RF1SH32x30M2BB2BW_DN_M10R0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0
+  D0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2BB2BW_DN_M10R0: 222 flat devices **
XI0_0 D0 Q0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI0_1 BL0 BL0_ BL1 BL1_ D0 GLTWIST GTP GTPSA_ GTP_0 Q0 WBYTE YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30M2WRSACD_UP1R0
XI1_0 D0_0 Q0_0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI1_1 BL0_0 BL0__0 BL1_0 BL1__0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0_0 WBYTE YP0
+  YP1 YP2 YP3 VSS VDD RF1SH32x30M2WRSACD_DN1MY
.ENDS RF1SH32x30M2BB2BW_DN_M10R0
****
.SUBCKT RF1SH32x30M2BB2BW_DN_M10MY BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0
+  D0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2BB2BW_DN_M10MY: 222 flat devices **
XI0_0 D0 Q0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI0_1 BL0 BL0_ BL1 BL1_ D0 GLTWIST GTP GTPSA_ GTP_0 Q0 WBYTE YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30M2WRSACD_UP1R0
XI1_0 D0_0 Q0_0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI1_1 BL0_0 BL0__0 BL1_0 BL1__0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0_0 WBYTE YP0
+  YP1 YP2 YP3 VSS VDD RF1SH32x30M2WRSACD_DN1MY
.ENDS RF1SH32x30M2BB2BW_DN_M10MY
****
.SUBCKT RF1SH32x30M2BOTWING_L BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0__0 BL0__1 BL0__2 BL0__3
+  BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL1 BL1_
+  BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11
+  BL1_12 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8
+  BL1__9 BL1__10 BL1__11 BL1__12 D0 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7
+  D0_8 D0_9 D0_10 D0_11 D0_12 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 Q0_1 Q0_2 Q0_3
+  Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 WBYTE YP0 YP1 YP2 YP3 VSS
+  VDD
** RF1SH32x30M2BOTWING_L: 1554 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0 D0 D0_0 GLTWIST GTP GTPSA_
+  GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD RF1SH32x30M2BB2BW_DN_M10R0
XI1 BL0_1 BL0__1 BL0_2 BL0__2 BL1_1 BL1__1 BL1_2 BL1__2 D0_1 D0_2 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_1 Q0_2 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10MY
XI2 BL0_3 BL0__3 BL0_4 BL0__4 BL1_3 BL1__3 BL1_4 BL1__4 D0_3 D0_4 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_3 Q0_4 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10R0
XI3 BL0_5 BL0__5 BL0_6 BL0__6 BL1_5 BL1__5 BL1_6 BL1__6 D0_5 D0_6 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_5 Q0_6 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10MY
XI5 BL0_7 BL0__7 BL0_8 BL0__8 BL1_7 BL1__7 BL1_8 BL1__8 D0_7 D0_8 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_7 Q0_8 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10R0
XI6 BL0_9 BL0__9 BL0_10 BL0__10 BL1_9 BL1__9 BL1_10 BL1__10 D0_9 D0_10 GLTWIST
+  GTP GTPSA_ GTP_0 Q0_9 Q0_10 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10MY
XI7 BL0_11 BL0__11 BL0_12 BL0__12 BL1_11 BL1__11 BL1_12 BL1__12 D0_11 D0_12
+  GLTWIST GTP GTPSA_ GTP_0 Q0_11 Q0_12 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_DN_M10R0
.ENDS RF1SH32x30M2BOTWING_L
****
.SUBCKT RF1SH32x30FLCIOL2 GTP GTPN GTPSA GTPSATW WEI_ YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30FLCIOL2: 6 flat devices **
d1 VSS GTPSA DN 0.2116P 1.84U
d2 VSS YP0 DN 0.2116P 1.84U
d3 VSS YP1 DN 0.2116P 1.84U
d4 VSS YP2 DN 0.2116P 1.84U
d5 VSS YP3 DN 0.2116P 1.84U
d6 VSS GTP DN 0.2116P 1.84U
.ENDS RF1SH32x30FLCIOL2
****
.SUBCKT RF1SH32x30FLCHXP224 A0 A1 GTP WEI VSS VDD
** RF1SH32x30FLCHXP224: 2 flat devices **
d1 VSS A1 DN 0.2116P 1.84U
d2 VSS A0 DN 0.2116P 1.84U
.ENDS RF1SH32x30FLCHXP224
****
.SUBCKT RF1SH32x30HXP24 AX0 AX1 GTP GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0 YP1 YP2
+  YP3 VSS VDD
** RF1SH32x30HXP24: 42 flat devices **
m1 N24 AX0 VDD VDD P L=0.13U W=1.55U
m10 N31 N24 VSS VSS N L=0.13U W=1.19U
m11 XPA0 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m12 XPA0 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m13 XPA1 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m14 XPA1 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m15 N36 IN1_ VSS VSS N L=0.13U W=2.22U
m16 VDD IN0 AP0-APND0 VDD P L=0.13U W=1.29U
m17 VDD IN1_ AP0-APND0 VDD P L=0.13U W=1.29U
m18 N36 IN0 AP0-APND0 VSS N L=0.13U W=1.65U
m19 VDD IN0_ AP0-AIND1 VDD P L=0.13U W=1.29U
m2 N24 AX0 VSS VSS N L=0.13U W=1.19U
m20 VDD IN1_ AP0-AIND1 VDD P L=0.13U W=1.29U
m21 N36 IN0_ AP0-AIND1 VSS N L=0.13U W=1.65U
m22 XPA3 AP1-AIND1 VDD VDD P L=0.13U W=5.07U
m23 XPA3 AP1-AIND1 VSS VSS N L=0.13U W=3.13U
m24 XPA2 AP1-APND0 VDD VDD P L=0.13U W=5.07U
m25 XPA2 AP1-APND0 VSS VSS N L=0.13U W=3.13U
m26 N43 IN1 VSS VSS N L=0.13U W=2.22U
m27 VDD IN0_ AP1-APND0 VDD P L=0.13U W=1.29U
m28 VDD IN1 AP1-APND0 VDD P L=0.13U W=1.29U
m29 N43 IN0_ AP1-APND0 VSS N L=0.13U W=1.65U
m3 IN0_ IN0 VDD VDD P L=0.13U W=0.7U
m30 VDD IN0 AP1-AIND1 VDD P L=0.13U W=1.29U
m31 VDD IN1 AP1-AIND1 VDD P L=0.13U W=1.29U
m32 N43 IN0 AP1-AIND1 VSS N L=0.13U W=1.65U
m33 N48 AX1 VDD VDD P L=0.13U W=1.55U
m34 N48 AX1 VSS VSS N L=0.13U W=1.19U
m35 IN1_ IN1 VDD VDD P L=0.13U W=0.7U
m36 IN1_ IN1 VSS VSS N L=0.13U W=0.3U
m37 IN1 IN1_ VDD VDD P L=0.13U W=0.7U
m38 IN1 IN1_ VSS VSS N L=0.13U W=0.3U
m39 IN1_ GTPN N48 VSS N L=0.13U W=1.19U
m4 IN0_ IN0 VSS VSS N L=0.13U W=0.3U
m40 IN1 GTPN N55 VSS N L=0.13U W=1.19U
m41 N55 N48 VDD VDD P L=0.13U W=1.19U
m42 N55 N48 VSS VSS N L=0.13U W=1.19U
m5 IN0 IN0_ VDD VDD P L=0.13U W=0.7U
m6 IN0 IN0_ VSS VSS N L=0.13U W=0.3U
m7 IN0_ GTPN N24 VSS N L=0.13U W=1.19U
m8 IN0 GTPN N31 VSS N L=0.13U W=1.19U
m9 N31 N24 VDD VDD P L=0.13U W=1.19U
.ENDS RF1SH32x30HXP24
****
.SUBCKT RF1SH32x30HXP24R AX0 AX1 GTP GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0 YP1
+  YP2 YP3 VSS VDD
** RF1SH32x30HXP24R: 42 flat devices **
m1 N25 AX0 VDD VDD P L=0.13U W=1.55U
m10 N32 N25 VSS VSS N L=0.13U W=1.19U
m11 XPA0 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m12 XPA0 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m13 XPA1 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m14 XPA1 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m15 N37 IN1_ VSS VSS N L=0.13U W=2.22U
m16 VDD IN0 AP0-APND0 VDD P L=0.13U W=1.29U
m17 VDD IN1_ AP0-APND0 VDD P L=0.13U W=1.29U
m18 N37 IN0 AP0-APND0 VSS N L=0.13U W=1.65U
m19 VDD IN0_ AP0-AIND1 VDD P L=0.13U W=1.29U
m2 N25 AX0 VSS VSS N L=0.13U W=1.19U
m20 VDD IN1_ AP0-AIND1 VDD P L=0.13U W=1.29U
m21 N37 IN0_ AP0-AIND1 VSS N L=0.13U W=1.65U
m22 XPA3 AP1-AIND1 VDD VDD P L=0.13U W=5.07U
m23 XPA3 AP1-AIND1 VSS VSS N L=0.13U W=3.13U
m24 XPA2 AP1-APND0 VDD VDD P L=0.13U W=5.07U
m25 XPA2 AP1-APND0 VSS VSS N L=0.13U W=3.13U
m26 N44 IN1 VSS VSS N L=0.13U W=2.22U
m27 VDD IN0_ AP1-APND0 VDD P L=0.13U W=1.29U
m28 VDD IN1 AP1-APND0 VDD P L=0.13U W=1.29U
m29 N44 IN0_ AP1-APND0 VSS N L=0.13U W=1.65U
m3 IN0_ IN0 VDD VDD P L=0.13U W=0.7U
m30 VDD IN0 AP1-AIND1 VDD P L=0.13U W=1.29U
m31 VDD IN1 AP1-AIND1 VDD P L=0.13U W=1.29U
m32 N44 IN0 AP1-AIND1 VSS N L=0.13U W=1.65U
m33 N49 AX1 VDD VDD P L=0.13U W=1.55U
m34 N49 AX1 VSS VSS N L=0.13U W=1.19U
m35 IN1_ IN1 VDD VDD P L=0.13U W=0.7U
m36 IN1_ IN1 VSS VSS N L=0.13U W=0.3U
m37 IN1 IN1_ VDD VDD P L=0.13U W=0.7U
m38 IN1 IN1_ VSS VSS N L=0.13U W=0.3U
m39 IN1_ GTPN N49 VSS N L=0.13U W=1.19U
m4 IN0_ IN0 VSS VSS N L=0.13U W=0.3U
m40 IN1 GTPN N56 VSS N L=0.13U W=1.19U
m41 N56 N49 VDD VDD P L=0.13U W=1.19U
m42 N56 N49 VSS VSS N L=0.13U W=1.19U
m5 IN0 IN0_ VDD VDD P L=0.13U W=0.7U
m6 IN0 IN0_ VSS VSS N L=0.13U W=0.3U
m7 IN0_ GTPN N25 VSS N L=0.13U W=1.19U
m8 IN0 GTPN N32 VSS N L=0.13U W=1.19U
m9 N32 N25 VDD VDD P L=0.13U W=1.19U
.ENDS RF1SH32x30HXP24R
****
.SUBCKT RF1SH32x30HXPS A0 A0_0 A1 A1_0 GTP GTPN GTPSA GTP_0 WEI XPA0 XPA0_0
+  XPA1 XPA1_0 XPA2 XPA2_0 XPA3 XPA3_0 YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30HXPS: 88 flat devices **
XI0_0 A0 A1 GTP WEI VSS VDD RF1SH32x30FLCHXP224
XI0_1 A0 A1 GTP_0 GTPN GTPSA XPA0 XPA1 XPA2 XPA3 YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30HXP24
XI1_0 A0_0 A1_0 GTP WEI VSS VDD RF1SH32x30FLCHXP224
XI1_1 A0_0 A1_0 GTP_0 GTPN GTPSA XPA0_0 XPA1_0 XPA2_0 XPA3_0 YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30HXP24R
.ENDS RF1SH32x30HXPS
****
.SUBCKT RF1SH32x30FLCHYP212 A0 GTP WEI VSS VDD
** RF1SH32x30FLCHYP212: 1 flat devices **
d1 VSS A0 DN 0.2116P 1.84U
.ENDS RF1SH32x30FLCHYP212
****
.SUBCKT RF1SH32x30HYP12 A0 AGTPN GTP GTPSA YP0 YP1 VSS VDD
** RF1SH32x30HYP12: 21 flat devices **
m1 YP1 AP0-AIND1 VDD VDD P L=0.13U W=5.07U
m10 VDD VDD AP0-AIND1 VDD P L=0.13U W=1.29U
m11 N16 IN0 AP0-AIND1 VSS N L=0.13U W=1.65U
m12 N21 A0 VDD VDD P L=0.13U W=1.55U
m13 N21 A0 VSS VSS N L=0.13U W=1.19U
m14 IN0_ IN0 VDD VDD P L=0.13U W=0.7U
m15 IN0_ IN0 VSS VSS N L=0.13U W=0.3U
m16 IN0 IN0_ VDD VDD P L=0.13U W=0.7U
m17 IN0 IN0_ VSS VSS N L=0.13U W=0.3U
m18 IN0_ AGTPN N21 VSS N L=0.13U W=1.19U
m19 IN0 AGTPN N28 VSS N L=0.13U W=1.19U
m2 YP1 AP0-AIND1 VSS VSS N L=0.13U W=3.13U
m20 N28 N21 VDD VDD P L=0.13U W=1.19U
m21 N28 N21 VSS VSS N L=0.13U W=1.19U
m3 YP0 AP0-APND0 VDD VDD P L=0.13U W=5.07U
m4 YP0 AP0-APND0 VSS VSS N L=0.13U W=3.13U
m5 N16 VDD VSS VSS N L=0.13U W=2.22U
m6 VDD IN0_ AP0-APND0 VDD P L=0.13U W=1.29U
m7 VDD VDD AP0-APND0 VDD P L=0.13U W=1.29U
m8 N16 IN0_ AP0-APND0 VSS N L=0.13U W=1.65U
m9 VDD IN0 AP0-AIND1 VDD P L=0.13U W=1.29U
.ENDS RF1SH32x30HYP12
****
.SUBCKT RF1SH32x30HYPS A0 AGTPN GTP GTPSA GTP_0 WEI YP0 YP1 VSS VDD
** RF1SH32x30HYPS: 22 flat devices **
XI0 A0 GTP WEI VSS VDD RF1SH32x30FLCHYP212
XI1 A0 AGTPN GTP_0 GTPSA YP0 YP1 VSS VDD RF1SH32x30HYP12
.ENDS RF1SH32x30HYPS
****
.SUBCKT RF1SH32x30FLCCTRL2NB CEN CLK STOV WEI WEN VSS VDD
** RF1SH32x30FLCCTRL2NB: 4 flat devices **
d1 VSS CEN DN 0.2116P 1.84U
d2 VSS CLK DN 0.2116P 1.84U
d3 VSS STOV DN 0.2116P 1.84U
d4 VSS WEN DN 0.2116P 1.84U
.ENDS RF1SH32x30FLCCTRL2NB
****
.SUBCKT RF1SH32x30CK2 CEN CLK DLY3 DLY5 GTP GTPN GTPSA GTPSATW MBL MBL_ STOV
+  WEI WEN YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30CK2: 73 flat devices **
m1 GTP GTPN VDD VDD P L=0.13U W=42.24U
m10 GTPN GTPSATW VDD VDD P L=0.13U W=15.48U
m11 CLKB RST GTPN VSS N L=0.13U W=14.8U
m12 CLKB CLK VDD VDD P L=0.13U W=7.44U
m13 CLKB CLK VSS VSS N L=0.13U W=14.8U
m14 RST N42 VDD VDD P L=0.13U W=2.32U
m15 RST N42 VSS VSS N L=0.13U W=1.5U
m16 N42 N45 VDD VDD P L=0.13U W=0.6U
m17 N42 N45 VSS VSS N L=0.13U W=0.39U
m18 N45 N48 VDD VDD P L=0.13U W=0.24U
m19 N45 N48 VSS VSS N L=0.13U W=0.15U
m2 GTP GTPN VSS VSS N L=0.13U W=27.04U
m20 N48 CLKB VDD VDD P L=0.13U W=0.15U
m21 N100 CLKB VSS VSS N L=0.13U W=0.31U
m22 N48 GTPSATW VDD VDD P L=0.13U W=0.15U
m23 N99 GTPSATW N100 VSS N L=0.13U W=0.31U
m24 N48 N51 VDD VDD P L=0.13U W=0.15U
m25 N98 N51 N99 VSS N L=0.13U W=0.31U
m26 N48 GTPN VDD VDD P L=0.13U W=0.15U
m27 N48 GTPN N98 VSS N L=0.13U W=0.31U
m28 N51 CEN VDD VDD P L=0.13U W=0.24U
m29 N51 CEN VSS VSS N L=0.13U W=0.15U
m3 MBL_ YI VDD VDD P L=0.13U W=1.59U
m30 YI YIIN0 VDD VDD P L=0.13U W=1.06U
m31 YI YIIN0 VSS VSS N L=0.13U W=0.68U
m32 YIIN0 GTP VDD VDD P L=0.13U W=0.71U
m33 YIIN0 GTP VSS VSS N L=0.13U W=0.46U
m34 GTPSA GTPSANINV VDD VDD P L=0.13U W=27.28U
m35 GTPSA GTPSANINV VSS VSS N L=0.13U W=16.36U
m36 GTPKEEPSA GTPSANINV VDD VDD P L=0.13U W=0.15U
m37 GTPKEEPSA GTPSANINV VSS VSS N L=0.13U W=0.15U
m38 GTPSANINV GTPKEEPSA VDD VDD P L=0.13U W=0.15U
m39 GTPSANINV GTPKEEPSA VSS VSS N L=0.13U W=0.15U
m4 MBL YI VDD VDD P L=0.13U W=1.59U
m40 GTPSANINV SARST N66 VSS N L=0.13U W=4.68U
m41 N66 N28 VSS VSS N L=0.13U W=4.68U
m42 N67 N28 VDD VDD P L=0.13U W=7.32U
m43 N67 SASET GTPSANINV VDD P L=0.13U W=7.32U
m44 SASET MBLINV VDD VDD P L=0.13U W=3.27U
m45 N101 MBLINV VSS VSS N L=0.13U W=4.18U
m46 SASET CLKSTOV VDD VDD P L=0.13U W=3.27U
m47 SASET CLKSTOV N101 VSS N L=0.13U W=4.18U
m48 N28 GTP VDD VDD P L=0.13U W=2.09U
m49 N28 GTP VSS VSS N L=0.13U W=3.43U
m5 MBL_ YI MBL VDD P L=0.13U W=1.59U
m50 SARST N73 VDD VDD P L=0.13U W=2.09U
m51 SARST N73 VSS VSS N L=0.13U W=1.34U
m52 N73 N76 VDD VDD P L=0.13U W=0.77U
m53 N73 N76 VSS VSS N L=0.13U W=0.49U
m54 N76 DLY3 VDD VDD P L=0.13U W=0.18U
m55 N76 DLY3 VSS VSS N L=0.13U W=0.18U
m56 DLY5 N81 VDD VDD P L=0.13U W=0.24U
m57 DLY5 N81 VSS VSS N L=0.13U W=0.15U
m58 N81 GTPSATW VDD VDD P L=0.13U W=0.15U
m59 N81 GTPSATW VSS VSS N L=0.13U W=0.15U
m6 GTPKEEP GTPN VDD VDD P L=0.13U W=0.15U
m60 MBLINV MBL VDD VDD P L=0.13U W=1.68U
m61 MBLINV MBL VSS VSS N L=0.13U W=1.08U
m62 CLKSTOV CLK VDD VDD P L=0.13U W=1.66U
m63 N102 CLK VSS VSS N L=0.13U W=2.13U
m64 CLKSTOV STOV VDD VDD P L=0.13U W=1.66U
m65 CLKSTOV STOV N102 VSS N L=0.13U W=2.13U
m66 WEI N90 VDD VDD P L=0.13U W=5.49U
m67 WEI N90 VSS VSS N L=0.13U W=3.51U
m68 N90 WEN VDD VDD P L=0.13U W=2.01U
m69 N90 WEN VSS VSS N L=0.13U W=1.29U
m7 GTPKEEP GTPN VSS VSS N L=0.13U W=0.15U
m70 GTPSANINV SARST N95 VSS N L=0.13U W=4.68U
m71 N95 N28 VSS VSS N L=0.13U W=4.68U
m72 N96 N28 VDD VDD P L=0.13U W=7.32U
m73 N96 SASET GTPSANINV VDD P L=0.13U W=7.32U
m8 GTPN GTPKEEP VDD VDD P L=0.13U W=0.15U
m9 GTPN GTPKEEP VSS VSS N L=0.13U W=0.15U
.ENDS RF1SH32x30CK2
****
.SUBCKT RF1SH32x30M24BOTCTRL CEN CLK GTP GTPN GTPSA GTPSATW MBL MBL_ STOV WEI
+  WEN YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M24BOTCTRL: 77 flat devices **
XI0 CEN CLK STOV WEI WEN VSS VDD RF1SH32x30FLCCTRL2NB
XI1 CEN CLK DLY3 DLY3 GTP GTPN GTPSA GTPSATW MBL MBL_ STOV WEI WEN YP0 YP1 YP2
+  YP3 VSS VDD RF1SH32x30CK2
.ENDS RF1SH32x30M24BOTCTRL
****
.SUBCKT RF1SH32x30M2WRSACD_DN1R0 BL0 BL0_ BL1 BL1_ D GRTWIST GTP GTPSA_ GTP_0
+  Q WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2WRSACD_DN1R0: 109 flat devices **
XI0 D DW DW_ GTP Q WBYTE VSS VDD RF1SH32x30WR2
XI1 DR DR_ DW DW_ GRTWIST GRTWIST GTPSA_ GTP_0 GRTWIST Q VSS VDD RF1SH32x30SA2
XI2 BL0 BL0_ BL1 BL1_ DR DR DR_ DR_ DW DW DW_ DW_ YP0 GTP_0 GTP_0 YP1 YP0 YP1
+  YP2 YP3 VSS VDD RF1SH32x30CD24
.ENDS RF1SH32x30M2WRSACD_DN1R0
****
.SUBCKT RF1SH32x30M2WRSACD_UP1MY BL0 BL0_ BL1 BL1_ D GRTWIST GTP GTPSA_ GTP_0
+  Q WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2WRSACD_UP1MY: 109 flat devices **
XI0 D DW DW_ GTP Q WBYTE VSS VDD RF1SH32x30WR2
XI1 DR DR_ DW DW_ GRTWIST GRTWIST GTPSA_ GTP_0 GRTWIST Q VSS VDD RF1SH32x30SA2
XI2 BL0 BL0_ BL1 BL1_ DR DR DR_ DR_ DW DW DW_ DW_ YP1 GTP_0 GTP_0 YP0 YP0 YP1
+  YP2 YP3 VSS VDD RF1SH32x30CD24
.ENDS RF1SH32x30M2WRSACD_UP1MY
****
.SUBCKT RF1SH32x30M2BB2BW_UP_M10R0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0
+  D0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2BB2BW_UP_M10R0: 222 flat devices **
XI0_0 D0 Q0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI0_1 BL0 BL0_ BL1 BL1_ D0 GLTWIST GTP GTPSA_ GTP_0 Q0 WBYTE YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30M2WRSACD_DN1R0
XI1_0 D0_0 Q0_0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI1_1 BL0_0 BL0__0 BL1_0 BL1__0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0_0 WBYTE YP0
+  YP1 YP2 YP3 VSS VDD RF1SH32x30M2WRSACD_UP1MY
.ENDS RF1SH32x30M2BB2BW_UP_M10R0
****
.SUBCKT RF1SH32x30M2BB2BW_UP_M10MY BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0
+  D0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2BB2BW_UP_M10MY: 222 flat devices **
XI0_0 D0 Q0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI0_1 BL0 BL0_ BL1 BL1_ D0 GLTWIST GTP GTPSA_ GTP_0 Q0 WBYTE YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30M2WRSACD_DN1R0
XI1_0 D0_0 Q0_0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI1_1 BL0_0 BL0__0 BL1_0 BL1__0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0_0 WBYTE YP0
+  YP1 YP2 YP3 VSS VDD RF1SH32x30M2WRSACD_UP1MY
.ENDS RF1SH32x30M2BB2BW_UP_M10MY
****
.SUBCKT RF1SH32x30M2WRSACD_DN0R0 BL0 BL0_ BL1 BL1_ D GRTWIST GTP GTPSA_ GTP_0
+  Q WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2WRSACD_DN0R0: 109 flat devices **
XI0 D DW DW_ GTP Q WBYTE VSS VDD RF1SH32x30WR2
XI1 DR DR_ DW DW_ GTPSA_ GRTWIST GTPSA_ GTP_0 GTPSA_ Q VSS VDD RF1SH32x30SA2
XI2 BL0 BL0_ BL1 BL1_ DR DR DR_ DR_ DW DW DW_ DW_ YP0 GTP_0 GTP_0 YP1 YP0 YP1
+  YP2 YP3 VSS VDD RF1SH32x30CD24
.ENDS RF1SH32x30M2WRSACD_DN0R0
****
.SUBCKT RF1SH32x30M2BB2BW_UP_M0MY BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0
+  D0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD
** RF1SH32x30M2BB2BW_UP_M0MY: 222 flat devices **
XI0_0 D0 Q0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI0_1 BL0 BL0_ BL1 BL1_ D0 GLTWIST GTP GTPSA_ GTP_0 Q0 WBYTE YP0 YP1 YP2 YP3
+  VSS VDD RF1SH32x30M2WRSACD_DN0R0
XI1_0 D0_0 Q0_0 WBYTE VSS VDD RF1SH32x30FLCWRM2
XI1_1 BL0_0 BL0__0 BL1_0 BL1__0 D0_0 GLTWIST GTP GTPSA_ GTP_0 Q0_0 WBYTE YP0
+  YP1 YP2 YP3 VSS VDD RF1SH32x30M2WRSACD_UP1MY
.ENDS RF1SH32x30M2BB2BW_UP_M0MY
****
.SUBCKT RF1SH32x30M2BOTWING_R BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0__0 BL0__1
+  BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11
+  BL0__12 BL0__13 BL0__14 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1__0 BL1__1 BL1__2
+  BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12
+  BL1__13 BL1__14 D0 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5 D0_6 D0_7 D0_8 D0_9 D0_10
+  D0_11 D0_12 D0_13 D0_14 GLTWIST GTP GTPSA_ GTP_0 Q0 Q0_0 Q0_1 Q0_2 Q0_3
+  Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13 Q0_14 WBYTE YP0 YP1
+  YP2 YP3 VSS VDD
** RF1SH32x30M2BOTWING_R: 1776 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 BL1 BL1_ BL1_0 BL1__0 D0 D0_0 GTPSA_ GTP GTPSA_
+  GTP_0 Q0 Q0_0 WBYTE YP0 YP1 YP2 YP3 VSS VDD RF1SH32x30M2BB2BW_UP_M10R0
XI1 BL0_1 BL0__1 BL0_2 BL0__2 BL1_1 BL1__1 BL1_2 BL1__2 D0_1 D0_2 GTPSA_ GTP
+  GTPSA_ GTP_0 Q0_1 Q0_2 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10MY
XI2 BL0_3 BL0__3 BL0_4 BL0__4 BL1_3 BL1__3 BL1_4 BL1__4 D0_3 D0_4 GTPSA_ GTP
+  GTPSA_ GTP_0 Q0_3 Q0_4 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10R0
XI3 BL0_5 BL0__5 BL0_6 BL0__6 BL1_5 BL1__5 BL1_6 BL1__6 D0_5 D0_6 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_5 Q0_6 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M0MY
XI5 BL0_7 BL0__7 BL0_8 BL0__8 BL1_7 BL1__7 BL1_8 BL1__8 D0_7 D0_8 GLTWIST GTP
+  GTPSA_ GTP_0 Q0_7 Q0_8 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10R0
XI6 BL0_9 BL0__9 BL0_10 BL0__10 BL1_9 BL1__9 BL1_10 BL1__10 D0_9 D0_10 GLTWIST
+  GTP GTPSA_ GTP_0 Q0_9 Q0_10 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10MY
XI7 BL0_11 BL0__11 BL0_12 BL0__12 BL1_11 BL1__11 BL1_12 BL1__12 D0_11 D0_12
+  GLTWIST GTP GTPSA_ GTP_0 Q0_11 Q0_12 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10R0
XI8 BL0_13 BL0__13 BL0_14 BL0__14 BL1_13 BL1__13 BL1_14 BL1__14 D0_13 D0_14
+  GLTWIST GTP GTPSA_ GTP_0 Q0_13 Q0_14 WBYTE YP0 YP1 YP2 YP3 VSS VDD
+  RF1SH32x30M2BB2BW_UP_M10MY
.ENDS RF1SH32x30M2BOTWING_R
****
.SUBCKT RF1SH32x30M24BOT A0 A0_0 A0_1 A1 A1_0 BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3
+  BL0_4 BL0_5 BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14
+  BL0_15 BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24
+  BL0_25 BL0_26 BL0_27 BL0_28 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5
+  BL0__6 BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15
+  BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24
+  BL0__25 BL0__26 BL0__27 BL0__28 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1_3 BL1_4
+  BL1_5 BL1_6 BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15
+  BL1_16 BL1_17 BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25
+  BL1_26 BL1_27 BL1_28 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6
+  BL1__7 BL1__8 BL1__9 BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15
+  BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24
+  BL1__25 BL1__26 BL1__27 BL1__28 CEN CLK D0 D0_0 D0_1 D0_2 D0_3 D0_4 D0_5
+  D0_6 D0_7 D0_8 D0_9 D0_10 D0_11 D0_12 D0_13 D0_14 D0_15 D0_16 D0_17 D0_18
+  D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 GTP MBL MBL_ Q0
+  Q0_0 Q0_1 Q0_2 Q0_3 Q0_4 Q0_5 Q0_6 Q0_7 Q0_8 Q0_9 Q0_10 Q0_11 Q0_12 Q0_13
+  Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22 Q0_23 Q0_24 Q0_25
+  Q0_26 Q0_27 Q0_28 STOV WEN XPA0 XPA0_0 XPA1 XPA1_0 XPA2 XPA2_0 XPA3 XPA3_0
+  VSS VDD
** RF1SH32x30M24BOT: 3525 flat devices **
XI0 GTP GTP_0 GTP WE_ YP0 YP1 VSS VSS VSS VDD RF1SH32x30M24FCWRLEFT
XI1 BL0_12 BL0__12 BL0_11 BL0_10 BL0_9 BL0_8 BL0_7 BL0_6 BL0_5 BL0_4 BL0_3
+  BL0_2 BL0_1 BL0_0 BL0 BL0__11 BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5
+  BL0__4 BL0__3 BL0__2 BL0__1 BL0__0 BL0_ BL1_12 BL1__12 BL1_11 BL1_10 BL1_9
+  BL1_8 BL1_7 BL1_6 BL1_5 BL1_4 BL1_3 BL1_2 BL1_1 BL1_0 BL1 BL1__11 BL1__10
+  BL1__9 BL1__8 BL1__7 BL1__6 BL1__5 BL1__4 BL1__3 BL1__2 BL1__1 BL1__0 BL1_
+  D0_12 D0_11 D0_10 D0_9 D0_8 D0_7 D0_6 D0_5 D0_4 D0_3 D0_2 D0_1 D0_0 D0 VSS
+  GTP GTP_0 GTP Q0_12 Q0_11 Q0_10 Q0_9 Q0_8 Q0_7 Q0_6 Q0_5 Q0_4 Q0_3 Q0_2
+  Q0_1 Q0_0 Q0 WE_ YP0 YP1 VSS VSS VSS VDD RF1SH32x30M2BOTWING_L
XI2 GTP GTPN GTP_0 VSS WE_ YP0 YP1 VSS VSS VSS VDD RF1SH32x30FLCIOL2
XI3 A0 A0_0 A1 A1_0 GTP GTPN GTP_0 GTP WE_ XPA0 XPA0_0 XPA1 XPA1_0 XPA2 XPA2_0
+  XPA3 XPA3_0 YP0 YP1 VSS VSS VSS VDD RF1SH32x30HXPS
XI4 A0_1 GTPN GTP GTP_0 GTP WE_ YP0 YP1 VSS VDD RF1SH32x30HYPS
XI5 CEN CLK GTP GTPN GTP_0 GTP_0 MBL MBL_ STOV WE_ WEN YP0 YP1 VSS VSS VSS VDD
+  RF1SH32x30M24BOTCTRL
XI6 BL0_13 BL0__13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18 BL0_19 BL0_20 BL0_21
+  BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27 BL0_28 BL0__14 BL0__15 BL0__16
+  BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25
+  BL0__26 BL0__27 BL0__28 BL1_13 BL1__13 BL1_14 BL1_15 BL1_16 BL1_17 BL1_18
+  BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27 BL1_28
+  BL1__14 BL1__15 BL1__16 BL1__17 BL1__18 BL1__19 BL1__20 BL1__21 BL1__22
+  BL1__23 BL1__24 BL1__25 BL1__26 BL1__27 BL1__28 D0_13 D0_14 D0_15 D0_16
+  D0_17 D0_18 D0_19 D0_20 D0_21 D0_22 D0_23 D0_24 D0_25 D0_26 D0_27 D0_28 VSS
+  GTP GTP_0 GTP Q0_13 Q0_14 Q0_15 Q0_16 Q0_17 Q0_18 Q0_19 Q0_20 Q0_21 Q0_22
+  Q0_23 Q0_24 Q0_25 Q0_26 Q0_27 Q0_28 WE_ YP0 YP1 VSS VSS VSS VDD
+  RF1SH32x30M2BOTWING_R
XI7 GTP GTP_0 GTP WE_ YP0 YP1 VSS VSS VSS VDD RF1SH32x30M24FCWRRIGHT
.ENDS RF1SH32x30M24BOT
****
.SUBCKT RF1SH32x30CC BL BL_ WL WP VSS VDD
** RF1SH32x30CC: 6 flat devices **
m1 BL WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BL_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RF1SH32x30CC
****
.SUBCKT RF1SH32x30FLCCMW BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** RF1SH32x30FLCCMW: 24 flat devices **
m1 N11 WP1 N19 VSS NCH_SRAM L=0.16U W=0.16U
m10 N13 N14 VSS VSS NCH_SRAM L=0.13U W=0.23U
m11 N18 WP3 N28 VSS NCH_SRAM L=0.16U W=0.16U
m12 N17 N18 VDD VDD PCH_SRAM L=0.145U W=0.16U
m13 N17 N18 VSS VSS NCH_SRAM L=0.13U W=0.23U
m14 N18 N17 VDD VDD PCH_SRAM L=0.145U W=0.16U
m15 N18 N17 VSS VSS NCH_SRAM L=0.13U W=0.23U
m16 N16 WP2 N28 VSS NCH_SRAM L=0.16U W=0.16U
m17 N15 N16 VDD VDD PCH_SRAM L=0.145U W=0.16U
m18 N15 N16 VSS VSS NCH_SRAM L=0.13U W=0.23U
m19 N16 N15 VDD VDD PCH_SRAM L=0.145U W=0.16U
m2 N12 N11 VDD VDD PCH_SRAM L=0.145U W=0.16U
m20 N16 N15 VSS VSS NCH_SRAM L=0.13U W=0.23U
m21 N12 WP3 N37 VSS NCH_SRAM L=0.16U W=0.16U
m22 N14 WP2 N37 VSS NCH_SRAM L=0.16U W=0.16U
m23 N17 WP3 N38 VSS NCH_SRAM L=0.16U W=0.16U
m24 N15 WP2 N38 VSS NCH_SRAM L=0.16U W=0.16U
m3 N12 N11 VSS VSS NCH_SRAM L=0.13U W=0.23U
m4 N11 N12 VDD VDD PCH_SRAM L=0.145U W=0.16U
m5 N11 N12 VSS VSS NCH_SRAM L=0.13U W=0.23U
m6 N13 WP0 N19 VSS NCH_SRAM L=0.16U W=0.16U
m7 N14 N13 VDD VDD PCH_SRAM L=0.145U W=0.16U
m8 N14 N13 VSS VSS NCH_SRAM L=0.13U W=0.23U
m9 N13 N14 VDD VDD PCH_SRAM L=0.145U W=0.16U
.ENDS RF1SH32x30FLCCMW
****
.SUBCKT RF1SH32x30MCR_TURN BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** RF1SH32x30MCR_TURN: 24 flat devices **
XI0_0 BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD RF1SH32x30FLCCMW
.ENDS RF1SH32x30MCR_TURN
****
.SUBCKT RF1SH32x30CCCOLTURN BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WP WP0 WP1 WP2
+  WP3 WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12
+  WP_13 WP_14 VSS VDD
** RF1SH32x30CCCOLTURN: 216 flat devices **
XI0_1 BL0 BL0_ WL WP VSS VDD RF1SH32x30CC
XI0_10 BL0_ BL0 WL_7 WP_7 VSS VDD RF1SH32x30CC
XI0_11 BL0 BL0_ WL_8 WP_8 VSS VDD RF1SH32x30CC
XI0_12 BL0_ BL0 WL_9 WP_9 VSS VDD RF1SH32x30CC
XI0_13 BL0 BL0_ WL_10 WP_10 VSS VDD RF1SH32x30CC
XI0_14 BL0_ BL0 WL_11 WP_11 VSS VDD RF1SH32x30CC
XI0_15 BL0 BL0_ WL_12 WP_12 VSS VDD RF1SH32x30CC
XI0_16 BL0_ BL0 WL_13 WP_13 VSS VDD RF1SH32x30CC
XI0_17 BL0 BL0_ WL_14 WP_14 VSS VDD RF1SH32x30CC
XI0_18 BL0_ BL0 BL0_0 BL0__0 WL_15 WP0 WP1 WP2 WP3 VSS VDD RF1SH32x30MCR_TURN
XI0_2 BL0_ BL0 WL_0 WP_0 VSS VDD RF1SH32x30CC
XI0_3 BL0 BL0_ WL_1 WP_1 VSS VDD RF1SH32x30CC
XI0_4 BL0_ BL0 WL_2 WP_2 VSS VDD RF1SH32x30CC
XI0_5 BL0 BL0_ WL_3 WP_3 VSS VDD RF1SH32x30CC
XI0_6 BL0_ BL0 WL_4 WP_4 VSS VDD RF1SH32x30CC
XI0_7 BL0 BL0_ WL_5 WP_5 VSS VDD RF1SH32x30CC
XI0_8 BL0_ BL0 WL_6 WP_6 VSS VDD RF1SH32x30CC
XI1_1 BL0_0 BL0__0 WL WP VSS VDD RF1SH32x30CC
XI1_10 BL0__0 BL0_0 WL_7 WP_7 VSS VDD RF1SH32x30CC
XI1_11 BL0_0 BL0__0 WL_8 WP_8 VSS VDD RF1SH32x30CC
XI1_12 BL0__0 BL0_0 WL_9 WP_9 VSS VDD RF1SH32x30CC
XI1_13 BL0_0 BL0__0 WL_10 WP_10 VSS VDD RF1SH32x30CC
XI1_14 BL0__0 BL0_0 WL_11 WP_11 VSS VDD RF1SH32x30CC
XI1_15 BL0_0 BL0__0 WL_12 WP_12 VSS VDD RF1SH32x30CC
XI1_16 BL0__0 BL0_0 WL_13 WP_13 VSS VDD RF1SH32x30CC
XI1_17 BL0_0 BL0__0 WL_14 WP_14 VSS VDD RF1SH32x30CC
XI1_2 BL0__0 BL0_0 WL_0 WP_0 VSS VDD RF1SH32x30CC
XI1_3 BL0_0 BL0__0 WL_1 WP_1 VSS VDD RF1SH32x30CC
XI1_4 BL0__0 BL0_0 WL_2 WP_2 VSS VDD RF1SH32x30CC
XI1_5 BL0_0 BL0__0 WL_3 WP_3 VSS VDD RF1SH32x30CC
XI1_6 BL0__0 BL0_0 WL_4 WP_4 VSS VDD RF1SH32x30CC
XI1_7 BL0_0 BL0__0 WL_5 WP_5 VSS VDD RF1SH32x30CC
XI1_8 BL0__0 BL0_0 WL_6 WP_6 VSS VDD RF1SH32x30CC
.ENDS RF1SH32x30CCCOLTURN
****
.SUBCKT RF1SH32x30CCMW BL BLD BLD_ BL_ WL WP VSS VDD
** RF1SH32x30CCMW: 6 flat devices **
m1 BLD WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BLD_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RF1SH32x30CCMW
****
.SUBCKT RF1SH32x30MCR_NO BL BL_ BL_0 BL__0 WL WL_0 WP WP_0 VSS VDD
** RF1SH32x30MCR_NO: 24 flat devices **
XI0_0 BL BLD BLD_ BL_ WL WP VSS VDD RF1SH32x30CCMW
XI0_1 BL_ BLD_ BLD BL WL_0 WP_0 VSS VDD RF1SH32x30CCMW
XI1_0 BL_0 BLD_4 BLD__2 BL__0 WL WP VSS VDD RF1SH32x30CCMW
XI1_1 BL__0 BLD__2 BLD_4 BL_0 WL_0 WP_0 VSS VDD RF1SH32x30CCMW
.ENDS RF1SH32x30MCR_NO
****
.SUBCKT RF1SH32x30CCCOLNO BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WP WP_0
+  WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14
+  WP_15 WP_16 VSS VDD
** RF1SH32x30CCCOLNO: 216 flat devices **
XI0_1 BL0 BL0_ WL WP VSS VDD RF1SH32x30CC
XI0_10 BL0_ BL0 WL_7 WP_7 VSS VDD RF1SH32x30CC
XI0_11 BL0 BL0_ WL_8 WP_8 VSS VDD RF1SH32x30CC
XI0_12 BL0_ BL0 WL_9 WP_9 VSS VDD RF1SH32x30CC
XI0_13 BL0 BL0_ WL_10 WP_10 VSS VDD RF1SH32x30CC
XI0_14 BL0_ BL0 WL_11 WP_11 VSS VDD RF1SH32x30CC
XI0_15 BL0 BL0_ WL_12 WP_12 VSS VDD RF1SH32x30CC
XI0_16 BL0_ BL0 WL_13 WP_13 VSS VDD RF1SH32x30CC
XI0_17 BL0 BL0_ WL_14 WP_14 VSS VDD RF1SH32x30CC
XI0_18 BL0_ BL0 BL0__0 BL0_0 WL_15 WL_16 WP_15 WP_16 VSS VDD RF1SH32x30MCR_NO
XI0_2 BL0_ BL0 WL_0 WP_0 VSS VDD RF1SH32x30CC
XI0_3 BL0 BL0_ WL_1 WP_1 VSS VDD RF1SH32x30CC
XI0_4 BL0_ BL0 WL_2 WP_2 VSS VDD RF1SH32x30CC
XI0_5 BL0 BL0_ WL_3 WP_3 VSS VDD RF1SH32x30CC
XI0_6 BL0_ BL0 WL_4 WP_4 VSS VDD RF1SH32x30CC
XI0_7 BL0 BL0_ WL_5 WP_5 VSS VDD RF1SH32x30CC
XI0_8 BL0_ BL0 WL_6 WP_6 VSS VDD RF1SH32x30CC
XI1_1 BL0_0 BL0__0 WL WP VSS VDD RF1SH32x30CC
XI1_10 BL0__0 BL0_0 WL_7 WP_7 VSS VDD RF1SH32x30CC
XI1_11 BL0_0 BL0__0 WL_8 WP_8 VSS VDD RF1SH32x30CC
XI1_12 BL0__0 BL0_0 WL_9 WP_9 VSS VDD RF1SH32x30CC
XI1_13 BL0_0 BL0__0 WL_10 WP_10 VSS VDD RF1SH32x30CC
XI1_14 BL0__0 BL0_0 WL_11 WP_11 VSS VDD RF1SH32x30CC
XI1_15 BL0_0 BL0__0 WL_12 WP_12 VSS VDD RF1SH32x30CC
XI1_16 BL0__0 BL0_0 WL_13 WP_13 VSS VDD RF1SH32x30CC
XI1_17 BL0_0 BL0__0 WL_14 WP_14 VSS VDD RF1SH32x30CC
XI1_2 BL0__0 BL0_0 WL_0 WP_0 VSS VDD RF1SH32x30CC
XI1_3 BL0_0 BL0__0 WL_1 WP_1 VSS VDD RF1SH32x30CC
XI1_4 BL0__0 BL0_0 WL_2 WP_2 VSS VDD RF1SH32x30CC
XI1_5 BL0_0 BL0__0 WL_3 WP_3 VSS VDD RF1SH32x30CC
XI1_6 BL0__0 BL0_0 WL_4 WP_4 VSS VDD RF1SH32x30CC
XI1_7 BL0_0 BL0__0 WL_5 WP_5 VSS VDD RF1SH32x30CC
XI1_8 BL0__0 BL0_0 WL_6 WP_6 VSS VDD RF1SH32x30CC
.ENDS RF1SH32x30CCCOLNO
****
.SUBCKT RF1SH32x30CCWING_L BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17
+  BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0__0
+  BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8 BL0__9 BL0__10
+  BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16 BL0__17 BL0__18 BL0__19
+  BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WP
+  WP_0 VSS VDD
** RF1SH32x30CCWING_L: 3024 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI1 BL0_1 BL0__1 BL0_2 BL0__2 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI10 BL0_17 BL0__17 BL0_18 BL0__18 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI11 BL0_19 BL0__19 BL0_20 BL0__20 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI12 BL0_21 BL0__21 BL0_22 BL0__22 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI13 BL0_23 BL0__23 BL0_24 BL0__24 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI14 BL0_25 BL0__25 BL0_26 BL0__26 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI2 BL0_3 BL0__3 BL0_4 BL0__4 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI3 BL0_5 BL0__5 BL0_6 BL0__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI4 BL0_7 BL0__7 BL0_8 BL0__8 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI5 BL0_9 BL0__9 BL0_10 BL0__10 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI6 BL0_11 BL0__11 BL0_12 BL0__12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI7 BL0_13 BL0__13 BL0_14 BL0__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL WP WP_0 VSS VSS WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS
+  VDD RF1SH32x30CCCOLTURN
XI9 BL0_15 BL0__15 BL0_16 BL0__16 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
.ENDS RF1SH32x30CCWING_L
****
.SUBCKT RF1SH32x30WD G00 G01 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x30WD: 27 flat devices **
m1 WL1 WIN1 VDD VDD P L=0.13U W=5.18U
m10 GTPIN1 WL1 GTP VSS N L=0.13U W=0.33U
m11 GTPIN0 N27 GTP VDD P L=0.13U W=0.52U
m12 GTP WL0 GTPIN0 VSS N L=0.13U W=0.33U
m13 GTPIN1 N28 VSS VSS N L=0.13U W=0.15U
m14 GTPIN0 N27 VSS VSS N L=0.13U W=0.15U
m15 VDD G2 N28 VDD P L=0.13U W=0.15U
m16 VDD G3 N28 VDD P L=0.13U W=0.15U
m17 VDD G01 N28 VDD P L=0.13U W=0.15U
m18 N27 G2 VDD VDD P L=0.13U W=0.15U
m19 N27 G3 VDD VDD P L=0.13U W=0.15U
m2 WL1 WIN1 VSS VSS N L=0.13U W=2.68U
m20 N27 G00 VDD VDD P L=0.13U W=0.15U
m21 N27 G00 N29 VSS N L=0.13U W=0.38U
m22 N29 G01 N28 VSS N L=0.13U W=0.38U
m23 VDD G1 N28 VDD P L=0.13U W=0.15U
m24 N27 G1 VDD VDD P L=0.13U W=0.15U
m25 N29 G3 N40 VSS N L=0.13U W=0.38U
m26 N40 G2 N41 VSS N L=0.13U W=0.38U
m27 N41 G1 VSS VSS N L=0.13U W=0.38U
m3 WL0 WIN0 VDD VDD P L=0.13U W=5.18U
m4 WL0 WIN0 VSS VSS N L=0.13U W=2.68U
m5 WIN0 GTPIN0 VDD VDD P L=0.13U W=1.76U
m6 WIN0 GTPIN0 VSS VSS N L=0.13U W=1.12U
m7 WIN1 GTPIN1 VDD VDD P L=0.13U W=1.76U
m8 WIN1 GTPIN1 VSS VSS N L=0.13U W=1.12U
m9 GTP N28 GTPIN1 VDD P L=0.13U W=0.52U
.ENDS RF1SH32x30WD
****
.SUBCKT RF1SH32x30WDV_1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x30WDV_1: 27 flat devices **
XI0 XP3 XP2 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WD
.ENDS RF1SH32x30WDV_1
****
.SUBCKT RF1SH32x30WDV_0 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x30WDV_0: 27 flat devices **
XI0 XP0 XP1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WD
.ENDS RF1SH32x30WDV_0
****
.SUBCKT RF1SH32x30MWD GTP GTPIN GTPIN1 GTPIN2 GTPOUT0 GTPOUT1 GTPOUT2 MBL MWL
+  MWLLATE P1 P2 P3 P4 P5 P6 P7 P8 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x30MWD: 30 flat devices **
m1 MWL WINB1 VDD VDD P L=0.13U W=5.18U
m10 P6 MWLLATE VSS VSS N L=0.13U W=0.44U
m11 VSS MWLLATE P7 VSS N L=0.13U W=0.44U
m12 VSS MWLLATE P8 VSS N L=0.13U W=0.44U
m13 N26 VSS GTPAT VDD P L=0.13U W=0.52U
m14 GTPAT MWL N26 VSS N L=0.13U W=0.33U
m15 GTPOUT2 N32 VDD VDD P L=0.13U W=0.15U
m16 GTPOUT2 N32 VSS VSS N L=0.13U W=0.15U
m17 N32 GTPIN2 VDD VDD P L=0.13U W=0.15U
m18 N32 GTPIN2 VSS VSS N L=0.13U W=0.15U
m19 GTPOUT1 N37 VDD VDD P L=0.13U W=0.15U
m2 MWL WINB1 VSS VSS N L=0.13U W=2.68U
m20 GTPOUT1 N37 VSS VSS N L=0.13U W=0.15U
m21 N37 GTPIN1 VDD VDD P L=0.13U W=0.15U
m22 N37 GTPIN1 VSS VSS N L=0.13U W=0.15U
m23 GTPOUT0 N42 VDD VDD P L=0.13U W=0.15U
m24 GTPOUT0 N42 VSS VSS N L=0.13U W=0.15U
m25 N42 GTP VDD VDD P L=0.13U W=0.15U
m26 N42 GTP VSS VSS N L=0.13U W=0.15U
m27 N47 GTPIN VDD VDD P L=0.13U W=0.52U
m28 N47 GTPIN VSS VSS N L=0.13U W=0.33U
m29 N26 N47 VDD VDD P L=0.13U W=0.52U
m3 WINB1 GTPAT VDD VDD P L=0.13U W=1.76U
m30 N26 N47 VSS VSS N L=0.13U W=0.33U
m4 WINB1 GTPAT VSS VSS N L=0.13U W=1.12U
m5 P1 MWLLATE VSS VSS N L=0.13U W=0.44U
m6 P2 MWLLATE VSS VSS N L=0.13U W=0.44U
m7 P3 MWLLATE VSS VSS N L=0.13U W=0.44U
m8 P4 MWLLATE VSS VSS N L=0.13U W=0.44U
m9 P5 MWLLATE VSS VSS N L=0.13U W=0.44U
.ENDS RF1SH32x30MWD
****
.SUBCKT RF1SH32x30WDSTACK G1 G1_0 G1_1 G1_2 G1_3 G1_4 G1_5 G1_6 G2 G2_0 G2_1
+  G2_2 G2_3 G2_4 G2_5 G2_6 G3 G3_0 G3_1 G3_2 G3_3 G3_4 G3_5 G3_6 GTP MBL MWL
+  MWLLATE WL0 WL0_0 WL0_1 WL0_2 WL0_3 WL0_4 WL0_5 WL0_6 WL1 WL1_0 WL1_1 WL1_2
+  WL1_3 WL1_4 WL1_5 WL1_6 XP0 XP1 XP2 XP3 VSS VDD
** RF1SH32x30WDSTACK: 246 flat devices **
XI1 G1 G2 G3 GTP WL0 WL1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_0
XI10 GTP GTPIN GTP GTPIN2 GTPOUT0 GTPIN2 GTPIN MBL MWL MWLLATE P1 P2 P3 P4 P5
+  P6 P7 P8 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30MWD
XI2 G1_0 G2_0 G3_0 GTP WL0_0 WL1_0 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_1
XI3 G1_1 G2_1 G3_1 GTP WL0_1 WL1_1 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_0
XI4 G1_2 G2_2 G3_2 GTP WL0_2 WL1_2 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_1
XI6 G1_3 G2_3 G3_3 GTP WL0_3 WL1_3 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_0
XI7 G1_4 G2_4 G3_4 GTP WL0_4 WL1_4 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_1
XI8 G1_5 G2_5 G3_5 GTP WL0_5 WL1_5 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_0
XI9 G1_6 G2_6 G3_6 GTP WL0_6 WL1_6 XP0 XP1 XP2 XP3 VSS VDD RF1SH32x30WDV_1
.ENDS RF1SH32x30WDSTACK
****
.SUBCKT RF1SH32x30CCMBL2 BL BL_ WL WL_0 WP WP_0 VSS VDD
** RF1SH32x30CCMBL2: 12 flat devices **
XI1_0 BL_ BL WL WP VSS VDD RF1SH32x30CC
XI1_1 BL BL_ WL_0 WP_0 VSS VDD RF1SH32x30CC
.ENDS RF1SH32x30CCMBL2
****
.SUBCKT RF1SH32x30MBLBASE MBL MBL_ MWL MWLS VSS VDD
** RF1SH32x30MBLBASE: 4 flat devices **
m1 VSS MWL MBL VSS N L=0.13U W=0.15U
m2 VSS MWL MBL VSS N L=0.13U W=0.15U
m3 VDD VDD VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 VDD VDD VDD VDD PCH_SRAM L=0.145U W=0.16U
.ENDS RF1SH32x30MBLBASE
****
.SUBCKT RF1SH32x30MBLENDTOP MBL MBL_ WL WL_0 VSS VDD
** RF1SH32x30MBLENDTOP: 4 flat devices **
XI0_0 MBL MBL_ WL_0 WL VSS VDD RF1SH32x30MBLBASE
.ENDS RF1SH32x30MBLENDTOP
****
.SUBCKT RF1SH32x30MODEL_COL BL0 BL0_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WP WP_0 WP_1 WP_2
+  WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 VSS VDD
** RF1SH32x30MODEL_COL: 100 flat devices **
XI1 BL0_ BL0 WL WL_0 WP WP_0 VSS VDD RF1SH32x30CCMBL2
XI10 BL0_ BL0 WL_15 WL_16 VSS VDD RF1SH32x30MBLENDTOP
XI2 BL0_ BL0 WL_1 WL_2 WP_1 WP_2 VSS VDD RF1SH32x30CCMBL2
XI3 BL0_ BL0 WL_3 WL_4 WP_3 WP_4 VSS VDD RF1SH32x30CCMBL2
XI4 BL0_ BL0 WL_5 WL_6 WP_5 WP_6 VSS VDD RF1SH32x30CCMBL2
XI6 BL0 BL0_ WL_7 WL_8 WP_7 WP_8 VSS VDD RF1SH32x30CCMBL2
XI7 BL0 BL0_ WL_9 WL_10 WP_9 WP_10 VSS VDD RF1SH32x30CCMBL2
XI8 BL0 BL0_ WL_11 WL_12 WP_11 WP_12 VSS VDD RF1SH32x30CCMBL2
XI9 BL0 BL0_ WL_13 WL_14 WP_13 WP_14 VSS VDD RF1SH32x30CCMBL2
.ENDS RF1SH32x30MODEL_COL
****
.SUBCKT RF1SH32x30CCWING_R BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6
+  BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17
+  BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27
+  BL0_28 BL0_29 BL0_30 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6
+  BL0__7 BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15
+  BL0__16 BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24
+  BL0__25 BL0__26 BL0__27 BL0__28 BL0__29 BL0__30 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WP WP_0 VSS
+  VDD
** RF1SH32x30CCWING_R: 3456 flat devices **
XI0 BL0 BL0_ BL0_0 BL0__0 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI1 BL0_1 BL0__1 BL0_2 BL0__2 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI10 BL0_17 BL0__17 BL0_18 BL0__18 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI11 BL0_19 BL0__19 BL0_20 BL0__20 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI12 BL0_21 BL0__21 BL0_22 BL0__22 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI13 BL0_23 BL0__23 BL0_24 BL0__24 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI14 BL0_25 BL0__25 BL0_26 BL0__26 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI15 BL0_27 BL0__27 BL0_28 BL0__28 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI16 BL0_29 BL0__29 BL0_30 BL0__30 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
XI2 BL0_3 BL0__3 BL0_4 BL0__4 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI3 BL0_5 BL0__5 BL0_6 BL0__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI4 BL0_7 BL0__7 BL0_8 BL0__8 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8
+  WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI5 BL0_9 BL0__9 BL0_10 BL0__10 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI6 BL0_11 BL0__11 BL0_12 BL0__12 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WP WP_0 VSS VDD
+  RF1SH32x30CCCOLNO
XI7 BL0_13 BL0__13 BL0_14 BL0__14 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL WP WP_0 VSS VSS WL_0 WL_1
+  WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS
+  VDD RF1SH32x30CCCOLTURN
XI9 BL0_15 BL0__15 BL0_16 BL0__16 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 VSS VSS VSS VDD
+  RF1SH32x30CCCOLNO
.ENDS RF1SH32x30CCWING_R
****
.SUBCKT RF1SH32x30MID BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5 BL0_6 BL0_7
+  BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16 BL0_17 BL0_18
+  BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26 BL0_27 BL0_28
+  BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36 BL0_37 BL0_38
+  BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46 BL0_47 BL0_48
+  BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56 BL0_57 BL0_58
+  BL0_59 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7 BL0__8
+  BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16 BL0__17
+  BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25 BL0__26
+  BL0__27 BL0__28 BL0__29 BL0__30 BL0__31 BL0__32 BL0__33 BL0__34 BL0__35
+  BL0__36 BL0__37 BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43 BL0__44
+  BL0__45 BL0__46 BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52 BL0__53
+  BL0__54 BL0__55 BL0__56 BL0__57 BL0__58 BL0__59 G2 G3 GTP XP0 XP0_0 XP0_1
+  XP1 XP1_0 XP1_1 XP2 XP3 VSS VDD
** RF1SH32x30MID: 6826 flat devices **
XI1 BL0_26 BL0__26 BL0_25 BL0_24 BL0_23 BL0_22 BL0_21 BL0_20 BL0_19 BL0_18
+  BL0_17 BL0_16 BL0_15 BL0_14 BL0_13 BL0_12 BL0_11 BL0_10 BL0_9 BL0_8 BL0_7
+  BL0_6 BL0_5 BL0_4 BL0_3 BL0_2 BL0_1 BL0_0 BL0 BL0__25 BL0__24 BL0__23
+  BL0__22 BL0__21 BL0__20 BL0__19 BL0__18 BL0__17 BL0__16 BL0__15 BL0__14
+  BL0__13 BL0__12 BL0__11 BL0__10 BL0__9 BL0__8 BL0__7 BL0__6 BL0__5 BL0__4
+  BL0__3 BL0__2 BL0__1 BL0__0 BL0_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 WL_15 VSS VDD
+  RF1SH32x30CCWING_L
XI3 XP0_0 XP0_0 XP1_0 XP1_0 XP0 XP0 XP1 XP1 VDD VDD VDD VDD VDD VDD VDD VDD
+  VDD VDD VDD VDD VDD VDD VDD VDD GTP BL0__27 WL_15 WL_15 WL WL_2 WL_3 WL_6
+  WL_7 WL_10 WL_11 WL_14 WL_0 WL_1 WL_4 WL_5 WL_8 WL_9 WL_12 WL_13 XP0_1
+  XP1_1 XP2 XP3 VSS VDD RF1SH32x30WDSTACK
XI4 BL0_27 BL0__27 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_15 VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VDD RF1SH32x30MODEL_COL
XI5 BL0_28 BL0__28 BL0_29 BL0_30 BL0_31 BL0_32 BL0_33 BL0_34 BL0_35 BL0_36
+  BL0_37 BL0_38 BL0_39 BL0_40 BL0_41 BL0_42 BL0_43 BL0_44 BL0_45 BL0_46
+  BL0_47 BL0_48 BL0_49 BL0_50 BL0_51 BL0_52 BL0_53 BL0_54 BL0_55 BL0_56
+  BL0_57 BL0_58 BL0_59 BL0__29 BL0__30 BL0__31 BL0__32 BL0__33 BL0__34
+  BL0__35 BL0__36 BL0__37 BL0__38 BL0__39 BL0__40 BL0__41 BL0__42 BL0__43
+  BL0__44 BL0__45 BL0__46 BL0__47 BL0__48 BL0__49 BL0__50 BL0__51 BL0__52
+  BL0__53 BL0__54 BL0__55 BL0__56 BL0__57 BL0__58 BL0__59 WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_15 WL_15 VSS VDD RF1SH32x30CCWING_R
.ENDS RF1SH32x30MID
****
.SUBCKT RF1SH32x30 A[0] A[1] A[2] A[3] A[4] CEN CLK D[0] D[1] D[2] D[3] D[4]
+  D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17]
+  D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29]
+  Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13]
+  Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25]
+  Q[26] Q[27] Q[28] Q[29] WEN VSS VDD
** RF1SH32x30: 10351 flat devices **
XI0 A[3] A[1] A[0] A[4] A[2] BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4 BL0_5
+  BL0_6 BL0_7 BL0_8 BL0_9 BL0_10 BL0_11 BL0_12 BL0_13 BL0_14 BL0_15 BL0_16
+  BL0_17 BL0_18 BL0_19 BL0_20 BL0_21 BL0_22 BL0_23 BL0_24 BL0_25 BL0_26
+  BL0_27 BL0_28 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 BL0__7
+  BL0__8 BL0__9 BL0__10 BL0__11 BL0__12 BL0__13 BL0__14 BL0__15 BL0__16
+  BL0__17 BL0__18 BL0__19 BL0__20 BL0__21 BL0__22 BL0__23 BL0__24 BL0__25
+  BL0__26 BL0__27 BL0__28 BL1 BL1_ BL1_0 BL1_1 BL1_2 BL1_3 BL1_4 BL1_5 BL1_6
+  BL1_7 BL1_8 BL1_9 BL1_10 BL1_11 BL1_12 BL1_13 BL1_14 BL1_15 BL1_16 BL1_17
+  BL1_18 BL1_19 BL1_20 BL1_21 BL1_22 BL1_23 BL1_24 BL1_25 BL1_26 BL1_27
+  BL1_28 BL1__0 BL1__1 BL1__2 BL1__3 BL1__4 BL1__5 BL1__6 BL1__7 BL1__8
+  BL1__9 BL1__10 BL1__11 BL1__12 BL1__13 BL1__14 BL1__15 BL1__16 BL1__17
+  BL1__18 BL1__19 BL1__20 BL1__21 BL1__22 BL1__23 BL1__24 BL1__25 BL1__26
+  BL1__27 BL1__28 CEN CLK D[0] D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9]
+  D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[19] D[20] D[21]
+  D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] GTP MBL MBL_ Q[0] Q[1] Q[2]
+  Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+  Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27]
+  Q[28] Q[29] VSS WEN XPA0 XPA0_0 XPA1 XPA1_0 XPA2 XPA2_0 XPA3 XPA3_0 VSS VDD
+  RF1SH32x30M24BOT
XI1 BL0_ BL0 BL1 BL1__0 BL0_0 BL0__1 BL1_1 BL1__2 BL0_2 BL0__3 BL1_3 BL1__4
+  BL0_4 BL0__5 BL1_5 BL1__6 BL0_6 BL0__7 BL1_7 BL1__8 BL0_8 BL0__9 BL1_9
+  BL1__10 BL0_10 BL0__11 BL1_11 BL1__12 BL0_12 MBL_ BL0_13 BL1__13 BL1_14
+  BL0__14 BL0_15 BL1__15 BL1_16 BL0__16 BL0_17 BL1__17 BL1_18 BL0__18 BL0_19
+  BL1__19 BL1_20 BL0__20 BL0_21 BL1__21 BL1_22 BL0__22 BL0_23 BL1__23 BL1_24
+  BL0__24 BL0_25 BL1__25 BL1_26 BL0__26 BL0_27 BL1__27 BL1_28 BL0__28 BL1_
+  BL1_0 BL0__0 BL0_1 BL1__1 BL1_2 BL0__2 BL0_3 BL1__3 BL1_4 BL0__4 BL0_5
+  BL1__5 BL1_6 BL0__6 BL0_7 BL1__7 BL1_8 BL0__8 BL0_9 BL1__9 BL1_10 BL0__10
+  BL0_11 BL1__11 BL1_12 BL0__12 MBL BL0__13 BL1_13 BL1__14 BL0_14 BL0__15
+  BL1_15 BL1__16 BL0_16 BL0__17 BL1_17 BL1__18 BL0_18 BL0__19 BL1_19 BL1__20
+  BL0_20 BL0__21 BL1_21 BL1__22 BL0_22 BL0__23 BL1_23 BL1__24 BL0_24 BL0__25
+  BL1_25 BL1__26 BL0_26 BL0__27 BL1_27 BL1__28 BL0_28 VDD VDD GTP XPA2 XPA0
+  XPA0_0 XPA3 XPA1 XPA1_0 XPA2_0 XPA3_0 VSS VDD RF1SH32x30MID
.ENDS RF1SH32x30
