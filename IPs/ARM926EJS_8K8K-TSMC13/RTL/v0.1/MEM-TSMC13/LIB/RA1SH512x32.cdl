* 
* Copyright 2006 by Artisan Components, Inc.
* This file has been provided pursuant to a License Agreement
* containing restrictions on its use.  This file contains valuable
* trade secrets and proprietary information of Artisan Components,
* Inc. and is protected by law.
* 
* Generated by bif2cdl v3.3c
* Version: 2003Q4V1
* Name: SRAM-SP-HS SRAM Generator|TSMC CL013G-FSG Process
* Comment: 
* Configuration:  -instname RA1SH512x32 -words 512 -bits 32 -freque\
* Configuration: ncy 100 -ring_width 4 -mux 8 -drive 6 -write_mask \
* Configuration: off -wp_size 8 -redundancy off -redundancy_bits 1 \
* Configuration: -top_layer met6 -power_type rings -horiz met3 -ver\
* Configuration: t met2 -cust_comment "" -left_bus_delim "[" -right\
* Configuration: _bus_delim "]" -pwr_gnd_rename "VDD:VDD,GND:VSS" -\
* Configuration: prefix "" -pin_space 0.0 -name_case upper -check_i\
* Configuration: nstname on -diodes on -inside_ring_type GND -fuse_\
* Configuration: encoding encoded -insert_fuse yes -fusebox_name FU\
* Configuration: SE -rtl_style mux
* Codefile: 
* 
*
** begin lvs.header
** end lvs.header
*.BIPOLAR
*.DIOAREA
*.DIOPERI
*
****
.SUBCKT RA1SH512x32FCIO8 GTP OE_ WE VSS VDD
** RA1SH512x32FCIO8: 3 flat devices **
d1 VSS OE_ DN 0.2116P 1.84U
d2 VSS GTP DN 0.2116P 1.84U
d3 VSS WE DN 0.2116P 1.84U
.ENDS RA1SH512x32FCIO8
****
.SUBCKT RA1SH512x32FCSA8 GTP VSS VDD
** RA1SH512x32FCSA8: 1 flat devices **
d1 VSS GTP DN 0.2116P 1.84U
.ENDS RA1SH512x32FCSA8
****
.SUBCKT RA1SH512x32LEFT_CAP A0 A0_ DR DR_ DW DW_ GTP GTP_0 GTP_1 OE_ WE WL
+  WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13
+  WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25
+  WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37
+  WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49
+  WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61
+  WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32LEFT_CAP: 4 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SH512x32FCIO8
XI0_1 GTP_0 VSS VDD RA1SH512x32FCSA8
.ENDS RA1SH512x32LEFT_CAP
****
.SUBCKT RA1SH512x32FCBWM8 BWEN D Q VSS VDD
** RA1SH512x32FCBWM8: 2 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS D DN 0.2116P 1.84U
.ENDS RA1SH512x32FCBWM8
****
.SUBCKT RA1SH512x32IO8 BWE BWEN D DPN DPU DW DW_ GTP OE_ Q SP STUBWE STUBWEI
+  WE VSS VDD
** RA1SH512x32IO8: 58 flat devices **
m1 QI DPU VSS VSS N L=0.13U W=1.25U
m10 QPD OEI_ VSS VSS N L=0.13U W=0.26U
m11 QIL QI VDD VDD P L=0.13U W=0.33U
m12 QIL QI VSS VSS N L=0.13U W=0.26U
m13 SPN SP VDD VDD P L=0.13U W=0.17U
m14 SPN SP VSS VSS N L=0.13U W=0.15U
m15 DWPD GTPND DWI VSS N L=0.13U W=0.38U
m16 DWPD DW VDD VDD P L=0.3U W=0.15U
m17 DWPD DW VSS VSS N L=0.8U W=0.15U
m18 DWPD GTP DWI VDD P L=0.13U W=0.48U
m19 DW_PU GTPND DNWI VSS N L=0.13U W=0.38U
m2 QI DPN VDD VDD P L=0.13U W=2.4U
m20 DW_PU GTP DNWI VDD P L=0.13U W=0.48U
m21 GTPND GTP VDD VDD P L=0.13U W=0.2U
m22 GTPND GTP VSS VSS N L=0.13U W=0.19U
m23 DI N48 VDD VDD P L=0.13U W=0.64U
m24 DI N48 VSS VSS N L=0.13U W=0.43U
m25 DNN DI VDD VDD P L=0.13U W=0.47U
m26 DNN DI VSS VSS N L=0.13U W=0.31U
m27 WEI N53 VDD VDD P L=0.13U W=0.55U
m28 WEI N53 VSS VSS N L=0.13U W=0.44U
m29 OEI OEI_ VDD VDD P L=0.13U W=0.3U
m3 Q QPU VDD VDD P L=0.13U W=3.94U
m30 OEI OEI_ VSS VSS N L=0.13U W=0.21U
m31 QI SP N79 VDD P L=0.13U W=0.72U
m32 N79 QIL VDD VDD P L=0.13U W=0.72U
m33 QI SPN N78 VSS N L=0.13U W=0.72U
m34 N78 QIL VSS VSS N L=0.13U W=0.72U
m35 N35 OE_ VDD VDD P L=0.13U W=0.22U
m36 N35 OE_ VSS VSS N L=0.13U W=0.15U
m37 N53 WE VDD VDD P L=0.13U W=0.23U
m38 N53 WE VSS VSS N L=0.13U W=0.15U
m39 DWI WEI VDD VDD P L=0.13U W=0.76U
m4 Q QPD VSS VSS N L=0.13U W=2.52U
m40 N80 WEI VSS VSS N L=0.13U W=0.93U
m41 DWI DI VDD VDD P L=0.13U W=0.76U
m42 DWI DI N80 VSS N L=0.13U W=0.93U
m43 DNWI WEI VDD VDD P L=0.13U W=0.76U
m44 N81 WEI VSS VSS N L=0.13U W=0.93U
m45 DNWI DNN VDD VDD P L=0.13U W=0.76U
m46 DNWI DNN N81 VSS N L=0.13U W=0.93U
m47 N48 D VDD VDD P L=0.13U W=0.23U
m48 N48 D VSS VSS N L=0.13U W=0.15U
m49 QPU OEI_ QI VDD P L=0.13U W=0.15U
m5 OEI_ N35 VDD VDD P L=0.13U W=0.43U
m50 QPD OEI QI VSS N L=0.13U W=0.17U
m51 DW DWPD VDD VDD P L=0.13U W=3.14U
m52 DW DWPD VSS VSS N L=0.13U W=2.12U
m53 DW_PU DW_ VDD VDD P L=0.3U W=0.15U
m54 DW_PU DW_ VSS VSS N L=0.8U W=0.15U
m55 DW_ DW_PU VDD VDD P L=0.13U W=3.14U
m56 DW_ DW_PU VSS VSS N L=0.13U W=2.12U
m57 BWE BWEN VDD VDD P L=0.13U W=0.7U
m58 BWE BWEN VSS VSS N L=0.13U W=0.48U
m6 OEI_ N35 VSS VSS N L=0.13U W=0.3U
m7 QPD OEI_ QI VDD P L=0.13U W=1.78U
m8 QPU OEI QI VSS N L=0.13U W=1.18U
m9 QPU OEI VDD VDD P L=0.13U W=0.47U
.ENDS RA1SH512x32IO8
****
.SUBCKT RA1SH512x32IOX BWE D DPN DPU DW DW_ GTP OE_ Q SP STUBWEI VSS VDD
** RA1SH512x32IOX: 58 flat devices **
XI0_0 BWE VSS D DPN DPU DW DW_ GTP OE_ Q SP STUBWEI STUBWEI STUBWEI VSS VDD
+  RA1SH512x32IO8
.ENDS RA1SH512x32IOX
****
.SUBCKT RA1SH512x32SA8 DPN DPU DR DR_ DW DW_ GTP SP VSS VDD
** RA1SH512x32SA8: 41 flat devices **
m1 N22 SRCD VSS VSS N L=0.13U W=1.61U
m10 DPN SDN VDD VDD P L=0.13U W=1.21U
m11 DPN SDN VSS VSS N L=0.13U W=3.1U
m12 SP SPN VDD VDD P L=0.13U W=0.85U
m13 SP SPN VSS VSS N L=0.13U W=0.78U
m14 GTPN GTP VDD VDD P L=0.13U W=0.37U
m15 GTPN GTP VSS VSS N L=0.13U W=0.22U
m16 ND1 GTPN VDD VDD P L=0.13U W=0.21U
m17 ND1 GTPN VSS VSS N L=0.13U W=0.16U
m18 ND2 ND1 VDD VDD P L=0.13U W=0.18U
m19 ND2 ND1 VSS VSS N L=0.13U W=0.41U
m2 SD SP DR VDD P L=0.13U W=1.2U
m20 N40 DRP VSS VSS N L=0.13U W=0.6U
m21 SPN GTPN N40 VSS N L=0.13U W=0.41U
m22 SPN DRP VDD VDD P L=0.13U W=0.4U
m23 SPN GTPN VDD VDD P L=0.13U W=0.24U
m24 DRP ND2 VDD VDD P L=0.13U W=1.48U
m25 DRP ND2 VSS VSS N L=0.13U W=0.94U
m26 DR_ DRP VDD VDD P L=0.13U W=2.58U
m27 DR DRP VDD VDD P L=0.13U W=2.58U
m28 DR DRP DR_ VDD P L=0.13U W=3.3U
m29 SD_ SD SRC VSS N L=0.19U W=2.7U
m3 SD_ SP DR_ VDD P L=0.13U W=1.2U
m30 SD SD_ SRC VSS N L=0.19U W=2.7U
m31 SD_ SD SRC VSS N L=0.19U W=2.7U
m32 SD SD_ SRC VSS N L=0.19U W=2.7U
m33 SRC GTPN N22 VSS N L=0.13U W=1.76U
m34 SRCD SRCPU VDD VDD P L=0.13U W=0.36U
m35 SRCD SRCPU VSS VSS N L=0.13U W=0.23U
m36 SRCPU DRP VDD VDD P L=0.13U W=0.51U
m37 SRCPU DRP VSS VSS N L=0.13U W=0.25U
m38 VDD SRCPU SRC VSS N L=0.13U W=1.76U
m39 SD SRCD SD_ VDD P L=0.13U W=0.34U
m4 SD_ SD VDD VDD P L=0.13U W=0.34U
m40 SRC GTPN N52 VSS N L=0.13U W=1.76U
m41 N52 SRCD VSS VSS N L=0.13U W=1.61U
m5 SD SD_ VDD VDD P L=0.13U W=0.34U
m6 SDN SD VDD VDD P L=0.13U W=1.29U
m7 SDN SD VSS VSS N L=0.13U W=0.62U
m8 DPU SD_ VDD VDD P L=0.13U W=1.29U
m9 DPU SD_ VSS VSS N L=0.13U W=0.62U
.ENDS RA1SH512x32SA8
****
.SUBCKT RA1SH512x32CD A0 A0_ BL0 BL0_ BL1 BL1_ DR DRSA DR_ DW DWSA DW_ G0 G1
+  GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32CD: 43 flat devices **
m1 BL0_ CS0 DR_ VDD P L=0.13U W=2.28U
m10 BL1 BL1PD VSS VSS N L=0.13U W=4.8U
m11 BL1_PD CS1 DW_ VDD P L=0.13U W=0.92U
m12 BL1_PD CS1 VSS VSS N L=0.13U W=0.64U
m13 BL1 CS1 DR_ VDD P L=0.13U W=2.28U
m14 BL1PD CS1 DW VDD P L=0.13U W=0.92U
m15 BL1PD CS1 VSS VSS N L=0.13U W=0.64U
m16 BL1_ BL1_PD VSS VSS N L=0.13U W=4.8U
m17 BL0_ YI VDD VDD P L=0.13U W=4.14U
m18 BL0 YI VDD VDD P L=0.13U W=4.14U
m19 BL0 YI BL0_ VDD P L=0.13U W=4.14U
m2 BL0 BL0PD VSS VSS N L=0.13U W=4.8U
m20 BL1_ YI VDD VDD P L=0.13U W=4.14U
m21 BL1 YI VDD VDD P L=0.13U W=4.14U
m22 BL1 YI BL1_ VDD P L=0.13U W=4.14U
m23 CS0 A0_ VDD VDD P L=0.13U W=1.04U
m24 N65 A0_ VSS VSS N L=0.13U W=1.45U
m25 CS0 YI VDD VDD P L=0.13U W=1.04U
m26 CS0 YI N65 VSS N L=0.13U W=1.45U
m27 CS1 A0 VDD VDD P L=0.13U W=1.04U
m28 N66 A0 VSS VSS N L=0.13U W=1.45U
m29 CS1 YI VDD VDD P L=0.13U W=1.04U
m3 BL0_PD CS0 DW VDD P L=0.13U W=0.92U
m30 CS1 YI N66 VSS N L=0.13U W=1.45U
m31 YCDSEL_ G0 VDD VDD P L=0.13U W=0.3U
m32 N67 G0 VSS VSS N L=0.13U W=0.38U
m33 YCDSEL_ G1 VDD VDD P L=0.13U W=0.3U
m34 YCDSEL_ G1 N67 VSS N L=0.13U W=0.38U
m35 YCDSEL YCDSEL_ VDD VDD P L=0.13U W=0.24U
m36 YCDSEL YCDSEL_ VSS VSS N L=0.13U W=0.15U
m37 N37 YCDSEL_ GTP VDD P L=0.13U W=0.3U
m38 N37 YCDSEL_ VSS VSS N L=0.13U W=0.3U
m39 YI WL1_EN_ VDD VDD P L=0.13U W=3.62U
m4 BL0_PD CS0 VSS VSS N L=0.13U W=0.64U
m40 YI WL1_EN_ VSS VSS N L=0.13U W=2.9U
m41 WL1_EN_ N37 VDD VDD P L=0.13U W=1.46U
m42 WL1_EN_ N37 VSS VSS N L=0.13U W=0.93U
m43 N37 YCDSEL GTP VSS N L=0.13U W=0.3U
m5 BL0 CS0 DR VDD P L=0.13U W=2.28U
m6 BL0PD CS0 DW_ VDD P L=0.13U W=0.92U
m7 BL0PD CS0 VSS VSS N L=0.13U W=0.64U
m8 BL0_ BL0_PD VSS VSS N L=0.13U W=4.8U
m9 BL1_ CS1 DR VDD P L=0.13U W=2.28U
.ENDS RA1SH512x32CD
****
.SUBCKT RA1SH512x32CDXY A0 A0_ BL0 BL0_ BL0_0 BL0__0 DR DRSA DR_ DW DWSA DW_
+  G0 G1 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SH512x32CDXY: 43 flat devices **
XI0_0 A0 A0_ BL0_ BL0 BL0_0 BL0__0 DR DRSA DR_ DW DWSA DW_ G0 G1 GTP STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CD
.ENDS RA1SH512x32CDXY
****
.SUBCKT RA1SH512x32CDXX A0 A0_ BL0 BL0_ BL0_0 BL0__0 DR DRSA DR_ DW DWSA DW_
+  G0 G1 GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SH512x32CDXX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0__0 BL0_0 DR DRSA DR_ DW DWSA DW_ G0 G1 GTP STUBDR
+  STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CD
.ENDS RA1SH512x32CDXX
****
.SUBCKT RA1SH512x32CDX A0 A0_ BL0 BL0_ BL0_0 BL0__0 DR DRSA DR_ DW DWSA DW_ G0
+  G1 GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32CDX: 43 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0_0 BL0__0 DR DRSA DR_ DW DWSA DW_ G0 G1 GTP DR DR_ DW
+  DW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32CDXX
.ENDS RA1SH512x32CDX
****
.SUBCKT RA1SH512x32MUX_CD_ODD A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA DRSA_0
+  DWSA DWSA_0 GTP STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0
+  STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32MUX_CD_ODD: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0_0 BL0__0 STUBDR DRSA STUBDR_ STUBDW DWSA STUBDW_
+  YP0_3 VDD GTP STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32CDXY
XI1_0 A0 A0_ BL0_2 BL0__2 BL0_1 BL0__1 STUBDR STUBDR STUBDR_ STUBDW STUBDW
+  STUBDW_ YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CDX
XI2_0 A0 A0_ BL0_3 BL0__3 BL0_4 BL0__4 STUBDR STUBDR_ STUBDR_ STUBDW STUBDW_
+  STUBDW_ YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CDX
XI3_0 A0 A0_ BL0_6 BL0__6 BL0_5 BL0__5 STUBDR DRSA_0 STUBDR_ STUBDW DWSA_0
+  STUBDW_ YP0_0 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CDX
.ENDS RA1SH512x32MUX_CD_ODD
****
.SUBCKT RA1SH512x32CCG BL BL_ WL WP VSS VDD
** RA1SH512x32CCG: 6 flat devices **
m1 BL WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BL_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RA1SH512x32CCG
****
.SUBCKT RA1SH512x32CCP BL BL_ WL WP VSS VDD
** RA1SH512x32CCP: 6 flat devices **
m1 BL WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BL_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RA1SH512x32CCP
****
.SUBCKT RA1SH512x32BIT_MUX_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SH512x32BIT_MUX_1: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SH512x32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SH512x32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SH512x32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SH512x32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SH512x32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SH512x32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SH512x32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SH512x32CCG
.ENDS RA1SH512x32BIT_MUX_1
****
.SUBCKT RA1SH512x32BIT_MUX_0 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WP VSS VDD
** RA1SH512x32BIT_MUX_0: 48 flat devices **
XI0_0 BL BL_ WL WP VSS VDD RA1SH512x32CCG
XI1_0 BL_0 BL__0 WL WP VSS VDD RA1SH512x32CCP
XI2_0 BL_1 BL__1 WL WP VSS VDD RA1SH512x32CCP
XI3_0 BL_2 BL__2 WL WP VSS VDD RA1SH512x32CCG
XI4_0 BL_3 BL__3 WL WP VSS VDD RA1SH512x32CCG
XI5_0 BL_4 BL__4 WL WP VSS VDD RA1SH512x32CCP
XI6_0 BL_5 BL__5 WL WP VSS VDD RA1SH512x32CCP
XI7_0 BL_6 BL__6 WL WP VSS VDD RA1SH512x32CCG
.ENDS RA1SH512x32BIT_MUX_0
****
.SUBCKT RA1SH512x32BIT_COL BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0
+  BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5
+  WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18
+  WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30
+  WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42
+  WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54
+  WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD
** RA1SH512x32BIT_COL: 3072 flat devices **
XI0_0 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL WP VSS VDD RA1SH512x32BIT_MUX_0
XI0_1 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_0 WP_0 VSS VDD RA1SH512x32BIT_MUX_1
XI0_10 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_9 WP_9 VSS VDD RA1SH512x32BIT_MUX_0
XI0_11 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_10 WP_10 VSS VDD RA1SH512x32BIT_MUX_1
XI0_12 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_11 WP_11 VSS VDD RA1SH512x32BIT_MUX_0
XI0_13 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_12 WP_12 VSS VDD RA1SH512x32BIT_MUX_1
XI0_14 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_13 WP_13 VSS VDD RA1SH512x32BIT_MUX_0
XI0_15 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_14 WP_14 VSS VDD RA1SH512x32BIT_MUX_1
XI0_16 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_15 WP_15 VSS VDD RA1SH512x32BIT_MUX_0
XI0_17 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_16 WP_16 VSS VDD RA1SH512x32BIT_MUX_1
XI0_18 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_17 WP_17 VSS VDD RA1SH512x32BIT_MUX_0
XI0_19 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_18 WP_18 VSS VDD RA1SH512x32BIT_MUX_1
XI0_2 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_1 WP_1 VSS VDD RA1SH512x32BIT_MUX_0
XI0_20 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_19 WP_19 VSS VDD RA1SH512x32BIT_MUX_0
XI0_21 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_20 WP_20 VSS VDD RA1SH512x32BIT_MUX_1
XI0_22 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_21 WP_21 VSS VDD RA1SH512x32BIT_MUX_0
XI0_23 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_22 WP_22 VSS VDD RA1SH512x32BIT_MUX_1
XI0_24 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_23 WP_23 VSS VDD RA1SH512x32BIT_MUX_0
XI0_25 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_24 WP_24 VSS VDD RA1SH512x32BIT_MUX_1
XI0_26 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_25 WP_25 VSS VDD RA1SH512x32BIT_MUX_0
XI0_27 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_26 WP_26 VSS VDD RA1SH512x32BIT_MUX_1
XI0_28 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_27 WP_27 VSS VDD RA1SH512x32BIT_MUX_0
XI0_29 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_28 WP_28 VSS VDD RA1SH512x32BIT_MUX_1
XI0_3 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_2 WP_2 VSS VDD RA1SH512x32BIT_MUX_1
XI0_30 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_29 WP_29 VSS VDD RA1SH512x32BIT_MUX_0
XI0_31 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_30 WP_30 VSS VDD RA1SH512x32BIT_MUX_1
XI0_32 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_31 WP_31 VSS VDD RA1SH512x32BIT_MUX_0
XI0_33 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_32 WP_32 VSS VDD RA1SH512x32BIT_MUX_1
XI0_34 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_33 WP_33 VSS VDD RA1SH512x32BIT_MUX_0
XI0_35 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_34 WP_34 VSS VDD RA1SH512x32BIT_MUX_1
XI0_36 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_35 WP_35 VSS VDD RA1SH512x32BIT_MUX_0
XI0_37 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_36 WP_36 VSS VDD RA1SH512x32BIT_MUX_1
XI0_38 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_37 WP_37 VSS VDD RA1SH512x32BIT_MUX_0
XI0_39 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_38 WP_38 VSS VDD RA1SH512x32BIT_MUX_1
XI0_4 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_3 WP_3 VSS VDD RA1SH512x32BIT_MUX_0
XI0_40 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_39 WP_39 VSS VDD RA1SH512x32BIT_MUX_0
XI0_41 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_40 WP_40 VSS VDD RA1SH512x32BIT_MUX_1
XI0_42 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_41 WP_41 VSS VDD RA1SH512x32BIT_MUX_0
XI0_43 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_42 WP_42 VSS VDD RA1SH512x32BIT_MUX_1
XI0_44 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_43 WP_43 VSS VDD RA1SH512x32BIT_MUX_0
XI0_45 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_44 WP_44 VSS VDD RA1SH512x32BIT_MUX_1
XI0_46 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_45 WP_45 VSS VDD RA1SH512x32BIT_MUX_0
XI0_47 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_46 WP_46 VSS VDD RA1SH512x32BIT_MUX_1
XI0_48 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_47 WP_47 VSS VDD RA1SH512x32BIT_MUX_0
XI0_49 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_48 WP_48 VSS VDD RA1SH512x32BIT_MUX_1
XI0_5 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_4 WP_4 VSS VDD RA1SH512x32BIT_MUX_1
XI0_50 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_49 WP_49 VSS VDD RA1SH512x32BIT_MUX_0
XI0_51 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_50 WP_50 VSS VDD RA1SH512x32BIT_MUX_1
XI0_52 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_51 WP_51 VSS VDD RA1SH512x32BIT_MUX_0
XI0_53 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_52 WP_52 VSS VDD RA1SH512x32BIT_MUX_1
XI0_54 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_53 WP_53 VSS VDD RA1SH512x32BIT_MUX_0
XI0_55 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_54 WP_54 VSS VDD RA1SH512x32BIT_MUX_1
XI0_56 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_55 WP_55 VSS VDD RA1SH512x32BIT_MUX_0
XI0_57 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_56 WP_56 VSS VDD RA1SH512x32BIT_MUX_1
XI0_58 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_57 WP_57 VSS VDD RA1SH512x32BIT_MUX_0
XI0_59 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_58 WP_58 VSS VDD RA1SH512x32BIT_MUX_1
XI0_6 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_5 WP_5 VSS VDD RA1SH512x32BIT_MUX_0
XI0_60 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_59 WP_59 VSS VDD RA1SH512x32BIT_MUX_0
XI0_61 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_60 WP_60 VSS VDD RA1SH512x32BIT_MUX_1
XI0_62 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_61 WP_61 VSS VDD RA1SH512x32BIT_MUX_0
XI0_63 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_62 WP_62 VSS VDD RA1SH512x32BIT_MUX_1
XI0_7 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_6 WP_6 VSS VDD RA1SH512x32BIT_MUX_1
XI0_8 BL_ BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 WL_7 WP_7 VSS VDD RA1SH512x32BIT_MUX_0
XI0_9 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL_8 WP_8 VSS VDD RA1SH512x32BIT_MUX_1
.ENDS RA1SH512x32BIT_COL
****
.SUBCKT RA1SH512x32MCOL_ODD_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32MCOL_ODD_M8: 3345 flat devices **
XI0_0 VSS D Q VSS VDD RA1SH512x32FCBWM8
XI0_1 BWE D DPN DPU STUBDW STUBDW_ GTP OE_ Q SP STUBWEI VSS VDD RA1SH512x32IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SH512x32SA8
XI0_3 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL__0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0
+  STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32BIT_COL
.ENDS RA1SH512x32MCOL_ODD_M8
****
.SUBCKT RA1SH512x32MUX_CD_EVEN A0 A0_ BL0 BL0_ BL0_0 BL0_1 BL0_2 BL0_3 BL0_4
+  BL0_5 BL0_6 BL0__0 BL0__1 BL0__2 BL0__3 BL0__4 BL0__5 BL0__6 DRSA DRSA_0
+  DRSA_1 DRSA_2 DWSA DWSA_0 DWSA_1 DWSA_2 GTP STUBDR STUBDR_ STUBDW STUBDW_
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32MUX_CD_EVEN: 172 flat devices **
XI0_0 A0 A0_ BL0 BL0_ BL0_0 BL0__0 DRSA_0 DRSA DRSA_1 DWSA_0 DWSA DWSA_1 YP0_0
+  VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32CDX
XI1_0 A0 A0_ BL0_2 BL0__2 BL0_1 BL0__1 DRSA_0 DRSA_0 DRSA_1 DWSA_0 DWSA_0
+  DWSA_1 YP0_1 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CDX
XI2_0 A0 A0_ BL0_3 BL0__3 BL0_4 BL0__4 DRSA_0 DRSA_1 DRSA_1 DWSA_0 DWSA_1
+  DWSA_1 YP0_2 VDD GTP YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD RA1SH512x32CDX
XI3_0 A0 A0_ BL0_6 BL0__6 BL0_5 BL0__5 DRSA_0 DRSA_2 DRSA_1 DWSA_0 DWSA_2
+  DWSA_1 YP0_3 VDD GTP STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32CDXY
.ENDS RA1SH512x32MUX_CD_EVEN
****
.SUBCKT RA1SH512x32MCOL_EVEN_M8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32MCOL_EVEN_M8: 3345 flat devices **
XI0_0 VSS D Q VSS VDD RA1SH512x32FCBWM8
XI0_1 BWE D DPN DPU STUBDW_0 STUBDW__0 GTP OE_ Q SP STUBWEI VSS VDD
+  RA1SH512x32IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SH512x32SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL__5 BL__6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL_5 BL_6 VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0 STUBDW__0 VSS
+  GTP_1 STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32BIT_COL
.ENDS RA1SH512x32MCOL_EVEN_M8
****
.SUBCKT RA1SH512x32FCBWLE8 BWEN D Q VSS VDD
** RA1SH512x32FCBWLE8: 3 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS BWEN DN 0.2116P 1.84U
d3 VSS D DN 0.2116P 1.84U
.ENDS RA1SH512x32FCBWLE8
****
.SUBCKT RA1SH512x32FCBWLX BWEN D Q VSS VDD
** RA1SH512x32FCBWLX: 3 flat devices **
XI0_0 BWEN D Q VSS VDD RA1SH512x32FCBWLE8
.ENDS RA1SH512x32FCBWLX
****
.SUBCKT RA1SH512x32MCOL_EVEN_LX8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32MCOL_EVEN_LX8: 3346 flat devices **
XI0_0 VSS D Q VSS VDD RA1SH512x32FCBWLX
XI0_1 BWE D DPN DPU STUBDW_0 STUBDW__0 GTP OE_ Q SP STUBWEI VSS VDD
+  RA1SH512x32IOX
XI0_2 DPN DPU STUBDR_0 STUBDR__0 STUBDW_0 STUBDW__0 GTP_0 SP VSS VDD
+  RA1SH512x32SA8
XI0_3 A0 A0_ BL_ BL BL__0 BL_1 BL_2 BL__3 BL__4 BL__5 BL__6 BL_0 BL__1 BL__2
+  BL_3 BL_4 BL_5 BL_6 VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0 STUBDW__0 VSS
+  GTP_1 STUBDR STUBDR_ STUBDW STUBDW_ YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MUX_CD_EVEN
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32BIT_COL
.ENDS RA1SH512x32MCOL_EVEN_LX8
****
.SUBCKT RA1SH512x32WING_16_LEFT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14
+  GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11
+  Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0
+  STUBDW__0 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32WING_16_LEFT: 53521 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q STUBDR_67 STUBDR__65 STUBDR_0
+  STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0 STUBDW__0 STUBWE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32MCOL_ODD_M8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 D_7 GTP GTP_0 GTP_1 OE_ Q_7
+  STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 D_8 GTP GTP_0 GTP_1 OE_ Q_8
+  STUBDR_3 STUBDR__1 STUBDR_0_19 STUBDR__0_17 STUBDW_5 STUBDW__7 STUBDW_0_21
+  STUBDW__0_23 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 D_9 GTP GTP_0 GTP_1 OE_ Q_9
+  STUBDR_27 STUBDR__25 STUBDR_0_19 STUBDR__0_17 STUBDW_29 STUBDW__31
+  STUBDW_0_21 STUBDW__0_23 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 D_10 GTP GTP_0 GTP_1 OE_ Q_10
+  STUBDR_27 STUBDR__25 STUBDR_0_35 STUBDR__0_33 STUBDW_29 STUBDW__31
+  STUBDW_0_37 STUBDW__0_39 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 D_11 GTP GTP_0 GTP_1 OE_ Q_11
+  STUBDR_43 STUBDR__41 STUBDR_0_35 STUBDR__0_33 STUBDW_45 STUBDW__47
+  STUBDW_0_37 STUBDW__0_39 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 D_12 GTP GTP_0
+  GTP_1 OE_ Q_12 STUBDR_43 STUBDR__41 STUBDR_0_51 STUBDR__0_49 STUBDW_45
+  STUBDW__47 STUBDW_0_53 STUBDW__0_55 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 D_13 GTP GTP_0
+  GTP_1 OE_ Q_13 STUBDR_59 STUBDR__57 STUBDR_0_51 STUBDR__0_49 STUBDW_61
+  STUBDW__63 STUBDW_0_53 STUBDW__0_55 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 D_14 GTP GTP_0
+  GTP_1 OE_ Q_14 STUBDR_59 STUBDR__57 STUBDR STUBDR_ STUBDW_61 STUBDW__63
+  STUBDW STUBDW_ STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_LX8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67
+  STUBDR__65 STUBDR_0_75 STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77
+  STUBDW__0_79 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_83 STUBDR__81 STUBDR_0_75 STUBDR__0_73 STUBDW_85 STUBDW__87
+  STUBDW_0_77 STUBDW__0_79 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_83 STUBDR__81 STUBDR_0_91 STUBDR__0_89 STUBDW_85 STUBDW__87
+  STUBDW_0_93 STUBDW__0_95 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 D_3 GTP GTP_0 GTP_1 OE_ Q_3
+  STUBDR_99 STUBDR__97 STUBDR_0_91 STUBDR__0_89 STUBDW_101 STUBDW__103
+  STUBDW_0_93 STUBDW__0_95 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 D_4 GTP GTP_0 GTP_1 OE_ Q_4
+  STUBDR_99 STUBDR__97 STUBDR_0_107 STUBDR__0_105 STUBDW_101 STUBDW__103
+  STUBDW_0_109 STUBDW__0_111 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 D_5 GTP GTP_0 GTP_1 OE_ Q_5
+  STUBDR_115 STUBDR__113 STUBDR_0_107 STUBDR__0_105 STUBDW_117 STUBDW__119
+  STUBDW_0_109 STUBDW__0_111 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 D_6 GTP GTP_0 GTP_1 OE_ Q_6
+  STUBDR_115 STUBDR__113 STUBDR_0_11 STUBDR__0_9 STUBDW_117 STUBDW__119
+  STUBDW_0_13 STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
.ENDS RA1SH512x32WING_16_LEFT
****
.SUBCKT RA1SH512x32HXP38 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1
+  XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD
** RA1SH512x32HXP38: 192 flat devices **
d175 VSS A2 DN 0.2116P 1.84U
d176 VSS BWEN DN 0.2116P 1.84U
d183 VSS A1 DN 0.2116P 1.84U
d184 VSS BWEN DN 0.2116P 1.84U
d191 VSS A0 DN 0.2116P 1.84U
d192 VSS BWEN DN 0.2116P 1.84U
m1 AP67-APN1 N47 AP67-AIND1 VSS N L=0.13U W=3.32U
m10 N42 AI2_ VSS VSS N L=0.13U W=1.34U
m100 AP23-AIND1 N125 VDD VDD P L=0.13U W=4.16U
m101 N157 N125 N158 VSS N L=0.13U W=3.32U
m102 AP23-AIND1 AP23-AIN21 VDD VDD P L=0.13U W=4.16U
m103 AP23-AIND1 AP23-AIN21 N157 VSS N L=0.13U W=3.32U
m104 AP23-APN0 N142 AP23-AIND0 VSS N L=0.13U W=3.32U
m105 AP23-APN0 AGTPB AP23-AIND0 VDD P L=0.13U W=4.15U
m106 N142 AGTPB VDD VDD P L=0.13U W=0.58U
m107 N142 AGTPB VSS VSS N L=0.13U W=0.5U
m108 AP23-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m109 AP23-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m11 N76 N42 VSS VSS N L=0.13U W=3.32U
m110 N164 N126 VSS VSS N L=0.13U W=3.32U
m111 N163 N125 N164 VSS N L=0.13U W=3.32U
m112 AP23-AIND0 AP23-AIN20 N163 VSS N L=0.13U W=3.32U
m113 AP23-AIND0 N126 VDD VDD P L=0.13U W=4.16U
m114 N162 N126 VSS VSS N L=0.13U W=3.32U
m115 AP23-AIND0 N125 VDD VDD P L=0.13U W=4.16U
m116 N161 N125 N162 VSS N L=0.13U W=3.32U
m117 AP23-AIND0 AP23-AIN20 VDD VDD P L=0.13U W=4.16U
m118 AP23-AIND0 AP23-AIN20 N161 VSS N L=0.13U W=3.32U
m119 AP23-APN1 XP_3 VDD VDD P L=0.2U W=0.15U
m12 N75 N41 N76 VSS N L=0.13U W=3.32U
m120 AP23-APN1 XP_3 VSS VSS N L=0.39U W=0.15U
m121 XP_3 AP23-APN1 VDD VDD P L=0.13U W=13.74U
m122 XP_3 AP23-APN1 VSS VSS N L=0.13U W=9.48U
m123 AP23-APN0 XP_2 VDD VDD P L=0.2U W=0.15U
m124 AP23-APN0 XP_2 VSS VSS N L=0.39U W=0.15U
m125 XP_2 AP23-APN0 VDD VDD P L=0.13U W=13.74U
m126 XP_2 AP23-APN0 VSS VSS N L=0.13U W=9.48U
m127 AP01-APN1 N173 AP01-AIND1 VSS N L=0.13U W=3.32U
m128 AP01-APN1 AGTPT AP01-AIND1 VDD P L=0.13U W=4.15U
m129 N173 AGTPT VDD VDD P L=0.13U W=0.58U
m13 AP67-AIND1 AP67-AIN21 N75 VSS N L=0.13U W=3.32U
m130 N173 AGTPT VSS VSS N L=0.13U W=0.5U
m131 AP01-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m132 AP01-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m133 N167 AI1 VDD VDD P L=0.13U W=2.03U
m134 N167 AI1 VSS VSS N L=0.13U W=1.34U
m135 N168 AI2 VDD VDD P L=0.13U W=2.03U
m136 N168 AI2 VSS VSS N L=0.13U W=1.34U
m137 N202 N168 VSS VSS N L=0.13U W=3.32U
m138 N201 N167 N202 VSS N L=0.13U W=3.32U
m139 AP01-AIND1 AP01-AIN21 N201 VSS N L=0.13U W=3.32U
m14 AP67-AIND1 N42 VDD VDD P L=0.13U W=4.16U
m140 AP01-AIND1 N168 VDD VDD P L=0.13U W=4.16U
m141 N200 N168 VSS VSS N L=0.13U W=3.32U
m142 AP01-AIND1 N167 VDD VDD P L=0.13U W=4.16U
m143 N199 N167 N200 VSS N L=0.13U W=3.32U
m144 AP01-AIND1 AP01-AIN21 VDD VDD P L=0.13U W=4.16U
m145 AP01-AIND1 AP01-AIN21 N199 VSS N L=0.13U W=3.32U
m146 AP01-APN0 N184 AP01-AIND0 VSS N L=0.13U W=3.32U
m147 AP01-APN0 AGTPB AP01-AIND0 VDD P L=0.13U W=4.15U
m148 N184 AGTPB VDD VDD P L=0.13U W=0.58U
m149 N184 AGTPB VSS VSS N L=0.13U W=0.5U
m15 N74 N42 VSS VSS N L=0.13U W=3.32U
m150 AP01-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m151 AP01-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m152 N206 N168 VSS VSS N L=0.13U W=3.32U
m153 N205 N167 N206 VSS N L=0.13U W=3.32U
m154 AP01-AIND0 AP01-AIN20 N205 VSS N L=0.13U W=3.32U
m155 AP01-AIND0 N168 VDD VDD P L=0.13U W=4.16U
m156 N204 N168 VSS VSS N L=0.13U W=3.32U
m157 AP01-AIND0 N167 VDD VDD P L=0.13U W=4.16U
m158 N203 N167 N204 VSS N L=0.13U W=3.32U
m159 AP01-AIND0 AP01-AIN20 VDD VDD P L=0.13U W=4.16U
m16 AP67-AIND1 N41 VDD VDD P L=0.13U W=4.16U
m160 AP01-AIND0 AP01-AIN20 N203 VSS N L=0.13U W=3.32U
m161 AP01-APN1 XP_1 VDD VDD P L=0.2U W=0.15U
m162 AP01-APN1 XP_1 VSS VSS N L=0.39U W=0.15U
m163 XP_1 AP01-APN1 VDD VDD P L=0.13U W=13.74U
m164 XP_1 AP01-APN1 VSS VSS N L=0.13U W=9.48U
m165 AP01-APN0 XP_0 VDD VDD P L=0.2U W=0.15U
m166 AP01-APN0 XP_0 VSS VSS N L=0.39U W=0.15U
m167 XP_0 AP01-APN0 VDD VDD P L=0.13U W=13.74U
m168 XP_0 AP01-APN0 VSS VSS N L=0.13U W=9.48U
m169 AI2 N207 VDD VDD P L=0.13U W=2.3U
m17 N73 N41 N74 VSS N L=0.13U W=3.32U
m170 AI2 N207 VSS VSS N L=0.13U W=1.54U
m171 AI2_ A2 VDD VDD P L=0.13U W=2.3U
m172 AI2_ A2 VSS VSS N L=0.13U W=1.54U
m173 N207 A2 VDD VDD P L=0.13U W=1.84U
m174 N207 A2 VSS VSS N L=0.13U W=1.24U
m177 AI1 N216 VDD VDD P L=0.13U W=2.3U
m178 AI1 N216 VSS VSS N L=0.13U W=1.54U
m179 AI1_ A1 VDD VDD P L=0.13U W=2.3U
m18 AP67-AIND1 AP67-AIN21 VDD VDD P L=0.13U W=4.16U
m180 AI1_ A1 VSS VSS N L=0.13U W=1.54U
m181 N216 A1 VDD VDD P L=0.13U W=1.84U
m182 N216 A1 VSS VSS N L=0.13U W=1.24U
m185 AI0 N225 VDD VDD P L=0.13U W=2.3U
m186 AI0 N225 VSS VSS N L=0.13U W=1.54U
m187 AI0_ A0 VDD VDD P L=0.13U W=2.3U
m188 AI0_ A0 VSS VSS N L=0.13U W=1.54U
m189 N225 A0 VDD VDD P L=0.13U W=1.84U
m19 AP67-AIND1 AP67-AIN21 N73 VSS N L=0.13U W=3.32U
m190 N225 A0 VSS VSS N L=0.13U W=1.24U
m2 AP67-APN1 AGTPT AP67-AIND1 VDD P L=0.13U W=4.15U
m20 AP67-APN0 N58 AP67-AIND0 VSS N L=0.13U W=3.32U
m21 AP67-APN0 AGTPB AP67-AIND0 VDD P L=0.13U W=4.15U
m22 N58 AGTPB VDD VDD P L=0.13U W=0.58U
m23 N58 AGTPB VSS VSS N L=0.13U W=0.5U
m24 AP67-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m25 AP67-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m26 N80 N42 VSS VSS N L=0.13U W=3.32U
m27 N79 N41 N80 VSS N L=0.13U W=3.32U
m28 AP67-AIND0 AP67-AIN20 N79 VSS N L=0.13U W=3.32U
m29 AP67-AIND0 N42 VDD VDD P L=0.13U W=4.16U
m3 N47 AGTPT VDD VDD P L=0.13U W=0.58U
m30 N78 N42 VSS VSS N L=0.13U W=3.32U
m31 AP67-AIND0 N41 VDD VDD P L=0.13U W=4.16U
m32 N77 N41 N78 VSS N L=0.13U W=3.32U
m33 AP67-AIND0 AP67-AIN20 VDD VDD P L=0.13U W=4.16U
m34 AP67-AIND0 AP67-AIN20 N77 VSS N L=0.13U W=3.32U
m35 AP67-APN1 XP_7 VDD VDD P L=0.2U W=0.15U
m36 AP67-APN1 XP_7 VSS VSS N L=0.39U W=0.15U
m37 XP_7 AP67-APN1 VDD VDD P L=0.13U W=13.74U
m38 XP_7 AP67-APN1 VSS VSS N L=0.13U W=9.48U
m39 AP67-APN0 XP_6 VDD VDD P L=0.2U W=0.15U
m4 N47 AGTPT VSS VSS N L=0.13U W=0.5U
m40 AP67-APN0 XP_6 VSS VSS N L=0.39U W=0.15U
m41 XP_6 AP67-APN0 VDD VDD P L=0.13U W=13.74U
m42 XP_6 AP67-APN0 VSS VSS N L=0.13U W=9.48U
m43 AP45-APN1 N89 AP45-AIND1 VSS N L=0.13U W=3.32U
m44 AP45-APN1 AGTPT AP45-AIND1 VDD P L=0.13U W=4.15U
m45 N89 AGTPT VDD VDD P L=0.13U W=0.58U
m46 N89 AGTPT VSS VSS N L=0.13U W=0.5U
m47 AP45-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m48 AP45-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m49 N83 AI1 VDD VDD P L=0.13U W=2.03U
m5 AP67-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m50 N83 AI1 VSS VSS N L=0.13U W=1.34U
m51 N84 AI2_ VDD VDD P L=0.13U W=2.03U
m52 N84 AI2_ VSS VSS N L=0.13U W=1.34U
m53 N118 N84 VSS VSS N L=0.13U W=3.32U
m54 N117 N83 N118 VSS N L=0.13U W=3.32U
m55 AP45-AIND1 AP45-AIN21 N117 VSS N L=0.13U W=3.32U
m56 AP45-AIND1 N84 VDD VDD P L=0.13U W=4.16U
m57 N116 N84 VSS VSS N L=0.13U W=3.32U
m58 AP45-AIND1 N83 VDD VDD P L=0.13U W=4.16U
m59 N115 N83 N116 VSS N L=0.13U W=3.32U
m6 AP67-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m60 AP45-AIND1 AP45-AIN21 VDD VDD P L=0.13U W=4.16U
m61 AP45-AIND1 AP45-AIN21 N115 VSS N L=0.13U W=3.32U
m62 AP45-APN0 N100 AP45-AIND0 VSS N L=0.13U W=3.32U
m63 AP45-APN0 AGTPB AP45-AIND0 VDD P L=0.13U W=4.15U
m64 N100 AGTPB VDD VDD P L=0.13U W=0.58U
m65 N100 AGTPB VSS VSS N L=0.13U W=0.5U
m66 AP45-AIN20 AI0 VDD VDD P L=0.13U W=2.03U
m67 AP45-AIN20 AI0 VSS VSS N L=0.13U W=1.34U
m68 N122 N84 VSS VSS N L=0.13U W=3.32U
m69 N121 N83 N122 VSS N L=0.13U W=3.32U
m7 N41 AI1_ VDD VDD P L=0.13U W=2.03U
m70 AP45-AIND0 AP45-AIN20 N121 VSS N L=0.13U W=3.32U
m71 AP45-AIND0 N84 VDD VDD P L=0.13U W=4.16U
m72 N120 N84 VSS VSS N L=0.13U W=3.32U
m73 AP45-AIND0 N83 VDD VDD P L=0.13U W=4.16U
m74 N119 N83 N120 VSS N L=0.13U W=3.32U
m75 AP45-AIND0 AP45-AIN20 VDD VDD P L=0.13U W=4.16U
m76 AP45-AIND0 AP45-AIN20 N119 VSS N L=0.13U W=3.32U
m77 AP45-APN1 XP_5 VDD VDD P L=0.2U W=0.15U
m78 AP45-APN1 XP_5 VSS VSS N L=0.39U W=0.15U
m79 XP_5 AP45-APN1 VDD VDD P L=0.13U W=13.74U
m8 N41 AI1_ VSS VSS N L=0.13U W=1.34U
m80 XP_5 AP45-APN1 VSS VSS N L=0.13U W=9.48U
m81 AP45-APN0 XP_4 VDD VDD P L=0.2U W=0.15U
m82 AP45-APN0 XP_4 VSS VSS N L=0.39U W=0.15U
m83 XP_4 AP45-APN0 VDD VDD P L=0.13U W=13.74U
m84 XP_4 AP45-APN0 VSS VSS N L=0.13U W=9.48U
m85 AP23-APN1 N131 AP23-AIND1 VSS N L=0.13U W=3.32U
m86 AP23-APN1 AGTPT AP23-AIND1 VDD P L=0.13U W=4.15U
m87 N131 AGTPT VDD VDD P L=0.13U W=0.58U
m88 N131 AGTPT VSS VSS N L=0.13U W=0.5U
m89 AP23-AIN21 AI0_ VDD VDD P L=0.13U W=2.03U
m9 N42 AI2_ VDD VDD P L=0.13U W=2.03U
m90 AP23-AIN21 AI0_ VSS VSS N L=0.13U W=1.34U
m91 N125 AI1_ VDD VDD P L=0.13U W=2.03U
m92 N125 AI1_ VSS VSS N L=0.13U W=1.34U
m93 N126 AI2 VDD VDD P L=0.13U W=2.03U
m94 N126 AI2 VSS VSS N L=0.13U W=1.34U
m95 N160 N126 VSS VSS N L=0.13U W=3.32U
m96 N159 N125 N160 VSS N L=0.13U W=3.32U
m97 AP23-AIND1 AP23-AIN21 N159 VSS N L=0.13U W=3.32U
m98 AP23-AIND1 N126 VDD VDD P L=0.13U W=4.16U
m99 N158 N126 VSS VSS N L=0.13U W=3.32U
.ENDS RA1SH512x32HXP38
****
.SUBCKT RA1SH512x32HXP38X A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0
+  XP_1 XP_2 XP_3 XP_4 XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SH512x32HXP38X: 192 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4
+  XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32HXP38
.ENDS RA1SH512x32HXP38X
****
.SUBCKT RA1SH512x32X_PRE_DECODE A0 A0_0 A1 A1_0 A2 A2_0 AGTPB AGTPT AY0 AY0_
+  BWEN OEI_ WEI XP_0 XP_0_0 XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_4_0
+  XP_5 XP_5_0 XP_6 XP_6_0 XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD
** RA1SH512x32X_PRE_DECODE: 384 flat devices **
XI0_0 A0 A1 A2 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0 XP_1 XP_2 XP_3 XP_4
+  XP_5 XP_6 XP_7 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32HXP38X
XI1_0 A0_0 A1_0 A2_0 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI XP_0_0 XP_1_0 XP_2_0
+  XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32HXP38X
.ENDS RA1SH512x32X_PRE_DECODE
****
.SUBCKT RA1SH512x32HYP24 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** RA1SH512x32HYP24: 100 flat devices **
d15 VSS A1 DN 0.2116P 1.84U
d16 VSS BWEN DN 0.2116P 1.84U
d7 VSS A0 DN 0.2116P 1.84U
d8 VSS BWEN DN 0.2116P 1.84U
m1 AI0 N24 VDD VDD P L=0.13U W=2.3U
m10 AI1 N33 VSS VSS N L=0.13U W=1.54U
m100 YP0_3 AP_I6-APN0 VSS VSS N L=0.13U W=9.48U
m11 AI1_ A1 VDD VDD P L=0.13U W=2.3U
m12 AI1_ A1 VSS VSS N L=0.13U W=1.54U
m13 N33 A1 VDD VDD P L=0.13U W=1.84U
m14 N33 A1 VSS VSS N L=0.13U W=1.24U
m17 AP_I5-APN1 N50 AP_I5-AIND1 VSS N L=0.13U W=3.32U
m18 AP_I5-APN1 AGTPT AP_I5-AIND1 VDD P L=0.13U W=4.15U
m19 N50 AGTPT VDD VDD P L=0.13U W=0.58U
m2 AI0 N24 VSS VSS N L=0.13U W=1.54U
m20 N50 AGTPT VSS VSS N L=0.13U W=0.5U
m21 AP_I5-AIN21 AI0 VDD VDD P L=0.13U W=2.03U
m22 AP_I5-AIN21 AI0 VSS VSS N L=0.13U W=1.34U
m23 N44 AI1 VDD VDD P L=0.13U W=2.03U
m24 N44 AI1 VSS VSS N L=0.13U W=1.34U
m25 N45 VSS VDD VDD P L=0.13U W=2.03U
m26 N45 VSS VSS VSS N L=0.13U W=1.34U
m27 N79 N45 VSS VSS N L=0.13U W=3.32U
m28 N78 N44 N79 VSS N L=0.13U W=3.32U
m29 AP_I5-AIND1 AP_I5-AIN21 N78 VSS N L=0.13U W=3.32U
m3 AI0_ A0 VDD VDD P L=0.13U W=2.3U
m30 AP_I5-AIND1 N45 VDD VDD P L=0.13U W=4.16U
m31 N77 N45 VSS VSS N L=0.13U W=3.32U
m32 AP_I5-AIND1 N44 VDD VDD P L=0.13U W=4.16U
m33 N76 N44 N77 VSS N L=0.13U W=3.32U
m34 AP_I5-AIND1 AP_I5-AIN21 VDD VDD P L=0.13U W=4.16U
m35 AP_I5-AIND1 AP_I5-AIN21 N76 VSS N L=0.13U W=3.32U
m36 AP_I5-APN0 N61 AP_I5-AIND0 VSS N L=0.13U W=3.32U
m37 AP_I5-APN0 AGTPB AP_I5-AIND0 VDD P L=0.13U W=4.15U
m38 N61 AGTPB VDD VDD P L=0.13U W=0.58U
m39 N61 AGTPB VSS VSS N L=0.13U W=0.5U
m4 AI0_ A0 VSS VSS N L=0.13U W=1.54U
m40 AP_I5-AIN20 AI0_ VDD VDD P L=0.13U W=2.03U
m41 AP_I5-AIN20 AI0_ VSS VSS N L=0.13U W=1.34U
m42 N83 N45 VSS VSS N L=0.13U W=3.32U
m43 N82 N44 N83 VSS N L=0.13U W=3.32U
m44 AP_I5-AIND0 AP_I5-AIN20 N82 VSS N L=0.13U W=3.32U
m45 AP_I5-AIND0 N45 VDD VDD P L=0.13U W=4.16U
m46 N81 N45 VSS VSS N L=0.13U W=3.32U
m47 AP_I5-AIND0 N44 VDD VDD P L=0.13U W=4.16U
m48 N80 N44 N81 VSS N L=0.13U W=3.32U
m49 AP_I5-AIND0 AP_I5-AIN20 VDD VDD P L=0.13U W=4.16U
m5 N24 A0 VDD VDD P L=0.13U W=1.84U
m50 AP_I5-AIND0 AP_I5-AIN20 N80 VSS N L=0.13U W=3.32U
m51 AP_I5-APN1 YP0_0 VDD VDD P L=0.2U W=0.15U
m52 AP_I5-APN1 YP0_0 VSS VSS N L=0.39U W=0.15U
m53 YP0_0 AP_I5-APN1 VDD VDD P L=0.13U W=13.74U
m54 YP0_0 AP_I5-APN1 VSS VSS N L=0.13U W=9.48U
m55 AP_I5-APN0 YP0_1 VDD VDD P L=0.2U W=0.15U
m56 AP_I5-APN0 YP0_1 VSS VSS N L=0.39U W=0.15U
m57 YP0_1 AP_I5-APN0 VDD VDD P L=0.13U W=13.74U
m58 YP0_1 AP_I5-APN0 VSS VSS N L=0.13U W=9.48U
m59 AP_I6-APN1 N92 AP_I6-AIND1 VSS N L=0.13U W=3.32U
m6 N24 A0 VSS VSS N L=0.13U W=1.24U
m60 AP_I6-APN1 AGTPT AP_I6-AIND1 VDD P L=0.13U W=4.15U
m61 N92 AGTPT VDD VDD P L=0.13U W=0.58U
m62 N92 AGTPT VSS VSS N L=0.13U W=0.5U
m63 AP_I6-AIN21 AI0 VDD VDD P L=0.13U W=2.03U
m64 AP_I6-AIN21 AI0 VSS VSS N L=0.13U W=1.34U
m65 N86 AI1_ VDD VDD P L=0.13U W=2.03U
m66 N86 AI1_ VSS VSS N L=0.13U W=1.34U
m67 N87 VSS VDD VDD P L=0.13U W=2.03U
m68 N87 VSS VSS VSS N L=0.13U W=1.34U
m69 N121 N87 VSS VSS N L=0.13U W=3.32U
m70 N120 N86 N121 VSS N L=0.13U W=3.32U
m71 AP_I6-AIND1 AP_I6-AIN21 N120 VSS N L=0.13U W=3.32U
m72 AP_I6-AIND1 N87 VDD VDD P L=0.13U W=4.16U
m73 N119 N87 VSS VSS N L=0.13U W=3.32U
m74 AP_I6-AIND1 N86 VDD VDD P L=0.13U W=4.16U
m75 N118 N86 N119 VSS N L=0.13U W=3.32U
m76 AP_I6-AIND1 AP_I6-AIN21 VDD VDD P L=0.13U W=4.16U
m77 AP_I6-AIND1 AP_I6-AIN21 N118 VSS N L=0.13U W=3.32U
m78 AP_I6-APN0 N103 AP_I6-AIND0 VSS N L=0.13U W=3.32U
m79 AP_I6-APN0 AGTPB AP_I6-AIND0 VDD P L=0.13U W=4.15U
m80 N103 AGTPB VDD VDD P L=0.13U W=0.58U
m81 N103 AGTPB VSS VSS N L=0.13U W=0.5U
m82 AP_I6-AIN20 AI0_ VDD VDD P L=0.13U W=2.03U
m83 AP_I6-AIN20 AI0_ VSS VSS N L=0.13U W=1.34U
m84 N125 N87 VSS VSS N L=0.13U W=3.32U
m85 N124 N86 N125 VSS N L=0.13U W=3.32U
m86 AP_I6-AIND0 AP_I6-AIN20 N124 VSS N L=0.13U W=3.32U
m87 AP_I6-AIND0 N87 VDD VDD P L=0.13U W=4.16U
m88 N123 N87 VSS VSS N L=0.13U W=3.32U
m89 AP_I6-AIND0 N86 VDD VDD P L=0.13U W=4.16U
m9 AI1 N33 VDD VDD P L=0.13U W=2.3U
m90 N122 N86 N123 VSS N L=0.13U W=3.32U
m91 AP_I6-AIND0 AP_I6-AIN20 VDD VDD P L=0.13U W=4.16U
m92 AP_I6-AIND0 AP_I6-AIN20 N122 VSS N L=0.13U W=3.32U
m93 AP_I6-APN1 YP0_2 VDD VDD P L=0.2U W=0.15U
m94 AP_I6-APN1 YP0_2 VSS VSS N L=0.39U W=0.15U
m95 YP0_2 AP_I6-APN1 VDD VDD P L=0.13U W=13.74U
m96 YP0_2 AP_I6-APN1 VSS VSS N L=0.13U W=9.48U
m97 AP_I6-APN0 YP0_3 VDD VDD P L=0.2U W=0.15U
m98 AP_I6-APN0 YP0_3 VSS VSS N L=0.39U W=0.15U
m99 YP0_3 AP_I6-APN0 VDD VDD P L=0.13U W=13.74U
.ENDS RA1SH512x32HYP24
****
.SUBCKT RA1SH512x32HYP24X A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD
** RA1SH512x32HYP24X: 100 flat devices **
XI0_0 A0 A1 AGTPB AGTPT AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SH512x32HYP24
.ENDS RA1SH512x32HYP24X
****
.SUBCKT RA1SH512x32HYP12XR A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32HYP12XR: 92 flat devices **
d7 VSS A0 DN 0.2116P 1.84U
d8 VSS BWEN DN 0.2116P 1.84U
m1 N22 N25 VDD VDD P L=0.13U W=2.3U
m10 AP0-APN1 AGTP AP0-AIND1 VDD P L=0.13U W=4.15U
m11 N42 AGTP VDD VDD P L=0.13U W=0.58U
m12 N42 AGTP VSS VSS N L=0.13U W=0.5U
m13 AP0-AIN21 N22 VDD VDD P L=0.13U W=2.03U
m14 AP0-AIN21 N22 VSS VSS N L=0.13U W=1.34U
m15 N36 VSS VDD VDD P L=0.13U W=2.03U
m16 N36 VSS VSS VSS N L=0.13U W=1.34U
m17 N37 VSS VDD VDD P L=0.13U W=2.03U
m18 N37 VSS VSS VSS N L=0.13U W=1.34U
m19 N71 N37 VSS VSS N L=0.13U W=3.32U
m2 N22 N25 VSS VSS N L=0.13U W=1.54U
m20 N70 N36 N71 VSS N L=0.13U W=3.32U
m21 AP0-AIND1 AP0-AIN21 N70 VSS N L=0.13U W=3.32U
m22 AP0-AIND1 N37 VDD VDD P L=0.13U W=4.16U
m23 N69 N37 VSS VSS N L=0.13U W=3.32U
m24 AP0-AIND1 N36 VDD VDD P L=0.13U W=4.16U
m25 N68 N36 N69 VSS N L=0.13U W=3.32U
m26 AP0-AIND1 AP0-AIN21 VDD VDD P L=0.13U W=4.16U
m27 AP0-AIND1 AP0-AIN21 N68 VSS N L=0.13U W=3.32U
m28 AP0-APN0 N53 AP0-AIND0 VSS N L=0.13U W=3.32U
m29 AP0-APN0 AGTP AP0-AIND0 VDD P L=0.13U W=4.15U
m3 N21 A0 VDD VDD P L=0.13U W=2.3U
m30 N53 AGTP VDD VDD P L=0.13U W=0.58U
m31 N53 AGTP VSS VSS N L=0.13U W=0.5U
m32 AP0-AIN20 N21 VDD VDD P L=0.13U W=2.03U
m33 AP0-AIN20 N21 VSS VSS N L=0.13U W=1.34U
m34 N75 N37 VSS VSS N L=0.13U W=3.32U
m35 N74 N36 N75 VSS N L=0.13U W=3.32U
m36 AP0-AIND0 AP0-AIN20 N74 VSS N L=0.13U W=3.32U
m37 AP0-AIND0 N37 VDD VDD P L=0.13U W=4.16U
m38 N73 N37 VSS VSS N L=0.13U W=3.32U
m39 AP0-AIND0 N36 VDD VDD P L=0.13U W=4.16U
m4 N21 A0 VSS VSS N L=0.13U W=1.54U
m40 N72 N36 N73 VSS N L=0.13U W=3.32U
m41 AP0-AIND0 AP0-AIN20 VDD VDD P L=0.13U W=4.16U
m42 AP0-AIND0 AP0-AIN20 N72 VSS N L=0.13U W=3.32U
m43 AP0-APN1 AY0_ VDD VDD P L=0.2U W=0.15U
m44 AP0-APN1 AY0_ VSS VSS N L=0.39U W=0.15U
m45 AY0_ AP0-APN1 VDD VDD P L=0.13U W=13.74U
m46 AY0_ AP0-APN1 VSS VSS N L=0.13U W=9.48U
m47 AP0-APN0 AY0 VDD VDD P L=0.2U W=0.15U
m48 AP0-APN0 AY0 VSS VSS N L=0.39U W=0.15U
m49 AY0 AP0-APN0 VDD VDD P L=0.13U W=13.74U
m5 N25 A0 VDD VDD P L=0.13U W=1.84U
m50 AY0 AP0-APN0 VSS VSS N L=0.13U W=9.48U
m51 AP_I1-APN1 N84 AP_I1-AIND1 VSS N L=0.13U W=3.32U
m52 AP_I1-APN1 AGTP AP_I1-AIND1 VDD P L=0.13U W=4.15U
m53 N84 AGTP VDD VDD P L=0.13U W=0.58U
m54 N84 AGTP VSS VSS N L=0.13U W=0.5U
m55 AP_I1-AIN21 N22 VDD VDD P L=0.13U W=2.03U
m56 AP_I1-AIN21 N22 VSS VSS N L=0.13U W=1.34U
m57 N78 VSS VDD VDD P L=0.13U W=2.03U
m58 N78 VSS VSS VSS N L=0.13U W=1.34U
m59 N79 VSS VDD VDD P L=0.13U W=2.03U
m6 N25 A0 VSS VSS N L=0.13U W=1.24U
m60 N79 VSS VSS VSS N L=0.13U W=1.34U
m61 N113 N79 VSS VSS N L=0.13U W=3.32U
m62 N112 N78 N113 VSS N L=0.13U W=3.32U
m63 AP_I1-AIND1 AP_I1-AIN21 N112 VSS N L=0.13U W=3.32U
m64 AP_I1-AIND1 N79 VDD VDD P L=0.13U W=4.16U
m65 N111 N79 VSS VSS N L=0.13U W=3.32U
m66 AP_I1-AIND1 N78 VDD VDD P L=0.13U W=4.16U
m67 N110 N78 N111 VSS N L=0.13U W=3.32U
m68 AP_I1-AIND1 AP_I1-AIN21 VDD VDD P L=0.13U W=4.16U
m69 AP_I1-AIND1 AP_I1-AIN21 N110 VSS N L=0.13U W=3.32U
m70 AP_I1-APN0 N95 AP_I1-AIND0 VSS N L=0.13U W=3.32U
m71 AP_I1-APN0 AGTP AP_I1-AIND0 VDD P L=0.13U W=4.15U
m72 N95 AGTP VDD VDD P L=0.13U W=0.58U
m73 N95 AGTP VSS VSS N L=0.13U W=0.5U
m74 AP_I1-AIN20 N21 VDD VDD P L=0.13U W=2.03U
m75 AP_I1-AIN20 N21 VSS VSS N L=0.13U W=1.34U
m76 N117 N79 VSS VSS N L=0.13U W=3.32U
m77 N116 N78 N117 VSS N L=0.13U W=3.32U
m78 AP_I1-AIND0 AP_I1-AIN20 N116 VSS N L=0.13U W=3.32U
m79 AP_I1-AIND0 N79 VDD VDD P L=0.13U W=4.16U
m80 N115 N79 VSS VSS N L=0.13U W=3.32U
m81 AP_I1-AIND0 N78 VDD VDD P L=0.13U W=4.16U
m82 N114 N78 N115 VSS N L=0.13U W=3.32U
m83 AP_I1-AIND0 AP_I1-AIN20 VDD VDD P L=0.13U W=4.16U
m84 AP_I1-AIND0 AP_I1-AIN20 N114 VSS N L=0.13U W=3.32U
m85 AP_I1-APN1 AY0_ VDD VDD P L=0.2U W=0.15U
m86 AP_I1-APN1 AY0_ VSS VSS N L=0.39U W=0.15U
m87 AY0_ AP_I1-APN1 VDD VDD P L=0.13U W=13.74U
m88 AY0_ AP_I1-APN1 VSS VSS N L=0.13U W=9.48U
m89 AP_I1-APN0 AY0 VDD VDD P L=0.2U W=0.15U
m9 AP0-APN1 N42 AP0-AIND1 VSS N L=0.13U W=3.32U
m90 AP_I1-APN0 AY0 VSS VSS N L=0.39U W=0.15U
m91 AY0 AP_I1-APN0 VDD VDD P L=0.13U W=13.74U
m92 AY0 AP_I1-APN0 VSS VSS N L=0.13U W=9.48U
.ENDS RA1SH512x32HYP12XR
****
.SUBCKT RA1SH512x32HYP12XRX A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32HYP12XRX: 92 flat devices **
XI0_0 A0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32HYP12XR
.ENDS RA1SH512x32HYP12XRX
****
.SUBCKT RA1SH512x32Y_DECODE A0 A0_0 A1 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_
+  RST WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
** RA1SH512x32Y_DECODE: 192 flat devices **
XI0_0 A0 A1 AGTP AGTP AY0 AY0_ BWEN OEI_ WEI YP0_0 YP0_1 YP0_2 YP0_3 VSS VDD
+  RA1SH512x32HYP24X
XI1_0 A0_0 AGTP AY0 AY0_ BWEN CLK GSRCN GTPN OEI_ RST WEI YP0_0 YP0_1 YP0_2
+  YP0_3 VSS VSS VSS VSS VSS VDD RA1SH512x32HYP12XRX
.ENDS RA1SH512x32Y_DECODE
****
.SUBCKT RA1SH512x32HBF8 CEN CLK GSRCN GTP GTPN MBL RST STOV STUBWE TMS WE WEI
+  WEN VSS VDD
** RA1SH512x32HBF8: 76 flat devices **
d72 VSS WEN DN 0.2116P 1.84U
d73 VSS CEN DN 0.2116P 1.84U
d74 VSS STOV DN 0.2116P 1.84U
d75 VSS CLK DN 0.2116P 1.84U
d76 VSS TMS DN 0.2116P 1.84U
m1 WE N31 VDD VDD P L=0.13U W=7.67U
m10 BF-RSRCN BF-CKSTOV N75 VSS N L=0.13U W=0.91U
m11 BF-RSRCN GTP VDD VDD P L=0.13U W=1.43U
m12 N74 GTP VSS VSS N L=0.13U W=0.91U
m13 BF-RSRCN BF-CKSTOV VDD VDD P L=0.13U W=1.43U
m14 BF-RSRCN BF-CKSTOV N74 VSS N L=0.13U W=0.91U
m15 BF-RSTSRC BF-RSRCN VDD VDD P L=0.13U W=4.32U
m16 BF-RSTSRC BF-RSRCN VSS VSS N L=0.13U W=2.77U
m17 BF-CKSTOV STOV VDD VDD P L=0.13U W=0.58U
m18 N76 STOV VSS VSS N L=0.13U W=0.74U
m19 BF-CKSTOV CLK VDD VDD P L=0.13U W=0.58U
m2 WE N31 VSS VSS N L=0.13U W=5.39U
m20 BF-CKSTOV CLK N76 VSS N L=0.13U W=0.74U
m21 GTPN BF-GTPI N44 VSS N L=0.13U W=0.15U
m22 N25 N25 VDD VDD P L=0.13U W=0.15U
m23 GTPN BF-GTPI VDD VDD P L=0.13U W=0.15U
m24 N25 VDD VDD VDD P L=0.13U W=0.15U
m25 BF-GTPI GTPN VDD VDD P L=0.13U W=0.3U
m26 BF-GTPI GTPN VSS VSS N L=0.13U W=0.15U
m27 N44 N25 VSS VSS N L=0.13U W=0.15U
m28 N78 BF-CLKN VSS VSS N L=0.13U W=1.78U
m29 GSRCN BF-CEL N78 VSS N L=0.13U W=1.78U
m3 BF-CENMML BF-CLKN N73 VDD P L=0.13U W=0.15U
m30 GSRCN BF-CLKN VDD VDD P L=0.13U W=2.22U
m31 N77 BF-CLKN VSS VSS N L=0.13U W=1.78U
m32 GSRCN BF-CEL VDD VDD P L=0.13U W=2.22U
m33 GSRCN BF-CEL N77 VSS N L=0.13U W=1.78U
m34 N53 BF-CLKN VSS VSS N L=0.13U W=0.34U
m35 N55 CLK VDD VDD P L=0.13U W=0.63U
m36 BF-CENMML N57 N58 VDD P L=0.13U W=0.63U
m37 BF-CENMML N57 N53 VSS N L=0.13U W=0.34U
m38 N58 TMS N55 VDD P L=0.13U W=0.63U
m39 BF-CENMML TMS N53 VSS N L=0.13U W=0.34U
m4 N73 BF-CEL VDD VDD P L=0.13U W=0.15U
m40 RST BF-MBLN VDD VDD P L=0.13U W=2.25U
m41 RST BF-RSTSRC VDD VDD P L=0.13U W=7.66U
m42 BF-MBLN MBL VDD VDD P L=0.13U W=3.28U
m43 BF-MBLN MBL VSS VSS N L=0.13U W=1.5U
m44 N63 WEN VDD VDD P L=0.13U W=0.79U
m45 N63 WEN VSS VSS N L=0.13U W=0.53U
m46 N57 CEN VDD VDD P L=0.13U W=0.7U
m47 N57 CEN VSS VSS N L=0.13U W=0.47U
m48 RST BF-MBLN N88 VSS N L=0.13U W=1.28U
m49 N88 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m5 BF-CENMML CLK N72 VSS N L=0.13U W=0.15U
m50 RST BF-MBLN N87 VSS N L=0.13U W=1.28U
m51 N87 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m52 RST BF-MBLN N86 VSS N L=0.13U W=1.28U
m53 N86 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m54 RST BF-MBLN N85 VSS N L=0.13U W=1.28U
m55 N85 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m56 RST BF-MBLN N84 VSS N L=0.13U W=1.28U
m57 N84 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m58 RST BF-MBLN N83 VSS N L=0.13U W=1.28U
m59 N83 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m6 N72 BF-CEL VSS VSS N L=0.13U W=0.15U
m60 RST BF-MBLN N82 VSS N L=0.13U W=1.28U
m61 N82 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m62 RST BF-MBLN N81 VSS N L=0.13U W=1.28U
m63 N81 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m64 RST BF-MBLN N80 VSS N L=0.13U W=1.28U
m65 N80 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m66 RST BF-MBLN N79 VSS N L=0.13U W=1.28U
m67 N79 BF-RSTSRC VSS VSS N L=0.13U W=1.66U
m68 N31 N63 VDD VDD P L=0.13U W=2.24U
m69 N31 N63 VSS VSS N L=0.13U W=1.44U
m7 BF-CEL BF-CENMML VDD VDD P L=0.13U W=0.91U
m70 BF-CLKN CLK VDD VDD P L=0.13U W=1.05U
m71 BF-CLKN CLK VSS VSS N L=0.26U W=0.67U
m8 BF-CEL BF-CENMML VSS VSS N L=0.13U W=0.65U
m9 N75 GTP VSS VSS N L=0.13U W=0.91U
.ENDS RA1SH512x32HBF8
****
.SUBCKT RA1SH512x32HBFX CEN CLK GSRCN GTP GTPN MBL RST STUBWE WEI WEN VSS VDD
** RA1SH512x32HBFX: 76 flat devices **
XI0_0 CEN CLK GSRCN GTP GTPN MBL RST VSS STUBWE VSS WEI WEI WEN VSS VDD
+  RA1SH512x32HBF8
.ENDS RA1SH512x32HBFX
****
.SUBCKT RA1SH512x32CCMWP BL BLD BLD_ BL_ WL WP VSS VDD
** RA1SH512x32CCMWP: 6 flat devices **
m1 BLD WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BLD_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RA1SH512x32CCMWP
****
.SUBCKT RA1SH512x32CCMWG BL BLD BLD_ BL_ WL WP VSS VDD
** RA1SH512x32CCMWG: 6 flat devices **
m1 BLD WP CORED VSS NCH_SRAM L=0.16U W=0.16U
m2 BLD_ WP CORED_ VSS NCH_SRAM L=0.16U W=0.16U
m3 CORED_ CORED VDD VDD PCH_SRAM L=0.145U W=0.16U
m4 CORED_ CORED VSS VSS NCH_SRAM L=0.13U W=0.23U
m5 CORED CORED_ VDD VDD PCH_SRAM L=0.145U W=0.16U
m6 CORED CORED_ VSS VSS NCH_SRAM L=0.13U W=0.23U
.ENDS RA1SH512x32CCMWG
****
.SUBCKT RA1SH512x32FLMWG BL0 BL0_ BL1 BL1_ WL WP0 WP1 WP2 WP3 VSS VDD
** RA1SH512x32FLMWG: 24 flat devices **
m1 N11 WP1 N19 VSS NCH_SRAM L=0.16U W=0.16U
m10 N13 N14 VSS VSS NCH_SRAM L=0.13U W=0.23U
m11 N18 WP3 N28 VSS NCH_SRAM L=0.16U W=0.16U
m12 N17 N18 VDD VDD PCH_SRAM L=0.145U W=0.16U
m13 N17 N18 VSS VSS NCH_SRAM L=0.13U W=0.23U
m14 N18 N17 VDD VDD PCH_SRAM L=0.145U W=0.16U
m15 N18 N17 VSS VSS NCH_SRAM L=0.13U W=0.23U
m16 N16 WP2 N28 VSS NCH_SRAM L=0.16U W=0.16U
m17 N15 N16 VDD VDD PCH_SRAM L=0.145U W=0.16U
m18 N15 N16 VSS VSS NCH_SRAM L=0.13U W=0.23U
m19 N16 N15 VDD VDD PCH_SRAM L=0.145U W=0.16U
m2 N12 N11 VDD VDD PCH_SRAM L=0.145U W=0.16U
m20 N16 N15 VSS VSS NCH_SRAM L=0.13U W=0.23U
m21 N12 WP3 N37 VSS NCH_SRAM L=0.16U W=0.16U
m22 N14 WP2 N37 VSS NCH_SRAM L=0.16U W=0.16U
m23 N17 WP3 N38 VSS NCH_SRAM L=0.16U W=0.16U
m24 N15 WP2 N38 VSS NCH_SRAM L=0.16U W=0.16U
m3 N12 N11 VSS VSS NCH_SRAM L=0.13U W=0.23U
m4 N11 N12 VDD VDD PCH_SRAM L=0.145U W=0.16U
m5 N11 N12 VSS VSS NCH_SRAM L=0.13U W=0.23U
m6 N13 WP0 N19 VSS NCH_SRAM L=0.16U W=0.16U
m7 N14 N13 VDD VDD PCH_SRAM L=0.145U W=0.16U
m8 N14 N13 VSS VSS NCH_SRAM L=0.13U W=0.23U
m9 N13 N14 VDD VDD PCH_SRAM L=0.145U W=0.16U
.ENDS RA1SH512x32FLMWG
****
.SUBCKT RA1SH512x32MODEL_ROW_16 BL BL0 BL0_ BL1 BL1_ BL_ BL_0 BL_1 BL_2 BL_3
+  BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16
+  BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40
+  BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52
+  BL_53 BL_54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64
+  BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76
+  BL_77 BL_78 BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88
+  BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100
+  BL_101 BL_102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110
+  BL_111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120
+  BL_121 BL_122 BL_123 BL_124 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 WL VSS VDD
** RA1SH512x32MODEL_ROW_16: 1536 flat devices **
XI0_0 BL BLD_216 BLD__214 BL_ WL WL VSS VDD RA1SH512x32CCMWG
XI0_1 BL_ BLD__214 BLD_216 BL WL WL VSS VDD RA1SH512x32CCMWG
XI100_0 BL_94 BLD_276 BLD__274 BL__94 VSS VSS VSS VDD RA1SH512x32CCMWP
XI100_1 BL__94 BLD__274 BLD_276 BL_94 VSS VSS VSS VDD RA1SH512x32CCMWP
XI101_0 BL_95 BLD_408 BLD__406 BL__95 VSS VSS VSS VDD RA1SH512x32CCMWP
XI101_1 BL__95 BLD__406 BLD_408 BL_95 VSS VSS VSS VDD RA1SH512x32CCMWP
XI102_0 BL_96 BLD_32 BLD__30 BL__96 VSS VSS VSS VDD RA1SH512x32CCMWG
XI102_1 BL__96 BLD__30 BLD_32 BL_96 VSS VSS VSS VDD RA1SH512x32CCMWG
XI103_0 BL_97 BLD_156 BLD__154 BL__97 VSS VSS VSS VDD RA1SH512x32CCMWG
XI103_1 BL__97 BLD__154 BLD_156 BL_97 VSS VSS VSS VDD RA1SH512x32CCMWG
XI104_0 BL_98 BLD_284 BLD__282 BL__98 VSS VSS VSS VDD RA1SH512x32CCMWP
XI104_1 BL__98 BLD__282 BLD_284 BL_98 VSS VSS VSS VDD RA1SH512x32CCMWP
XI105_0 BL_99 BLD_416 BLD__414 BL__99 VSS VSS VSS VDD RA1SH512x32CCMWP
XI105_1 BL__99 BLD__414 BLD_416 BL_99 VSS VSS VSS VDD RA1SH512x32CCMWP
XI106_0 BL_100 BLD_40 BLD__38 BL__100 VSS VSS VSS VDD RA1SH512x32CCMWG
XI106_1 BL__100 BLD__38 BLD_40 BL_100 VSS VSS VSS VDD RA1SH512x32CCMWG
XI107_0 BL_101 BLD_164 BLD__162 BL__101 VSS VSS VSS VDD RA1SH512x32CCMWG
XI107_1 BL__101 BLD__162 BLD_164 BL_101 VSS VSS VSS VDD RA1SH512x32CCMWG
XI108_0 BL_102 BLD_292 BLD__290 BL__102 VSS VSS VSS VDD RA1SH512x32CCMWP
XI108_1 BL__102 BLD__290 BLD_292 BL_102 VSS VSS VSS VDD RA1SH512x32CCMWP
XI109_0 BL_103 BLD_424 BLD__422 BL__103 VSS VSS VSS VDD RA1SH512x32CCMWP
XI109_1 BL__103 BLD__422 BLD_424 BL_103 VSS VSS VSS VDD RA1SH512x32CCMWP
XI10_0 BL_9 BLD_48 BLD__46 BL__9 WL WL VSS VDD RA1SH512x32CCMWP
XI10_1 BL__9 BLD__46 BLD_48 BL_9 WL WL VSS VDD RA1SH512x32CCMWP
XI110_0 BL_104 BLD_480 BLD__478 BL__104 VSS VSS VSS VDD RA1SH512x32CCMWG
XI110_1 BL__104 BLD__478 BLD_480 BL_104 VSS VSS VSS VDD RA1SH512x32CCMWG
XI111_0 BL_105 BLD_96 BLD__94 BL__105 VSS VSS VSS VDD RA1SH512x32CCMWG
XI111_1 BL__105 BLD__94 BLD_96 BL_105 VSS VSS VSS VDD RA1SH512x32CCMWG
XI112_0 BL_106 BLD_228 BLD__226 BL__106 VSS VSS VSS VDD RA1SH512x32CCMWP
XI112_1 BL__106 BLD__226 BLD_228 BL_106 VSS VSS VSS VDD RA1SH512x32CCMWP
XI113_0 BL_107 BLD_356 BLD__354 BL__107 VSS VSS VSS VDD RA1SH512x32CCMWP
XI113_1 BL__107 BLD__354 BLD_356 BL_107 VSS VSS VSS VDD RA1SH512x32CCMWP
XI114_0 BL_108 BLD_488 BLD__486 BL__108 VSS VSS VSS VDD RA1SH512x32CCMWG
XI114_1 BL__108 BLD__486 BLD_488 BL_108 VSS VSS VSS VDD RA1SH512x32CCMWG
XI115_0 BL_109 BLD_104 BLD__102 BL__109 VSS VSS VSS VDD RA1SH512x32CCMWG
XI115_1 BL__109 BLD__102 BLD_104 BL_109 VSS VSS VSS VDD RA1SH512x32CCMWG
XI116_0 BL_110 BLD_236 BLD__234 BL__110 VSS VSS VSS VDD RA1SH512x32CCMWP
XI116_1 BL__110 BLD__234 BLD_236 BL_110 VSS VSS VSS VDD RA1SH512x32CCMWP
XI117_0 BL_111 BLD_364 BLD__362 BL__111 VSS VSS VSS VDD RA1SH512x32CCMWP
XI117_1 BL__111 BLD__362 BLD_364 BL_111 VSS VSS VSS VDD RA1SH512x32CCMWP
XI118_0 BL_112 BLD_492 BLD__490 BL__112 VSS VSS VSS VDD RA1SH512x32CCMWG
XI118_1 BL__112 BLD__490 BLD_492 BL_112 VSS VSS VSS VDD RA1SH512x32CCMWG
XI119_0 BL_113 BLD_112 BLD__110 BL__113 VSS VSS VSS VDD RA1SH512x32CCMWG
XI119_1 BL__113 BLD__110 BLD_112 BL_113 VSS VSS VSS VDD RA1SH512x32CCMWG
XI11_0 BL_10 BLD_172 BLD__170 BL__10 WL WL VSS VDD RA1SH512x32CCMWG
XI11_1 BL__10 BLD__170 BLD_172 BL_10 WL WL VSS VDD RA1SH512x32CCMWG
XI120_0 BL_114 BLD_152 BLD__150 BL__114 VSS VSS VSS VDD RA1SH512x32CCMWP
XI120_1 BL__114 BLD__150 BLD_152 BL_114 VSS VSS VSS VDD RA1SH512x32CCMWP
XI121_0 BL_115 BLD_280 BLD__278 BL__115 VSS VSS VSS VDD RA1SH512x32CCMWP
XI121_1 BL__115 BLD__278 BLD_280 BL_115 VSS VSS VSS VDD RA1SH512x32CCMWP
XI122_0 BL_116 BLD_412 BLD__410 BL__116 VSS VSS VSS VDD RA1SH512x32CCMWG
XI122_1 BL__116 BLD__410 BLD_412 BL_116 VSS VSS VSS VDD RA1SH512x32CCMWG
XI123_0 BL_117 BLD_36 BLD__34 BL__117 VSS VSS VSS VDD RA1SH512x32CCMWG
XI123_1 BL__117 BLD__34 BLD_36 BL_117 VSS VSS VSS VDD RA1SH512x32CCMWG
XI124_0 BL_118 BLD_160 BLD__158 BL__118 VSS VSS VSS VDD RA1SH512x32CCMWP
XI124_1 BL__118 BLD__158 BLD_160 BL_118 VSS VSS VSS VDD RA1SH512x32CCMWP
XI125_0 BL_119 BLD_288 BLD__286 BL__119 VSS VSS VSS VDD RA1SH512x32CCMWP
XI125_1 BL__119 BLD__286 BLD_288 BL_119 VSS VSS VSS VDD RA1SH512x32CCMWP
XI126_0 BL_120 BLD_420 BLD__418 BL__120 VSS VSS VSS VDD RA1SH512x32CCMWG
XI126_1 BL__120 BLD__418 BLD_420 BL_120 VSS VSS VSS VDD RA1SH512x32CCMWG
XI127_0 BL_121 BLD_44 BLD__42 BL__121 VSS VSS VSS VDD RA1SH512x32CCMWG
XI127_1 BL__121 BLD__42 BLD_44 BL_121 VSS VSS VSS VDD RA1SH512x32CCMWG
XI128_0 BL_122 BLD_168 BLD__166 BL__122 VSS VSS VSS VDD RA1SH512x32CCMWP
XI128_1 BL__122 BLD__166 BLD_168 BL_122 VSS VSS VSS VDD RA1SH512x32CCMWP
XI129_0 BL_123 BLD_296 BLD__294 BL__123 VSS VSS VSS VDD RA1SH512x32CCMWP
XI129_1 BL__123 BLD__294 BLD_296 BL_123 VSS VSS VSS VDD RA1SH512x32CCMWP
XI12_0 BL_11 BLD_300 BLD__298 BL__11 WL WL VSS VDD RA1SH512x32CCMWG
XI12_1 BL__11 BLD__298 BLD_300 BL_11 WL WL VSS VDD RA1SH512x32CCMWG
XI130_0 BL_124 BLD_352 BLD__350 BL__124 VSS VSS VSS VDD RA1SH512x32CCMWG
XI130_1 BL__124 BLD__350 BLD_352 BL_124 VSS VSS VSS VDD RA1SH512x32CCMWG
XI13_0 BL_12 BLD_432 BLD__430 BL__12 WL WL VSS VDD RA1SH512x32CCMWP
XI13_1 BL__12 BLD__430 BLD_432 BL_12 WL WL VSS VDD RA1SH512x32CCMWP
XI14_0 BL_13 BLD_56 BLD__54 BL__13 WL WL VSS VDD RA1SH512x32CCMWP
XI14_1 BL__13 BLD__54 BLD_56 BL_13 WL WL VSS VDD RA1SH512x32CCMWP
XI15_0 BL_14 BLD_176 BLD__174 BL__14 WL WL VSS VDD RA1SH512x32CCMWG
XI15_1 BL__14 BLD__174 BLD_176 BL_14 WL WL VSS VDD RA1SH512x32CCMWG
XI16_0 BL_15 BLD_312 BLD__310 BL__15 WL WL VSS VDD RA1SH512x32CCMWG
XI16_1 BL__15 BLD__310 BLD_312 BL_15 WL WL VSS VDD RA1SH512x32CCMWG
XI17_0 BL_16 BLD_444 BLD__442 BL__16 WL WL VSS VDD RA1SH512x32CCMWP
XI17_1 BL__16 BLD__442 BLD_444 BL_16 WL WL VSS VDD RA1SH512x32CCMWP
XI18_0 BL_17 BLD_72 BLD__70 BL__17 WL WL VSS VDD RA1SH512x32CCMWP
XI18_1 BL__17 BLD__70 BLD_72 BL_17 WL WL VSS VDD RA1SH512x32CCMWP
XI19_0 BL_18 BLD_192 BLD__190 BL__18 WL WL VSS VDD RA1SH512x32CCMWG
XI19_1 BL__18 BLD__190 BLD_192 BL_18 WL WL VSS VDD RA1SH512x32CCMWG
XI1_0 BL_0 BLD_348 BLD__346 BL__0 WL WL VSS VDD RA1SH512x32CCMWP
XI1_1 BL__0 BLD__346 BLD_348 BL_0 WL WL VSS VDD RA1SH512x32CCMWP
XI20_0 BL_19 BLD_240 BLD__238 BL__19 WL WL VSS VDD RA1SH512x32CCMWG
XI20_1 BL__19 BLD__238 BLD_240 BL_19 WL WL VSS VDD RA1SH512x32CCMWG
XI21_0 BL_20 BLD_372 BLD__370 BL__20 WL WL VSS VDD RA1SH512x32CCMWP
XI21_1 BL__20 BLD__370 BLD_372 BL_20 WL WL VSS VDD RA1SH512x32CCMWP
XI22_0 BL_21 BLD_496 BLD__494 BL__21 WL WL VSS VDD RA1SH512x32CCMWP
XI22_1 BL__21 BLD__494 BLD_496 BL_21 WL WL VSS VDD RA1SH512x32CCMWP
XI23_0 BL_22 BLD_120 BLD__118 BL__22 WL WL VSS VDD RA1SH512x32CCMWG
XI23_1 BL__22 BLD__118 BLD_120 BL_22 WL WL VSS VDD RA1SH512x32CCMWG
XI24_0 BL_23 BLD_248 BLD__246 BL__23 WL WL VSS VDD RA1SH512x32CCMWG
XI24_1 BL__23 BLD__246 BLD_248 BL_23 WL WL VSS VDD RA1SH512x32CCMWG
XI25_0 BL_24 BLD_380 BLD__378 BL__24 WL WL VSS VDD RA1SH512x32CCMWP
XI25_1 BL__24 BLD__378 BLD_380 BL_24 WL WL VSS VDD RA1SH512x32CCMWP
XI26_0 BL_25 BLD_4 BLD__2 BL__25 WL WL VSS VDD RA1SH512x32CCMWP
XI26_1 BL__25 BLD__2 BLD_4 BL_25 WL WL VSS VDD RA1SH512x32CCMWP
XI27_0 BL_26 BLD_132 BLD__130 BL__26 WL WL VSS VDD RA1SH512x32CCMWG
XI27_1 BL__26 BLD__130 BLD_132 BL_26 WL WL VSS VDD RA1SH512x32CCMWG
XI28_0 BL_27 BLD_260 BLD__258 BL__27 WL WL VSS VDD RA1SH512x32CCMWG
XI28_1 BL__27 BLD__258 BLD_260 BL_27 WL WL VSS VDD RA1SH512x32CCMWG
XI29_0 BL_28 BLD_396 BLD__394 BL__28 WL WL VSS VDD RA1SH512x32CCMWP
XI29_1 BL__28 BLD__394 BLD_396 BL_28 WL WL VSS VDD RA1SH512x32CCMWP
XI2_0 BL_1 BLD_476 BLD__474 BL__1 WL WL VSS VDD RA1SH512x32CCMWP
XI2_1 BL__1 BLD__474 BLD_476 BL_1 WL WL VSS VDD RA1SH512x32CCMWP
XI30_0 BL_29 BLD_428 BLD__426 BL__29 WL WL VSS VDD RA1SH512x32CCMWP
XI30_1 BL__29 BLD__426 BLD_428 BL_29 WL WL VSS VDD RA1SH512x32CCMWP
XI31_0 BL_30 BLD_52 BLD__50 BL__30 WL WL VSS VDD RA1SH512x32CCMWG
XI31_1 BL__30 BLD__50 BLD_52 BL_30 WL WL VSS VDD RA1SH512x32CCMWG
XI33_0 BL_31 BLD_308 BLD__306 BL__31 WL WL VSS VDD RA1SH512x32CCMWG
XI33_1 BL__31 BLD__306 BLD_308 BL_31 WL WL VSS VDD RA1SH512x32CCMWG
XI34_0 BL_32 BLD_440 BLD__438 BL__32 WL WL VSS VDD RA1SH512x32CCMWP
XI34_1 BL__32 BLD__438 BLD_440 BL_32 WL WL VSS VDD RA1SH512x32CCMWP
XI35_0 BL_33 BLD_64 BLD__62 BL__33 WL WL VSS VDD RA1SH512x32CCMWP
XI35_1 BL__33 BLD__62 BLD_64 BL_33 WL WL VSS VDD RA1SH512x32CCMWP
XI36_0 BL_34 BLD_188 BLD__186 BL__34 WL WL VSS VDD RA1SH512x32CCMWG
XI36_1 BL__34 BLD__186 BLD_188 BL_34 WL WL VSS VDD RA1SH512x32CCMWG
XI37_0 BL_35 BLD_324 BLD__322 BL__35 WL WL VSS VDD RA1SH512x32CCMWG
XI37_1 BL__35 BLD__322 BLD_324 BL_35 WL WL VSS VDD RA1SH512x32CCMWG
XI38_0 BL_36 BLD_456 BLD__454 BL__36 WL WL VSS VDD RA1SH512x32CCMWP
XI38_1 BL__36 BLD__454 BLD_456 BL_36 WL WL VSS VDD RA1SH512x32CCMWP
XI39_0 BL_37 BLD_84 BLD__82 BL__37 WL WL VSS VDD RA1SH512x32CCMWP
XI39_1 BL__37 BLD__82 BLD_84 BL_37 WL WL VSS VDD RA1SH512x32CCMWP
XI3_0 BL_2 BLD_100 BLD__98 BL__2 WL WL VSS VDD RA1SH512x32CCMWG
XI3_1 BL__2 BLD__98 BLD_100 BL_2 WL WL VSS VDD RA1SH512x32CCMWG
XI40_0 BL_38 BLD_116 BLD__114 BL__38 WL WL VSS VDD RA1SH512x32CCMWG
XI40_1 BL__38 BLD__114 BLD_116 BL_38 WL WL VSS VDD RA1SH512x32CCMWG
XI41_0 BL_39 BLD_244 BLD__242 BL__39 WL WL VSS VDD RA1SH512x32CCMWG
XI41_1 BL__39 BLD__242 BLD_244 BL_39 WL WL VSS VDD RA1SH512x32CCMWG
XI42_0 BL_40 BLD_376 BLD__374 BL__40 WL WL VSS VDD RA1SH512x32CCMWP
XI42_1 BL__40 BLD__374 BLD_376 BL_40 WL WL VSS VDD RA1SH512x32CCMWP
XI43_0 BL_41 BLD_ BLD BL__41 WL WL VSS VDD RA1SH512x32CCMWP
XI43_1 BL__41 BLD BLD_ BL_41 WL WL VSS VDD RA1SH512x32CCMWP
XI44_0 BL_42 BLD_128 BLD__126 BL__42 WL WL VSS VDD RA1SH512x32CCMWG
XI44_1 BL__42 BLD__126 BLD_128 BL_42 WL WL VSS VDD RA1SH512x32CCMWG
XI45_0 BL_43 BLD_256 BLD__254 BL__43 WL WL VSS VDD RA1SH512x32CCMWG
XI45_1 BL__43 BLD__254 BLD_256 BL_43 WL WL VSS VDD RA1SH512x32CCMWG
XI46_0 BL_44 BLD_392 BLD__390 BL__44 WL WL VSS VDD RA1SH512x32CCMWP
XI46_1 BL__44 BLD__390 BLD_392 BL_44 WL WL VSS VDD RA1SH512x32CCMWP
XI47_0 BL_45 BLD_16 BLD__14 BL__45 WL WL VSS VDD RA1SH512x32CCMWP
XI47_1 BL__45 BLD__14 BLD_16 BL_45 WL WL VSS VDD RA1SH512x32CCMWP
XI48_0 BL_46 BLD_140 BLD__138 BL__46 WL WL VSS VDD RA1SH512x32CCMWG
XI48_1 BL__46 BLD__138 BLD_140 BL_46 WL WL VSS VDD RA1SH512x32CCMWG
XI49_0 BL_47 BLD_268 BLD__266 BL__47 WL WL VSS VDD RA1SH512x32CCMWG
XI49_1 BL__47 BLD__266 BLD_268 BL_47 WL WL VSS VDD RA1SH512x32CCMWG
XI4_0 BL_3 BLD_224 BLD__222 BL__3 WL WL VSS VDD RA1SH512x32CCMWG
XI4_1 BL__3 BLD__222 BLD_224 BL_3 WL WL VSS VDD RA1SH512x32CCMWG
XI50_0 BL_48 BLD_304 BLD__302 BL__48 WL WL VSS VDD RA1SH512x32CCMWP
XI50_1 BL__48 BLD__302 BLD_304 BL_48 WL WL VSS VDD RA1SH512x32CCMWP
XI51_0 BL_49 BLD_436 BLD__434 BL__49 WL WL VSS VDD RA1SH512x32CCMWP
XI51_1 BL__49 BLD__434 BLD_436 BL_49 WL WL VSS VDD RA1SH512x32CCMWP
XI52_0 BL_50 BLD_60 BLD__58 BL__50 WL WL VSS VDD RA1SH512x32CCMWG
XI52_1 BL__50 BLD__58 BLD_60 BL_50 WL WL VSS VDD RA1SH512x32CCMWG
XI53_0 BL_51 BLD_184 BLD__182 BL__51 WL WL VSS VDD RA1SH512x32CCMWG
XI53_1 BL__51 BLD__182 BLD_184 BL_51 WL WL VSS VDD RA1SH512x32CCMWG
XI54_0 BL_52 BLD_320 BLD__318 BL__52 WL WL VSS VDD RA1SH512x32CCMWP
XI54_1 BL__52 BLD__318 BLD_320 BL_52 WL WL VSS VDD RA1SH512x32CCMWP
XI55_0 BL_53 BLD_452 BLD__450 BL__53 WL WL VSS VDD RA1SH512x32CCMWP
XI55_1 BL__53 BLD__450 BLD_452 BL_53 WL WL VSS VDD RA1SH512x32CCMWP
XI56_0 BL_54 BLD_80 BLD__78 BL__54 WL WL VSS VDD RA1SH512x32CCMWG
XI56_1 BL__54 BLD__78 BLD_80 BL_54 WL WL VSS VDD RA1SH512x32CCMWG
XI57_0 BL_55 BLD_204 BLD__202 BL__55 WL WL VSS VDD RA1SH512x32CCMWG
XI57_1 BL__55 BLD__202 BLD_204 BL_55 WL WL VSS VDD RA1SH512x32CCMWG
XI58_0 BL_56 BLD_336 BLD__334 BL__56 WL WL VSS VDD RA1SH512x32CCMWP
XI58_1 BL__56 BLD__334 BLD_336 BL_56 WL WL VSS VDD RA1SH512x32CCMWP
XI59_0 BL_57 BLD_468 BLD__466 BL__57 WL WL VSS VDD RA1SH512x32CCMWP
XI59_1 BL__57 BLD__466 BLD_468 BL_57 WL WL VSS VDD RA1SH512x32CCMWP
XI5_0 BL_4 BLD_360 BLD__358 BL__4 WL WL VSS VDD RA1SH512x32CCMWP
XI5_1 BL__4 BLD__358 BLD_360 BL_4 WL WL VSS VDD RA1SH512x32CCMWP
XI60_0 BL_58 BLD_500 BLD__498 BL__58 WL WL VSS VDD RA1SH512x32CCMWG
XI60_1 BL__58 BLD__498 BLD_500 BL_58 WL WL VSS VDD RA1SH512x32CCMWG
XI61_0 BL_59 BLD_124 BLD__122 BL__59 WL WL VSS VDD RA1SH512x32CCMWG
XI61_1 BL__59 BLD__122 BLD_124 BL_59 WL WL VSS VDD RA1SH512x32CCMWG
XI62_0 BL_60 BLD_252 BLD__250 BL__60 WL WL VSS VDD RA1SH512x32CCMWP
XI62_1 BL__60 BLD__250 BLD_252 BL_60 WL WL VSS VDD RA1SH512x32CCMWP
XI63_0 BL_61 BLD_388 BLD__386 BL__61 WL WL VSS VDD RA1SH512x32CCMWP
XI63_1 BL__61 BLD__386 BLD_388 BL_61 WL WL VSS VDD RA1SH512x32CCMWP
XI64_0 BL_62 BLD_12 BLD__10 BL__62 WL WL VSS VDD RA1SH512x32CCMWG
XI64_1 BL__62 BLD__10 BLD_12 BL_62 WL WL VSS VDD RA1SH512x32CCMWG
XI66_0 BL0 BL0_ BL1 BL1_ WL WL WL VSS VSS VSS VDD RA1SH512x32FLMWG
XI68_0 BL_63 BLD_24 BLD__22 BL__63 VSS VSS VSS VDD RA1SH512x32CCMWP
XI68_1 BL__63 BLD__22 BLD_24 BL_63 VSS VSS VSS VDD RA1SH512x32CCMWP
XI69_0 BL_64 BLD_148 BLD__146 BL__64 VSS VSS VSS VDD RA1SH512x32CCMWG
XI69_1 BL__64 BLD__146 BLD_148 BL_64 VSS VSS VSS VDD RA1SH512x32CCMWG
XI6_0 BL_5 BLD_484 BLD__482 BL__5 WL WL VSS VDD RA1SH512x32CCMWP
XI6_1 BL__5 BLD__482 BLD_484 BL_5 WL WL VSS VDD RA1SH512x32CCMWP
XI70_0 BL_65 BLD_180 BLD__178 BL__65 VSS VSS VSS VDD RA1SH512x32CCMWG
XI70_1 BL__65 BLD__178 BLD_180 BL_65 VSS VSS VSS VDD RA1SH512x32CCMWG
XI71_0 BL_66 BLD_316 BLD__314 BL__66 VSS VSS VSS VDD RA1SH512x32CCMWP
XI71_1 BL__66 BLD__314 BLD_316 BL_66 VSS VSS VSS VDD RA1SH512x32CCMWP
XI72_0 BL_67 BLD_448 BLD__446 BL__67 VSS VSS VSS VDD RA1SH512x32CCMWP
XI72_1 BL__67 BLD__446 BLD_448 BL_67 VSS VSS VSS VDD RA1SH512x32CCMWP
XI73_0 BL_68 BLD_76 BLD__74 BL__68 VSS VSS VSS VDD RA1SH512x32CCMWG
XI73_1 BL__68 BLD__74 BLD_76 BL_68 VSS VSS VSS VDD RA1SH512x32CCMWG
XI74_0 BL_69 BLD_200 BLD__198 BL__69 VSS VSS VSS VDD RA1SH512x32CCMWG
XI74_1 BL__69 BLD__198 BLD_200 BL_69 VSS VSS VSS VDD RA1SH512x32CCMWG
XI75_0 BL_70 BLD_332 BLD__330 BL__70 VSS VSS VSS VDD RA1SH512x32CCMWP
XI75_1 BL__70 BLD__330 BLD_332 BL_70 VSS VSS VSS VDD RA1SH512x32CCMWP
XI76_0 BL_71 BLD_464 BLD__462 BL__71 VSS VSS VSS VDD RA1SH512x32CCMWP
XI76_1 BL__71 BLD__462 BLD_464 BL_71 VSS VSS VSS VDD RA1SH512x32CCMWP
XI77_0 BL_72 BLD_92 BLD__90 BL__72 VSS VSS VSS VDD RA1SH512x32CCMWG
XI77_1 BL__72 BLD__90 BLD_92 BL_72 VSS VSS VSS VDD RA1SH512x32CCMWG
XI78_0 BL_73 BLD_212 BLD__210 BL__73 VSS VSS VSS VDD RA1SH512x32CCMWG
XI78_1 BL__73 BLD__210 BLD_212 BL_73 VSS VSS VSS VDD RA1SH512x32CCMWG
XI79_0 BL_74 BLD_344 BLD__342 BL__74 VSS VSS VSS VDD RA1SH512x32CCMWP
XI79_1 BL__74 BLD__342 BLD_344 BL_74 VSS VSS VSS VDD RA1SH512x32CCMWP
XI7_0 BL_6 BLD_108 BLD__106 BL__6 WL WL VSS VDD RA1SH512x32CCMWG
XI7_1 BL__6 BLD__106 BLD_108 BL_6 WL WL VSS VDD RA1SH512x32CCMWG
XI80_0 BL_75 BLD_384 BLD__382 BL__75 VSS VSS VSS VDD RA1SH512x32CCMWP
XI80_1 BL__75 BLD__382 BLD_384 BL_75 VSS VSS VSS VDD RA1SH512x32CCMWP
XI81_0 BL_76 BLD_8 BLD__6 BL__76 VSS VSS VSS VDD RA1SH512x32CCMWG
XI81_1 BL__76 BLD__6 BLD_8 BL_76 VSS VSS VSS VDD RA1SH512x32CCMWG
XI82_0 BL_77 BLD_136 BLD__134 BL__77 VSS VSS VSS VDD RA1SH512x32CCMWG
XI82_1 BL__77 BLD__134 BLD_136 BL_77 VSS VSS VSS VDD RA1SH512x32CCMWG
XI83_0 BL_78 BLD_264 BLD__262 BL__78 VSS VSS VSS VDD RA1SH512x32CCMWP
XI83_1 BL__78 BLD__262 BLD_264 BL_78 VSS VSS VSS VDD RA1SH512x32CCMWP
XI84_0 BL_79 BLD_400 BLD__398 BL__79 VSS VSS VSS VDD RA1SH512x32CCMWP
XI84_1 BL__79 BLD__398 BLD_400 BL_79 VSS VSS VSS VDD RA1SH512x32CCMWP
XI85_0 BL_80 BLD_20 BLD__18 BL__80 VSS VSS VSS VDD RA1SH512x32CCMWG
XI85_1 BL__80 BLD__18 BLD_20 BL_80 VSS VSS VSS VDD RA1SH512x32CCMWG
XI86_0 BL_81 BLD_144 BLD__142 BL__81 VSS VSS VSS VDD RA1SH512x32CCMWG
XI86_1 BL__81 BLD__142 BLD_144 BL_81 VSS VSS VSS VDD RA1SH512x32CCMWG
XI87_0 BL_82 BLD_272 BLD__270 BL__82 VSS VSS VSS VDD RA1SH512x32CCMWP
XI87_1 BL__82 BLD__270 BLD_272 BL_82 VSS VSS VSS VDD RA1SH512x32CCMWP
XI88_0 BL_83 BLD_404 BLD__402 BL__83 VSS VSS VSS VDD RA1SH512x32CCMWP
XI88_1 BL__83 BLD__402 BLD_404 BL_83 VSS VSS VSS VDD RA1SH512x32CCMWP
XI89_0 BL_84 BLD_28 BLD__26 BL__84 VSS VSS VSS VDD RA1SH512x32CCMWG
XI89_1 BL__84 BLD__26 BLD_28 BL_84 VSS VSS VSS VDD RA1SH512x32CCMWG
XI8_0 BL_7 BLD_232 BLD__230 BL__7 WL WL VSS VDD RA1SH512x32CCMWG
XI8_1 BL__7 BLD__230 BLD_232 BL_7 WL WL VSS VDD RA1SH512x32CCMWG
XI90_0 BL_85 BLD_68 BLD__66 BL__85 VSS VSS VSS VDD RA1SH512x32CCMWG
XI90_1 BL__85 BLD__66 BLD_68 BL_85 VSS VSS VSS VDD RA1SH512x32CCMWG
XI91_0 BL_86 BLD_196 BLD__194 BL__86 VSS VSS VSS VDD RA1SH512x32CCMWP
XI91_1 BL__86 BLD__194 BLD_196 BL_86 VSS VSS VSS VDD RA1SH512x32CCMWP
XI92_0 BL_87 BLD_328 BLD__326 BL__87 VSS VSS VSS VDD RA1SH512x32CCMWP
XI92_1 BL__87 BLD__326 BLD_328 BL_87 VSS VSS VSS VDD RA1SH512x32CCMWP
XI93_0 BL_88 BLD_460 BLD__458 BL__88 VSS VSS VSS VDD RA1SH512x32CCMWG
XI93_1 BL__88 BLD__458 BLD_460 BL_88 VSS VSS VSS VDD RA1SH512x32CCMWG
XI94_0 BL_89 BLD_88 BLD__86 BL__89 VSS VSS VSS VDD RA1SH512x32CCMWG
XI94_1 BL__89 BLD__86 BLD_88 BL_89 VSS VSS VSS VDD RA1SH512x32CCMWG
XI95_0 BL_90 BLD_208 BLD__206 BL__90 VSS VSS VSS VDD RA1SH512x32CCMWP
XI95_1 BL__90 BLD__206 BLD_208 BL_90 VSS VSS VSS VDD RA1SH512x32CCMWP
XI96_0 BL_91 BLD_340 BLD__338 BL__91 VSS VSS VSS VDD RA1SH512x32CCMWP
XI96_1 BL__91 BLD__338 BLD_340 BL_91 VSS VSS VSS VDD RA1SH512x32CCMWP
XI97_0 BL_92 BLD_472 BLD__470 BL__92 VSS VSS VSS VDD RA1SH512x32CCMWG
XI97_1 BL__92 BLD__470 BLD_472 BL_92 VSS VSS VSS VDD RA1SH512x32CCMWG
XI99_0 BL_93 BLD_220 BLD__218 BL__93 VSS VSS VSS VDD RA1SH512x32CCMWG
XI99_1 BL__93 BLD__218 BLD_220 BL_93 VSS VSS VSS VDD RA1SH512x32CCMWG
XI9_0 BL_8 BLD_368 BLD__366 BL__8 WL WL VSS VDD RA1SH512x32CCMWP
XI9_1 BL__8 BLD__366 BLD_368 BL_8 WL WL VSS VDD RA1SH512x32CCMWP
.ENDS RA1SH512x32MODEL_ROW_16
****
.SUBCKT RA1SH512x32WD G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32WD: 30 flat devices **
m1 N26 RSWN0 GTP VDD P L=0.13U W=0.96U
m10 WL0 WL0_EN_ VSS VSS N L=0.13U W=10.02U
m11 N25 RSWN1 GTP VDD P L=0.13U W=0.96U
m12 N25 WLI1 GTP VSS N L=0.13U W=0.96U
m13 N34 G0 VSS VSS N L=0.13U W=0.57U
m14 N35 G1 N34 VSS N L=0.13U W=0.57U
m15 RSWN1 G2_W1 N35 VSS N L=0.13U W=0.57U
m16 RSWN1 G0 VDD VDD P L=0.13U W=0.33U
m17 RSWN1 G2_W1 VDD VDD P L=0.13U W=0.33U
m18 RSWN1 G1 VDD VDD P L=0.13U W=0.33U
m19 WL1 WL1_EN_ VDD VDD P L=0.13U W=16.29U
m2 N26 WLI0 GTP VSS N L=0.13U W=0.96U
m20 WL1 WL1_EN_ VSS VSS N L=0.13U W=10.02U
m21 WLI1 RSWN1 VDD VDD P L=0.13U W=0.24U
m22 WLI1 RSWN1 VSS VSS N L=0.13U W=0.15U
m23 WLI0 RSWN0 VDD VDD P L=0.13U W=0.24U
m24 WLI0 RSWN0 VSS VSS N L=0.13U W=0.15U
m25 N25 RSWN1 VSS VSS N L=0.13U W=0.3U
m26 N26 RSWN0 VSS VSS N L=0.13U W=0.3U
m27 WL1_EN_ N25 VDD VDD P L=0.13U W=5.88U
m28 WL1_EN_ N25 VSS VSS N L=0.13U W=3.78U
m29 WL0_EN_ N26 VDD VDD P L=0.13U W=5.88U
m3 N27 G0 VSS VSS N L=0.13U W=0.57U
m30 WL0_EN_ N26 VSS VSS N L=0.13U W=3.78U
m4 N28 G1 N27 VSS N L=0.13U W=0.57U
m5 RSWN0 G2_W0 N28 VSS N L=0.13U W=0.57U
m6 RSWN0 G0 VDD VDD P L=0.13U W=0.33U
m7 RSWN0 G2_W0 VDD VDD P L=0.13U W=0.33U
m8 RSWN0 G1 VDD VDD P L=0.13U W=0.33U
m9 WL0 WL0_EN_ VDD VDD P L=0.13U W=16.29U
.ENDS RA1SH512x32WD
****
.SUBCKT RA1SH512x32WD1 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SH512x32WD1: 30 flat devices **
XI0_0 G0 G1 XP2_3 XP2_2 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32WD
.ENDS RA1SH512x32WD1
****
.SUBCKT RA1SH512x32ROW_FILLER1 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1 XP1F
+  XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32ROW_FILLER1: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32WD1
.ENDS RA1SH512x32ROW_FILLER1
****
.SUBCKT RA1SH512x32WD2 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SH512x32WD2: 30 flat devices **
XI0_0 G0 G1 XP2_4 XP2_5 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32WD
.ENDS RA1SH512x32WD2
****
.SUBCKT RA1SH512x32ROW_FILLER2 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1 XP1F
+  XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32ROW_FILLER2: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32WD2
.ENDS RA1SH512x32ROW_FILLER2
****
.SUBCKT RA1SH512x32WD3 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SH512x32WD3: 30 flat devices **
XI0_0 G0 G1 XP2_7 XP2_6 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32WD
.ENDS RA1SH512x32WD3
****
.SUBCKT RA1SH512x32ROW_FILLER3 G0 G1 GTP WL0 WL1 XP0 XP0F XP0_0 XP0_1 XP1 XP1F
+  XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32ROW_FILLER3: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32WD3
.ENDS RA1SH512x32ROW_FILLER3
****
.SUBCKT RA1SH512x32WD0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SH512x32WD0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32WD
.ENDS RA1SH512x32WD0
****
.SUBCKT RA1SH512x32ROW_8 G0 G1 G1B GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2 XP1F
+  XP1F_0 XP1F_1 XP1F_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD
** RA1SH512x32ROW_8: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32WD0
.ENDS RA1SH512x32ROW_8
****
.SUBCKT RA1SH512x32HWDB G0 G1 G2_W0 G2_W1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3
+  XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32HWDB: 30 flat devices **
m1 N26 WD_I0-RSWN0 GTP VDD P L=0.13U W=0.96U
m10 WL0 WD_I0-WL0_EN_ VSS VSS N L=0.13U W=10.02U
m11 N25 WD_I0-RSWN1 GTP VDD P L=0.13U W=0.96U
m12 N25 WD_I0-WLI1 GTP VSS N L=0.13U W=0.96U
m13 N34 G0 VSS VSS N L=0.13U W=0.57U
m14 N35 G1 N34 VSS N L=0.13U W=0.57U
m15 WD_I0-RSWN1 G2_W1 N35 VSS N L=0.13U W=0.57U
m16 WD_I0-RSWN1 G0 VDD VDD P L=0.13U W=0.33U
m17 WD_I0-RSWN1 G2_W1 VDD VDD P L=0.13U W=0.33U
m18 WD_I0-RSWN1 G1 VDD VDD P L=0.13U W=0.33U
m19 WL1 WD_I0-WL1_EN_ VDD VDD P L=0.13U W=16.29U
m2 N26 WD_I0-WLI0 GTP VSS N L=0.13U W=0.96U
m20 WL1 WD_I0-WL1_EN_ VSS VSS N L=0.13U W=10.02U
m21 WD_I0-WLI1 WD_I0-RSWN1 VDD VDD P L=0.13U W=0.24U
m22 WD_I0-WLI1 WD_I0-RSWN1 VSS VSS N L=0.13U W=0.15U
m23 WD_I0-WLI0 WD_I0-RSWN0 VDD VDD P L=0.13U W=0.24U
m24 WD_I0-WLI0 WD_I0-RSWN0 VSS VSS N L=0.13U W=0.15U
m25 N25 WD_I0-RSWN1 VSS VSS N L=0.13U W=0.3U
m26 N26 WD_I0-RSWN0 VSS VSS N L=0.13U W=0.3U
m27 WD_I0-WL1_EN_ N25 VDD VDD P L=0.13U W=5.88U
m28 WD_I0-WL1_EN_ N25 VSS VSS N L=0.13U W=3.78U
m29 WD_I0-WL0_EN_ N26 VDD VDD P L=0.13U W=5.88U
m3 N27 G0 VSS VSS N L=0.13U W=0.57U
m30 WD_I0-WL0_EN_ N26 VSS VSS N L=0.13U W=3.78U
m4 N28 G1 N27 VSS N L=0.13U W=0.57U
m5 WD_I0-RSWN0 G2_W0 N28 VSS N L=0.13U W=0.57U
m6 WD_I0-RSWN0 G0 VDD VDD P L=0.13U W=0.33U
m7 WD_I0-RSWN0 G2_W0 VDD VDD P L=0.13U W=0.33U
m8 WD_I0-RSWN0 G1 VDD VDD P L=0.13U W=0.33U
m9 WL0 WD_I0-WL0_EN_ VDD VDD P L=0.13U W=16.29U
.ENDS RA1SH512x32HWDB
****
.SUBCKT RA1SH512x32HWDB0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5
+  XP2_6 XP2_7 VSS VDD
** RA1SH512x32HWDB0: 30 flat devices **
XI0_0 G0 G1 XP2_0 XP2_1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD RA1SH512x32HWDB
.ENDS RA1SH512x32HWDB0
****
.SUBCKT RA1SH512x32ROW_BOTTOM G0 G1 GTP WL0 WL1 XP0F XP0F_0 XP0F_1 XP0F_2 XP1F
+  XP1F_0 XP1F_1 XP1F_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD
** RA1SH512x32ROW_BOTTOM: 30 flat devices **
XI4_0 G0 G1 GTP WL0 WL1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD RA1SH512x32HWDB0
.ENDS RA1SH512x32ROW_BOTTOM
****
.SUBCKT RA1SH512x32FCMWDX MWL XP0 XP1 VSS VDD
** RA1SH512x32FCMWDX: 2 flat devices **
d1 VSS XP1 DN 0.2116P 1.84U
d2 VSS XP0 DN 0.2116P 1.84U
.ENDS RA1SH512x32FCMWDX
****
.SUBCKT RA1SH512x32FCMWD G0F G1F MWL XP0F XP1F VSS VDD
** RA1SH512x32FCMWD: 2 flat devices **
d1 VSS XP1F DN 0.2116P 1.84U
d2 VSS XP0F DN 0.2116P 1.84U
.ENDS RA1SH512x32FCMWD
****
.SUBCKT RA1SH512x32MWD GTP MBL MBL_ MWG0 MWG1 MWG2 MWG3 MWG4 MWG5 MWG6 MWG7
+  MWG8 MWG9 MWG10 MWG11 MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6
+  XP2_7 VSS VDD
** RA1SH512x32MWD: 37 flat devices **
m1 MWL N58 VDD VDD P L=0.13U W=16.29U
m10 MBL MWG1 VSS VSS N L=0.4U W=0.15U
m11 MBL MWG0 VSS VSS N L=0.4U W=0.15U
m12 MBL MWG3 VSS VSS N L=0.4U W=0.15U
m13 MBL MWG2 VSS VSS N L=0.4U W=0.15U
m14 MBL MWG3 VSS VSS N L=0.4U W=0.15U
m15 MBL MWG2 VSS VSS N L=0.4U W=0.15U
m16 MBL MWG5 VSS VSS N L=0.4U W=0.15U
m17 MBL MWG4 VSS VSS N L=0.4U W=0.15U
m18 MBL MWG5 VSS VSS N L=0.4U W=0.15U
m19 MBL MWG4 VSS VSS N L=0.4U W=0.15U
m2 MWL N58 VSS VSS N L=0.13U W=10.02U
m20 MBL MWG7 VSS VSS N L=0.4U W=0.15U
m21 MBL MWG6 VSS VSS N L=0.4U W=0.15U
m22 MBL MWG7 VSS VSS N L=0.4U W=0.15U
m23 MBL MWG6 VSS VSS N L=0.4U W=0.15U
m24 MBL MWG9 VSS VSS N L=0.4U W=0.15U
m25 MBL MWG8 VSS VSS N L=0.4U W=0.15U
m26 MBL MWG9 VSS VSS N L=0.4U W=0.15U
m27 MBL MWG8 VSS VSS N L=0.4U W=0.15U
m28 MBL MWG11 VSS VSS N L=0.4U W=0.15U
m29 MBL MWG10 VSS VSS N L=0.4U W=0.15U
m3 MBL GTP VDD VDD P L=0.13U W=5.38U
m30 MBL MWG11 VSS VSS N L=0.4U W=0.15U
m31 MBL MWG10 VSS VSS N L=0.4U W=0.15U
m32 MBL MWLD VSS VSS N L=0.4U W=0.15U
m33 MBL MWLD VSS VSS N L=0.4U W=0.15U
m34 MBL MWLD VSS VSS N L=0.4U W=0.15U
m35 MBL MWLD VSS VSS N L=0.4U W=0.15U
m36 N58 N57 VDD VDD P L=0.13U W=6.81U
m37 N58 N57 VSS VSS N L=0.13U W=4.36U
m4 MBL_ GTP VDD VDD P L=0.13U W=5.38U
m5 MBL GTP MBL_ VDD P L=0.13U W=12.28U
m6 N57 VSS GTP VDD P L=0.4U W=0.9U
m7 N57 VDD GTP VSS N L=0.4U W=0.9U
m8 MBL MWG1 VSS VSS N L=0.4U W=0.15U
m9 MBL MWG0 VSS VSS N L=0.4U W=0.15U
.ENDS RA1SH512x32MWD
****
.SUBCKT RA1SH512x32MWDX GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4
+  XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32MWDX: 37 flat devices **
XI0_0 GTP MBL MBL_ MWLD MWLD VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS MWL MWLD
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA1SH512x32MWD
.ENDS RA1SH512x32MWDX
****
.SUBCKT RA1SH512x32ROW_TOP G0F G1F GTP MBL MBL_ MWL MWLD XP0 XP0F XP0_0 XP0_1
+  XP1 XP1F XP1_0 XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS
+  VDD
** RA1SH512x32ROW_TOP: 45 flat devices **
XI0_0 MWL XP0 XP1 VSS VDD RA1SH512x32FCMWDX
XI1_0 MWL XP0_0 XP1_0 VSS VDD RA1SH512x32FCMWDX
XI2_0 MWL XP0_1 XP1_1 VSS VDD RA1SH512x32FCMWDX
XI3_0 G0F G1F MWL XP0F XP1F VSS VDD RA1SH512x32FCMWD
XI4_0 GTP MBL MBL_ MWL MWLD XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7
+  VSS VDD RA1SH512x32MWDX
.ENDS RA1SH512x32ROW_TOP
****
.SUBCKT RA1SH512x32WORD_ROWS G0 GTP MBL MBL_ MWL MWLD WL0 WL0_0 WL0_1 WL0_2
+  WL0_3 WL0_4 WL0_5 WL0_6 WL0_7 WL0_8 WL0_9 WL0_10 WL0_11 WL0_12 WL0_13
+  WL0_14 WL0_15 WL0_16 WL0_17 WL0_18 WL0_19 WL0_20 WL0_21 WL0_22 WL0_23
+  WL0_24 WL0_25 WL0_26 WL0_27 WL0_28 WL0_29 WL0_30 WL1 WL1_0 WL1_1 WL1_2
+  WL1_3 WL1_4 WL1_5 WL1_6 WL1_7 WL1_8 WL1_9 WL1_10 WL1_11 WL1_12 WL1_13
+  WL1_14 WL1_15 WL1_16 WL1_17 WL1_18 WL1_19 WL1_20 WL1_21 WL1_22 WL1_23
+  WL1_24 WL1_25 WL1_26 WL1_27 WL1_28 WL1_29 WL1_30 XP0 XP0_0 XP0_1 XP0_2 XP1
+  XP1_0 XP1_1 XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
** RA1SH512x32WORD_ROWS: 1005 flat devices **
XI0_0 G0 XP0_2 GTP WL0 WL1 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1 XP1_2 XP2_0
+  XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD RA1SH512x32ROW_BOTTOM
XI0_1 G0 XP0_2 GTP WL0_0 WL1_0 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_10 G0 XP0_1 GTP WL0_9 WL1_9 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_11 G0 XP0_1 GTP WL0_10 WL1_10 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_12 G0 XP1_1 XP0_1 GTP WL0_11 WL1_11 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_13 G0 XP1_1 GTP WL0_12 WL1_12 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_14 G0 XP1_1 GTP WL0_13 WL1_13 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_15 G0 XP1_1 GTP WL0_14 WL1_14 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_16 G0 XP0_0 XP1_1 GTP WL0_15 WL1_15 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_17 G0 XP0_0 GTP WL0_16 WL1_16 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_18 G0 XP0_0 GTP WL0_17 WL1_17 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_19 G0 XP0_0 GTP WL0_18 WL1_18 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_2 G0 XP0_2 GTP WL0_1 WL1_1 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_20 G0 XP1_0 XP0_0 GTP WL0_19 WL1_19 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_21 G0 XP1_0 GTP WL0_20 WL1_20 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_22 G0 XP1_0 GTP WL0_21 WL1_21 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_23 G0 XP1_0 GTP WL0_22 WL1_22 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_24 G0 XP0 XP1_0 GTP WL0_23 WL1_23 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_25 G0 XP0 GTP WL0_24 WL1_24 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_26 G0 XP0 GTP WL0_25 WL1_25 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_27 G0 XP0 GTP WL0_26 WL1_26 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_28 G0 XP1 XP0 GTP WL0_27 WL1_27 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_29 G0 XP1 GTP WL0_28 WL1_28 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_3 G0 XP0_2 GTP WL0_2 WL1_2 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_30 G0 XP1 GTP WL0_29 WL1_29 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_31 G0 XP1 GTP WL0_30 WL1_30 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_32 G0 XP1 GTP MBL MBL_ MWL MWLD XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0
+  XP1_1 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_TOP
XI0_4 G0 XP1_2 XP0_2 GTP WL0_3 WL1_3 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_5 G0 XP1_2 GTP WL0_4 WL1_4 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
XI0_6 G0 XP1_2 GTP WL0_5 WL1_5 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER2
XI0_7 G0 XP1_2 GTP WL0_6 WL1_6 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER3
XI0_8 G0 XP0_1 XP1_2 GTP WL0_7 WL1_7 XP0 XP0_0 XP0_1 XP0_2 XP1 XP1_0 XP1_1
+  XP1_2 XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_8
XI0_9 G0 XP0_1 GTP WL0_8 WL1_8 XP0 XP0_2 XP0_0 XP0_1 XP1 XP1_2 XP1_0 XP1_1
+  XP2_0 XP2_1 XP2_2 XP2_3 XP2_4 XP2_5 XP2_6 XP2_7 VSS VDD
+  RA1SH512x32ROW_FILLER1
.ENDS RA1SH512x32WORD_ROWS
****
.SUBCKT RA1SH512x32HCKA A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32HCKA: 9 flat devices **
m1 CK-SRCFEED CK-GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK CK-GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 AGTP GTPN VDD VDD P L=0.13U W=27.52U
m5 AGTP GTPN VSS VSS N L=0.13U W=12.44U
m6 CK-GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 CK-GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 CK-GTPFEED CLK CK-SRCFEED VSS N L=0.13U W=6.27U
m9 CK-GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA1SH512x32HCKA
****
.SUBCKT RA1SH512x32CK A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32CK: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 GTP GTPN VDD VDD P L=0.13U W=27.52U
m5 GTP GTPN VSS VSS N L=0.13U W=12.44U
m6 GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 GTPFEED CLK SRCFEED VSS N L=0.13U W=6.27U
m9 GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA1SH512x32CK
****
.SUBCKT RA1SH512x32CK1 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32CK1: 9 flat devices **
m1 SRCFEED GTPNSRC VSS VSS N L=0.13U W=18.84U
m2 GTPN CLK GTPFEED VSS N L=0.13U W=6.27U
m3 GTPN RST VDD VDD P L=0.13U W=8.92U
m4 GTP GTPN VDD VDD P L=0.13U W=27.52U
m5 GTP GTPN VSS VSS N L=0.13U W=12.44U
m6 GTPNSRC GSRCN VDD VDD P L=0.13U W=2.12U
m7 GTPNSRC GSRCN VSS VSS N L=0.13U W=1.64U
m8 GTPFEED CLK SRCFEED VSS N L=0.13U W=6.27U
m9 GTPFEED GTPN VDD VSS N L=0.13U W=1.58U
.ENDS RA1SH512x32CK1
****
.SUBCKT RA1SH512x32CLK_DRVS A0 A0_ AGTP CLK GSRCN GTP GTPN GTP_0 GTP_1 GTP_2
+  RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32CLK_DRVS: 45 flat devices **
XI0_0 A0 A0_ AGTP CLK GSRCN GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32HCKA
XI1_0 A0 A0_ CLK GSRCN GTP GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2
+  YP1_3 VSS VDD RA1SH512x32CK
XI2_0 A0 A0_ CLK GSRCN GTP_0 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32CK
XI3_0 A0 A0_ CLK GSRCN GTP_1 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32CK
XI4_0 A0 A0_ CLK GSRCN GTP_2 GTPN RST YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32CK1
.ENDS RA1SH512x32CLK_DRVS
****
.SUBCKT RA1SH512x32FCBWRO8 BWEN D Q VSS VDD
** RA1SH512x32FCBWRO8: 2 flat devices **
d1 VSS Q DN 0.2116P 1.84U
d2 VSS D DN 0.2116P 1.84U
.ENDS RA1SH512x32FCBWRO8
****
.SUBCKT RA1SH512x32MCOL_ODD_R8 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q
+  STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 STUBWEI
+  WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12
+  WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24
+  WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36
+  WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48
+  WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60
+  WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8 WP_9 WP_10
+  WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20 WP_21 WP_22
+  WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32 WP_33 WP_34
+  WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44 WP_45 WP_46
+  WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56 WP_57 WP_58
+  WP_59 WP_60 WP_61 WP_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32MCOL_ODD_R8: 3345 flat devices **
XI0_0 VSS D Q VSS VDD RA1SH512x32FCBWRO8
XI0_1 BWE D DPN DPU STUBDW STUBDW_ GTP OE_ Q SP STUBWEI VSS VDD RA1SH512x32IOX
XI0_2 DPN DPU STUBDR STUBDR_ STUBDW STUBDW_ GTP_0 SP VSS VDD RA1SH512x32SA8
XI0_3 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL__3 BL__4 BL_5 BL_6 BL__0 BL__1 BL__2
+  BL_3 BL_4 BL__5 BL__6 VSS VSS VSS VSS GTP_1 STUBDR STUBDR_ STUBDR_0
+  STUBDR__0 STUBDW STUBDW_ STUBDW_0 STUBDW__0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MUX_CD_ODD
XI0_4 BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3 BL__4
+  BL__5 BL__6 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 WP WP_0 WP_1 WP_2 WP_3 WP_4 WP_5 WP_6 WP_7 WP_8
+  WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17 WP_18 WP_19 WP_20
+  WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29 WP_30 WP_31 WP_32
+  WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41 WP_42 WP_43 WP_44
+  WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53 WP_54 WP_55 WP_56
+  WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD RA1SH512x32BIT_COL
.ENDS RA1SH512x32MCOL_ODD_R8
****
.SUBCKT RA1SH512x32WING_16_RIGHT A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5
+  BL_6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18
+  BL_19 BL_20 BL_21 BL_22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30
+  BL_31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42
+  BL_43 BL_44 BL_45 BL_46 BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54
+  BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66
+  BL_67 BL_68 BL_69 BL_70 BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78
+  BL_79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90
+  BL_91 BL_92 BL_93 BL_94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102
+  BL_103 BL_104 BL_105 BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112
+  BL_113 BL_114 BL_115 BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122
+  BL_123 BL_124 BL_125 BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7
+  BL__8 BL__9 BL__10 BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18
+  BL__19 BL__20 BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28
+  BL__29 BL__30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38
+  BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68
+  BL__69 BL__70 BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78
+  BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88
+  BL__89 BL__90 BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107
+  BL__108 BL__109 BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116
+  BL__117 BL__118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125
+  BL__126 D D_0 D_1 D_2 D_3 D_4 D_5 D_6 D_7 D_8 D_9 D_10 D_11 D_12 D_13 D_14
+  GTP GTP_0 GTP_1 OE_ Q Q_0 Q_1 Q_2 Q_3 Q_4 Q_5 Q_6 Q_7 Q_8 Q_9 Q_10 Q_11
+  Q_12 Q_13 Q_14 STUBDR STUBDR_ STUBDR_0 STUBDR__0 STUBDW STUBDW_ STUBDW_0
+  STUBDW__0 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS
+  VDD
** RA1SH512x32WING_16_RIGHT: 53520 flat devices **
XI0_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL__0 BL__1 BL__2 BL__3
+  BL__4 BL__5 BL__6 D GTP GTP_0 GTP_1 OE_ Q STUBDR_67 STUBDR__65 STUBDR_0
+  STUBDR__0 STUBDW_69 STUBDW__71 STUBDW_0 STUBDW__0 STUBWE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
+  RA1SH512x32MCOL_EVEN_M8
XI10_0 A0 A0_ BL_63 BL__63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__64
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 D_7 GTP GTP_0 GTP_1 OE_ Q_7
+  STUBDR_3 STUBDR__1 STUBDR_0_11 STUBDR__0_9 STUBDW_5 STUBDW__7 STUBDW_0_13
+  STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI11_0 A0 A0_ BL_78 BL__78 BL_77 BL_76 BL_75 BL_74 BL_73 BL_72 BL_71 BL__77
+  BL__76 BL__75 BL__74 BL__73 BL__72 BL__71 D_8 GTP GTP_0 GTP_1 OE_ Q_8
+  STUBDR_3 STUBDR__1 STUBDR_0_19 STUBDR__0_17 STUBDW_5 STUBDW__7 STUBDW_0_21
+  STUBDW__0_23 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI12_0 A0 A0_ BL_79 BL__79 BL_80 BL_81 BL_82 BL_83 BL_84 BL_85 BL_86 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 D_9 GTP GTP_0 GTP_1 OE_ Q_9
+  STUBDR_27 STUBDR__25 STUBDR_0_19 STUBDR__0_17 STUBDW_29 STUBDW__31
+  STUBDW_0_21 STUBDW__0_23 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI13_0 A0 A0_ BL_94 BL__94 BL_93 BL_92 BL_91 BL_90 BL_89 BL_88 BL_87 BL__93
+  BL__92 BL__91 BL__90 BL__89 BL__88 BL__87 D_10 GTP GTP_0 GTP_1 OE_ Q_10
+  STUBDR_27 STUBDR__25 STUBDR_0_35 STUBDR__0_33 STUBDW_29 STUBDW__31
+  STUBDW_0_37 STUBDW__0_39 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI15_0 A0 A0_ BL_95 BL__95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__96
+  BL__97 BL__98 BL__99 BL__100 BL__101 BL__102 D_11 GTP GTP_0 GTP_1 OE_ Q_11
+  STUBDR_43 STUBDR__41 STUBDR_0_35 STUBDR__0_33 STUBDW_45 STUBDW__47
+  STUBDW_0_37 STUBDW__0_39 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI16_0 A0 A0_ BL_110 BL__110 BL_109 BL_108 BL_107 BL_106 BL_105 BL_104 BL_103
+  BL__109 BL__108 BL__107 BL__106 BL__105 BL__104 BL__103 D_12 GTP GTP_0
+  GTP_1 OE_ Q_12 STUBDR_43 STUBDR__41 STUBDR_0_51 STUBDR__0_49 STUBDW_45
+  STUBDW__47 STUBDW_0_53 STUBDW__0_55 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI17_0 A0 A0_ BL_111 BL__111 BL_112 BL_113 BL_114 BL_115 BL_116 BL_117 BL_118
+  BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118 D_13 GTP GTP_0
+  GTP_1 OE_ Q_13 STUBDR_59 STUBDR__57 STUBDR_0_51 STUBDR__0_49 STUBDW_61
+  STUBDW__63 STUBDW_0_53 STUBDW__0_55 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4
+  WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17
+  WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29
+  WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41
+  WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53
+  WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI18_0 A0 A0_ BL_126 BL__126 BL_125 BL_124 BL_123 BL_122 BL_121 BL_120 BL_119
+  BL__125 BL__124 BL__123 BL__122 BL__121 BL__120 BL__119 D_14 GTP GTP_0
+  GTP_1 OE_ Q_14 STUBDR_59 STUBDR__57 STUBDR STUBDR_ STUBDW_61 STUBDW__63
+  STUBDW STUBDW_ STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_R8
XI1_0 A0 A0_ BL_14 BL__14 BL_13 BL_12 BL_11 BL_10 BL_9 BL_8 BL_7 BL__13 BL__12
+  BL__11 BL__10 BL__9 BL__8 BL__7 D_0 GTP GTP_0 GTP_1 OE_ Q_0 STUBDR_67
+  STUBDR__65 STUBDR_0_75 STUBDR__0_73 STUBDW_69 STUBDW__71 STUBDW_0_77
+  STUBDW__0_79 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9
+  WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21
+  WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33
+  WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45
+  WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57
+  WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI2_0 A0 A0_ BL_15 BL__15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__16
+  BL__17 BL__18 BL__19 BL__20 BL__21 BL__22 D_1 GTP GTP_0 GTP_1 OE_ Q_1
+  STUBDR_83 STUBDR__81 STUBDR_0_75 STUBDR__0_73 STUBDW_85 STUBDW__87
+  STUBDW_0_77 STUBDW__0_79 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI3_0 A0 A0_ BL_30 BL__30 BL_29 BL_28 BL_27 BL_26 BL_25 BL_24 BL_23 BL__29
+  BL__28 BL__27 BL__26 BL__25 BL__24 BL__23 D_2 GTP GTP_0 GTP_1 OE_ Q_2
+  STUBDR_83 STUBDR__81 STUBDR_0_91 STUBDR__0_89 STUBDW_85 STUBDW__87
+  STUBDW_0_93 STUBDW__0_95 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI5_0 A0 A0_ BL_31 BL__31 BL_32 BL_33 BL_34 BL_35 BL_36 BL_37 BL_38 BL__32
+  BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 D_3 GTP GTP_0 GTP_1 OE_ Q_3
+  STUBDR_99 STUBDR__97 STUBDR_0_91 STUBDR__0_89 STUBDW_101 STUBDW__103
+  STUBDW_0_93 STUBDW__0_95 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI6_0 A0 A0_ BL_46 BL__46 BL_45 BL_44 BL_43 BL_42 BL_41 BL_40 BL_39 BL__45
+  BL__44 BL__43 BL__42 BL__41 BL__40 BL__39 D_4 GTP GTP_0 GTP_1 OE_ Q_4
+  STUBDR_99 STUBDR__97 STUBDR_0_107 STUBDR__0_105 STUBDW_101 STUBDW__103
+  STUBDW_0_109 STUBDW__0_111 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
XI7_0 A0 A0_ BL_47 BL__47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__48
+  BL__49 BL__50 BL__51 BL__52 BL__53 BL__54 D_5 GTP GTP_0 GTP_1 OE_ Q_5
+  STUBDR_115 STUBDR__113 STUBDR_0_107 STUBDR__0_105 STUBDW_117 STUBDW__119
+  STUBDW_0_109 STUBDW__0_111 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5
+  WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18
+  WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30
+  WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42
+  WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54
+  WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3
+  YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_EVEN_M8
XI8_0 A0 A0_ BL_62 BL__62 BL_61 BL_60 BL_59 BL_58 BL_57 BL_56 BL_55 BL__61
+  BL__60 BL__59 BL__58 BL__57 BL__56 BL__55 D_6 GTP GTP_0 GTP_1 OE_ Q_6
+  STUBDR_115 STUBDR__113 STUBDR_0_11 STUBDR__0_9 STUBDW_117 STUBDW__119
+  STUBDW_0_13 STUBDW__0_15 STUBWE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0
+  YP1_1 YP1_2 YP1_3 VSS VDD RA1SH512x32MCOL_ODD_M8
.ENDS RA1SH512x32WING_16_RIGHT
****
.SUBCKT RA1SH512x32FLCIO A0 A0_ CLK GSRCN GTP GTPN MBL MBL_ YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32FLCIO: 11 flat devices **
d1 VSS A0_ DN 0.2116P 1.84U
d10 VSS YP1_0 DN 0.2116P 1.84U
d11 VSS GTP DN 0.2116P 1.84U
d2 VSS A0 DN 0.2116P 1.84U
d3 VSS YP0_0 DN 0.2116P 1.84U
d4 VSS YP0_1 DN 0.2116P 1.84U
d5 VSS YP0_2 DN 0.2116P 1.84U
d6 VSS YP0_3 DN 0.2116P 1.84U
d7 VSS YP1_3 DN 0.2116P 1.84U
d8 VSS YP1_2 DN 0.2116P 1.84U
d9 VSS YP1_1 DN 0.2116P 1.84U
.ENDS RA1SH512x32FLCIO
****
.SUBCKT RA1SH512x32FLCIOX A0 A0_ BL0 BL0_ CLK GSRCN GTP GTPN YP0_0 YP0_1 YP0_2
+  YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32FLCIOX: 11 flat devices **
XI0_0 A0 A0_ CLK GSRCN GTP GTPN BL0_ BL0 YP0_0 YP0_1 YP0_2 YP0_3 YP1_0 YP1_1
+  YP1_2 YP1_3 VSS VDD RA1SH512x32FLCIO
.ENDS RA1SH512x32FLCIOX
****
.SUBCKT RA1SH512x32RIGHT_CAP A0 A0_ GTP GTP_0 GTP_1 OE_ WE WL WL_0 WL_1 WL_2
+  WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15
+  WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27
+  WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39
+  WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51
+  WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0
+  YP0_1 YP0_2 YP0_3 YP1_0 YP1_1 YP1_2 YP1_3 VSS VDD
** RA1SH512x32RIGHT_CAP: 4 flat devices **
XI0_0 GTP OE_ WE VSS VDD RA1SH512x32FCIO8
XI0_1 GTP_0 VSS VDD RA1SH512x32FCSA8
.ENDS RA1SH512x32RIGHT_CAP
****
.SUBCKT RA1SH512x32MODEL_COL BL BL_ WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7
+  WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20
+  WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32
+  WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44
+  WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56
+  WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 WL_63 WL_64 WP WP_0 WP_1 WP_2 WP_3 WP_4
+  WP_5 WP_6 WP_7 WP_8 WP_9 WP_10 WP_11 WP_12 WP_13 WP_14 WP_15 WP_16 WP_17
+  WP_18 WP_19 WP_20 WP_21 WP_22 WP_23 WP_24 WP_25 WP_26 WP_27 WP_28 WP_29
+  WP_30 WP_31 WP_32 WP_33 WP_34 WP_35 WP_36 WP_37 WP_38 WP_39 WP_40 WP_41
+  WP_42 WP_43 WP_44 WP_45 WP_46 WP_47 WP_48 WP_49 WP_50 WP_51 WP_52 WP_53
+  WP_54 WP_55 WP_56 WP_57 WP_58 WP_59 WP_60 WP_61 WP_62 VSS VDD
** RA1SH512x32MODEL_COL: 384 flat devices **
XI1_0 BL BL_ WL WP VSS VDD RA1SH512x32CCP
XI1_1 BL_ BL WL_0 WP_0 VSS VDD RA1SH512x32CCP
XI1_10 BL BL_ WL_9 WP_9 VSS VDD RA1SH512x32CCP
XI1_11 BL_ BL WL_10 WP_10 VSS VDD RA1SH512x32CCP
XI1_12 BL BL_ WL_11 WP_11 VSS VDD RA1SH512x32CCP
XI1_13 BL_ BL WL_12 WP_12 VSS VDD RA1SH512x32CCP
XI1_14 BL BL_ WL_13 WP_13 VSS VDD RA1SH512x32CCP
XI1_15 BL_ BL WL_14 WP_14 VSS VDD RA1SH512x32CCP
XI1_16 BL BL_ WL_15 WP_15 VSS VDD RA1SH512x32CCP
XI1_17 BL_ BL WL_16 WP_16 VSS VDD RA1SH512x32CCP
XI1_18 BL BL_ WL_17 WP_17 VSS VDD RA1SH512x32CCP
XI1_19 BL_ BL WL_18 WP_18 VSS VDD RA1SH512x32CCP
XI1_2 BL BL_ WL_1 WP_1 VSS VDD RA1SH512x32CCP
XI1_20 BL BL_ WL_19 WP_19 VSS VDD RA1SH512x32CCP
XI1_21 BL_ BL WL_20 WP_20 VSS VDD RA1SH512x32CCP
XI1_22 BL BL_ WL_21 WP_21 VSS VDD RA1SH512x32CCP
XI1_23 BL_ BL WL_22 WP_22 VSS VDD RA1SH512x32CCP
XI1_24 BL BL_ WL_23 WP_23 VSS VDD RA1SH512x32CCP
XI1_25 BL_ BL WL_24 WP_24 VSS VDD RA1SH512x32CCP
XI1_26 BL BL_ WL_25 WP_25 VSS VDD RA1SH512x32CCP
XI1_27 BL_ BL WL_26 WP_26 VSS VDD RA1SH512x32CCP
XI1_28 BL BL_ WL_27 WP_27 VSS VDD RA1SH512x32CCP
XI1_29 BL_ BL WL_28 WP_28 VSS VDD RA1SH512x32CCP
XI1_3 BL_ BL WL_2 WP_2 VSS VDD RA1SH512x32CCP
XI1_30 BL BL_ WL_29 WP_29 VSS VDD RA1SH512x32CCP
XI1_31 BL_ BL WL_30 WP_30 VSS VDD RA1SH512x32CCP
XI1_32 BL BL_ WL_31 WP_31 VSS VDD RA1SH512x32CCP
XI1_33 BL_ BL WL_32 WP_32 VSS VDD RA1SH512x32CCP
XI1_34 BL BL_ WL_33 WP_33 VSS VDD RA1SH512x32CCP
XI1_35 BL_ BL WL_34 WP_34 VSS VDD RA1SH512x32CCP
XI1_36 BL BL_ WL_35 WP_35 VSS VDD RA1SH512x32CCP
XI1_37 BL_ BL WL_36 WP_36 VSS VDD RA1SH512x32CCP
XI1_38 BL BL_ WL_37 WP_37 VSS VDD RA1SH512x32CCP
XI1_39 BL_ BL WL_38 WP_38 VSS VDD RA1SH512x32CCP
XI1_4 BL BL_ WL_3 WP_3 VSS VDD RA1SH512x32CCP
XI1_40 BL BL_ WL_39 WP_39 VSS VDD RA1SH512x32CCP
XI1_41 BL_ BL WL_40 WP_40 VSS VDD RA1SH512x32CCP
XI1_42 BL BL_ WL_41 WP_41 VSS VDD RA1SH512x32CCP
XI1_43 BL_ BL WL_42 WP_42 VSS VDD RA1SH512x32CCP
XI1_44 BL BL_ WL_43 WP_43 VSS VDD RA1SH512x32CCP
XI1_45 BL_ BL WL_44 WP_44 VSS VDD RA1SH512x32CCP
XI1_46 BL BL_ WL_45 WP_45 VSS VDD RA1SH512x32CCP
XI1_47 BL_ BL WL_46 WP_46 VSS VDD RA1SH512x32CCP
XI1_48 BL BL_ WL_47 WP_47 VSS VDD RA1SH512x32CCP
XI1_49 BL_ BL WL_48 WP_48 VSS VDD RA1SH512x32CCP
XI1_5 BL_ BL WL_4 WP_4 VSS VDD RA1SH512x32CCP
XI1_50 BL BL_ WL_49 WP_49 VSS VDD RA1SH512x32CCP
XI1_51 BL_ BL WL_50 WP_50 VSS VDD RA1SH512x32CCP
XI1_52 BL BL_ WL_51 WP_51 VSS VDD RA1SH512x32CCP
XI1_53 BL_ BL WL_52 WP_52 VSS VDD RA1SH512x32CCP
XI1_54 BL BL_ WL_53 WP_53 VSS VDD RA1SH512x32CCP
XI1_55 BL_ BL WL_54 WP_54 VSS VDD RA1SH512x32CCP
XI1_56 BL BL_ WL_55 WP_55 VSS VDD RA1SH512x32CCP
XI1_57 BL_ BL WL_56 WP_56 VSS VDD RA1SH512x32CCP
XI1_58 BL BL_ WL_57 WP_57 VSS VDD RA1SH512x32CCP
XI1_59 BL_ BL WL_58 WP_58 VSS VDD RA1SH512x32CCP
XI1_6 BL BL_ WL_5 WP_5 VSS VDD RA1SH512x32CCP
XI1_60 BL BL_ WL_59 WP_59 VSS VDD RA1SH512x32CCP
XI1_61 BL_ BL WL_60 WP_60 VSS VDD RA1SH512x32CCP
XI1_62 BL BL_ WL_61 WP_61 VSS VDD RA1SH512x32CCP
XI1_63 BL_ BL WL_62 WP_62 VSS VDD RA1SH512x32CCP
XI1_7 BL_ BL WL_6 WP_6 VSS VDD RA1SH512x32CCP
XI1_8 BL BL_ WL_7 WP_7 VSS VDD RA1SH512x32CCP
XI1_9 BL_ BL WL_8 WP_8 VSS VDD RA1SH512x32CCP
.ENDS RA1SH512x32MODEL_COL
****
.SUBCKT RA1SH512x32 A[0] A[1] A[2] A[3] A[4] A[5] A[6] A[7] A[8] CEN CLK D[0]
+  D[1] D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] D[10] D[11] D[12] D[13] D[14]
+  D[15] D[16] D[17] D[18] D[19] D[20] D[21] D[22] D[23] D[24] D[25] D[26]
+  D[27] D[28] D[29] D[30] D[31] Q[0] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8]
+  Q[9] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[18] Q[19] Q[20]
+  Q[21] Q[22] Q[23] Q[24] Q[25] Q[26] Q[27] Q[28] Q[29] Q[30] Q[31] WEN VSS
+  VDD
** RA1SH512x32: 112218 flat devices **
XI0_0 A0 A0_ DR DR_ DW DW_ GTP_1 GTP_1 GTP_1 VSS WE WL WL_0 WL_1 WL_2 WL_3
+  WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16
+  WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28
+  WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40
+  WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52
+  WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SH512x32LEFT_CAP
XI1_0 A0 A0_ BL BL_ BL_0 BL_1 BL_2 BL_3 BL_4 BL_5 BL_6 BL_7 BL_8 BL_9 BL_10
+  BL_11 BL_12 BL_13 BL_14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22
+  BL_23 BL_24 BL_25 BL_26 BL_27 BL_28 BL_29 BL_30 BL_31 BL_32 BL_33 BL_34
+  BL_35 BL_36 BL_37 BL_38 BL_39 BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46
+  BL_47 BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL_55 BL_56 BL_57 BL_58
+  BL_59 BL_60 BL_61 BL_62 BL_63 BL_64 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70
+  BL_71 BL_72 BL_73 BL_74 BL_75 BL_76 BL_77 BL_78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94
+  BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL_103 BL_104 BL_105
+  BL_106 BL_107 BL_108 BL_109 BL_110 BL_111 BL_112 BL_113 BL_114 BL_115
+  BL_116 BL_117 BL_118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125
+  BL_126 BL__0 BL__1 BL__2 BL__3 BL__4 BL__5 BL__6 BL__7 BL__8 BL__9 BL__10
+  BL__11 BL__12 BL__13 BL__14 BL__15 BL__16 BL__17 BL__18 BL__19 BL__20
+  BL__21 BL__22 BL__23 BL__24 BL__25 BL__26 BL__27 BL__28 BL__29 BL__30
+  BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL__39 BL__40
+  BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL__55 BL__56 BL__57 BL__58 BL__59 BL__60
+  BL__61 BL__62 BL__63 BL__64 BL__65 BL__66 BL__67 BL__68 BL__69 BL__70
+  BL__71 BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL__79 BL__80
+  BL__81 BL__82 BL__83 BL__84 BL__85 BL__86 BL__87 BL__88 BL__89 BL__90
+  BL__91 BL__92 BL__93 BL__94 BL__95 BL__96 BL__97 BL__98 BL__99 BL__100
+  BL__101 BL__102 BL__103 BL__104 BL__105 BL__106 BL__107 BL__108 BL__109
+  BL__110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117 BL__118
+  BL__119 BL__120 BL__121 BL__122 BL__123 BL__124 BL__125 BL__126 D[15] D[14]
+  D[13] D[12] D[11] D[10] D[9] D[8] D[7] D[6] D[5] D[4] D[3] D[2] D[1] D[0]
+  GTP_1 GTP_1 GTP_1 VSS Q[15] Q[14] Q[13] Q[12] Q[11] Q[10] Q[9] Q[8] Q[7]
+  Q[6] Q[5] Q[4] Q[3] Q[2] Q[1] Q[0] DR DR_ VSS VSS DW DW_ VSS VSS WE WL WL_0
+  WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14
+  WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26
+  WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38
+  WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50
+  WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62
+  YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SH512x32WING_16_LEFT
XI1_5 BL_ BL__63 BL_63 BL_64 BL__64 BL BL__0 BL__1 BL__2 BL__3 BL__4 BL__5
+  BL__6 BL_7 BL_8 BL_9 BL_10 BL_11 BL_12 BL_13 BL_14 BL__15 BL__16 BL__17
+  BL__18 BL__19 BL__20 BL__21 BL__22 BL_23 BL_24 BL_25 BL_26 BL_27 BL_28
+  BL_29 BL_30 BL__31 BL__32 BL__33 BL__34 BL__35 BL__36 BL__37 BL__38 BL_39
+  BL_40 BL_41 BL_42 BL_43 BL_44 BL_45 BL_46 BL__47 BL__48 BL__49 BL__50
+  BL__51 BL__52 BL__53 BL__54 BL_55 BL_56 BL_57 BL_58 BL_59 BL_60 BL_61 BL_62
+  BL__65 BL__66 BL__67 BL__68 BL__69 BL__70 BL_71 BL_72 BL_73 BL_74 BL_75
+  BL_76 BL_77 BL_78 BL__79 BL__80 BL__81 BL__82 BL__83 BL__84 BL__85 BL__86
+  BL_87 BL_88 BL_89 BL_90 BL_91 BL_92 BL_93 BL_94 BL__95 BL__96 BL__97 BL__98
+  BL__99 BL__100 BL__101 BL__102 BL_103 BL_104 BL_105 BL_106 BL_107 BL_108
+  BL_109 BL_110 BL__111 BL__112 BL__113 BL__114 BL__115 BL__116 BL__117
+  BL__118 BL_119 BL_120 BL_121 BL_122 BL_123 BL_124 BL_125 BL_126 BL_0 BL_1
+  BL_2 BL_3 BL_4 BL_5 BL_6 BL__7 BL__8 BL__9 BL__10 BL__11 BL__12 BL__13
+  BL__14 BL_15 BL_16 BL_17 BL_18 BL_19 BL_20 BL_21 BL_22 BL__23 BL__24 BL__25
+  BL__26 BL__27 BL__28 BL__29 BL__30 BL_31 BL_32 BL_33 BL_34 BL_35 BL_36
+  BL_37 BL_38 BL__39 BL__40 BL__41 BL__42 BL__43 BL__44 BL__45 BL__46 BL_47
+  BL_48 BL_49 BL_50 BL_51 BL_52 BL_53 BL_54 BL__55 BL__56 BL__57 BL__58
+  BL__59 BL__60 BL__61 BL__62 BL_65 BL_66 BL_67 BL_68 BL_69 BL_70 BL__71
+  BL__72 BL__73 BL__74 BL__75 BL__76 BL__77 BL__78 BL_79 BL_80 BL_81 BL_82
+  BL_83 BL_84 BL_85 BL_86 BL__87 BL__88 BL__89 BL__90 BL__91 BL__92 BL__93
+  BL__94 BL_95 BL_96 BL_97 BL_98 BL_99 BL_100 BL_101 BL_102 BL__103 BL__104
+  BL__105 BL__106 BL__107 BL__108 BL__109 BL__110 BL_111 BL_112 BL_113 BL_114
+  BL_115 BL_116 BL_117 BL_118 BL__119 BL__120 BL__121 BL__122 BL__123 BL__124
+  BL__125 BL__126 MWLB VSS VDD RA1SH512x32MODEL_ROW_16
XI3_0 A[6] A[3] A[7] A[4] A[8] A[5] AGTPT AGTPT A0 A0_ VSS VSS WE XP_0 XP_0_0
+  XP_1 XP_1_0 XP_2 XP_2_0 XP_3 XP_3_0 XP_4 XP_4_0 XP_5 XP_5_0 XP_6 XP_6_0
+  XP_7 XP_7_0 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SH512x32X_PRE_DECODE
XI3_3 VDD GTP_1 MBL MBL_ MWLB MWLB WL WL_2 WL_3 WL_6 WL_7 WL_10 WL_11 WL_14
+  WL_15 WL_18 WL_19 WL_22 WL_23 WL_26 WL_27 WL_30 WL_31 WL_34 WL_35 WL_38
+  WL_39 WL_42 WL_43 WL_46 WL_47 WL_50 WL_51 WL_54 WL_55 WL_58 WL_59 WL_62
+  WL_0 WL_1 WL_4 WL_5 WL_8 WL_9 WL_12 WL_13 WL_16 WL_17 WL_20 WL_21 WL_24
+  WL_25 WL_28 WL_29 WL_32 WL_33 WL_36 WL_37 WL_40 WL_41 WL_44 WL_45 WL_48
+  WL_49 WL_52 WL_53 WL_56 WL_57 WL_60 WL_61 XP_6 XP_4 XP_2 XP_0 XP_7 XP_5
+  XP_3 XP_1 XP_0_0 XP_1_0 XP_2_0 XP_3_0 XP_4_0 XP_5_0 XP_6_0 XP_7_0 VSS VDD
+  RA1SH512x32WORD_ROWS
XI4_0 A[1] A[0] A[2] AGTPT A0 A0_ VSS CLK GSRCN GTPN VSS RST WE YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VDD RA1SH512x32Y_DECODE
XI5_0 CEN CLK GSRCN GTP_1 GTPN MBL RST VSS WE WEN VSS VDD RA1SH512x32HBFX
XI5_2 A0 A0_ AGTPT CLK GSRCN GTP_1 GTPN GTP_1 GTP_1 GTP_1 RST YP0_0 YP0_1
+  YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD RA1SH512x32CLK_DRVS
XI6_2 A0 A0_ MBL_ MBL CLK GSRCN GTP_1 GTPN YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS
+  VSS VSS VDD RA1SH512x32FLCIOX
XI6_4 MBL_ MBL WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 MWLB MWLB VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS
+  VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VSS VDD
+  RA1SH512x32MODEL_COL
XI7_0 A0 A0_ BL_863 BL__865 BL_0_859 BL_1_855 BL_2_851 BL_3_847 BL_4_843
+  BL_5_839 BL_6_835 BL_7_833 BL_8_829 BL_9_825 BL_10_821 BL_11_817 BL_12_813
+  BL_13_809 BL_14_805 BL_15_799 BL_16_795 BL_17_791 BL_18_787 BL_19_783
+  BL_20_779 BL_21_775 BL_22_771 BL_23_769 BL_24_765 BL_25_761 BL_26_757
+  BL_27_753 BL_28_749 BL_29_745 BL_30_741 BL_31_735 BL_32_731 BL_33_727
+  BL_34_723 BL_35_719 BL_36_715 BL_37_711 BL_38_707 BL_39_705 BL_40_701
+  BL_41_697 BL_42_693 BL_43_689 BL_44_685 BL_45_681 BL_46_677 BL_47_671
+  BL_48_667 BL_49_663 BL_50_659 BL_51_655 BL_52_651 BL_53_647 BL_54_643
+  BL_55_641 BL_56_637 BL_57_633 BL_58_629 BL_59_625 BL_60_621 BL_61_617
+  BL_62_613 BL_63_607 BL_64_603 BL_65_599 BL_66_595 BL_67_591 BL_68_587
+  BL_69_583 BL_70_579 BL_71_577 BL_72_573 BL_73_569 BL_74_565 BL_75_561
+  BL_76_557 BL_77_553 BL_78_549 BL_79_543 BL_80_539 BL_81_535 BL_82_531
+  BL_83_527 BL_84_523 BL_85_519 BL_86_515 BL_87_513 BL_88_509 BL_89_505
+  BL_90_501 BL_91_497 BL_92_493 BL_93_489 BL_94_485 BL_95_479 BL_96_475
+  BL_97_471 BL_98_467 BL_99_463 BL_100_459 BL_101_455 BL_102_451 BL_103_449
+  BL_104_445 BL_105_441 BL_106_437 BL_107_433 BL_108_429 BL_109_425
+  BL_110_421 BL_111_415 BL_112_411 BL_113_407 BL_114_403 BL_115_399
+  BL_116_395 BL_117_391 BL_118_387 BL_119_385 BL_120_381 BL_121_377
+  BL_122_373 BL_123_369 BL_124_365 BL_125_361 BL_126_357 BL__0_861 BL__1_857
+  BL__2_853 BL__3_849 BL__4_845 BL__5_841 BL__6_837 BL__7_831 BL__8_827
+  BL__9_823 BL__10_819 BL__11_815 BL__12_811 BL__13_807 BL__14_803 BL__15_801
+  BL__16_797 BL__17_793 BL__18_789 BL__19_785 BL__20_781 BL__21_777
+  BL__22_773 BL__23_767 BL__24_763 BL__25_759 BL__26_755 BL__27_751
+  BL__28_747 BL__29_743 BL__30_739 BL__31_737 BL__32_733 BL__33_729
+  BL__34_725 BL__35_721 BL__36_717 BL__37_713 BL__38_709 BL__39_703
+  BL__40_699 BL__41_695 BL__42_691 BL__43_687 BL__44_683 BL__45_679
+  BL__46_675 BL__47_673 BL__48_669 BL__49_665 BL__50_661 BL__51_657
+  BL__52_653 BL__53_649 BL__54_645 BL__55_639 BL__56_635 BL__57_631
+  BL__58_627 BL__59_623 BL__60_619 BL__61_615 BL__62_611 BL__63_609
+  BL__64_605 BL__65_601 BL__66_597 BL__67_593 BL__68_589 BL__69_585
+  BL__70_581 BL__71_575 BL__72_571 BL__73_567 BL__74_563 BL__75_559
+  BL__76_555 BL__77_551 BL__78_547 BL__79_545 BL__80_541 BL__81_537
+  BL__82_533 BL__83_529 BL__84_525 BL__85_521 BL__86_517 BL__87_511
+  BL__88_507 BL__89_503 BL__90_499 BL__91_495 BL__92_491 BL__93_487
+  BL__94_483 BL__95_481 BL__96_477 BL__97_473 BL__98_469 BL__99_465
+  BL__100_461 BL__101_457 BL__102_453 BL__103_447 BL__104_443 BL__105_439
+  BL__106_435 BL__107_431 BL__108_427 BL__109_423 BL__110_419 BL__111_417
+  BL__112_413 BL__113_409 BL__114_405 BL__115_401 BL__116_397 BL__117_393
+  BL__118_389 BL__119_383 BL__120_379 BL__121_375 BL__122_371 BL__123_367
+  BL__124_363 BL__125_359 BL__126_355 D[16] D[17] D[18] D[19] D[20] D[21]
+  D[22] D[23] D[24] D[25] D[26] D[27] D[28] D[29] D[30] D[31] GTP_1 GTP_1
+  GTP_1 VSS Q[16] Q[17] Q[18] Q[19] Q[20] Q[21] Q[22] Q[23] Q[24] Q[25] Q[26]
+  Q[27] Q[28] Q[29] Q[30] Q[31] VSS VSS STUBDR_0 STUBDR__0 VSS VSS STUBDW_0
+  STUBDW__0 WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6 WL_7 WL_8 WL_9 WL_10
+  WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19 WL_20 WL_21 WL_22
+  WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31 WL_32 WL_33 WL_34
+  WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43 WL_44 WL_45 WL_46
+  WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55 WL_56 WL_57 WL_58
+  WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS VSS VSS VSS VDD
+  RA1SH512x32WING_16_RIGHT
XI7_5 BL__865 BL__63_609 BL_63_607 BL_64_603 BL__64_605 BL_863 BL__0_861
+  BL__1_857 BL__2_853 BL__3_849 BL__4_845 BL__5_841 BL__6_837 BL_7_833
+  BL_8_829 BL_9_825 BL_10_821 BL_11_817 BL_12_813 BL_13_809 BL_14_805
+  BL__15_801 BL__16_797 BL__17_793 BL__18_789 BL__19_785 BL__20_781
+  BL__21_777 BL__22_773 BL_23_769 BL_24_765 BL_25_761 BL_26_757 BL_27_753
+  BL_28_749 BL_29_745 BL_30_741 BL__31_737 BL__32_733 BL__33_729 BL__34_725
+  BL__35_721 BL__36_717 BL__37_713 BL__38_709 BL_39_705 BL_40_701 BL_41_697
+  BL_42_693 BL_43_689 BL_44_685 BL_45_681 BL_46_677 BL__47_673 BL__48_669
+  BL__49_665 BL__50_661 BL__51_657 BL__52_653 BL__53_649 BL__54_645 BL_55_641
+  BL_56_637 BL_57_633 BL_58_629 BL_59_625 BL_60_621 BL_61_617 BL_62_613
+  BL__65_601 BL__66_597 BL__67_593 BL__68_589 BL__69_585 BL__70_581 BL_71_577
+  BL_72_573 BL_73_569 BL_74_565 BL_75_561 BL_76_557 BL_77_553 BL_78_549
+  BL__79_545 BL__80_541 BL__81_537 BL__82_533 BL__83_529 BL__84_525
+  BL__85_521 BL__86_517 BL_87_513 BL_88_509 BL_89_505 BL_90_501 BL_91_497
+  BL_92_493 BL_93_489 BL_94_485 BL__95_481 BL__96_477 BL__97_473 BL__98_469
+  BL__99_465 BL__100_461 BL__101_457 BL__102_453 BL_103_449 BL_104_445
+  BL_105_441 BL_106_437 BL_107_433 BL_108_429 BL_109_425 BL_110_421
+  BL__111_417 BL__112_413 BL__113_409 BL__114_405 BL__115_401 BL__116_397
+  BL__117_393 BL__118_389 BL_119_385 BL_120_381 BL_121_377 BL_122_373
+  BL_123_369 BL_124_365 BL_125_361 BL_126_357 BL_0_859 BL_1_855 BL_2_851
+  BL_3_847 BL_4_843 BL_5_839 BL_6_835 BL__7_831 BL__8_827 BL__9_823
+  BL__10_819 BL__11_815 BL__12_811 BL__13_807 BL__14_803 BL_15_799 BL_16_795
+  BL_17_791 BL_18_787 BL_19_783 BL_20_779 BL_21_775 BL_22_771 BL__23_767
+  BL__24_763 BL__25_759 BL__26_755 BL__27_751 BL__28_747 BL__29_743
+  BL__30_739 BL_31_735 BL_32_731 BL_33_727 BL_34_723 BL_35_719 BL_36_715
+  BL_37_711 BL_38_707 BL__39_703 BL__40_699 BL__41_695 BL__42_691 BL__43_687
+  BL__44_683 BL__45_679 BL__46_675 BL_47_671 BL_48_667 BL_49_663 BL_50_659
+  BL_51_655 BL_52_651 BL_53_647 BL_54_643 BL__55_639 BL__56_635 BL__57_631
+  BL__58_627 BL__59_623 BL__60_619 BL__61_615 BL__62_611 BL_65_599 BL_66_595
+  BL_67_591 BL_68_587 BL_69_583 BL_70_579 BL__71_575 BL__72_571 BL__73_567
+  BL__74_563 BL__75_559 BL__76_555 BL__77_551 BL__78_547 BL_79_543 BL_80_539
+  BL_81_535 BL_82_531 BL_83_527 BL_84_523 BL_85_519 BL_86_515 BL__87_511
+  BL__88_507 BL__89_503 BL__90_499 BL__91_495 BL__92_491 BL__93_487
+  BL__94_483 BL_95_479 BL_96_475 BL_97_471 BL_98_467 BL_99_463 BL_100_459
+  BL_101_455 BL_102_451 BL__103_447 BL__104_443 BL__105_439 BL__106_435
+  BL__107_431 BL__108_427 BL__109_423 BL__110_419 BL_111_415 BL_112_411
+  BL_113_407 BL_114_403 BL_115_399 BL_116_395 BL_117_391 BL_118_387
+  BL__119_383 BL__120_379 BL__121_375 BL__122_371 BL__123_367 BL__124_363
+  BL__125_359 BL__126_355 MWLB VSS VDD RA1SH512x32MODEL_ROW_16
XI8_0 A0 A0_ GTP_1 GTP_1 GTP_1 VSS WE WL WL_0 WL_1 WL_2 WL_3 WL_4 WL_5 WL_6
+  WL_7 WL_8 WL_9 WL_10 WL_11 WL_12 WL_13 WL_14 WL_15 WL_16 WL_17 WL_18 WL_19
+  WL_20 WL_21 WL_22 WL_23 WL_24 WL_25 WL_26 WL_27 WL_28 WL_29 WL_30 WL_31
+  WL_32 WL_33 WL_34 WL_35 WL_36 WL_37 WL_38 WL_39 WL_40 WL_41 WL_42 WL_43
+  WL_44 WL_45 WL_46 WL_47 WL_48 WL_49 WL_50 WL_51 WL_52 WL_53 WL_54 WL_55
+  WL_56 WL_57 WL_58 WL_59 WL_60 WL_61 WL_62 YP0_0 YP0_1 YP0_2 YP0_3 VSS VSS
+  VSS VSS VSS VDD RA1SH512x32RIGHT_CAP
.ENDS RA1SH512x32
