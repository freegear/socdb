short sine_table256[256] = {
/* sin(2*PI*1/4096) */    1,
/* sin(2*PI*3/4096) */    2,
/* sin(2*PI*5/4096) */    4,
/* sin(2*PI*7/4096) */    5,
/* sin(2*PI*9/4096) */    7,
/* sin(2*PI*11/4096) */    9,
/* sin(2*PI*13/4096) */   10,
/* sin(2*PI*15/4096) */   12,
/* sin(2*PI*17/4096) */   13,
/* sin(2*PI*19/4096) */   15,
/* sin(2*PI*21/4096) */   16,
/* sin(2*PI*23/4096) */   18,
/* sin(2*PI*25/4096) */   20,
/* sin(2*PI*27/4096) */   21,
/* sin(2*PI*29/4096) */   23,
/* sin(2*PI*31/4096) */   24,
/* sin(2*PI*33/4096) */   26,
/* sin(2*PI*35/4096) */   27,
/* sin(2*PI*37/4096) */   29,
/* sin(2*PI*39/4096) */   31,
/* sin(2*PI*41/4096) */   32,
/* sin(2*PI*43/4096) */   34,
/* sin(2*PI*45/4096) */   35,
/* sin(2*PI*47/4096) */   37,
/* sin(2*PI*49/4096) */   38,
/* sin(2*PI*51/4096) */   40,
/* sin(2*PI*53/4096) */   42,
/* sin(2*PI*55/4096) */   43,
/* sin(2*PI*57/4096) */   45,
/* sin(2*PI*59/4096) */   46,
/* sin(2*PI*61/4096) */   48,
/* sin(2*PI*63/4096) */   49,
/* sin(2*PI*65/4096) */   51,
/* sin(2*PI*67/4096) */   53,
/* sin(2*PI*69/4096) */   54,
/* sin(2*PI*71/4096) */   56,
/* sin(2*PI*73/4096) */   57,
/* sin(2*PI*75/4096) */   59,
/* sin(2*PI*77/4096) */   60,
/* sin(2*PI*79/4096) */   62,
/* sin(2*PI*81/4096) */   63,
/* sin(2*PI*83/4096) */   65,
/* sin(2*PI*85/4096) */   67,
/* sin(2*PI*87/4096) */   68,
/* sin(2*PI*89/4096) */   70,
/* sin(2*PI*91/4096) */   71,
/* sin(2*PI*93/4096) */   73,
/* sin(2*PI*95/4096) */   74,
/* sin(2*PI*97/4096) */   76,
/* sin(2*PI*99/4096) */   77,
/* sin(2*PI*101/4096) */   79,
/* sin(2*PI*103/4096) */   81,
/* sin(2*PI*105/4096) */   82,
/* sin(2*PI*107/4096) */   84,
/* sin(2*PI*109/4096) */   85,
/* sin(2*PI*111/4096) */   87,
/* sin(2*PI*113/4096) */   88,
/* sin(2*PI*115/4096) */   90,
/* sin(2*PI*117/4096) */   91,
/* sin(2*PI*119/4096) */   93,
/* sin(2*PI*121/4096) */   94,
/* sin(2*PI*123/4096) */   96,
/* sin(2*PI*125/4096) */   98,
/* sin(2*PI*127/4096) */   99,
/* sin(2*PI*129/4096) */  101,
/* sin(2*PI*131/4096) */  102,
/* sin(2*PI*133/4096) */  104,
/* sin(2*PI*135/4096) */  105,
/* sin(2*PI*137/4096) */  107,
/* sin(2*PI*139/4096) */  108,
/* sin(2*PI*141/4096) */  110,
/* sin(2*PI*143/4096) */  111,
/* sin(2*PI*145/4096) */  113,
/* sin(2*PI*147/4096) */  114,
/* sin(2*PI*149/4096) */  116,
/* sin(2*PI*151/4096) */  118,
/* sin(2*PI*153/4096) */  119,
/* sin(2*PI*155/4096) */  121,
/* sin(2*PI*157/4096) */  122,
/* sin(2*PI*159/4096) */  124,
/* sin(2*PI*161/4096) */  125,
/* sin(2*PI*163/4096) */  127,
/* sin(2*PI*165/4096) */  128,
/* sin(2*PI*167/4096) */  130,
/* sin(2*PI*169/4096) */  131,
/* sin(2*PI*171/4096) */  133,
/* sin(2*PI*173/4096) */  134,
/* sin(2*PI*175/4096) */  136,
/* sin(2*PI*177/4096) */  137,
/* sin(2*PI*179/4096) */  139,
/* sin(2*PI*181/4096) */  140,
/* sin(2*PI*183/4096) */  142,
/* sin(2*PI*185/4096) */  143,
/* sin(2*PI*187/4096) */  145,
/* sin(2*PI*189/4096) */  146,
/* sin(2*PI*191/4096) */  148,
/* sin(2*PI*193/4096) */  149,
/* sin(2*PI*195/4096) */  151,
/* sin(2*PI*197/4096) */  152,
/* sin(2*PI*199/4096) */  154,
/* sin(2*PI*201/4096) */  155,
/* sin(2*PI*203/4096) */  157,
/* sin(2*PI*205/4096) */  158,
/* sin(2*PI*207/4096) */  160,
/* sin(2*PI*209/4096) */  161,
/* sin(2*PI*211/4096) */  163,
/* sin(2*PI*213/4096) */  164,
/* sin(2*PI*215/4096) */  166,
/* sin(2*PI*217/4096) */  167,
/* sin(2*PI*219/4096) */  169,
/* sin(2*PI*221/4096) */  170,
/* sin(2*PI*223/4096) */  172,
/* sin(2*PI*225/4096) */  173,
/* sin(2*PI*227/4096) */  175,
/* sin(2*PI*229/4096) */  176,
/* sin(2*PI*231/4096) */  178,
/* sin(2*PI*233/4096) */  179,
/* sin(2*PI*235/4096) */  181,
/* sin(2*PI*237/4096) */  182,
/* sin(2*PI*239/4096) */  184,
/* sin(2*PI*241/4096) */  185,
/* sin(2*PI*243/4096) */  186,
/* sin(2*PI*245/4096) */  188,
/* sin(2*PI*247/4096) */  189,
/* sin(2*PI*249/4096) */  191,
/* sin(2*PI*251/4096) */  192,
/* sin(2*PI*253/4096) */  194,
/* sin(2*PI*255/4096) */  195,
/* sin(2*PI*257/4096) */  197,
/* sin(2*PI*259/4096) */  198,
/* sin(2*PI*261/4096) */  200,
/* sin(2*PI*263/4096) */  201,
/* sin(2*PI*265/4096) */  202,
/* sin(2*PI*267/4096) */  204,
/* sin(2*PI*269/4096) */  205,
/* sin(2*PI*271/4096) */  207,
/* sin(2*PI*273/4096) */  208,
/* sin(2*PI*275/4096) */  210,
/* sin(2*PI*277/4096) */  211,
/* sin(2*PI*279/4096) */  212,
/* sin(2*PI*281/4096) */  214,
/* sin(2*PI*283/4096) */  215,
/* sin(2*PI*285/4096) */  217,
/* sin(2*PI*287/4096) */  218,
/* sin(2*PI*289/4096) */  220,
/* sin(2*PI*291/4096) */  221,
/* sin(2*PI*293/4096) */  222,
/* sin(2*PI*295/4096) */  224,
/* sin(2*PI*297/4096) */  225,
/* sin(2*PI*299/4096) */  227,
/* sin(2*PI*301/4096) */  228,
/* sin(2*PI*303/4096) */  229,
/* sin(2*PI*305/4096) */  231,
/* sin(2*PI*307/4096) */  232,
/* sin(2*PI*309/4096) */  234,
/* sin(2*PI*311/4096) */  235,
/* sin(2*PI*313/4096) */  236,
/* sin(2*PI*315/4096) */  238,
/* sin(2*PI*317/4096) */  239,
/* sin(2*PI*319/4096) */  241,
/* sin(2*PI*321/4096) */  242,
/* sin(2*PI*323/4096) */  243,
/* sin(2*PI*325/4096) */  245,
/* sin(2*PI*327/4096) */  246,
/* sin(2*PI*329/4096) */  248,
/* sin(2*PI*331/4096) */  249,
/* sin(2*PI*333/4096) */  250,
/* sin(2*PI*335/4096) */  252,
/* sin(2*PI*337/4096) */  253,
/* sin(2*PI*339/4096) */  254,
/* sin(2*PI*341/4096) */  256,
/* sin(2*PI*343/4096) */  257,
/* sin(2*PI*345/4096) */  258,
/* sin(2*PI*347/4096) */  260,
/* sin(2*PI*349/4096) */  261,
/* sin(2*PI*351/4096) */  263,
/* sin(2*PI*353/4096) */  264,
/* sin(2*PI*355/4096) */  265,
/* sin(2*PI*357/4096) */  267,
/* sin(2*PI*359/4096) */  268,
/* sin(2*PI*361/4096) */  269,
/* sin(2*PI*363/4096) */  271,
/* sin(2*PI*365/4096) */  272,
/* sin(2*PI*367/4096) */  273,
/* sin(2*PI*369/4096) */  275,
/* sin(2*PI*371/4096) */  276,
/* sin(2*PI*373/4096) */  277,
/* sin(2*PI*375/4096) */  279,
/* sin(2*PI*377/4096) */  280,
/* sin(2*PI*379/4096) */  281,
/* sin(2*PI*381/4096) */  282,
/* sin(2*PI*383/4096) */  284,
/* sin(2*PI*385/4096) */  285,
/* sin(2*PI*387/4096) */  286,
/* sin(2*PI*389/4096) */  288,
/* sin(2*PI*391/4096) */  289,
/* sin(2*PI*393/4096) */  290,
/* sin(2*PI*395/4096) */  292,
/* sin(2*PI*397/4096) */  293,
/* sin(2*PI*399/4096) */  294,
/* sin(2*PI*401/4096) */  295,
/* sin(2*PI*403/4096) */  297,
/* sin(2*PI*405/4096) */  298,
/* sin(2*PI*407/4096) */  299,
/* sin(2*PI*409/4096) */  301,
/* sin(2*PI*411/4096) */  302,
/* sin(2*PI*413/4096) */  303,
/* sin(2*PI*415/4096) */  304,
/* sin(2*PI*417/4096) */  306,
/* sin(2*PI*419/4096) */  307,
/* sin(2*PI*421/4096) */  308,
/* sin(2*PI*423/4096) */  309,
/* sin(2*PI*425/4096) */  311,
/* sin(2*PI*427/4096) */  312,
/* sin(2*PI*429/4096) */  313,
/* sin(2*PI*431/4096) */  314,
/* sin(2*PI*433/4096) */  316,
/* sin(2*PI*435/4096) */  317,
/* sin(2*PI*437/4096) */  318,
/* sin(2*PI*439/4096) */  319,
/* sin(2*PI*441/4096) */  321,
/* sin(2*PI*443/4096) */  322,
/* sin(2*PI*445/4096) */  323,
/* sin(2*PI*447/4096) */  324,
/* sin(2*PI*449/4096) */  325,
/* sin(2*PI*451/4096) */  327,
/* sin(2*PI*453/4096) */  328,
/* sin(2*PI*455/4096) */  329,
/* sin(2*PI*457/4096) */  330,
/* sin(2*PI*459/4096) */  331,
/* sin(2*PI*461/4096) */  333,
/* sin(2*PI*463/4096) */  334,
/* sin(2*PI*465/4096) */  335,
/* sin(2*PI*467/4096) */  336,
/* sin(2*PI*469/4096) */  337,
/* sin(2*PI*471/4096) */  339,
/* sin(2*PI*473/4096) */  340,
/* sin(2*PI*475/4096) */  341,
/* sin(2*PI*477/4096) */  342,
/* sin(2*PI*479/4096) */  343,
/* sin(2*PI*481/4096) */  344,
/* sin(2*PI*483/4096) */  346,
/* sin(2*PI*485/4096) */  347,
/* sin(2*PI*487/4096) */  348,
/* sin(2*PI*489/4096) */  349,
/* sin(2*PI*491/4096) */  350,
/* sin(2*PI*493/4096) */  351,
/* sin(2*PI*495/4096) */  352,
/* sin(2*PI*497/4096) */  354,
/* sin(2*PI*499/4096) */  355,
/* sin(2*PI*501/4096) */  356,
/* sin(2*PI*503/4096) */  357,
/* sin(2*PI*505/4096) */  358,
/* sin(2*PI*507/4096) */  359,
/* sin(2*PI*509/4096) */  360,
/* sin(2*PI*511/4096) */  361
};
short cosine_table256[256] = {
/* cos(2*PI*1/4096) */  512,
/* cos(2*PI*3/4096) */  512,
/* cos(2*PI*5/4096) */  512,
/* cos(2*PI*7/4096) */  512,
/* cos(2*PI*9/4096) */  512,
/* cos(2*PI*11/4096) */  512,
/* cos(2*PI*13/4096) */  512,
/* cos(2*PI*15/4096) */  512,
/* cos(2*PI*17/4096) */  512,
/* cos(2*PI*19/4096) */  512,
/* cos(2*PI*21/4096) */  512,
/* cos(2*PI*23/4096) */  512,
/* cos(2*PI*25/4096) */  512,
/* cos(2*PI*27/4096) */  512,
/* cos(2*PI*29/4096) */  511,
/* cos(2*PI*31/4096) */  511,
/* cos(2*PI*33/4096) */  511,
/* cos(2*PI*35/4096) */  511,
/* cos(2*PI*37/4096) */  511,
/* cos(2*PI*39/4096) */  511,
/* cos(2*PI*41/4096) */  511,
/* cos(2*PI*43/4096) */  511,
/* cos(2*PI*45/4096) */  511,
/* cos(2*PI*47/4096) */  511,
/* cos(2*PI*49/4096) */  511,
/* cos(2*PI*51/4096) */  510,
/* cos(2*PI*53/4096) */  510,
/* cos(2*PI*55/4096) */  510,
/* cos(2*PI*57/4096) */  510,
/* cos(2*PI*59/4096) */  510,
/* cos(2*PI*61/4096) */  510,
/* cos(2*PI*63/4096) */  510,
/* cos(2*PI*65/4096) */  509,
/* cos(2*PI*67/4096) */  509,
/* cos(2*PI*69/4096) */  509,
/* cos(2*PI*71/4096) */  509,
/* cos(2*PI*73/4096) */  509,
/* cos(2*PI*75/4096) */  509,
/* cos(2*PI*77/4096) */  508,
/* cos(2*PI*79/4096) */  508,
/* cos(2*PI*81/4096) */  508,
/* cos(2*PI*83/4096) */  508,
/* cos(2*PI*85/4096) */  508,
/* cos(2*PI*87/4096) */  507,
/* cos(2*PI*89/4096) */  507,
/* cos(2*PI*91/4096) */  507,
/* cos(2*PI*93/4096) */  507,
/* cos(2*PI*95/4096) */  507,
/* cos(2*PI*97/4096) */  506,
/* cos(2*PI*99/4096) */  506,
/* cos(2*PI*101/4096) */  506,
/* cos(2*PI*103/4096) */  506,
/* cos(2*PI*105/4096) */  505,
/* cos(2*PI*107/4096) */  505,
/* cos(2*PI*109/4096) */  505,
/* cos(2*PI*111/4096) */  505,
/* cos(2*PI*113/4096) */  504,
/* cos(2*PI*115/4096) */  504,
/* cos(2*PI*117/4096) */  504,
/* cos(2*PI*119/4096) */  503,
/* cos(2*PI*121/4096) */  503,
/* cos(2*PI*123/4096) */  503,
/* cos(2*PI*125/4096) */  503,
/* cos(2*PI*127/4096) */  502,
/* cos(2*PI*129/4096) */  502,
/* cos(2*PI*131/4096) */  502,
/* cos(2*PI*133/4096) */  501,
/* cos(2*PI*135/4096) */  501,
/* cos(2*PI*137/4096) */  501,
/* cos(2*PI*139/4096) */  500,
/* cos(2*PI*141/4096) */  500,
/* cos(2*PI*143/4096) */  500,
/* cos(2*PI*145/4096) */  499,
/* cos(2*PI*147/4096) */  499,
/* cos(2*PI*149/4096) */  499,
/* cos(2*PI*151/4096) */  498,
/* cos(2*PI*153/4096) */  498,
/* cos(2*PI*155/4096) */  498,
/* cos(2*PI*157/4096) */  497,
/* cos(2*PI*159/4096) */  497,
/* cos(2*PI*161/4096) */  496,
/* cos(2*PI*163/4096) */  496,
/* cos(2*PI*165/4096) */  496,
/* cos(2*PI*167/4096) */  495,
/* cos(2*PI*169/4096) */  495,
/* cos(2*PI*171/4096) */  494,
/* cos(2*PI*173/4096) */  494,
/* cos(2*PI*175/4096) */  494,
/* cos(2*PI*177/4096) */  493,
/* cos(2*PI*179/4096) */  493,
/* cos(2*PI*181/4096) */  492,
/* cos(2*PI*183/4096) */  492,
/* cos(2*PI*185/4096) */  492,
/* cos(2*PI*187/4096) */  491,
/* cos(2*PI*189/4096) */  491,
/* cos(2*PI*191/4096) */  490,
/* cos(2*PI*193/4096) */  490,
/* cos(2*PI*195/4096) */  489,
/* cos(2*PI*197/4096) */  489,
/* cos(2*PI*199/4096) */  488,
/* cos(2*PI*201/4096) */  488,
/* cos(2*PI*203/4096) */  487,
/* cos(2*PI*205/4096) */  487,
/* cos(2*PI*207/4096) */  486,
/* cos(2*PI*209/4096) */  486,
/* cos(2*PI*211/4096) */  485,
/* cos(2*PI*213/4096) */  485,
/* cos(2*PI*215/4096) */  484,
/* cos(2*PI*217/4096) */  484,
/* cos(2*PI*219/4096) */  483,
/* cos(2*PI*221/4096) */  483,
/* cos(2*PI*223/4096) */  482,
/* cos(2*PI*225/4096) */  482,
/* cos(2*PI*227/4096) */  481,
/* cos(2*PI*229/4096) */  481,
/* cos(2*PI*231/4096) */  480,
/* cos(2*PI*233/4096) */  480,
/* cos(2*PI*235/4096) */  479,
/* cos(2*PI*237/4096) */  479,
/* cos(2*PI*239/4096) */  478,
/* cos(2*PI*241/4096) */  477,
/* cos(2*PI*243/4096) */  477,
/* cos(2*PI*245/4096) */  476,
/* cos(2*PI*247/4096) */  476,
/* cos(2*PI*249/4096) */  475,
/* cos(2*PI*251/4096) */  475,
/* cos(2*PI*253/4096) */  474,
/* cos(2*PI*255/4096) */  473,
/* cos(2*PI*257/4096) */  473,
/* cos(2*PI*259/4096) */  472,
/* cos(2*PI*261/4096) */  472,
/* cos(2*PI*263/4096) */  471,
/* cos(2*PI*265/4096) */  470,
/* cos(2*PI*267/4096) */  470,
/* cos(2*PI*269/4096) */  469,
/* cos(2*PI*271/4096) */  468,
/* cos(2*PI*273/4096) */  468,
/* cos(2*PI*275/4096) */  467,
/* cos(2*PI*277/4096) */  466,
/* cos(2*PI*279/4096) */  466,
/* cos(2*PI*281/4096) */  465,
/* cos(2*PI*283/4096) */  465,
/* cos(2*PI*285/4096) */  464,
/* cos(2*PI*287/4096) */  463,
/* cos(2*PI*289/4096) */  463,
/* cos(2*PI*291/4096) */  462,
/* cos(2*PI*293/4096) */  461,
/* cos(2*PI*295/4096) */  460,
/* cos(2*PI*297/4096) */  460,
/* cos(2*PI*299/4096) */  459,
/* cos(2*PI*301/4096) */  458,
/* cos(2*PI*303/4096) */  458,
/* cos(2*PI*305/4096) */  457,
/* cos(2*PI*307/4096) */  456,
/* cos(2*PI*309/4096) */  456,
/* cos(2*PI*311/4096) */  455,
/* cos(2*PI*313/4096) */  454,
/* cos(2*PI*315/4096) */  453,
/* cos(2*PI*317/4096) */  453,
/* cos(2*PI*319/4096) */  452,
/* cos(2*PI*321/4096) */  451,
/* cos(2*PI*323/4096) */  450,
/* cos(2*PI*325/4096) */  450,
/* cos(2*PI*327/4096) */  449,
/* cos(2*PI*329/4096) */  448,
/* cos(2*PI*331/4096) */  447,
/* cos(2*PI*333/4096) */  447,
/* cos(2*PI*335/4096) */  446,
/* cos(2*PI*337/4096) */  445,
/* cos(2*PI*339/4096) */  444,
/* cos(2*PI*341/4096) */  444,
/* cos(2*PI*343/4096) */  443,
/* cos(2*PI*345/4096) */  442,
/* cos(2*PI*347/4096) */  441,
/* cos(2*PI*349/4096) */  440,
/* cos(2*PI*351/4096) */  440,
/* cos(2*PI*353/4096) */  439,
/* cos(2*PI*355/4096) */  438,
/* cos(2*PI*357/4096) */  437,
/* cos(2*PI*359/4096) */  436,
/* cos(2*PI*361/4096) */  435,
/* cos(2*PI*363/4096) */  435,
/* cos(2*PI*365/4096) */  434,
/* cos(2*PI*367/4096) */  433,
/* cos(2*PI*369/4096) */  432,
/* cos(2*PI*371/4096) */  431,
/* cos(2*PI*373/4096) */  430,
/* cos(2*PI*375/4096) */  430,
/* cos(2*PI*377/4096) */  429,
/* cos(2*PI*379/4096) */  428,
/* cos(2*PI*381/4096) */  427,
/* cos(2*PI*383/4096) */  426,
/* cos(2*PI*385/4096) */  425,
/* cos(2*PI*387/4096) */  424,
/* cos(2*PI*389/4096) */  424,
/* cos(2*PI*391/4096) */  423,
/* cos(2*PI*393/4096) */  422,
/* cos(2*PI*395/4096) */  421,
/* cos(2*PI*397/4096) */  420,
/* cos(2*PI*399/4096) */  419,
/* cos(2*PI*401/4096) */  418,
/* cos(2*PI*403/4096) */  417,
/* cos(2*PI*405/4096) */  416,
/* cos(2*PI*407/4096) */  415,
/* cos(2*PI*409/4096) */  414,
/* cos(2*PI*411/4096) */  414,
/* cos(2*PI*413/4096) */  413,
/* cos(2*PI*415/4096) */  412,
/* cos(2*PI*417/4096) */  411,
/* cos(2*PI*419/4096) */  410,
/* cos(2*PI*421/4096) */  409,
/* cos(2*PI*423/4096) */  408,
/* cos(2*PI*425/4096) */  407,
/* cos(2*PI*427/4096) */  406,
/* cos(2*PI*429/4096) */  405,
/* cos(2*PI*431/4096) */  404,
/* cos(2*PI*433/4096) */  403,
/* cos(2*PI*435/4096) */  402,
/* cos(2*PI*437/4096) */  401,
/* cos(2*PI*439/4096) */  400,
/* cos(2*PI*441/4096) */  399,
/* cos(2*PI*443/4096) */  398,
/* cos(2*PI*445/4096) */  397,
/* cos(2*PI*447/4096) */  396,
/* cos(2*PI*449/4096) */  395,
/* cos(2*PI*451/4096) */  394,
/* cos(2*PI*453/4096) */  393,
/* cos(2*PI*455/4096) */  392,
/* cos(2*PI*457/4096) */  391,
/* cos(2*PI*459/4096) */  390,
/* cos(2*PI*461/4096) */  389,
/* cos(2*PI*463/4096) */  388,
/* cos(2*PI*465/4096) */  387,
/* cos(2*PI*467/4096) */  386,
/* cos(2*PI*469/4096) */  385,
/* cos(2*PI*471/4096) */  384,
/* cos(2*PI*473/4096) */  383,
/* cos(2*PI*475/4096) */  382,
/* cos(2*PI*477/4096) */  381,
/* cos(2*PI*479/4096) */  380,
/* cos(2*PI*481/4096) */  379,
/* cos(2*PI*483/4096) */  378,
/* cos(2*PI*485/4096) */  377,
/* cos(2*PI*487/4096) */  376,
/* cos(2*PI*489/4096) */  375,
/* cos(2*PI*491/4096) */  374,
/* cos(2*PI*493/4096) */  372,
/* cos(2*PI*495/4096) */  371,
/* cos(2*PI*497/4096) */  370,
/* cos(2*PI*499/4096) */  369,
/* cos(2*PI*501/4096) */  368,
/* cos(2*PI*503/4096) */  367,
/* cos(2*PI*505/4096) */  366,
/* cos(2*PI*507/4096) */  365,
/* cos(2*PI*509/4096) */  364,
/* cos(2*PI*511/4096) */  363
};
