#define sine_bit_resolution 9
short sine_table[2048] = {
   1,    2,    4,    5,    7,    9,   10,   12, 
  13,   15,   16,   18,   20,   21,   23,   24, 
  26,   27,   29,   31,   32,   34,   35,   37, 
  38,   40,   42,   43,   45,   46,   48,   49, 
  51,   53,   54,   56,   57,   59,   60,   62, 
  63,   65,   67,   68,   70,   71,   73,   74, 
  76,   77,   79,   81,   82,   84,   85,   87, 
  88,   90,   91,   93,   94,   96,   98,   99, 
 101,  102,  104,  105,  107,  108,  110,  111, 
 113,  114,  116,  118,  119,  121,  122,  124, 
 125,  127,  128,  130,  131,  133,  134,  136, 
 137,  139,  140,  142,  143,  145,  146,  148, 
 149,  151,  152,  154,  155,  157,  158,  160, 
 161,  163,  164,  166,  167,  169,  170,  172, 
 173,  175,  176,  178,  179,  181,  182,  184, 
 185,  186,  188,  189,  191,  192,  194,  195, 
 197,  198,  200,  201,  202,  204,  205,  207, 
 208,  210,  211,  212,  214,  215,  217,  218, 
 220,  221,  222,  224,  225,  227,  228,  229, 
 231,  232,  234,  235,  236,  238,  239,  241, 
 242,  243,  245,  246,  248,  249,  250,  252, 
 253,  254,  256,  257,  258,  260,  261,  263, 
 264,  265,  267,  268,  269,  271,  272,  273, 
 275,  276,  277,  279,  280,  281,  282,  284, 
 285,  286,  288,  289,  290,  292,  293,  294, 
 295,  297,  298,  299,  301,  302,  303,  304, 
 306,  307,  308,  309,  311,  312,  313,  314, 
 316,  317,  318,  319,  321,  322,  323,  324, 
 325,  327,  328,  329,  330,  331,  333,  334, 
 335,  336,  337,  339,  340,  341,  342,  343, 
 344,  346,  347,  348,  349,  350,  351,  352, 
 354,  355,  356,  357,  358,  359,  360,  361, 
 363,  364,  365,  366,  367,  368,  369,  370, 
 371,  372,  374,  375,  376,  377,  378,  379, 
 380,  381,  382,  383,  384,  385,  386,  387, 
 388,  389,  390,  391,  392,  393,  394,  395, 
 396,  397,  398,  399,  400,  401,  402,  403, 
 404,  405,  406,  407,  408,  409,  410,  411, 
 412,  413,  414,  414,  415,  416,  417,  418, 
 419,  420,  421,  422,  423,  424,  424,  425, 
 426,  427,  428,  429,  430,  430,  431,  432, 
 433,  434,  435,  435,  436,  437,  438,  439, 
 440,  440,  441,  442,  443,  444,  444,  445, 
 446,  447,  447,  448,  449,  450,  450,  451, 
 452,  453,  453,  454,  455,  456,  456,  457, 
 458,  458,  459,  460,  460,  461,  462,  463, 
 463,  464,  465,  465,  466,  466,  467,  468, 
 468,  469,  470,  470,  471,  472,  472,  473, 
 473,  474,  475,  475,  476,  476,  477,  477, 
 478,  479,  479,  480,  480,  481,  481,  482, 
 482,  483,  483,  484,  484,  485,  485,  486, 
 486,  487,  487,  488,  488,  489,  489,  490, 
 490,  491,  491,  492,  492,  492,  493,  493, 
 494,  494,  494,  495,  495,  496,  496,  496, 
 497,  497,  498,  498,  498,  499,  499,  499, 
 500,  500,  500,  501,  501,  501,  502,  502, 
 502,  503,  503,  503,  503,  504,  504,  504, 
 505,  505,  505,  505,  506,  506,  506,  506, 
 507,  507,  507,  507,  507,  508,  508,  508, 
 508,  508,  509,  509,  509,  509,  509,  509, 
 510,  510,  510,  510,  510,  510,  510,  511, 
 511,  511,  511,  511,  511,  511,  511,  511, 
 511,  511,  512,  512,  512,  512,  512,  512, 
 512,  512,  512,  512,  512,  512,  512,  512, 
 512,  512,  512,  512,  512,  512,  512,  512, 
 512,  512,  512,  512,  512,  512,  511,  511, 
 511,  511,  511,  511,  511,  511,  511,  511, 
 511,  510,  510,  510,  510,  510,  510,  510, 
 509,  509,  509,  509,  509,  509,  508,  508, 
 508,  508,  508,  507,  507,  507,  507,  507, 
 506,  506,  506,  506,  505,  505,  505,  505, 
 504,  504,  504,  503,  503,  503,  503,  502, 
 502,  502,  501,  501,  501,  500,  500,  500, 
 499,  499,  499,  498,  498,  498,  497,  497, 
 496,  496,  496,  495,  495,  494,  494,  494, 
 493,  493,  492,  492,  492,  491,  491,  490, 
 490,  489,  489,  488,  488,  487,  487,  486, 
 486,  485,  485,  484,  484,  483,  483,  482, 
 482,  481,  481,  480,  480,  479,  479,  478, 
 477,  477,  476,  476,  475,  475,  474,  473, 
 473,  472,  472,  471,  470,  470,  469,  468, 
 468,  467,  466,  466,  465,  465,  464,  463, 
 463,  462,  461,  460,  460,  459,  458,  458, 
 457,  456,  456,  455,  454,  453,  453,  452, 
 451,  450,  450,  449,  448,  447,  447,  446, 
 445,  444,  444,  443,  442,  441,  440,  440, 
 439,  438,  437,  436,  435,  435,  434,  433, 
 432,  431,  430,  430,  429,  428,  427,  426, 
 425,  424,  424,  423,  422,  421,  420,  419, 
 418,  417,  416,  415,  414,  414,  413,  412, 
 411,  410,  409,  408,  407,  406,  405,  404, 
 403,  402,  401,  400,  399,  398,  397,  396, 
 395,  394,  393,  392,  391,  390,  389,  388, 
 387,  386,  385,  384,  383,  382,  381,  380, 
 379,  378,  377,  376,  375,  374,  372,  371, 
 370,  369,  368,  367,  366,  365,  364,  363, 
 361,  360,  359,  358,  357,  356,  355,  354, 
 352,  351,  350,  349,  348,  347,  346,  344, 
 343,  342,  341,  340,  339,  337,  336,  335, 
 334,  333,  331,  330,  329,  328,  327,  325, 
 324,  323,  322,  321,  319,  318,  317,  316, 
 314,  313,  312,  311,  309,  308,  307,  306, 
 304,  303,  302,  301,  299,  298,  297,  295, 
 294,  293,  292,  290,  289,  288,  286,  285, 
 284,  282,  281,  280,  279,  277,  276,  275, 
 273,  272,  271,  269,  268,  267,  265,  264, 
 263,  261,  260,  258,  257,  256,  254,  253, 
 252,  250,  249,  248,  246,  245,  243,  242, 
 241,  239,  238,  236,  235,  234,  232,  231, 
 229,  228,  227,  225,  224,  222,  221,  220, 
 218,  217,  215,  214,  212,  211,  210,  208, 
 207,  205,  204,  202,  201,  200,  198,  197, 
 195,  194,  192,  191,  189,  188,  186,  185, 
 184,  182,  181,  179,  178,  176,  175,  173, 
 172,  170,  169,  167,  166,  164,  163,  161, 
 160,  158,  157,  155,  154,  152,  151,  149, 
 148,  146,  145,  143,  142,  140,  139,  137, 
 136,  134,  133,  131,  130,  128,  127,  125, 
 124,  122,  121,  119,  118,  116,  114,  113, 
 111,  110,  108,  107,  105,  104,  102,  101, 
  99,   98,   96,   94,   93,   91,   90,   88, 
  87,   85,   84,   82,   81,   79,   77,   76, 
  74,   73,   71,   70,   68,   67,   65,   63, 
  62,   60,   59,   57,   56,   54,   53,   51, 
  49,   48,   46,   45,   43,   42,   40,   38, 
  37,   35,   34,   32,   31,   29,   27,   26, 
  24,   23,   21,   20,   18,   16,   15,   13, 
  12,   10,    9,    7,    5,    4,    2,    1, 
   0,   -1,   -3,   -4,   -6,   -8,   -9,  -11, 
 -12,  -14,  -15,  -17,  -19,  -20,  -22,  -23, 
 -25,  -26,  -28,  -30,  -31,  -33,  -34,  -36, 
 -37,  -39,  -41,  -42,  -44,  -45,  -47,  -48, 
 -50,  -52,  -53,  -55,  -56,  -58,  -59,  -61, 
 -62,  -64,  -66,  -67,  -69,  -70,  -72,  -73, 
 -75,  -76,  -78,  -80,  -81,  -83,  -84,  -86, 
 -87,  -89,  -90,  -92,  -93,  -95,  -97,  -98, 
-100, -101, -103, -104, -106, -107, -109, -110, 
-112, -113, -115, -117, -118, -120, -121, -123, 
-124, -126, -127, -129, -130, -132, -133, -135, 
-136, -138, -139, -141, -142, -144, -145, -147, 
-148, -150, -151, -153, -154, -156, -157, -159, 
-160, -162, -163, -165, -166, -168, -169, -171, 
-172, -174, -175, -177, -178, -180, -181, -183, 
-184, -185, -187, -188, -190, -191, -193, -194, 
-196, -197, -199, -200, -201, -203, -204, -206, 
-207, -209, -210, -211, -213, -214, -216, -217, 
-219, -220, -221, -223, -224, -226, -227, -228, 
-230, -231, -233, -234, -235, -237, -238, -240, 
-241, -242, -244, -245, -247, -248, -249, -251, 
-252, -253, -255, -256, -257, -259, -260, -262, 
-263, -264, -266, -267, -268, -270, -271, -272, 
-274, -275, -276, -278, -279, -280, -281, -283, 
-284, -285, -287, -288, -289, -291, -292, -293, 
-294, -296, -297, -298, -300, -301, -302, -303, 
-305, -306, -307, -308, -310, -311, -312, -313, 
-315, -316, -317, -318, -320, -321, -322, -323, 
-324, -326, -327, -328, -329, -330, -332, -333, 
-334, -335, -336, -338, -339, -340, -341, -342, 
-343, -345, -346, -347, -348, -349, -350, -351, 
-353, -354, -355, -356, -357, -358, -359, -360, 
-362, -363, -364, -365, -366, -367, -368, -369, 
-370, -371, -373, -374, -375, -376, -377, -378, 
-379, -380, -381, -382, -383, -384, -385, -386, 
-387, -388, -389, -390, -391, -392, -393, -394, 
-395, -396, -397, -398, -399, -400, -401, -402, 
-403, -404, -405, -406, -407, -408, -409, -410, 
-411, -412, -413, -413, -414, -415, -416, -417, 
-418, -419, -420, -421, -422, -423, -423, -424, 
-425, -426, -427, -428, -429, -429, -430, -431, 
-432, -433, -434, -434, -435, -436, -437, -438, 
-439, -439, -440, -441, -442, -443, -443, -444, 
-445, -446, -446, -447, -448, -449, -449, -450, 
-451, -452, -452, -453, -454, -455, -455, -456, 
-457, -457, -458, -459, -459, -460, -461, -462, 
-462, -463, -464, -464, -465, -465, -466, -467, 
-467, -468, -469, -469, -470, -471, -471, -472, 
-472, -473, -474, -474, -475, -475, -476, -476, 
-477, -478, -478, -479, -479, -480, -480, -481, 
-481, -482, -482, -483, -483, -484, -484, -485, 
-485, -486, -486, -487, -487, -488, -488, -489, 
-489, -490, -490, -491, -491, -491, -492, -492, 
-493, -493, -493, -494, -494, -495, -495, -495, 
-496, -496, -497, -497, -497, -498, -498, -498, 
-499, -499, -499, -500, -500, -500, -501, -501, 
-501, -502, -502, -502, -502, -503, -503, -503, 
-504, -504, -504, -504, -505, -505, -505, -505, 
-506, -506, -506, -506, -506, -507, -507, -507, 
-507, -507, -508, -508, -508, -508, -508, -508, 
-509, -509, -509, -509, -509, -509, -509, -510, 
-510, -510, -510, -510, -510, -510, -510, -510, 
-510, -510, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -510, -510, 
-510, -510, -510, -510, -510, -510, -510, -510, 
-510, -509, -509, -509, -509, -509, -509, -509, 
-508, -508, -508, -508, -508, -508, -507, -507, 
-507, -507, -507, -506, -506, -506, -506, -506, 
-505, -505, -505, -505, -504, -504, -504, -504, 
-503, -503, -503, -502, -502, -502, -502, -501, 
-501, -501, -500, -500, -500, -499, -499, -499, 
-498, -498, -498, -497, -497, -497, -496, -496, 
-495, -495, -495, -494, -494, -493, -493, -493, 
-492, -492, -491, -491, -491, -490, -490, -489, 
-489, -488, -488, -487, -487, -486, -486, -485, 
-485, -484, -484, -483, -483, -482, -482, -481, 
-481, -480, -480, -479, -479, -478, -478, -477, 
-476, -476, -475, -475, -474, -474, -473, -472, 
-472, -471, -471, -470, -469, -469, -468, -467, 
-467, -466, -465, -465, -464, -464, -463, -462, 
-462, -461, -460, -459, -459, -458, -457, -457, 
-456, -455, -455, -454, -453, -452, -452, -451, 
-450, -449, -449, -448, -447, -446, -446, -445, 
-444, -443, -443, -442, -441, -440, -439, -439, 
-438, -437, -436, -435, -434, -434, -433, -432, 
-431, -430, -429, -429, -428, -427, -426, -425, 
-424, -423, -423, -422, -421, -420, -419, -418, 
-417, -416, -415, -414, -413, -413, -412, -411, 
-410, -409, -408, -407, -406, -405, -404, -403, 
-402, -401, -400, -399, -398, -397, -396, -395, 
-394, -393, -392, -391, -390, -389, -388, -387, 
-386, -385, -384, -383, -382, -381, -380, -379, 
-378, -377, -376, -375, -374, -373, -371, -370, 
-369, -368, -367, -366, -365, -364, -363, -362, 
-360, -359, -358, -357, -356, -355, -354, -353, 
-351, -350, -349, -348, -347, -346, -345, -343, 
-342, -341, -340, -339, -338, -336, -335, -334, 
-333, -332, -330, -329, -328, -327, -326, -324, 
-323, -322, -321, -320, -318, -317, -316, -315, 
-313, -312, -311, -310, -308, -307, -306, -305, 
-303, -302, -301, -300, -298, -297, -296, -294, 
-293, -292, -291, -289, -288, -287, -285, -284, 
-283, -281, -280, -279, -278, -276, -275, -274, 
-272, -271, -270, -268, -267, -266, -264, -263, 
-262, -260, -259, -257, -256, -255, -253, -252, 
-251, -249, -248, -247, -245, -244, -242, -241, 
-240, -238, -237, -235, -234, -233, -231, -230, 
-228, -227, -226, -224, -223, -221, -220, -219, 
-217, -216, -214, -213, -211, -210, -209, -207, 
-206, -204, -203, -201, -200, -199, -197, -196, 
-194, -193, -191, -190, -188, -187, -185, -184, 
-183, -181, -180, -178, -177, -175, -174, -172, 
-171, -169, -168, -166, -165, -163, -162, -160, 
-159, -157, -156, -154, -153, -151, -150, -148, 
-147, -145, -144, -142, -141, -139, -138, -136, 
-135, -133, -132, -130, -129, -127, -126, -124, 
-123, -121, -120, -118, -117, -115, -113, -112, 
-110, -109, -107, -106, -104, -103, -101, -100, 
 -98,  -97,  -95,  -93,  -92,  -90,  -89,  -87, 
 -86,  -84,  -83,  -81,  -80,  -78,  -76,  -75, 
 -73,  -72,  -70,  -69,  -67,  -66,  -64,  -62, 
 -61,  -59,  -58,  -56,  -55,  -53,  -52,  -50, 
 -48,  -47,  -45,  -44,  -42,  -41,  -39,  -37, 
 -36,  -34,  -33,  -31,  -30,  -28,  -26,  -25, 
 -23,  -22,  -20,  -19,  -17,  -15,  -14,  -12, 
 -11,   -9,   -8,   -6,   -4,   -3,   -1,    0
};
short cosine_table[2048] = {
 512,  512,  512,  512,  512,  512,  512,  512, 
 512,  512,  512,  512,  512,  512,  511,  511, 
 511,  511,  511,  511,  511,  511,  511,  511, 
 511,  510,  510,  510,  510,  510,  510,  510, 
 509,  509,  509,  509,  509,  509,  508,  508, 
 508,  508,  508,  507,  507,  507,  507,  507, 
 506,  506,  506,  506,  505,  505,  505,  505, 
 504,  504,  504,  503,  503,  503,  503,  502, 
 502,  502,  501,  501,  501,  500,  500,  500, 
 499,  499,  499,  498,  498,  498,  497,  497, 
 496,  496,  496,  495,  495,  494,  494,  494, 
 493,  493,  492,  492,  492,  491,  491,  490, 
 490,  489,  489,  488,  488,  487,  487,  486, 
 486,  485,  485,  484,  484,  483,  483,  482, 
 482,  481,  481,  480,  480,  479,  479,  478, 
 477,  477,  476,  476,  475,  475,  474,  473, 
 473,  472,  472,  471,  470,  470,  469,  468, 
 468,  467,  466,  466,  465,  465,  464,  463, 
 463,  462,  461,  460,  460,  459,  458,  458, 
 457,  456,  456,  455,  454,  453,  453,  452, 
 451,  450,  450,  449,  448,  447,  447,  446, 
 445,  444,  444,  443,  442,  441,  440,  440, 
 439,  438,  437,  436,  435,  435,  434,  433, 
 432,  431,  430,  430,  429,  428,  427,  426, 
 425,  424,  424,  423,  422,  421,  420,  419, 
 418,  417,  416,  415,  414,  414,  413,  412, 
 411,  410,  409,  408,  407,  406,  405,  404, 
 403,  402,  401,  400,  399,  398,  397,  396, 
 395,  394,  393,  392,  391,  390,  389,  388, 
 387,  386,  385,  384,  383,  382,  381,  380, 
 379,  378,  377,  376,  375,  374,  372,  371, 
 370,  369,  368,  367,  366,  365,  364,  363, 
 361,  360,  359,  358,  357,  356,  355,  354, 
 352,  351,  350,  349,  348,  347,  346,  344, 
 343,  342,  341,  340,  339,  337,  336,  335, 
 334,  333,  331,  330,  329,  328,  327,  325, 
 324,  323,  322,  321,  319,  318,  317,  316, 
 314,  313,  312,  311,  309,  308,  307,  306, 
 304,  303,  302,  301,  299,  298,  297,  295, 
 294,  293,  292,  290,  289,  288,  286,  285, 
 284,  282,  281,  280,  279,  277,  276,  275, 
 273,  272,  271,  269,  268,  267,  265,  264, 
 263,  261,  260,  258,  257,  256,  254,  253, 
 252,  250,  249,  248,  246,  245,  243,  242, 
 241,  239,  238,  236,  235,  234,  232,  231, 
 229,  228,  227,  225,  224,  222,  221,  220, 
 218,  217,  215,  214,  212,  211,  210,  208, 
 207,  205,  204,  202,  201,  200,  198,  197, 
 195,  194,  192,  191,  189,  188,  186,  185, 
 184,  182,  181,  179,  178,  176,  175,  173, 
 172,  170,  169,  167,  166,  164,  163,  161, 
 160,  158,  157,  155,  154,  152,  151,  149, 
 148,  146,  145,  143,  142,  140,  139,  137, 
 136,  134,  133,  131,  130,  128,  127,  125, 
 124,  122,  121,  119,  118,  116,  114,  113, 
 111,  110,  108,  107,  105,  104,  102,  101, 
  99,   98,   96,   94,   93,   91,   90,   88, 
  87,   85,   84,   82,   81,   79,   77,   76, 
  74,   73,   71,   70,   68,   67,   65,   63, 
  62,   60,   59,   57,   56,   54,   53,   51, 
  49,   48,   46,   45,   43,   42,   40,   38, 
  37,   35,   34,   32,   31,   29,   27,   26, 
  24,   23,   21,   20,   18,   16,   15,   13, 
  12,   10,    9,    7,    5,    4,    2,    1, 
   0,   -1,   -3,   -4,   -6,   -8,   -9,  -11, 
 -12,  -14,  -15,  -17,  -19,  -20,  -22,  -23, 
 -25,  -26,  -28,  -30,  -31,  -33,  -34,  -36, 
 -37,  -39,  -41,  -42,  -44,  -45,  -47,  -48, 
 -50,  -52,  -53,  -55,  -56,  -58,  -59,  -61, 
 -62,  -64,  -66,  -67,  -69,  -70,  -72,  -73, 
 -75,  -76,  -78,  -80,  -81,  -83,  -84,  -86, 
 -87,  -89,  -90,  -92,  -93,  -95,  -97,  -98, 
-100, -101, -103, -104, -106, -107, -109, -110, 
-112, -113, -115, -117, -118, -120, -121, -123, 
-124, -126, -127, -129, -130, -132, -133, -135, 
-136, -138, -139, -141, -142, -144, -145, -147, 
-148, -150, -151, -153, -154, -156, -157, -159, 
-160, -162, -163, -165, -166, -168, -169, -171, 
-172, -174, -175, -177, -178, -180, -181, -183, 
-184, -185, -187, -188, -190, -191, -193, -194, 
-196, -197, -199, -200, -201, -203, -204, -206, 
-207, -209, -210, -211, -213, -214, -216, -217, 
-219, -220, -221, -223, -224, -226, -227, -228, 
-230, -231, -233, -234, -235, -237, -238, -240, 
-241, -242, -244, -245, -247, -248, -249, -251, 
-252, -253, -255, -256, -257, -259, -260, -262, 
-263, -264, -266, -267, -268, -270, -271, -272, 
-274, -275, -276, -278, -279, -280, -281, -283, 
-284, -285, -287, -288, -289, -291, -292, -293, 
-294, -296, -297, -298, -300, -301, -302, -303, 
-305, -306, -307, -308, -310, -311, -312, -313, 
-315, -316, -317, -318, -320, -321, -322, -323, 
-324, -326, -327, -328, -329, -330, -332, -333, 
-334, -335, -336, -338, -339, -340, -341, -342, 
-343, -345, -346, -347, -348, -349, -350, -351, 
-353, -354, -355, -356, -357, -358, -359, -360, 
-362, -363, -364, -365, -366, -367, -368, -369, 
-370, -371, -373, -374, -375, -376, -377, -378, 
-379, -380, -381, -382, -383, -384, -385, -386, 
-387, -388, -389, -390, -391, -392, -393, -394, 
-395, -396, -397, -398, -399, -400, -401, -402, 
-403, -404, -405, -406, -407, -408, -409, -410, 
-411, -412, -413, -413, -414, -415, -416, -417, 
-418, -419, -420, -421, -422, -423, -423, -424, 
-425, -426, -427, -428, -429, -429, -430, -431, 
-432, -433, -434, -434, -435, -436, -437, -438, 
-439, -439, -440, -441, -442, -443, -443, -444, 
-445, -446, -446, -447, -448, -449, -449, -450, 
-451, -452, -452, -453, -454, -455, -455, -456, 
-457, -457, -458, -459, -459, -460, -461, -462, 
-462, -463, -464, -464, -465, -465, -466, -467, 
-467, -468, -469, -469, -470, -471, -471, -472, 
-472, -473, -474, -474, -475, -475, -476, -476, 
-477, -478, -478, -479, -479, -480, -480, -481, 
-481, -482, -482, -483, -483, -484, -484, -485, 
-485, -486, -486, -487, -487, -488, -488, -489, 
-489, -490, -490, -491, -491, -491, -492, -492, 
-493, -493, -493, -494, -494, -495, -495, -495, 
-496, -496, -497, -497, -497, -498, -498, -498, 
-499, -499, -499, -500, -500, -500, -501, -501, 
-501, -502, -502, -502, -502, -503, -503, -503, 
-504, -504, -504, -504, -505, -505, -505, -505, 
-506, -506, -506, -506, -506, -507, -507, -507, 
-507, -507, -508, -508, -508, -508, -508, -508, 
-509, -509, -509, -509, -509, -509, -509, -510, 
-510, -510, -510, -510, -510, -510, -510, -510, 
-510, -510, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -511, -511, 
-511, -511, -511, -511, -511, -511, -510, -510, 
-510, -510, -510, -510, -510, -510, -510, -510, 
-510, -509, -509, -509, -509, -509, -509, -509, 
-508, -508, -508, -508, -508, -508, -507, -507, 
-507, -507, -507, -506, -506, -506, -506, -506, 
-505, -505, -505, -505, -504, -504, -504, -504, 
-503, -503, -503, -502, -502, -502, -502, -501, 
-501, -501, -500, -500, -500, -499, -499, -499, 
-498, -498, -498, -497, -497, -497, -496, -496, 
-495, -495, -495, -494, -494, -493, -493, -493, 
-492, -492, -491, -491, -491, -490, -490, -489, 
-489, -488, -488, -487, -487, -486, -486, -485, 
-485, -484, -484, -483, -483, -482, -482, -481, 
-481, -480, -480, -479, -479, -478, -478, -477, 
-476, -476, -475, -475, -474, -474, -473, -472, 
-472, -471, -471, -470, -469, -469, -468, -467, 
-467, -466, -465, -465, -464, -464, -463, -462, 
-462, -461, -460, -459, -459, -458, -457, -457, 
-456, -455, -455, -454, -453, -452, -452, -451, 
-450, -449, -449, -448, -447, -446, -446, -445, 
-444, -443, -443, -442, -441, -440, -439, -439, 
-438, -437, -436, -435, -434, -434, -433, -432, 
-431, -430, -429, -429, -428, -427, -426, -425, 
-424, -423, -423, -422, -421, -420, -419, -418, 
-417, -416, -415, -414, -413, -413, -412, -411, 
-410, -409, -408, -407, -406, -405, -404, -403, 
-402, -401, -400, -399, -398, -397, -396, -395, 
-394, -393, -392, -391, -390, -389, -388, -387, 
-386, -385, -384, -383, -382, -381, -380, -379, 
-378, -377, -376, -375, -374, -373, -371, -370, 
-369, -368, -367, -366, -365, -364, -363, -362, 
-360, -359, -358, -357, -356, -355, -354, -353, 
-351, -350, -349, -348, -347, -346, -345, -343, 
-342, -341, -340, -339, -338, -336, -335, -334, 
-333, -332, -330, -329, -328, -327, -326, -324, 
-323, -322, -321, -320, -318, -317, -316, -315, 
-313, -312, -311, -310, -308, -307, -306, -305, 
-303, -302, -301, -300, -298, -297, -296, -294, 
-293, -292, -291, -289, -288, -287, -285, -284, 
-283, -281, -280, -279, -278, -276, -275, -274, 
-272, -271, -270, -268, -267, -266, -264, -263, 
-262, -260, -259, -257, -256, -255, -253, -252, 
-251, -249, -248, -247, -245, -244, -242, -241, 
-240, -238, -237, -235, -234, -233, -231, -230, 
-228, -227, -226, -224, -223, -221, -220, -219, 
-217, -216, -214, -213, -211, -210, -209, -207, 
-206, -204, -203, -201, -200, -199, -197, -196, 
-194, -193, -191, -190, -188, -187, -185, -184, 
-183, -181, -180, -178, -177, -175, -174, -172, 
-171, -169, -168, -166, -165, -163, -162, -160, 
-159, -157, -156, -154, -153, -151, -150, -148, 
-147, -145, -144, -142, -141, -139, -138, -136, 
-135, -133, -132, -130, -129, -127, -126, -124, 
-123, -121, -120, -118, -117, -115, -113, -112, 
-110, -109, -107, -106, -104, -103, -101, -100, 
 -98,  -97,  -95,  -93,  -92,  -90,  -89,  -87, 
 -86,  -84,  -83,  -81,  -80,  -78,  -76,  -75, 
 -73,  -72,  -70,  -69,  -67,  -66,  -64,  -62, 
 -61,  -59,  -58,  -56,  -55,  -53,  -52,  -50, 
 -48,  -47,  -45,  -44,  -42,  -41,  -39,  -37, 
 -36,  -34,  -33,  -31,  -30,  -28,  -26,  -25, 
 -23,  -22,  -20,  -19,  -17,  -15,  -14,  -12, 
 -11,   -9,   -8,   -6,   -4,   -3,   -1,    0, 
   1,    2,    4,    5,    7,    9,   10,   12, 
  13,   15,   16,   18,   20,   21,   23,   24, 
  26,   27,   29,   31,   32,   34,   35,   37, 
  38,   40,   42,   43,   45,   46,   48,   49, 
  51,   53,   54,   56,   57,   59,   60,   62, 
  63,   65,   67,   68,   70,   71,   73,   74, 
  76,   77,   79,   81,   82,   84,   85,   87, 
  88,   90,   91,   93,   94,   96,   98,   99, 
 101,  102,  104,  105,  107,  108,  110,  111, 
 113,  114,  116,  118,  119,  121,  122,  124, 
 125,  127,  128,  130,  131,  133,  134,  136, 
 137,  139,  140,  142,  143,  145,  146,  148, 
 149,  151,  152,  154,  155,  157,  158,  160, 
 161,  163,  164,  166,  167,  169,  170,  172, 
 173,  175,  176,  178,  179,  181,  182,  184, 
 185,  186,  188,  189,  191,  192,  194,  195, 
 197,  198,  200,  201,  202,  204,  205,  207, 
 208,  210,  211,  212,  214,  215,  217,  218, 
 220,  221,  222,  224,  225,  227,  228,  229, 
 231,  232,  234,  235,  236,  238,  239,  241, 
 242,  243,  245,  246,  248,  249,  250,  252, 
 253,  254,  256,  257,  258,  260,  261,  263, 
 264,  265,  267,  268,  269,  271,  272,  273, 
 275,  276,  277,  279,  280,  281,  282,  284, 
 285,  286,  288,  289,  290,  292,  293,  294, 
 295,  297,  298,  299,  301,  302,  303,  304, 
 306,  307,  308,  309,  311,  312,  313,  314, 
 316,  317,  318,  319,  321,  322,  323,  324, 
 325,  327,  328,  329,  330,  331,  333,  334, 
 335,  336,  337,  339,  340,  341,  342,  343, 
 344,  346,  347,  348,  349,  350,  351,  352, 
 354,  355,  356,  357,  358,  359,  360,  361, 
 363,  364,  365,  366,  367,  368,  369,  370, 
 371,  372,  374,  375,  376,  377,  378,  379, 
 380,  381,  382,  383,  384,  385,  386,  387, 
 388,  389,  390,  391,  392,  393,  394,  395, 
 396,  397,  398,  399,  400,  401,  402,  403, 
 404,  405,  406,  407,  408,  409,  410,  411, 
 412,  413,  414,  414,  415,  416,  417,  418, 
 419,  420,  421,  422,  423,  424,  424,  425, 
 426,  427,  428,  429,  430,  430,  431,  432, 
 433,  434,  435,  435,  436,  437,  438,  439, 
 440,  440,  441,  442,  443,  444,  444,  445, 
 446,  447,  447,  448,  449,  450,  450,  451, 
 452,  453,  453,  454,  455,  456,  456,  457, 
 458,  458,  459,  460,  460,  461,  462,  463, 
 463,  464,  465,  465,  466,  466,  467,  468, 
 468,  469,  470,  470,  471,  472,  472,  473, 
 473,  474,  475,  475,  476,  476,  477,  477, 
 478,  479,  479,  480,  480,  481,  481,  482, 
 482,  483,  483,  484,  484,  485,  485,  486, 
 486,  487,  487,  488,  488,  489,  489,  490, 
 490,  491,  491,  492,  492,  492,  493,  493, 
 494,  494,  494,  495,  495,  496,  496,  496, 
 497,  497,  498,  498,  498,  499,  499,  499, 
 500,  500,  500,  501,  501,  501,  502,  502, 
 502,  503,  503,  503,  503,  504,  504,  504, 
 505,  505,  505,  505,  506,  506,  506,  506, 
 507,  507,  507,  507,  507,  508,  508,  508, 
 508,  508,  509,  509,  509,  509,  509,  509, 
 510,  510,  510,  510,  510,  510,  510,  511, 
 511,  511,  511,  511,  511,  511,  511,  511, 
 511,  511,  512,  512,  512,  512,  512,  512, 
 512,  512,  512,  512,  512,  512,  512,  512
};
