library verilog;
use verilog.vl_types.all;
entity CursorPlane is
    generic(
        AW              : integer := 29;
        DW              : integer := 31;
        IW              : integer := 1;
        BW              : integer := 3;
        XW              : integer := 10;
        YW              : integer := 10;
        CW              : integer := 9;
        GW              : integer := 10;
        VW              : integer := 10;
        CPlaneMaxBL     : integer := 8;
        GPlaneMaxBL     : integer := 8;
        VPlaneMaxBL     : integer := 8;
        CBLQCD          : integer := 1;
        CBLQD           : integer := 3;
        CBLQW           : integer := 3;
        GBLQCD          : integer := 2;
        GBLQD           : integer := 7;
        GBLQW           : integer := 3;
        VBLQCD          : integer := 1;
        VBLQD           : integer := 3;
        VBLQW           : integer := 3;
        DMCON           : integer := 0;
        DMSTS           : integer := 4;
        CCON            : integer := 16;
        CBLND           : integer := 20;
        CBMOD           : integer := 24;
        CBASE           : integer := 28;
        CADDR           : integer := 32;
        CPALM           : integer := 36;
        CADDR2          : integer := 40;
        CBLINK          : integer := 44;
        BGCOL           : integer := 48;
        GCON            : integer := 64;
        GBLND           : integer := 68;
        GBMOD           : integer := 72;
        GBASE           : integer := 76;
        GADDR           : integer := 80;
        GPALM           : integer := 84;
        GGAMMA00        : integer := 256;
        GGAMMA01        : integer := 260;
        GGAMMA02        : integer := 264;
        GGAMMA03        : integer := 268;
        GGAMMA04        : integer := 272;
        GGAMMA05        : integer := 276;
        GGAMMA06        : integer := 280;
        GGAMMA07        : integer := 284;
        GGAMMA08        : integer := 288;
        GGAMMA09        : integer := 292;
        GGAMMA0A        : integer := 296;
        GGAMMA0B        : integer := 300;
        GGAMMA0C        : integer := 304;
        GGAMMA0D        : integer := 308;
        GGAMMA0E        : integer := 312;
        GGAMMA0F        : integer := 316;
        GGAMMA10        : integer := 320;
        VCON            : integer := 96;
        VBLND           : integer := 100;
        VBMOD           : integer := 104;
        VBASE           : integer := 108;
        VADDR           : integer := 112;
        VADDR2          : integer := 116;
        SCON            : integer := 128;
        SSIZE           : integer := 132;
        SRATIO          : integer := 136;
        VGAMMA00        : integer := 512;
        VGAMMA01        : integer := 516;
        VGAMMA02        : integer := 520;
        VGAMMA03        : integer := 524;
        VGAMMA04        : integer := 528;
        VGAMMA05        : integer := 532;
        VGAMMA06        : integer := 536;
        VGAMMA07        : integer := 540;
        VGAMMA08        : integer := 544;
        VGAMMA09        : integer := 548;
        VGAMMA0A        : integer := 552;
        VGAMMA0B        : integer := 556;
        VGAMMA0C        : integer := 560;
        VGAMMA0D        : integer := 564;
        VGAMMA0E        : integer := 568;
        VGAMMA0F        : integer := 572;
        VGAMMA10        : integer := 576;
        LCDCON          : integer := 224;
        VIDCON          : integer := 228;
        HSYNC0          : integer := 240;
        HSYNC1          : integer := 244;
        VSYNC0          : integer := 248;
        VSYNC1          : integer := 252;
        C_IDLE          : integer := 1;
        C_DREQ          : integer := 2;
        C_WD00          : integer := 4;
        C_WD01          : integer := 8;
        C_WD10          : integer := 16;
        C_WD11          : integer := 32
    );
    port(
        Clk             : in     vl_logic;
        nRST            : in     vl_logic;
        FIFOClear       : in     vl_logic;
        CPlaneEn        : in     vl_logic;
        FrameStart      : in     vl_logic;
        CDMADataRequest : out    vl_logic;
        CDMADataValid   : in     vl_logic;
        CDMADataIn      : in     vl_logic_vector;
        PalMemWrite     : in     vl_logic;
        PalMemWrAddr    : in     vl_logic_vector(7 downto 0);
        PalMemWrData    : in     vl_logic_vector(23 downto 0);
        PalMemRead      : in     vl_logic;
        PalMemRdData    : out    vl_logic_vector(23 downto 0);
        CPlanePixFormat : in     vl_logic_vector(1 downto 0);
        CPlaneAlphaMode : in     vl_logic_vector(1 downto 0);
        CPlaneAlphaValue: in     vl_logic_vector(7 downto 0);
        CPlaneXSize     : in     vl_logic_vector;
        CPlaneYSize     : in     vl_logic_vector;
        CPlaneXSizeRef  : out    vl_logic_vector;
        CPlaneDataRequest: in     vl_logic;
        CPlaneDataValid : out    vl_logic;
        CPlaneDataIn    : out    vl_logic_vector(31 downto 0);
        CurFIFOOverRun  : out    vl_logic;
        CurFIFOUnderRun : out    vl_logic
    );
end CursorPlane;
