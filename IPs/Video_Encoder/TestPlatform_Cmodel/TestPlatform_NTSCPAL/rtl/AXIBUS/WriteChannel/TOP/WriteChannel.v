// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannel.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code

`timescale 1 ns/ 10ps
module  WriteChannel(


    //_______________________________________________________________
    //For Master 0
    //Write address channel
//Disable_id_port
    AWADDRm02si0  ,
    AWLENm02si0   ,
    AWSIZEm02si0  ,
    AWBURSTm02si0 ,
    AWLOCKm02si0  ,
//Disable_cache_port
//Disable_protect_port

    AWVALIDm02si0 ,
    AWREADYsi02m0 ,

    //Write data channel
//Disable_id_port
    WDATAm02si0   ,
    WSTRBm02si0   ,
    WLASTm02si0   ,
    WVALIDm02si0  ,
    WREADYsi02m0  ,

    //Write response channel
//Disable_id_port
    BRESPsi02m0   ,
    BVALIDsi02m0  ,
    BREADYm02si0  ,

 
 

    
    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    AWIDmi02s0    ,
    AWADDRmi02s0  ,
    AWLENmi02s0   ,
    AWSIZEmi02s0  ,
    AWBURSTmi02s0 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi02s0 ,
    AWREADYs02mi0 ,

    //Write data channel
    WIDmi02s0     ,
    WDATAmi02s0   ,
    WSTRBmi02s0   ,
    WLASTmi02s0   ,
    WVALIDmi02s0  ,
    WREADYs02mi0  ,

    //Write response channel
    BIDs02mi0     ,
    BRESPs02mi0   ,
    BVALIDs02mi0  ,
    BREADYmi02s0  ,
    
    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    AWIDmi12s1    ,
    AWADDRmi12s1  ,
    AWLENmi12s1   ,
    AWSIZEmi12s1  ,
    AWBURSTmi12s1 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi12s1 ,
    AWREADYs12mi1 ,

    //Write data channel
    WIDmi12s1     ,
    WDATAmi12s1   ,
//Disable_WSTRB_port
    WLASTmi12s1   ,
    WVALIDmi12s1  ,
    WREADYs12mi1  ,

    //Write response channel
    BIDs12mi1     ,
    BRESPs12mi1   ,
    BVALIDs12mi1  ,
    BREADYmi12s1  ,
    
    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    AWIDmi22s2    ,
    AWADDRmi22s2  ,
    AWLENmi22s2   ,
    AWSIZEmi22s2  ,
    AWBURSTmi22s2 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi22s2 ,
    AWREADYs22mi2 ,

    //Write data channel
    WIDmi22s2     ,
    WDATAmi22s2   ,
//Disable_WSTRB_port
    WLASTmi22s2   ,
    WVALIDmi22s2  ,
    WREADYs22mi2  ,

    //Write response channel
    BIDs22mi2     ,
    BRESPs22mi2   ,
    BVALIDs22mi2  ,
    BREADYmi22s2  ,
    
    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    AWIDmi32s3    ,
    AWADDRmi32s3  ,
    AWLENmi32s3   ,
    AWSIZEmi32s3  ,
    AWBURSTmi32s3 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi32s3 ,
    AWREADYs32mi3 ,

    //Write data channel
    WIDmi32s3     ,
    WDATAmi32s3   ,
    WSTRBmi32s3   ,
    WLASTmi32s3   ,
    WVALIDmi32s3  ,
    WREADYs32mi3  ,

    //Write response channel
    BIDs32mi3     ,
    BRESPs32mi3   ,
    BVALIDs32mi3  ,
    BREADYmi32s3  ,
    
    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    AWIDmi42s4    ,
    AWADDRmi42s4  ,
    AWLENmi42s4   ,
    AWSIZEmi42s4  ,
    AWBURSTmi42s4 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi42s4 ,
    AWREADYs42mi4 ,

    //Write data channel
    WIDmi42s4     ,
    WDATAmi42s4   ,
    WSTRBmi42s4   ,
    WLASTmi42s4   ,
    WVALIDmi42s4  ,
    WREADYs42mi4  ,

    //Write response channel
    BIDs42mi4     ,
    BRESPs42mi4   ,
    BVALIDs42mi4  ,
    BREADYmi42s4  ,
    
    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    AWIDmi52s5    ,
    AWADDRmi52s5  ,
    AWLENmi52s5   ,
    AWSIZEmi52s5  ,
    AWBURSTmi52s5 ,
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    AWVALIDmi52s5 ,
    AWREADYs52mi5 ,

    //Write data channel
    WIDmi52s5     ,
    WDATAmi52s5   ,
    WSTRBmi52s5   ,
    WLASTmi52s5   ,
    WVALIDmi52s5  ,
    WREADYs52mi5  ,

    //Write response channel
    BIDs52mi5     ,
    BRESPs52mi5   ,
    BVALIDs52mi5  ,
    BREADYmi52s5  ,


    //Lock Access
    //_______________________________________________________________

    Lock2wrmi0,
    Lock2wrmi1,
    Lock2wrmi2,
    Lock2wrmi3,
    Lock2wrmi4,
    Lock2wrmi5,

    Lock2rdmi0,
    Lock2rdmi1,
    Lock2rdmi2,
    Lock2rdmi3,
    Lock2rdmi4,
    Lock2rdmi5,

    UnLock2wrmi0,
    UnLock2wrmi1,
    UnLock2wrmi2,
    UnLock2wrmi3,
    UnLock2wrmi4,
    UnLock2wrmi5,

    UnLock2rdmi0,
    UnLock2rdmi1,
    UnLock2rdmi2,
    UnLock2rdmi3,
    UnLock2rdmi4,
    UnLock2rdmi5,

    ARVALIDmi02s0,
    ARVALIDmi12s1,
    ARVALIDmi22s2,
    ARVALIDmi32s3,
    ARVALIDmi42s4,
    ARVALIDmi52s5,

    LockPort2wrmi0,
    LockPort2wrmi1,
    LockPort2wrmi2,
    LockPort2wrmi3,
    LockPort2wrmi4,
    LockPort2wrmi5,

    ReadIntEmptyWrmi02Rdmi0,
    ReadIntEmptyWrmi12Rdmi1,
    ReadIntEmptyWrmi22Rdmi2,
    ReadIntEmptyWrmi32Rdmi3,
    ReadIntEmptyWrmi42Rdmi4,
    ReadIntEmptyWrmi52Rdmi5,

    DataCntEmptyRdmi02Wrmi0,
    DataCntEmptyRdmi12Wrmi1,
    DataCntEmptyRdmi22Wrmi2,
    DataCntEmptyRdmi32Wrmi3,
    DataCntEmptyRdmi42Wrmi4,
    DataCntEmptyRdmi52Wrmi5,

    CtlDataWrite2Lock0,
    CtlDataWrite2Lock1,
    CtlDataWrite2Lock2,
    CtlDataWrite2Lock3,
    CtlDataWrite2Lock4,
    CtlDataWrite2Lock5,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 2;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 2;
parameter SELMASTER_WID= 1;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter MASTERID0_WID = 1 ;
parameter MASTERID1_WID = 1 ;
parameter MAXMASTERID_WID = 1 ;
parameter BLANKMASTERID0_WID = 0 ;
parameter BLANKMASTERID1_WID = 0 ;
parameter SLAVEID0_WID = 2 ;
parameter SLAVEID1_WID = 2 ;
parameter SLAVEID2_WID = 2 ;
parameter SLAVEID3_WID = 2 ;
parameter SLAVEID4_WID = 2 ;
parameter SLAVEID5_WID = 2 ;
parameter SELMASTER0_WID = 1 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 1 ;
parameter SELMASTER4_WID = 1 ;
parameter SELMASTER5_WID = 1 ;
parameter SLAVE_MASTERID0_WID = 1 ;
parameter SLAVE_MASTERID1_WID = 1 ;
parameter SLAVE_MASTERID2_WID = 1 ;
parameter SLAVE_MASTERID3_WID = 1 ;
parameter SLAVE_MASTERID4_WID = 1 ;
parameter SLAVE_MASTERID5_WID = 1 ;
    


  parameter STRB_WIDTH = BUS_WID/8; // WSTRB width
  parameter STRB_MAX   = STRB_WIDTH; // WSTRB max index

    input   ACLK;
    input   ARESETn;  

    //Lock Access
    //_______________________________________________________________


    //Slave 0
    //_____________________________________
    input   Lock2wrmi0;
    input   UnLock2wrmi0;
    output  Lock2rdmi0;
    output  UnLock2rdmi0;
    input   ARVALIDmi02s0;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER0_WID-1:0]LockPort2wrmi0;
    input   [SELMASTER0_WID:0]LockPort2wrmi0;

    output  ReadIntEmptyWrmi02Rdmi0;
    input   DataCntEmptyRdmi02Wrmi0;
    output  [SELMASTER0_WID-1:0]CtlDataWrite2Lock0;

    //Slave 1
    //_____________________________________
    input   Lock2wrmi1;
    input   UnLock2wrmi1;
    output  Lock2rdmi1;
    output  UnLock2rdmi1;
    input   ARVALIDmi12s1;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER1_WID-1:0]LockPort2wrmi1;
    input   [SELMASTER1_WID:0]LockPort2wrmi1;

    output  ReadIntEmptyWrmi12Rdmi1;
    input   DataCntEmptyRdmi12Wrmi1;
    output  [SELMASTER1_WID-1:0]CtlDataWrite2Lock1;

    //Slave 2
    //_____________________________________
    input   Lock2wrmi2;
    input   UnLock2wrmi2;
    output  Lock2rdmi2;
    output  UnLock2rdmi2;
    input   ARVALIDmi22s2;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER2_WID-1:0]LockPort2wrmi2;
    input   [SELMASTER2_WID:0]LockPort2wrmi2;

    output  ReadIntEmptyWrmi22Rdmi2;
    input   DataCntEmptyRdmi22Wrmi2;
    output  [SELMASTER2_WID-1:0]CtlDataWrite2Lock2;

    //Slave 3
    //_____________________________________
    input   Lock2wrmi3;
    input   UnLock2wrmi3;
    output  Lock2rdmi3;
    output  UnLock2rdmi3;
    input   ARVALIDmi32s3;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER3_WID-1:0]LockPort2wrmi3;
    input   [SELMASTER3_WID:0]LockPort2wrmi3;

    output  ReadIntEmptyWrmi32Rdmi3;
    input   DataCntEmptyRdmi32Wrmi3;
    output  [SELMASTER3_WID-1:0]CtlDataWrite2Lock3;

    //Slave 4
    //_____________________________________
    input   Lock2wrmi4;
    input   UnLock2wrmi4;
    output  Lock2rdmi4;
    output  UnLock2rdmi4;
    input   ARVALIDmi42s4;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER4_WID-1:0]LockPort2wrmi4;
    input   [SELMASTER4_WID:0]LockPort2wrmi4;

    output  ReadIntEmptyWrmi42Rdmi4;
    input   DataCntEmptyRdmi42Wrmi4;
    output  [SELMASTER4_WID-1:0]CtlDataWrite2Lock4;

    //Slave 5
    //_____________________________________
    input   Lock2wrmi5;
    input   UnLock2wrmi5;
    output  Lock2rdmi5;
    output  UnLock2rdmi5;
    input   ARVALIDmi52s5;
    //2006-9-8-ID-WID-FIXED
    //input   [SELMASTER5_WID-1:0]LockPort2wrmi5;
    input   [SELMASTER5_WID:0]LockPort2wrmi5;

    output  ReadIntEmptyWrmi52Rdmi5;
    input   DataCntEmptyRdmi52Wrmi5;
    output  [SELMASTER5_WID-1:0]CtlDataWrite2Lock5;
    //_______________________________________________________________

    //SlaveInterface
    //_______________________________________________________________

    //For Master 0
    //Write address channel
//Disable_id_port
    input   [ADDR_WID-1:0]          AWADDRm02si0;
    input   [AWLEN_WID-1:0]         AWLENm02si0;
    input   [AWSIZE_WID-1:0]        AWSIZEm02si0;  
    input   [AWBURST_WID-1:0]       AWBURSTm02si0; 
    input   [AWLOCK_WID-1:0]        AWLOCKm02si0;  
//Disable_cache_port
//Disable_protect_port

    input   AWVALIDm02si0; 
    output  AWREADYsi02m0; 

    //Write data channel
//Disable_id_port
    input   [BUS_WID-1:0]           WDATAm02si0;   
    input   [WSTRB_WID-1:0]         WSTRBm02si0;   
    input   WLASTm02si0;   
    input   WVALIDm02si0;  
    output  WREADYsi02m0;  

    //Write response channel
//Disable_id_port
    output   [BRESP_WID-1:0]        BRESPsi02m0;   
    output   BVALIDsi02m0;  
    input    BREADYm02si0;  
 
 


    //MasterInterface
    //_______________________________________________________________

    // For slave 0
    //__________________________________________________
    //Write address channel
    output   [SLAVEID0_WID-1:0]AWIDmi02s0;    
    output   [ADDR_WID-1:0]     AWADDRmi02s0;
    output   [AWLEN_WID-1:0]    AWLENmi02s0;
    output   [AWSIZE_WID-1:0]   AWSIZEmi02s0;  
    output   [AWBURST_WID-1:0]  AWBURSTmi02s0; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi02s0; 
    input    AWREADYs02mi0; 
    
    //Write data channel
    output   [SLAVEID0_WID-1:0]WIDmi02s0;     
    output   [BUS_WID-1:0]      WDATAmi02s0;   
    output   [WSTRB_WID-1:0]    WSTRBmi02s0;   
    output   WLASTmi02s0;   
    output   WVALIDmi02s0;  
    input    WREADYs02mi0; 

    //Write response channel
    input   [SLAVEID0_WID-1:0] BIDs02mi0;     
    input   [BRESP_WID-1:0]     BRESPs02mi0;   
    input   BVALIDs02mi0;  
    output  BREADYmi02s0;  

    // For slave 1
    //__________________________________________________
    //Write address channel
    output   [SLAVEID1_WID-1:0]AWIDmi12s1;    
    output   [ADDR_WID-1:0]     AWADDRmi12s1;
    output   [AWLEN_WID-1:0]    AWLENmi12s1;
    output   [AWSIZE_WID-1:0]   AWSIZEmi12s1;  
    output   [AWBURST_WID-1:0]  AWBURSTmi12s1; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi12s1; 
    input    AWREADYs12mi1; 
    
    //Write data channel
    output   [SLAVEID1_WID-1:0]WIDmi12s1;     
    output   [BUS_WID-1:0]      WDATAmi12s1;   
//Disable_WSTRB_port
    output   WLASTmi12s1;   
    output   WVALIDmi12s1;  
    input    WREADYs12mi1; 

    //Write response channel
    input   [SLAVEID1_WID-1:0] BIDs12mi1;     
    input   [BRESP_WID-1:0]     BRESPs12mi1;   
    input   BVALIDs12mi1;  
    output  BREADYmi12s1;  

    // For slave 2
    //__________________________________________________
    //Write address channel
    output   [SLAVEID2_WID-1:0]AWIDmi22s2;    
    output   [ADDR_WID-1:0]     AWADDRmi22s2;
    output   [AWLEN_WID-1:0]    AWLENmi22s2;
    output   [AWSIZE_WID-1:0]   AWSIZEmi22s2;  
    output   [AWBURST_WID-1:0]  AWBURSTmi22s2; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi22s2; 
    input    AWREADYs22mi2; 
    
    //Write data channel
    output   [SLAVEID2_WID-1:0]WIDmi22s2;     
    output   [BUS_WID-1:0]      WDATAmi22s2;   
//Disable_WSTRB_port
    output   WLASTmi22s2;   
    output   WVALIDmi22s2;  
    input    WREADYs22mi2; 

    //Write response channel
    input   [SLAVEID2_WID-1:0] BIDs22mi2;     
    input   [BRESP_WID-1:0]     BRESPs22mi2;   
    input   BVALIDs22mi2;  
    output  BREADYmi22s2;  

    // For slave 3
    //__________________________________________________
    //Write address channel
    output   [SLAVEID3_WID-1:0]AWIDmi32s3;    
    output   [ADDR_WID-1:0]     AWADDRmi32s3;
    output   [AWLEN_WID-1:0]    AWLENmi32s3;
    output   [AWSIZE_WID-1:0]   AWSIZEmi32s3;  
    output   [AWBURST_WID-1:0]  AWBURSTmi32s3; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi32s3; 
    input    AWREADYs32mi3; 
    
    //Write data channel
    output   [SLAVEID3_WID-1:0]WIDmi32s3;     
    output   [BUS_WID-1:0]      WDATAmi32s3;   
    output   [WSTRB_WID-1:0]    WSTRBmi32s3;   
    output   WLASTmi32s3;   
    output   WVALIDmi32s3;  
    input    WREADYs32mi3; 

    //Write response channel
    input   [SLAVEID3_WID-1:0] BIDs32mi3;     
    input   [BRESP_WID-1:0]     BRESPs32mi3;   
    input   BVALIDs32mi3;  
    output  BREADYmi32s3;  

    // For slave 4
    //__________________________________________________
    //Write address channel
    output   [SLAVEID4_WID-1:0]AWIDmi42s4;    
    output   [ADDR_WID-1:0]     AWADDRmi42s4;
    output   [AWLEN_WID-1:0]    AWLENmi42s4;
    output   [AWSIZE_WID-1:0]   AWSIZEmi42s4;  
    output   [AWBURST_WID-1:0]  AWBURSTmi42s4; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi42s4; 
    input    AWREADYs42mi4; 
    
    //Write data channel
    output   [SLAVEID4_WID-1:0]WIDmi42s4;     
    output   [BUS_WID-1:0]      WDATAmi42s4;   
    output   [WSTRB_WID-1:0]    WSTRBmi42s4;   
    output   WLASTmi42s4;   
    output   WVALIDmi42s4;  
    input    WREADYs42mi4; 

    //Write response channel
    input   [SLAVEID4_WID-1:0] BIDs42mi4;     
    input   [BRESP_WID-1:0]     BRESPs42mi4;   
    input   BVALIDs42mi4;  
    output  BREADYmi42s4;  

    // For slave 5
    //__________________________________________________
    //Write address channel
    output   [SLAVEID5_WID-1:0]AWIDmi52s5;    
    output   [ADDR_WID-1:0]     AWADDRmi52s5;
    output   [AWLEN_WID-1:0]    AWLENmi52s5;
    output   [AWSIZE_WID-1:0]   AWSIZEmi52s5;  
    output   [AWBURST_WID-1:0]  AWBURSTmi52s5; 
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    output   AWVALIDmi52s5; 
    input    AWREADYs52mi5; 
    
    //Write data channel
    output   [SLAVEID5_WID-1:0]WIDmi52s5;     
    output   [BUS_WID-1:0]      WDATAmi52s5;   
    output   [WSTRB_WID-1:0]    WSTRBmi52s5;   
    output   WLASTmi52s5;   
    output   WVALIDmi52s5;  
    input    WREADYs52mi5; 

    //Write response channel
    input   [SLAVEID5_WID-1:0] BIDs52mi5;     
    input   [BRESP_WID-1:0]     BRESPs52mi5;   
    input   BVALIDs52mi5;  
    output  BREADYmi52s5;  



//Master module wire were generated
//Master module 0 - 0
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi0 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi0;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi0 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi0};    
    wire  [BUS_WID-1:0]         WDATAsi02mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi0;  

//Master module wire were generated
//Master module 0 - 1
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi1 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi1;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi1 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi1};    
    wire  [BUS_WID-1:0]         WDATAsi02mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi1;  

//Master module wire were generated
//Master module 0 - 2
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi2 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi2;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi2 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi2};    
    wire  [BUS_WID-1:0]         WDATAsi02mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi2;  

//Master module wire were generated
//Master module 0 - 3
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi3 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi3;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi3 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi3};    
    wire  [BUS_WID-1:0]         WDATAsi02mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi3;  

//Master module wire were generated
//Master module 0 - 4
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi4 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi4;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi4 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi4};    
    wire  [BUS_WID-1:0]         WDATAsi02mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi4;  

//Master module wire were generated
//Master module 0 - 5
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi5 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi5;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi5 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi5};    
    wire  [BUS_WID-1:0]         WDATAsi02mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi5;  



    wire    [SLAVE_NUM-1:0]     AWVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     WLASTsi02mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si0;
    wire    [SLAVE_NUM-1:0]     BREADYsi02mi;
//_____________________________________________________________________

    //Slave Number 0(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si0;     
    wire   [BRESP_WID-1:0]               BRESPmi02si0; 
    //Slave Number 1(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si0;     
    wire   [BRESP_WID-1:0]               BRESPmi12si0; 
    //Slave Number 2(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si0;     
    wire   [BRESP_WID-1:0]               BRESPmi22si0; 
    //Slave Number 3(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si0;     
    wire   [BRESP_WID-1:0]               BRESPmi32si0; 
    //Slave Number 4(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si0;     
    wire   [BRESP_WID-1:0]               BRESPmi42si0; 
    //Slave Number 5(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si0;     
    wire   [BRESP_WID-1:0]               BRESPmi52si0; 

//Slave module wire were generated
//Slave module 0    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi02si;
    wire  [MASTER_NUM-1:0]    WREADYmi02si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi02si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi0;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi0;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi02si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi02si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi02si;

//Slave module wire were generated
//Slave module 1    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi12si;
    wire  [MASTER_NUM-1:0]    WREADYmi12si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi12si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi1;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi1;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi12si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi12si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi12si;

//Slave module wire were generated
//Slave module 2    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi22si;
    wire  [MASTER_NUM-1:0]    WREADYmi22si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi22si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi2;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi2;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi22si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi22si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi22si;

//Slave module wire were generated
//Slave module 3    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi32si;
    wire  [MASTER_NUM-1:0]    WREADYmi32si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi32si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi3;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi3;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi32si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi32si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi32si;

//Slave module wire were generated
//Slave module 4    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi42si;
    wire  [MASTER_NUM-1:0]    WREADYmi42si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi42si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi4;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi4;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi42si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi42si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi42si;

//Slave module wire were generated
//Slave module 5    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi52si;
    wire  [MASTER_NUM-1:0]    WREADYmi52si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi52si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi5;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi5;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi52si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi52si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi52si;


//MaserInterface to SlaveInterface Setting
//_____________________________________________________________________
//SlaveNum  [0]
/////////////////////////////
    assign SetAWREADYmi02si[0] = AWREADYmi02si[0]; 
    assign SetAWREADYmi02si[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetAWREADYmi12si[0] = AWREADYmi12si[0]; 
    assign SetAWREADYmi12si[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetAWREADYmi22si[0] = AWREADYmi22si[0]; 
    assign SetAWREADYmi22si[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetAWREADYmi32si[0] = AWREADYmi32si[0]; 
    assign SetAWREADYmi32si[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign SetAWREADYmi42si[0] = AWREADYmi42si[0]; 
    assign SetAWREADYmi42si[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetAWREADYmi52si[0] = AWREADYmi52si[0]; 
    assign SetAWREADYmi52si[1] = 1'b0;

//SlaveNum  [0]
/////////////////////////////
    assign  SetWREADYmi02si[0] = WREADYmi02si[0];   
    assign  SetWREADYmi02si[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  SetWREADYmi12si[0] = WREADYmi12si[0];   
    assign  SetWREADYmi12si[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  SetWREADYmi22si[0] = WREADYmi22si[0];   
    assign  SetWREADYmi22si[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  SetWREADYmi32si[0] = WREADYmi32si[0];   
    assign  SetWREADYmi32si[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  SetWREADYmi42si[0] = WREADYmi42si[0];   
    assign  SetWREADYmi42si[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  SetWREADYmi52si[0] = WREADYmi52si[0];   
    assign  SetWREADYmi52si[1] = 1'b0;

//SlaveNum  [0]
/////////////////////////////
    assign SetBVALIDmi02si[0]  = BVALIDmi02si[0];
    assign SetBVALIDmi02si[1]  = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign SetBVALIDmi12si[0]  = BVALIDmi12si[0];
    assign SetBVALIDmi12si[1]  = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign SetBVALIDmi22si[0]  = BVALIDmi22si[0];
    assign SetBVALIDmi22si[1]  = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign SetBVALIDmi32si[0]  = BVALIDmi32si[0];
    assign SetBVALIDmi32si[1]  = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign SetBVALIDmi42si[0]  = BVALIDmi42si[0];
    assign SetBVALIDmi42si[1]  = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign SetBVALIDmi52si[0]  = BVALIDmi52si[0];
    assign SetBVALIDmi52si[1]  = 1'b0;

//AWREADYmi2si///////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  AWREADYmi2si0[0] = SetAWREADYmi02si[0];
    assign  AWREADYmi2si0[1] = SetAWREADYmi12si[0];
    assign  AWREADYmi2si0[2] = SetAWREADYmi22si[0];
    assign  AWREADYmi2si0[3] = SetAWREADYmi32si[0];
    assign  AWREADYmi2si0[4] = SetAWREADYmi42si[0];
    assign  AWREADYmi2si0[5] = SetAWREADYmi52si[0];

//BVALIDmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  BVALIDmi2si0[0] = SetBVALIDmi02si[0];
    assign  BVALIDmi2si0[1] = SetBVALIDmi12si[0];
    assign  BVALIDmi2si0[2] = SetBVALIDmi22si[0];
    assign  BVALIDmi2si0[3] = SetBVALIDmi32si[0];
    assign  BVALIDmi2si0[4] = SetBVALIDmi42si[0];
    assign  BVALIDmi2si0[5] = SetBVALIDmi52si[0];

//WREADYmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  WREADYmi2si0[0] = SetWREADYmi02si[0];
    assign  WREADYmi2si0[1] = SetWREADYmi12si[0];
    assign  WREADYmi2si0[2] = SetWREADYmi22si[0];
    assign  WREADYmi2si0[3] = SetWREADYmi32si[0];
    assign  WREADYmi2si0[4] = SetWREADYmi42si[0];
    assign  WREADYmi2si0[5] = SetWREADYmi52si[0];

//_____________________________________________________________________


//SlaveInterface to MasterInterface Setting
//_____________________________________________________________________

//AWVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  AWVALIDsi2mi0[0] = AWVALIDsi02mi[0];
    assign  AWVALIDsi2mi0[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  AWVALIDsi2mi1[0] = AWVALIDsi02mi[1];
    assign  AWVALIDsi2mi1[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  AWVALIDsi2mi2[0] = AWVALIDsi02mi[2];
    assign  AWVALIDsi2mi2[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  AWVALIDsi2mi3[0] = AWVALIDsi02mi[3];
    assign  AWVALIDsi2mi3[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  AWVALIDsi2mi4[0] = AWVALIDsi02mi[4];
    assign  AWVALIDsi2mi4[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  AWVALIDsi2mi5[0] = AWVALIDsi02mi[5];
    assign  AWVALIDsi2mi5[1] = 1'b0;

//WVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WVALIDsi2mi0[0] = WVALIDsi02mi[0];
    assign  WVALIDsi2mi0[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WVALIDsi2mi1[0] = WVALIDsi02mi[1];
    assign  WVALIDsi2mi1[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WVALIDsi2mi2[0] = WVALIDsi02mi[2];
    assign  WVALIDsi2mi2[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WVALIDsi2mi3[0] = WVALIDsi02mi[3];
    assign  WVALIDsi2mi3[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WVALIDsi2mi4[0] = WVALIDsi02mi[4];
    assign  WVALIDsi2mi4[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WVALIDsi2mi5[0] = WVALIDsi02mi[5];
    assign  WVALIDsi2mi5[1] = 1'b0;

//WLASTsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WLASTsi2mi0[0] = WLASTsi02mi[0];
    assign  WLASTsi2mi0[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  WLASTsi2mi1[0] = WLASTsi02mi[1];
    assign  WLASTsi2mi1[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  WLASTsi2mi2[0] = WLASTsi02mi[2];
    assign  WLASTsi2mi2[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  WLASTsi2mi3[0] = WLASTsi02mi[3];
    assign  WLASTsi2mi3[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  WLASTsi2mi4[0] = WLASTsi02mi[4];
    assign  WLASTsi2mi4[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  WLASTsi2mi5[0] = WLASTsi02mi[5];
    assign  WLASTsi2mi5[1] = 1'b0;

//BREADYsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  BREADYsi2mi0[0] = BREADYsi02mi[0];
    assign  BREADYsi2mi0[1] = 1'b0;
//SlaveNum  [1]
/////////////////////////////
    assign  BREADYsi2mi1[0] = BREADYsi02mi[1];
    assign  BREADYsi2mi1[1] = 1'b0;
//SlaveNum  [2]
/////////////////////////////
    assign  BREADYsi2mi2[0] = BREADYsi02mi[2];
    assign  BREADYsi2mi2[1] = 1'b0;
//SlaveNum  [3]
/////////////////////////////
    assign  BREADYsi2mi3[0] = BREADYsi02mi[3];
    assign  BREADYsi2mi3[1] = 1'b0;
//SlaveNum  [4]
/////////////////////////////
    assign  BREADYsi2mi4[0] = BREADYsi02mi[4];
    assign  BREADYsi2mi4[1] = 1'b0;
//SlaveNum  [5]
/////////////////////////////
    assign  BREADYsi2mi5[0] = BREADYsi02mi[5];
    assign  BREADYsi2mi5[1] = 1'b0;

//_____________________________________________________________________



//Master module 0    
//________________________________________________________________________

ARM_RS_WriteChannelsi
ARM_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
//Disable_id_port
    .AWADDRm2si  (AWADDRm02si0),
    .AWLENm2si   (AWLENm02si0),
    .AWSIZEm2si  (AWSIZEm02si0),
    .AWBURSTm2si (AWBURSTm02si0),
    .AWLOCKm2si  (AWLOCKm02si0),
//Disable_cache_port
//Disable_protect_port

    .AWVALIDm2si (AWVALIDm02si0),
    .AWREADYsi2m (AWREADYsi02m0),

    //Write data channel
//Disable_id_port
    .WDATAm2si   (WDATAm02si0),
    .WSTRBm2si   (WSTRBm02si0),
    .WLASTm2si   (WLASTm02si0),
    .WVALIDm2si  (WVALIDm02si0),
    .WREADYsi2m  (WREADYsi02m0),

    //Write response channel
//Disable_id_port
    .BRESPsi2m   (BRESPsi02m0),
    .BVALIDsi2m  (BVALIDsi02m0),
    .BREADYm2si  (BREADYm02si0),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi02mi0),
    .AWADDRsi2mi0  (AWADDRsi02mi0),
    .AWLENsi2mi0   (AWLENsi02mi0),
    .AWSIZEsi2mi0  (AWSIZEsi02mi0),
    .AWBURSTsi2mi0 (AWBURSTsi02mi0),
    .AWLOCKsi2mi0  (AWLOCKsi02mi0),
    .AWCACHEsi2mi0 (AWCACHEsi02mi0),
    .AWPROTsi2mi0  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi02mi0),
    .WDATAsi2mi0   (WDATAsi02mi0),
    .WSTRBsi2mi0   (WSTRBsi02mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si0[MASTERID0_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi02mi1),
    .AWADDRsi2mi1  (AWADDRsi02mi1),
    .AWLENsi2mi1   (AWLENsi02mi1),
    .AWSIZEsi2mi1  (AWSIZEsi02mi1),
    .AWBURSTsi2mi1 (AWBURSTsi02mi1),
    .AWLOCKsi2mi1  (AWLOCKsi02mi1),
    .AWCACHEsi2mi1 (AWCACHEsi02mi1),
    .AWPROTsi2mi1  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi02mi1),
    .WDATAsi2mi1   (WDATAsi02mi1),
    .WSTRBsi2mi1   (WSTRBsi02mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si0[MASTERID0_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi02mi2),
    .AWADDRsi2mi2  (AWADDRsi02mi2),
    .AWLENsi2mi2   (AWLENsi02mi2),
    .AWSIZEsi2mi2  (AWSIZEsi02mi2),
    .AWBURSTsi2mi2 (AWBURSTsi02mi2),
    .AWLOCKsi2mi2  (AWLOCKsi02mi2),
    .AWCACHEsi2mi2 (AWCACHEsi02mi2),
    .AWPROTsi2mi2  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi02mi2),
    .WDATAsi2mi2   (WDATAsi02mi2),
    .WSTRBsi2mi2   (WSTRBsi02mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si0[MASTERID0_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi02mi3),
    .AWADDRsi2mi3  (AWADDRsi02mi3),
    .AWLENsi2mi3   (AWLENsi02mi3),
    .AWSIZEsi2mi3  (AWSIZEsi02mi3),
    .AWBURSTsi2mi3 (AWBURSTsi02mi3),
    .AWLOCKsi2mi3  (AWLOCKsi02mi3),
    .AWCACHEsi2mi3 (AWCACHEsi02mi3),
    .AWPROTsi2mi3  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi02mi3),
    .WDATAsi2mi3   (WDATAsi02mi3),
    .WSTRBsi2mi3   (WSTRBsi02mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si0[MASTERID0_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi02mi4),
    .AWADDRsi2mi4  (AWADDRsi02mi4),
    .AWLENsi2mi4   (AWLENsi02mi4),
    .AWSIZEsi2mi4  (AWSIZEsi02mi4),
    .AWBURSTsi2mi4 (AWBURSTsi02mi4),
    .AWLOCKsi2mi4  (AWLOCKsi02mi4),
    .AWCACHEsi2mi4 (AWCACHEsi02mi4),
    .AWPROTsi2mi4  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi02mi4),
    .WDATAsi2mi4   (WDATAsi02mi4),
    .WSTRBsi2mi4   (WSTRBsi02mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si0[MASTERID0_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi02mi5),
    .AWADDRsi2mi5  (AWADDRsi02mi5),
    .AWLENsi2mi5   (AWLENsi02mi5),
    .AWSIZEsi2mi5  (AWSIZEsi02mi5),
    .AWBURSTsi2mi5 (AWBURSTsi02mi5),
    .AWLOCKsi2mi5  (AWLOCKsi02mi5),
    .AWCACHEsi2mi5 (AWCACHEsi02mi5),
    .AWPROTsi2mi5  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi02mi5),
    .WDATAsi2mi5   (WDATAsi02mi5),
    .WSTRBsi2mi5   (WSTRBsi02mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si0[MASTERID0_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si0),

    .AWVALIDsi2mi (AWVALIDsi02mi),
    .AWREADYmi2si (AWREADYmi2si0),

    .WLASTsi2mi   (WLASTsi02mi),
    .WVALIDsi2mi  (WVALIDsi02mi),
    .WREADYmi2si  (WREADYmi2si0),

    .BVALIDmi2si    (BVALIDmi2si0),
    .BREADYsi2mi    (BREADYsi02mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Slave module 0    
//___________________________________________________________________________

DDRCtrl_RS_WriteChannelmi
DDRCtrl_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi02s0),
    .AWADDRmi2s  (AWADDRmi02s0),
    .AWLENmi2s   (AWLENmi02s0),
    .AWSIZEmi2s  (AWSIZEmi02s0),
    .AWBURSTmi2s (AWBURSTmi02s0),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi02s0),
    .AWREADYs2mi (AWREADYs02mi0),

    //Write data channel
    .WIDmi2s     (WIDmi02s0),
    .WDATAmi2s   (WDATAmi02s0),
    .WSTRBmi2s   (WSTRBmi02s0),
    .WLASTmi2s   (WLASTmi02s0),
    .WVALIDmi2s  (WVALIDmi02s0),
    .WREADYs2mi  (WREADYs02mi0),

    //Write response channel
    .BIDs2mi     (BIDs02mi0),
    .BRESPs2mi   (BRESPs02mi0),
    .BVALIDs2mi  (BVALIDs02mi0),
    .BREADYmi2s  (BREADYmi02s0),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi0),
    .AWLENsi02mi   (AWLENsi02mi0),
    .AWSIZEsi02mi  (AWSIZEsi02mi0),
    .AWBURSTsi02mi (AWBURSTsi02mi0),
    .AWLOCKsi02mi  (AWLOCKsi02mi0),
    .AWCACHEsi02mi (AWCACHEsi02mi0),
    .AWPROTsi02mi  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi0),   
    .WSTRBsi02mi (WSTRBsi02mi0),   

    //Write response channel
    .BIDmi2si0     (BIDmi02si0),
    .BRESPmi2si0   (BRESPmi02si0),

    .BVALIDmi2si  (BVALIDmi02si),
    .BREADYsi2mi   (BREADYsi2mi0),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi0),
    .AWREADYmi2si  (AWREADYmi02si),
    .WLASTsi2mi    (WLASTsi2mi0),
    .WVALIDsi2mi   (WVALIDsi2mi0),
    .WREADYmi2si   (WREADYmi02si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi0),
    .UnLock2Wrmi(UnLock2wrmi0),

    .Lock2Rdmi(Lock2rdmi0),
    .UnLock2Rdmi(UnLock2rdmi0),

    .ARVALID(ARVALIDmi02s0),
    .LockPort(LockPort2wrmi0),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi02Rdmi0),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi02Wrmi0),
    .CtlDataWrite2Lock(CtlDataWrite2Lock0)
    ////////////////////////////////////////

    );

//Slave module 1    
//___________________________________________________________________________

APB0_RS_WriteChannelmi
APB0_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi12s1),
    .AWADDRmi2s  (AWADDRmi12s1),
    .AWLENmi2s   (AWLENmi12s1),
    .AWSIZEmi2s  (AWSIZEmi12s1),
    .AWBURSTmi2s (AWBURSTmi12s1),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi12s1),
    .AWREADYs2mi (AWREADYs12mi1),

    //Write data channel
    .WIDmi2s     (WIDmi12s1),
    .WDATAmi2s   (WDATAmi12s1),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi12s1),
    .WVALIDmi2s  (WVALIDmi12s1),
    .WREADYs2mi  (WREADYs12mi1),

    //Write response channel
    .BIDs2mi     (BIDs12mi1),
    .BRESPs2mi   (BRESPs12mi1),
    .BVALIDs2mi  (BVALIDs12mi1),
    .BREADYmi2s  (BREADYmi12s1),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi1),
    .AWLENsi02mi   (AWLENsi02mi1),
    .AWSIZEsi02mi  (AWSIZEsi02mi1),
    .AWBURSTsi02mi (AWBURSTsi02mi1),
    .AWLOCKsi02mi  (AWLOCKsi02mi1),
    .AWCACHEsi02mi (AWCACHEsi02mi1),
    .AWPROTsi02mi  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi1),   
    .WSTRBsi02mi (WSTRBsi02mi1),   

    //Write response channel
    .BIDmi2si0     (BIDmi12si0),
    .BRESPmi2si0   (BRESPmi12si0),

    .BVALIDmi2si  (BVALIDmi12si),
    .BREADYsi2mi   (BREADYsi2mi1),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi1),
    .AWREADYmi2si  (AWREADYmi12si),
    .WLASTsi2mi    (WLASTsi2mi1),
    .WVALIDsi2mi   (WVALIDsi2mi1),
    .WREADYmi2si   (WREADYmi12si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi1),
    .UnLock2Wrmi(UnLock2wrmi1),

    .Lock2Rdmi(Lock2rdmi1),
    .UnLock2Rdmi(UnLock2rdmi1),

    .ARVALID(ARVALIDmi12s1),
    .LockPort(LockPort2wrmi1),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi12Rdmi1),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi12Wrmi1),
    .CtlDataWrite2Lock(CtlDataWrite2Lock1)
    ////////////////////////////////////////

    );

//Slave module 2    
//___________________________________________________________________________

APB1_RS_WriteChannelmi
APB1_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi22s2),
    .AWADDRmi2s  (AWADDRmi22s2),
    .AWLENmi2s   (AWLENmi22s2),
    .AWSIZEmi2s  (AWSIZEmi22s2),
    .AWBURSTmi2s (AWBURSTmi22s2),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi22s2),
    .AWREADYs2mi (AWREADYs22mi2),

    //Write data channel
    .WIDmi2s     (WIDmi22s2),
    .WDATAmi2s   (WDATAmi22s2),
//Disable_WSTRB_port
    .WLASTmi2s   (WLASTmi22s2),
    .WVALIDmi2s  (WVALIDmi22s2),
    .WREADYs2mi  (WREADYs22mi2),

    //Write response channel
    .BIDs2mi     (BIDs22mi2),
    .BRESPs2mi   (BRESPs22mi2),
    .BVALIDs2mi  (BVALIDs22mi2),
    .BREADYmi2s  (BREADYmi22s2),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi2),
    .AWLENsi02mi   (AWLENsi02mi2),
    .AWSIZEsi02mi  (AWSIZEsi02mi2),
    .AWBURSTsi02mi (AWBURSTsi02mi2),
    .AWLOCKsi02mi  (AWLOCKsi02mi2),
    .AWCACHEsi02mi (AWCACHEsi02mi2),
    .AWPROTsi02mi  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi2),   
    .WSTRBsi02mi (WSTRBsi02mi2),   

    //Write response channel
    .BIDmi2si0     (BIDmi22si0),
    .BRESPmi2si0   (BRESPmi22si0),

    .BVALIDmi2si  (BVALIDmi22si),
    .BREADYsi2mi   (BREADYsi2mi2),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi2),
    .AWREADYmi2si  (AWREADYmi22si),
    .WLASTsi2mi    (WLASTsi2mi2),
    .WVALIDsi2mi   (WVALIDsi2mi2),
    .WREADYmi2si   (WREADYmi22si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi2),
    .UnLock2Wrmi(UnLock2wrmi2),

    .Lock2Rdmi(Lock2rdmi2),
    .UnLock2Rdmi(UnLock2rdmi2),

    .ARVALID(ARVALIDmi22s2),
    .LockPort(LockPort2wrmi2),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi22Rdmi2),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi22Wrmi2),
    .CtlDataWrite2Lock(CtlDataWrite2Lock2)
    ////////////////////////////////////////

    );

//Slave module 3    
//___________________________________________________________________________

SMC_RS_WriteChannelmi
SMC_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi32s3),
    .AWADDRmi2s  (AWADDRmi32s3),
    .AWLENmi2s   (AWLENmi32s3),
    .AWSIZEmi2s  (AWSIZEmi32s3),
    .AWBURSTmi2s (AWBURSTmi32s3),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi32s3),
    .AWREADYs2mi (AWREADYs32mi3),

    //Write data channel
    .WIDmi2s     (WIDmi32s3),
    .WDATAmi2s   (WDATAmi32s3),
    .WSTRBmi2s   (WSTRBmi32s3),
    .WLASTmi2s   (WLASTmi32s3),
    .WVALIDmi2s  (WVALIDmi32s3),
    .WREADYs2mi  (WREADYs32mi3),

    //Write response channel
    .BIDs2mi     (BIDs32mi3),
    .BRESPs2mi   (BRESPs32mi3),
    .BVALIDs2mi  (BVALIDs32mi3),
    .BREADYmi2s  (BREADYmi32s3),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi3),
    .AWLENsi02mi   (AWLENsi02mi3),
    .AWSIZEsi02mi  (AWSIZEsi02mi3),
    .AWBURSTsi02mi (AWBURSTsi02mi3),
    .AWLOCKsi02mi  (AWLOCKsi02mi3),
    .AWCACHEsi02mi (AWCACHEsi02mi3),
    .AWPROTsi02mi  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi3),   
    .WSTRBsi02mi (WSTRBsi02mi3),   

    //Write response channel
    .BIDmi2si0     (BIDmi32si0),
    .BRESPmi2si0   (BRESPmi32si0),

    .BVALIDmi2si  (BVALIDmi32si),
    .BREADYsi2mi   (BREADYsi2mi3),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi3),
    .AWREADYmi2si  (AWREADYmi32si),
    .WLASTsi2mi    (WLASTsi2mi3),
    .WVALIDsi2mi   (WVALIDsi2mi3),
    .WREADYmi2si   (WREADYmi32si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi3),
    .UnLock2Wrmi(UnLock2wrmi3),

    .Lock2Rdmi(Lock2rdmi3),
    .UnLock2Rdmi(UnLock2rdmi3),

    .ARVALID(ARVALIDmi32s3),
    .LockPort(LockPort2wrmi3),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi32Rdmi3),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi32Wrmi3),
    .CtlDataWrite2Lock(CtlDataWrite2Lock3)
    ////////////////////////////////////////

    );

//Slave module 4    
//___________________________________________________________________________

IntSRAM_RS_WriteChannelmi
IntSRAM_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi42s4),
    .AWADDRmi2s  (AWADDRmi42s4),
    .AWLENmi2s   (AWLENmi42s4),
    .AWSIZEmi2s  (AWSIZEmi42s4),
    .AWBURSTmi2s (AWBURSTmi42s4),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi42s4),
    .AWREADYs2mi (AWREADYs42mi4),

    //Write data channel
    .WIDmi2s     (WIDmi42s4),
    .WDATAmi2s   (WDATAmi42s4),
    .WSTRBmi2s   (WSTRBmi42s4),
    .WLASTmi2s   (WLASTmi42s4),
    .WVALIDmi2s  (WVALIDmi42s4),
    .WREADYs2mi  (WREADYs42mi4),

    //Write response channel
    .BIDs2mi     (BIDs42mi4),
    .BRESPs2mi   (BRESPs42mi4),
    .BVALIDs2mi  (BVALIDs42mi4),
    .BREADYmi2s  (BREADYmi42s4),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi4),
    .AWLENsi02mi   (AWLENsi02mi4),
    .AWSIZEsi02mi  (AWSIZEsi02mi4),
    .AWBURSTsi02mi (AWBURSTsi02mi4),
    .AWLOCKsi02mi  (AWLOCKsi02mi4),
    .AWCACHEsi02mi (AWCACHEsi02mi4),
    .AWPROTsi02mi  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi4),   
    .WSTRBsi02mi (WSTRBsi02mi4),   

    //Write response channel
    .BIDmi2si0     (BIDmi42si0),
    .BRESPmi2si0   (BRESPmi42si0),

    .BVALIDmi2si  (BVALIDmi42si),
    .BREADYsi2mi   (BREADYsi2mi4),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi4),
    .AWREADYmi2si  (AWREADYmi42si),
    .WLASTsi2mi    (WLASTsi2mi4),
    .WVALIDsi2mi   (WVALIDsi2mi4),
    .WREADYmi2si   (WREADYmi42si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi4),
    .UnLock2Wrmi(UnLock2wrmi4),

    .Lock2Rdmi(Lock2rdmi4),
    .UnLock2Rdmi(UnLock2rdmi4),

    .ARVALID(ARVALIDmi42s4),
    .LockPort(LockPort2wrmi4),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi42Rdmi4),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi42Wrmi4),
    .CtlDataWrite2Lock(CtlDataWrite2Lock4)
    ////////////////////////////////////////

    );

//Slave module 5    
//___________________________________________________________________________

default_RS_WriteChannelmi
default_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi52s5),
    .AWADDRmi2s  (AWADDRmi52s5),
    .AWLENmi2s   (AWLENmi52s5),
    .AWSIZEmi2s  (AWSIZEmi52s5),
    .AWBURSTmi2s (AWBURSTmi52s5),
//Disable_lock_port
//Disable_cache_port
//Disable_protect_port

    .AWVALIDmi2s (AWVALIDmi52s5),
    .AWREADYs2mi (AWREADYs52mi5),

    //Write data channel
    .WIDmi2s     (WIDmi52s5),
    .WDATAmi2s   (WDATAmi52s5),
    .WSTRBmi2s   (WSTRBmi52s5),
    .WLASTmi2s   (WLASTmi52s5),
    .WVALIDmi2s  (WVALIDmi52s5),
    .WREADYs2mi  (WREADYs52mi5),

    //Write response channel
    .BIDs2mi     (BIDs52mi5),
    .BRESPs2mi   (BRESPs52mi5),
    .BVALIDs2mi  (BVALIDs52mi5),
    .BREADYmi2s  (BREADYmi52s5),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi5),
    .AWLENsi02mi   (AWLENsi02mi5),
    .AWSIZEsi02mi  (AWSIZEsi02mi5),
    .AWBURSTsi02mi (AWBURSTsi02mi5),
    .AWLOCKsi02mi  (AWLOCKsi02mi5),
    .AWCACHEsi02mi (AWCACHEsi02mi5),
    .AWPROTsi02mi  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi5),   
    .WSTRBsi02mi (WSTRBsi02mi5),   

    //Write response channel
    .BIDmi2si0     (BIDmi52si0),
    .BRESPmi2si0   (BRESPmi52si0),

    .BVALIDmi2si  (BVALIDmi52si),
    .BREADYsi2mi   (BREADYsi2mi5),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi5),
    .AWREADYmi2si  (AWREADYmi52si),
    .WLASTsi2mi    (WLASTsi2mi5),
    .WVALIDsi2mi   (WVALIDsi2mi5),
    .WREADYmi2si   (WREADYmi52si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi5),
    .UnLock2Wrmi(UnLock2wrmi5),

    .Lock2Rdmi(Lock2rdmi5),
    .UnLock2Rdmi(UnLock2rdmi5),

    .ARVALID(ARVALIDmi52s5),
    .LockPort(LockPort2wrmi5),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi52Rdmi5),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi52Wrmi5),
    .CtlDataWrite2Lock(CtlDataWrite2Lock5)
    ////////////////////////////////////////

    );

endmodule
