// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  VideoEnC_ReadChannelsi(

    //Global signal
    ACLK    ,
    ARESETn ,

    //Read address channel
//ENABLE_ID
    ARIDm2si    ,
    ARADDRm2si  ,
    ARLENm2si   ,
    ARSIZEm2si  ,
    ARBURSTm2si ,
//ENABLE_LOCK
    ARLOCKm2si  ,
//ENABLE_CACHE
    ARCACHEm2si ,
//ENABLE_PROT
    ARPROTm2si  ,

    ARVALIDm2si ,
    ARREADYsi2m ,

    //Read data channel
//ENABLE_ID
    RIDsi2m     ,
    RRESPsi2m   ,
    RVALIDsi2m  ,
    RDATAsi2m   ,
    RREADYm2si  ,
    RLASTsi2m   ,

    
    //For Master interface slave Number = 0
    //Read address channel
    ARIDsi2mi0    ,
    ARADDRsi2mi0  ,
    ARLENsi2mi0   ,
    ARSIZEsi2mi0  ,
    ARBURSTsi2mi0 ,
    ARLOCKsi2mi0  ,
    ARCACHEsi2mi0 ,
    ARPROTsi2mi0  ,
    
    //For Master interface slave Number = 3
    //Read address channel
    ARIDsi2mi3    ,
    ARADDRsi2mi3  ,
    ARLENsi2mi3   ,
    ARSIZEsi2mi3  ,
    ARBURSTsi2mi3 ,
    ARLOCKsi2mi3  ,
    ARCACHEsi2mi3 ,
    ARPROTsi2mi3  ,
    
    //For Master interface slave Number = 4
    //Read address channel
    ARIDsi2mi4    ,
    ARADDRsi2mi4  ,
    ARLENsi2mi4   ,
    ARSIZEsi2mi4  ,
    ARBURSTsi2mi4 ,
    ARLOCKsi2mi4  ,
    ARCACHEsi2mi4 ,
    ARPROTsi2mi4  ,

//Default Slave Number = 5    
    //For Master interface slave Number = 5
    //Read address channel
    ARIDsi2mi5    ,
    ARADDRsi2mi5  ,
    ARLENsi2mi5   ,
    ARSIZEsi2mi5  ,
    ARBURSTsi2mi5 ,
    ARLOCKsi2mi5  ,
    ARCACHEsi2mi5 ,
    ARPROTsi2mi5  ,
////////////////////////////

    ARVALIDsi2mi ,
    ARREADYmi2si ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    
    //Slave0
    //Read data channel
    //____________________________________
    RIDmi02si     ,
    RRESPmi02si   ,
    RDATAmi02si   ,

    
    //Slave3
    //Read data channel
    //____________________________________
    RIDmi32si     ,
    RRESPmi32si   ,
    RDATAmi32si   ,

    
    //Slave4
    //Read data channel
    //____________________________________
    RIDmi42si     ,
    RRESPmi42si   ,
    RDATAmi42si   ,


//Default Slave Number = 5    
    //Slave5
    //Read data channel
    //____________________________________
    RIDmi52si     ,
    RRESPmi52si   ,
    RDATAmi52si   ,

////////////////////////////

    RVALIDmi2si  ,
    RREADYsi2mi  ,
    RLASTmi2si
);

parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 2;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 2;
parameter SELMASTER_WID= 1;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 5;
parameter RdPermit_SLAVECNTWID= 5;
parameter ARSIZE_WID= 3;

    input   ACLK;
    input   ARESETn;

    //Read Address channel
    input   [ADDR_WID-1:0]     ARADDRm2si;
    input   [ARLEN_WID-1:0]    ARLENm2si;
    input   [ARSIZE_WID-1:0]   ARSIZEm2si;  
    input   [ARBURST_WID-1:0]  ARBURSTm2si; 
//ENABLE_ID
    input   [MASTERID_WID-1:0] ARIDm2si;    
//ENABLE_LOCK
    input   [ARLOCK_WID-1:0]   ARLOCKm2si;  
//ENABLE_CACHE
    input   [ARCACHE_WID-1:0]  ARCACHEm2si; 
//ENABLE_PROT
    input   [ARPROT_WID-1:0]   ARPROTm2si;  

    input   ARVALIDm2si; 
    output  ARREADYsi2m; 

    //Read data channel
//ENABLE_ID
    output   [MASTERID_WID-1:0]RIDsi2m;     
    output   [RRESP_WID-1:0]   RRESPsi2m;   
    output   [BUS_WID-1:0]     RDATAsi2m;
    output   RVALIDsi2m;  
    input    RREADYm2si;  
    output   RLASTsi2m;   

    //For Master interface SlaveNum = 0
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi0;    
    output  [ADDR_WID-1:0] ARADDRsi2mi0;  
    output  [ARLEN_WID-1:0] ARLENsi2mi0;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi0;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi0; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi0;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi0; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi0;  

    //For Master interface SlaveNum = 3
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi3;    
    output  [ADDR_WID-1:0] ARADDRsi2mi3;  
    output  [ARLEN_WID-1:0] ARLENsi2mi3;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi3;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi3; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi3;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi3; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi3;  

    //For Master interface SlaveNum = 4
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi4;    
    output  [ADDR_WID-1:0] ARADDRsi2mi4;  
    output  [ARLEN_WID-1:0] ARLENsi2mi4;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi4;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi4; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi4;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi4; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi4;  


//Default Slave Number = 5    //For Master interface SlaveNum = 5
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi5;    
    output  [ADDR_WID-1:0] ARADDRsi2mi5;  
    output  [ARLEN_WID-1:0] ARLENsi2mi5;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi5;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi5; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi5;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi5; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi5;  

////////////////////////////

    output  [SLAVE_NUM-1:0]ARVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]ARREADYmi2si; 

    //From SI(slave interface)
    
    //Slave0
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi02si;     
    input   [RRESP_WID-1:0] RRESPmi02si;   
    input   [BUS_WID-1:0]   RDATAmi02si;

    
    //Slave3
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi32si;     
    input   [RRESP_WID-1:0] RRESPmi32si;   
    input   [BUS_WID-1:0]   RDATAmi32si;

    
    //Slave4
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi42si;     
    input   [RRESP_WID-1:0] RRESPmi42si;   
    input   [BUS_WID-1:0]   RDATAmi42si;


//Default Slave Number = 5    
    //Slave5
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi52si;     
    input   [RRESP_WID-1:0] RRESPmi52si;   
    input   [BUS_WID-1:0]   RDATAmi52si;

////////////////////////////

    input   [SLAVE_NUM-1:0] RVALIDmi2si;  
    input   [SLAVE_NUM-1:0] RLASTmi2si;  
    output  [SLAVE_NUM-1:0] RREADYsi2mi;    


    wire [SLAVE_WID :0] CtlData2writech;

    //SLAVE 0
    assign  ARIDsi2mi0 = ARIDm2si;    
    assign  ARADDRsi2mi0 = ARADDRm2si;  
    assign  ARLENsi2mi0 = ARLENm2si;   
    assign  ARSIZEsi2mi0 = ARSIZEm2si;  
    assign  ARBURSTsi2mi0 = ARBURSTm2si; 
    assign  ARLOCKsi2mi0 = ARLOCKm2si;  
    assign  ARCACHEsi2mi0 = ARCACHEm2si; 
    assign  ARPROTsi2mi0 = ARPROTm2si;  

    //SLAVE 3
    assign  ARIDsi2mi3 = ARIDm2si;    
    assign  ARADDRsi2mi3 = ARADDRm2si;  
    assign  ARLENsi2mi3 = ARLENm2si;   
    assign  ARSIZEsi2mi3 = ARSIZEm2si;  
    assign  ARBURSTsi2mi3 = ARBURSTm2si; 
    assign  ARLOCKsi2mi3 = ARLOCKm2si;  
    assign  ARCACHEsi2mi3 = ARCACHEm2si; 
    assign  ARPROTsi2mi3 = ARPROTm2si;  

    //SLAVE 4
    assign  ARIDsi2mi4 = ARIDm2si;    
    assign  ARADDRsi2mi4 = ARADDRm2si;  
    assign  ARLENsi2mi4 = ARLENm2si;   
    assign  ARSIZEsi2mi4 = ARSIZEm2si;  
    assign  ARBURSTsi2mi4 = ARBURSTm2si; 
    assign  ARLOCKsi2mi4 = ARLOCKm2si;  
    assign  ARCACHEsi2mi4 = ARCACHEm2si; 
    assign  ARPROTsi2mi4 = ARPROTm2si;  

    //SLAVE 5
    assign  ARIDsi2mi5 = ARIDm2si;    
    assign  ARADDRsi2mi5 = ARADDRm2si;  
    assign  ARLENsi2mi5 = ARLENm2si;   
    assign  ARSIZEsi2mi5 = ARSIZEm2si;  
    assign  ARBURSTsi2mi5 = ARBURSTm2si; 
    assign  ARLOCKsi2mi5 = ARLOCKm2si;  
    assign  ARCACHEsi2mi5 = ARCACHEm2si; 
    assign  ARPROTsi2mi5 = ARPROTm2si;  



//Read address channel
//____________________________________________________________________

//ARVALID MUX 
reg [SLAVE_NUM-1:0]ARVALIDsi2mi; 

//MUX TYPE 00 was Generated 
always @(CtlData2writech  or 
         ARVALIDm2si  )
begin

    if(CtlData2writech [SLAVE_WID]) //MUX enalbe bit
    begin
        case(CtlData2writech [SLAVE_WID-1:0])
        //synopsys parallel_case full_case
            3'd0:   
            begin
                 ARVALIDsi2mi[0] <= ARVALIDm2si ;
                 ARVALIDsi2mi[3] <= 1'b0;
                 ARVALIDsi2mi[4] <= 1'b0;
                 ARVALIDsi2mi[5] <= 1'b0;
            end
            3'd3:   
            begin
                 ARVALIDsi2mi[0] <= 1'b0;
                 ARVALIDsi2mi[3] <= ARVALIDm2si ;
                 ARVALIDsi2mi[4] <= 1'b0;
                 ARVALIDsi2mi[5] <= 1'b0;
            end
            3'd4:   
            begin
                 ARVALIDsi2mi[0] <= 1'b0;
                 ARVALIDsi2mi[3] <= 1'b0;
                 ARVALIDsi2mi[4] <= ARVALIDm2si ;
                 ARVALIDsi2mi[5] <= 1'b0;
            end
            default:
            begin
                ARVALIDsi2mi[0] <= 1'b0;
                ARVALIDsi2mi[3] <= 1'b0;
                ARVALIDsi2mi[4] <= 1'b0;
                ARVALIDsi2mi[5] <= ARVALIDm2si ;
            end
        endcase
    end
    else
    begin
        ARVALIDsi2mi[0] <= 1'b0;
        ARVALIDsi2mi[3] <= 1'b0;
        ARVALIDsi2mi[4] <= 1'b0;
        ARVALIDsi2mi[5] <= 1'b0;
    end
end


reg ARREADYsi2m;

//ARREADY Demux
always @(CtlData2writech or ARREADYmi2si)
begin
    if(CtlData2writech[SLAVE_WID])
    begin
        case(CtlData2writech[SLAVE_WID-1:0])
        // synopsys parallel_case full_case
            3'd0:   ARREADYsi2m <= ARREADYmi2si[0]; 
            3'd3:   ARREADYsi2m <= ARREADYmi2si[3]; 
            3'd4:   ARREADYsi2m <= ARREADYmi2si[4]; 
            3'd5:   ARREADYsi2m <= ARREADYmi2si[5]; 
            default:
                ARREADYsi2m <= 1'b0;
        endcase
    end
    else
        ARREADYsi2m <= 1'b0;
end

reg [SLAVE_WID-1:0] SlaveNum;

//ADDRESS Decoder
//____________________________________________________________________

//Slave Number 0
wire Slave0MAXEn = (ARADDRm2si >= 32'h40000000) ? 1'b1:1'b0;
wire Slave0MINEn = (32'h80000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave0En = Slave0MAXEn & Slave0MINEn;

//Slave Number 3
wire Slave3MAXEn = (ARADDRm2si >= 32'h0) ? 1'b1:1'b0;
wire Slave3MINEn = (32'h10000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave3En = Slave3MAXEn & Slave3MINEn;

//Slave Number 4
wire Slave4MAXEn = (ARADDRm2si >= 32'h10000000) ? 1'b1:1'b0;
wire Slave4MINEn = (32'h20000000 >  ARADDRm2si)  ? 1'b1:1'b0;
wire Slave4En = Slave4MAXEn & Slave4MINEn;


wire Slave5En = 
                !Slave0En &
                !Slave3En &
                !Slave4En ;

always @(
         Slave0En or
         Slave3En or
         Slave4En or
         Slave5En  
        )
begin
    case(1'b1)
        Slave0En:   SlaveNum <= 3'd0;
        Slave3En:   SlaveNum <= 3'd3;
        Slave4En:   SlaveNum <= 3'd4;
        Slave5En:   SlaveNum <= 3'd5;
        default:   SlaveNum <= {3{1'd0}};
    endcase
end

//STATE_END

//____________________________________________________________________

//Read data channel
//____________________________________________________________________

reg   [MASTERID_WID-1:0]RIDsi2m;     
reg   [RRESP_WID-1:0]   RRESPsi2m;   
reg   RVALIDsi2m;  
reg   RLASTsi2m;
reg   [SLAVE_NUM-1:0]   RREADYsi2mi;    
reg   [BUS_WID-1:0]     RDATAsi2m;

//Data Arbiter
reg   [SLAVE_WID-1:0] CtlData2readch; 

//Response Arbiter
//Arbiter was Generated TYPE00
reg   EnArbiter;

always @(
         RVALIDmi2si or
         CtlData2readch
        )
begin
    case(CtlData2readch)
        //synopsys parallel_case full_case
        3'd0:    EnArbiter <= RVALIDmi2si[0];
        3'd3:    EnArbiter <= RVALIDmi2si[3];
        3'd4:    EnArbiter <= RVALIDmi2si[4];
        3'd5:    EnArbiter <= RVALIDmi2si[5];
        default: EnArbiter <= 1'b0;
    endcase
end

always  @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        CtlData2readch <= 0;
    end
    else if(!EnArbiter)
    begin
          if(RVALIDmi2si[0]) CtlData2readch <= 3'd0;
          else if(RVALIDmi2si[3]) CtlData2readch <= 3'd3;
          else if(RVALIDmi2si[4]) CtlData2readch <= 3'd4;
          else if(RVALIDmi2si[5]) CtlData2readch <= 3'd5;
    end
end



//MUX TYPE 01 was Generated 
always @(CtlData2readch[SLAVE_WID-1:0]  or 
         RREADYm2si  )
begin

   case(CtlData2readch[SLAVE_WID-1:0] )
   //synopsys parallel_case full_case
        3'd0:   
            begin
                 RREADYsi2mi[0] <= RREADYm2si ;
                 RREADYsi2mi[3] <= 1'b0;
                 RREADYsi2mi[4] <= 1'b0;
                 RREADYsi2mi[5] <= 1'b0;
            end
        3'd3:   
            begin
                 RREADYsi2mi[0] <= 1'b0;
                 RREADYsi2mi[3] <= RREADYm2si ;
                 RREADYsi2mi[4] <= 1'b0;
                 RREADYsi2mi[5] <= 1'b0;
            end
        3'd4:   
            begin
                 RREADYsi2mi[0] <= 1'b0;
                 RREADYsi2mi[3] <= 1'b0;
                 RREADYsi2mi[4] <= RREADYm2si ;
                 RREADYsi2mi[5] <= 1'b0;
            end
         default:
            begin
                RREADYsi2mi[0] <= 1'b0;
                RREADYsi2mi[3] <= 1'b0;
                RREADYsi2mi[4] <= 1'b0;
                RREADYsi2mi[5] <= RREADYm2si ;
            end
   endcase
end


    always @(//1
             RRESPmi02si or    
             RRESPmi32si or    
             RRESPmi42si or    
             RRESPmi52si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            3'd0:   RRESPsi2m  <= RRESPmi02si;
            3'd3:   RRESPsi2m  <= RRESPmi32si;
            3'd4:   RRESPsi2m  <= RRESPmi42si;
            3'd5:   RRESPsi2m  <= RRESPmi52si;
            default:     RRESPsi2m  <= 0;
        endcase
    end


    always @(//2
             RIDmi02si or    
             RIDmi32si or    
             RIDmi42si or    
             RIDmi52si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            3'd0:   RIDsi2m  <= RIDmi02si;
            3'd3:   RIDsi2m  <= RIDmi32si;
            3'd4:   RIDsi2m  <= RIDmi42si;
            3'd5:   RIDsi2m  <= RIDmi52si;
            default:     RIDsi2m  <= 0;
        endcase
    end


    always @(//3
             RDATAmi02si or    
             RDATAmi32si or    
             RDATAmi42si or    
             RDATAmi52si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            3'd0:   RDATAsi2m  <= RDATAmi02si;
            3'd3:   RDATAsi2m  <= RDATAmi32si;
            3'd4:   RDATAsi2m  <= RDATAmi42si;
            3'd5:   RDATAsi2m  <= RDATAmi52si;
            default:     RDATAsi2m  <= 0;
        endcase
    end


    always @(//4
             RVALIDmi2si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            3'd0:   RVALIDsi2m  <= RVALIDmi2si[0];
            3'd3:   RVALIDsi2m  <= RVALIDmi2si[3];
            3'd4:   RVALIDsi2m  <= RVALIDmi2si[4];
            3'd5:   RVALIDsi2m  <= RVALIDmi2si[5];
            default:     RVALIDsi2m  <= 0;
        endcase
    end


    always @(//5
             RLASTmi2si or    
             CtlData2readch
            )
    begin
        case(CtlData2readch[SLAVE_WID-1:0])
            // synopsys parallel_case full_case
            3'd0:   RLASTsi2m  <= RLASTmi2si[0];
            3'd3:   RLASTsi2m  <= RLASTmi2si[3];
            3'd4:   RLASTsi2m  <= RLASTmi2si[4];
            3'd5:   RLASTsi2m  <= RLASTmi2si[5];
            default:     RLASTsi2m  <= 0;
        endcase
    end

RDCH_VideoEnC_PermitCtl 
    U1PermitCtl(

    .ACLK       (ACLK)      ,
    .ARESETn    (ARESETn)   ,
    .SlaveNum   (SlaveNum)  ,

    .SID        (ARIDm2si),
    .AREADY     (ARREADYsi2m),
    .AVALID     (ARVALIDm2si),    

    .WID        ({MASTERID_WID{1'b0}}),
    .WREADY     (1'b0),
    .WVALID     (1'b0),
    .WLAST      (1'b0),

    .LID        (RIDsi2m),
    .LAST       (RLASTsi2m),
    .READY      (RREADYm2si),
    .RVALID     (RVALIDsi2m),

    .CtlData2datach  (),
    .CtlData2writech (CtlData2writech)

    );
   
endmodule
//Code_END
