// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelmi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel Master Interface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  ARM_RS_ReadChannelsi(

    //Global signal
    ACLK    ,
    ARESETn ,

    //Read address channel
    ARADDRm2si  ,
    ARLENm2si   ,
    ARSIZEm2si  ,
    ARBURSTm2si ,
    ARLOCKm2si  ,
    ARVALIDm2si ,
    ARREADYsi2m ,

    //Read data channel
    RRESPsi2m   ,
    RVALIDsi2m  ,
    RDATAsi2m   ,
    RREADYm2si  ,
    RLASTsi2m   ,

    
    //For Master interface slave Number = 0
    //Read address channel
    ARIDsi2mi0    ,
    ARADDRsi2mi0  ,
    ARLENsi2mi0   ,
    ARSIZEsi2mi0  ,
    ARBURSTsi2mi0 ,
    ARLOCKsi2mi0  ,
    ARCACHEsi2mi0 ,
    ARPROTsi2mi0  ,
    
    //For Master interface slave Number = 1
    //Read address channel
    ARIDsi2mi1    ,
    ARADDRsi2mi1  ,
    ARLENsi2mi1   ,
    ARSIZEsi2mi1  ,
    ARBURSTsi2mi1 ,
    ARLOCKsi2mi1  ,
    ARCACHEsi2mi1 ,
    ARPROTsi2mi1  ,
    
    //For Master interface slave Number = 2
    //Read address channel
    ARIDsi2mi2    ,
    ARADDRsi2mi2  ,
    ARLENsi2mi2   ,
    ARSIZEsi2mi2  ,
    ARBURSTsi2mi2 ,
    ARLOCKsi2mi2  ,
    ARCACHEsi2mi2 ,
    ARPROTsi2mi2  ,
    
    //For Master interface slave Number = 3
    //Read address channel
    ARIDsi2mi3    ,
    ARADDRsi2mi3  ,
    ARLENsi2mi3   ,
    ARSIZEsi2mi3  ,
    ARBURSTsi2mi3 ,
    ARLOCKsi2mi3  ,
    ARCACHEsi2mi3 ,
    ARPROTsi2mi3  ,
    
    //For Master interface slave Number = 4
    //Read address channel
    ARIDsi2mi4    ,
    ARADDRsi2mi4  ,
    ARLENsi2mi4   ,
    ARSIZEsi2mi4  ,
    ARBURSTsi2mi4 ,
    ARLOCKsi2mi4  ,
    ARCACHEsi2mi4 ,
    ARPROTsi2mi4  ,

//Default Slave Number = 5    
    //For Master interface slave Number = 5
    //Read address channel
    ARIDsi2mi5    ,
    ARADDRsi2mi5  ,
    ARLENsi2mi5   ,
    ARSIZEsi2mi5  ,
    ARBURSTsi2mi5 ,
    ARLOCKsi2mi5  ,
    ARCACHEsi2mi5 ,
    ARPROTsi2mi5  ,
////////////////////////////

    ARVALIDsi2mi ,
    ARREADYmi2si ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    
    //Slave0
    //Read data channel
    //____________________________________
    RIDmi02si     ,
    RRESPmi02si   ,
    RDATAmi02si   ,

    
    //Slave1
    //Read data channel
    //____________________________________
    RIDmi12si     ,
    RRESPmi12si   ,
    RDATAmi12si   ,

    
    //Slave2
    //Read data channel
    //____________________________________
    RIDmi22si     ,
    RRESPmi22si   ,
    RDATAmi22si   ,

    
    //Slave3
    //Read data channel
    //____________________________________
    RIDmi32si     ,
    RRESPmi32si   ,
    RDATAmi32si   ,

    
    //Slave4
    //Read data channel
    //____________________________________
    RIDmi42si     ,
    RRESPmi42si   ,
    RDATAmi42si   ,


//Default Slave Number = 5    
    //Slave5
    //Read data channel
    //____________________________________
    RIDmi52si     ,
    RRESPmi52si   ,
    RDATAmi52si   ,

////////////////////////////

    RVALIDmi2si  ,
    RREADYsi2mi  ,
    RLASTmi2si
);

parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 2;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 2;
parameter SELMASTER_WID= 1;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;

    input   ACLK;
    input   ARESETn;

    //Read Address channel
    input   [ADDR_WID-1:0]     ARADDRm2si;
    input   [ARLEN_WID-1:0]    ARLENm2si;
    input   [ARSIZE_WID-1:0]   ARSIZEm2si;  
    input   [ARBURST_WID-1:0]  ARBURSTm2si; 
    wire   [MASTERID_WID-1:0] ARIDm2si = 1'b0;
    input   [ARLOCK_WID-1:0]   ARLOCKm2si;  
    input   ARVALIDm2si; 
    output  ARREADYsi2m; 

    //Read data channel
     wire    [MASTERID_WID-1:0] RIDsi2m;
    output   [RRESP_WID-1:0]   RRESPsi2m;   
    output   [BUS_WID-1:0]     RDATAsi2m;
    output   RVALIDsi2m;  
    input    RREADYm2si;  
    output   RLASTsi2m;   

    //For Master interface SlaveNum = 0
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi0;    
    output  [ADDR_WID-1:0] ARADDRsi2mi0;  
    output  [ARLEN_WID-1:0] ARLENsi2mi0;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi0;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi0; 
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi0;  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi0; 
    assign  ARCACHEsi2mi0 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi0;  
    assign  ARPROTsi2mi0 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 1
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi1;    
    output  [ADDR_WID-1:0] ARADDRsi2mi1;  
    output  [ARLEN_WID-1:0] ARLENsi2mi1;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi1;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi1; 
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi1;  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi1; 
    assign  ARCACHEsi2mi1 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi1;  
    assign  ARPROTsi2mi1 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 2
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi2;    
    output  [ADDR_WID-1:0] ARADDRsi2mi2;  
    output  [ARLEN_WID-1:0] ARLENsi2mi2;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi2;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi2; 
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi2;  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi2; 
    assign  ARCACHEsi2mi2 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi2;  
    assign  ARPROTsi2mi2 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 3
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi3;    
    output  [ADDR_WID-1:0] ARADDRsi2mi3;  
    output  [ARLEN_WID-1:0] ARLENsi2mi3;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi3;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi3; 
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi3;  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi3; 
    assign  ARCACHEsi2mi3 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi3;  
    assign  ARPROTsi2mi3 = {ARPROT_WID{1'b0}};  

    //For Master interface SlaveNum = 4
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi4;    
    output  [ADDR_WID-1:0] ARADDRsi2mi4;  
    output  [ARLEN_WID-1:0] ARLENsi2mi4;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi4;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi4; 
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi4;  
//Disable_CachePortReadChannel(master)
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi4; 
    assign  ARCACHEsi2mi4 = {ARCACHE_WID{1'b0}};  
//Disable_ProtectPortReadChannel(master)
    output  [ARPROT_WID-1:0] ARPROTsi2mi4;  
    assign  ARPROTsi2mi4 = {ARPROT_WID{1'b0}};  


//Default Slave Number = 5    //For Master interface SlaveNum = 5
    //Write address channel
    output  [MASTERID_WID-1:0] ARIDsi2mi5;    
    output  [ADDR_WID-1:0] ARADDRsi2mi5;  
    output  [ARLEN_WID-1:0] ARLENsi2mi5;   
    output  [ARSIZE_WID-1:0] ARSIZEsi2mi5;  
    output  [ARBURST_WID-1:0] ARBURSTsi2mi5; 
//ENABLE_LOCK_ReadOutput
    output  [ARLOCK_WID-1:0] ARLOCKsi2mi5;  
//ENABLE_CACHE_ReadOutput
    output  [ARCACHE_WID-1:0] ARCACHEsi2mi5; 
//ENABLE_PROT_ReadOutput
    output  [ARPROT_WID-1:0] ARPROTsi2mi5;  

////////////////////////////

    output  [SLAVE_NUM-1:0]ARVALIDsi2mi; 
    input   [SLAVE_NUM-1:0]ARREADYmi2si; 

    //From SI(slave interface)
    
    //Slave0
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi02si;     
    input   [RRESP_WID-1:0] RRESPmi02si;   
    input   [BUS_WID-1:0]   RDATAmi02si;

    
    //Slave1
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi12si;     
    input   [RRESP_WID-1:0] RRESPmi12si;   
    input   [BUS_WID-1:0]   RDATAmi12si;

    
    //Slave2
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi22si;     
    input   [RRESP_WID-1:0] RRESPmi22si;   
    input   [BUS_WID-1:0]   RDATAmi22si;

    
    //Slave3
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi32si;     
    input   [RRESP_WID-1:0] RRESPmi32si;   
    input   [BUS_WID-1:0]   RDATAmi32si;

    
    //Slave4
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi42si;     
    input   [RRESP_WID-1:0] RRESPmi42si;   
    input   [BUS_WID-1:0]   RDATAmi42si;


//Default Slave Number = 5    
    //Slave5
    //__________________________________________________
    input   [MASTERID_WID-1:0]    RIDmi52si;     
    input   [RRESP_WID-1:0] RRESPmi52si;   
    input   [BUS_WID-1:0]   RDATAmi52si;

////////////////////////////

    input   [SLAVE_NUM-1:0] RVALIDmi2si;  
    input   [SLAVE_NUM-1:0] RLASTmi2si;  
    output  [SLAVE_NUM-1:0] RREADYsi2mi;    

    
//_______________________________________RS Number = 0
//
    
    //for register slice
    wire   [MASTERID_WID-1:0] w0ARIDm2si;    
    wire   [ADDR_WID-1:0]     w0ARADDRm2si;
    wire   [ARLEN_WID-1:0]    w0ARLENm2si;
    wire   [ARSIZE_WID-1:0]   w0ARSIZEm2si;  
    wire   [ARBURST_WID-1:0]  w0ARBURSTm2si; 
    wire   [ARLOCK_WID-1:0]   w0ARLOCKm2si;  
    wire   [ARCACHE_WID-1:0]  w0ARCACHEm2si; 
    wire   [ARPROT_WID-1:0]   w0ARPROTm2si;  
    wire   w0ARVALIDm2si; 
    wire   w0ARREADYsi2m; 

    //Read data channel
    wire   [MASTERID_WID-1:0]w0RIDsi2m;     
    wire   [RRESP_WID-1:0]   w0RRESPsi2m;   
    wire   [BUS_WID-1:0]     w0RDATAsi2m;
    wire   w0RVALIDsi2m;  
    wire   w0RREADYm2si;  
    wire   w0RLASTsi2m;   



//Mater to Slave interface register slice 
//Number == 0
//_________________________________________

ARM_ARSIm2si_registered
ARM_0_ARSIm2si_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 
		.INFORMATION_S({ ARIDm2si, 
                         ARLENm2si, 
                         ARSIZEm2si,  
                         ARBURSTm2si, 
                         ARLOCKm2si,  
                         ARADDRm2si 
                        }),

		.VALID_S      ( ARVALIDm2si),
		.READY_S      ( ARREADYsi2m),

		.INFORMATION_R({w0ARIDm2si, 
                        w0ARLENm2si, 
                        w0ARSIZEm2si,  
                        w0ARBURSTm2si, 
                        w0ARLOCKm2si,  
                        w0ARADDRm2si 
                        }),

		.VALID_R      (w0ARVALIDm2si),
		.READY_R      (w0ARREADYsi2m)
);

//Read data channel
ARM_RDSIm2si_registered
ARM_0_RDSIm2si_registered
(
		.ACLK         (ACLK         ), 
		.ARESETn      (ARESETn      ), 

		.INFORMATION_R({ RIDsi2m, 
                         RRESPsi2m, 
                         RDATAsi2m, 
                         RLASTsi2m }),

		.VALID_R      ( RVALIDsi2m),
		.READY_R      ( RREADYm2si),

		.INFORMATION_S({w0RIDsi2m, 
                        w0RRESPsi2m, 
                        w0RDATAsi2m, 
                        w0RLASTsi2m }), 

		.VALID_S      (w0RVALIDsi2m),
		.READY_S      (w0RREADYm2si)
);

//////////////////////////////////////////////////



//////////////////////////////////////////////////





//Master module     
//__________________________________________________

ARM_ReadChannelsi
ARM_ReadChannelsi(



    //Read address channel
    .ARIDm2si    (1'b0),
    .ARADDRm2si  (w0ARADDRm2si  ),
    .ARLENm2si   (w0ARLENm2si   ),
    .ARSIZEm2si  (w0ARSIZEm2si  ),
    .ARBURSTm2si (w0ARBURSTm2si ),
    .ARLOCKm2si  (w0ARLOCKm2si  ),
    .ARCACHEm2si ({ARCACHE_WID{1'b0}}),
    .ARPROTm2si  ({ARPROT_WID{1'b0}}),

    .ARVALIDm2si (w0ARVALIDm2si ),
    .ARREADYsi2m (w0ARREADYsi2m ),

    //Read data channel
    .RIDsi2m     (w0RIDsi2m     ),
    .RRESPsi2m   (w0RRESPsi2m   ),
    .RVALIDsi2m  (w0RVALIDsi2m  ),
    .RDATAsi2m   (w0RDATAsi2m   ),
    .RREADYm2si  (w0RREADYm2si  ),
    .RLASTsi2m   (w0RLASTsi2m   ),

    .ARVALIDsi2mi ( ARVALIDsi2mi ),
    .ARREADYmi2si ( ARREADYmi2si ),
    .RVALIDmi2si  ( RVALIDmi2si  ),
    .RREADYsi2mi  ( RREADYsi2mi  ),
    .RLASTmi2si   ( RLASTmi2si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 0
    //Write address channel

    .ARIDsi2mi0    ( ARIDsi2mi0   ),
    .ARADDRsi2mi0  ( ARADDRsi2mi0 ),
    .ARLENsi2mi0   ( ARLENsi2mi0  ),
    .ARSIZEsi2mi0  ( ARSIZEsi2mi0 ),
    .ARBURSTsi2mi0 ( ARBURSTsi2mi0),
    .ARLOCKsi2mi0  ( ARLOCKsi2mi0 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi0 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi0  ( ),

    .RIDmi02si     ( RIDmi02si     ),
    .RRESPmi02si   ( RRESPmi02si   ),
    .RDATAmi02si   ( RDATAmi02si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 1
    //Write address channel

    .ARIDsi2mi1    ( ARIDsi2mi1   ),
    .ARADDRsi2mi1  ( ARADDRsi2mi1 ),
    .ARLENsi2mi1   ( ARLENsi2mi1  ),
    .ARSIZEsi2mi1  ( ARSIZEsi2mi1 ),
    .ARBURSTsi2mi1 ( ARBURSTsi2mi1),
    .ARLOCKsi2mi1  ( ARLOCKsi2mi1 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi1 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi1  ( ),

    .RIDmi12si     ( RIDmi12si     ),
    .RRESPmi12si   ( RRESPmi12si   ),
    .RDATAmi12si   ( RDATAmi12si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 2
    //Write address channel

    .ARIDsi2mi2    ( ARIDsi2mi2   ),
    .ARADDRsi2mi2  ( ARADDRsi2mi2 ),
    .ARLENsi2mi2   ( ARLENsi2mi2  ),
    .ARSIZEsi2mi2  ( ARSIZEsi2mi2 ),
    .ARBURSTsi2mi2 ( ARBURSTsi2mi2),
    .ARLOCKsi2mi2  ( ARLOCKsi2mi2 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi2 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi2  ( ),

    .RIDmi22si     ( RIDmi22si     ),
    .RRESPmi22si   ( RRESPmi22si   ),
    .RDATAmi22si   ( RDATAmi22si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 3
    //Write address channel

    .ARIDsi2mi3    ( ARIDsi2mi3   ),
    .ARADDRsi2mi3  ( ARADDRsi2mi3 ),
    .ARLENsi2mi3   ( ARLENsi2mi3  ),
    .ARSIZEsi2mi3  ( ARSIZEsi2mi3 ),
    .ARBURSTsi2mi3 ( ARBURSTsi2mi3),
    .ARLOCKsi2mi3  ( ARLOCKsi2mi3 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi3 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi3  ( ),

    .RIDmi32si     ( RIDmi32si     ),
    .RRESPmi32si   ( RRESPmi32si   ),
    .RDATAmi32si   ( RDATAmi32si   ),

    ///////////////////////////////////////////////
    //For Master interface  slave Number = 4
    //Write address channel

    .ARIDsi2mi4    ( ARIDsi2mi4   ),
    .ARADDRsi2mi4  ( ARADDRsi2mi4 ),
    .ARLENsi2mi4   ( ARLENsi2mi4  ),
    .ARSIZEsi2mi4  ( ARSIZEsi2mi4 ),
    .ARBURSTsi2mi4 ( ARBURSTsi2mi4),
    .ARLOCKsi2mi4  ( ARLOCKsi2mi4 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi4 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi4  ( ),

    .RIDmi42si     ( RIDmi42si     ),
    .RRESPmi42si   ( RRESPmi42si   ),
    .RDATAmi42si   ( RDATAmi42si   ),


//Default Slave Number = 5    ///////////////////////////////////////////////
    //For Master interface  slave Number = 5
    //Write address channel

    .ARIDsi2mi5    ( ARIDsi2mi5   ),
    .ARADDRsi2mi5  ( ARADDRsi2mi5 ),
    .ARLENsi2mi5   ( ARLENsi2mi5  ),
    .ARSIZEsi2mi5  ( ARSIZEsi2mi5 ),
    .ARBURSTsi2mi5 ( ARBURSTsi2mi5),
    .ARLOCKsi2mi5  ( ARLOCKsi2mi5 ),
//Disable_CachePortReadChannel(master)
    .ARCACHEsi2mi5 ( ),
//Disable_ProtectPortReadChannel(master)
    .ARPROTsi2mi5  ( ),

    .RIDmi52si     ( RIDmi52si     ),
    .RRESPmi52si   ( RRESPmi52si   ),
    .RDATAmi52si   ( RDATAmi52si   ),

////////////////////////////
    
    //Global signal
    .ACLK    (ACLK    ),
    .ARESETn (ARESETn )

);
endmodule
//STATE_END
