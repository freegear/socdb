// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelmi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel Master Interface Block
//                       
//  ----------------------------------------------------------------
//START
//notice :: don't modify this code
//Syn 253:: modify ELAB-292(senstivelist)

`timescale 1 ns/ 10ps
module  APB0_ReadChannelmi(
    
    //Global signal
    ACLK    ,
    ARESETn ,

    //For slave 
    //Read address channel
    ARIDmi2s    ,
    ARADDRmi2s  ,
    ARLENmi2s   ,
    ARSIZEmi2s  ,
    ARBURSTmi2s ,
//ENABLE_LOCK
    ARLOCKmi2s  ,
//ENABLE_CACHE
    ARCACHEmi2s ,
//ENABLE_PROT
    ARPROTmi2s  ,

    ARVALIDmi2s ,
    ARREADYs2mi ,

    //Read data channel
    RIDs2mi     ,
    RRESPs2mi   ,
    RDATAs2mi   ,
    RVALIDs2mi  ,
    RLASTs2mi   ,
    RREADYmi2s  ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    //Master0
    //Read address channel
    //____________________________________
    ARIDsi02mi    ,
    ARADDRsi02mi  ,
    ARLENsi02mi   ,
    ARSIZEsi02mi  ,
    ARBURSTsi02mi ,
    ARLOCKsi02mi  ,
    ARCACHEsi02mi ,
    ARPROTsi02mi  ,

////////////////////////////

    //Master 0/1/2/3 etc...
    ARVALIDsi2mi  ,
    ARREADYmi2si  ,

    //Read data channel
    RIDmi2si0     ,
    RRESPmi2si0   ,
    RDATAmi2si0   ,
////////////////////////////

    RVALIDmi2si  ,
    RLASTmi2si  ,
    RREADYsi2mi,

//LOCKSig_START
    //Lock control
    //____________________________________
    
    Lock2Rdmi,
    UnLock2Rdmi,
    Lock2Wrmi,
    UnLock2Wrmi,
    AWVALID,
    LockPort,
    ReadIntEmptyWrmi2Rdmi,
    DataCntEmptyRdmi2Wrmi,
    CtlDataRead2Lock
    
    //____________________________________
//LOCKSig_END

    );
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 1;
parameter SLAVEID_WID= 2;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 2;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 2;
parameter SELMASTER_WID= 1;
parameter Wr_REQDEPTH_WID= 1;
parameter Rd_REQDEPTH_WID= 1;
parameter WrPermit_SLAVECNTWID= 0;
parameter RdPermit_SLAVECNTWID= 0;
parameter ARSIZE_WID= 3;

    input   ACLK;
    input   ARESETn;

    // For slave 
    // 2s (Slave)
    output   [SLAVEID_WID-1:0]  ARIDmi2s;    
    output   [ADDR_WID-1:0]     ARADDRmi2s;
    output   [ARLEN_WID-1:0]    ARLENmi2s;
    output   [ARSIZE_WID-1:0]   ARSIZEmi2s;  
    output   [ARBURST_WID-1:0]  ARBURSTmi2s; 
//ENABLE_LOCK
    output   [ARLOCK_WID-1:0]   ARLOCKmi2s;  
//ENABLE_CACHE
    output   [ARCACHE_WID-1:0]  ARCACHEmi2s; 
//ENABLE_PROT
    output   [ARPROT_WID-1:0]   ARPROTmi2s;  

    output   ARVALIDmi2s; 
    input    ARREADYs2mi; 
    
    //Read data channel
    input   [SLAVEID_WID-1:0] RIDs2mi;     
    input   [RRESP_WID-1:0]   RRESPs2mi;   
    input   [BUS_WID-1:0]     RDATAs2mi;
    input   RLASTs2mi;
    input   RVALIDs2mi;  
    output  RREADYmi2s;  

    //From SI(slave interface)
    
    //Master0
    //__________________________________________________
    input   [MASTERID_WID-1:0]  ARIDsi02mi;    
    input   [ADDR_WID-1:0]     ARADDRsi02mi;
    input   [ARLEN_WID-1:0]    ARLENsi02mi;
    input   [ARSIZE_WID-1:0]   ARSIZEsi02mi;  
    input   [ARBURST_WID-1:0]  ARBURSTsi02mi; 
    input   [ARLOCK_WID-1:0]   ARLOCKsi02mi;  
    input   [ARCACHE_WID-1:0]  ARCACHEsi02mi; 
    input   [ARPROT_WID-1:0]   ARPROTsi02mi; 

////////////////////////////


    input   [MASTER_NUM-1:0]    ARVALIDsi2mi;
    output  [MASTER_NUM-1:0]    ARREADYmi2si;

    //Read data channel
    output   [MASTERID_WID-1:0] RIDmi2si0;     
    output   [RRESP_WID-1:0]    RRESPmi2si0;   
    output   [BUS_WID-1:0]      RDATAmi2si0;

////////////////////////////

    output   [MASTER_NUM-1:0]   RVALIDmi2si;  
    output   [MASTER_NUM-1:0]   RLASTmi2si;  
    input    [MASTER_NUM-1:0]   RREADYsi2mi;    
    

//LOCKSig_START
    //Lock signal
    input    Lock2Rdmi;
    input    UnLock2Rdmi;
    input    AWVALID;
    //2006-9-8-ID-WID-FIXED
    //input    [SELMASTER_WID-1:0]LockPort;
    input    [SELMASTER_WID:0]LockPort;
    input    ReadIntEmptyWrmi2Rdmi;

    //output   [MASTER_WID-1:0]CtlDataRead2Lock;
    output   [SELMASTER_WID-1:0]CtlDataRead2Lock;
    output   DataCntEmptyRdmi2Wrmi;

    output   Lock2Wrmi;
    output   UnLock2Wrmi;

    wire    DataCntEmptyRdmi2Wrmi;
    wire    EnARMUXn      ;
    wire    EnARREADYMUXn ;
    wire    [5:0]   LockArbiter   ;
//LOCKSig_END


    //Arbiter
    //_______________________________________________________________
    reg    [SELMASTER_WID-1:0] CtlData2RdchMux;
    wire   ReqFull;
    wire   [SELMASTER_WID-1:0]CtlDataRead2Lock = CtlData2RdchMux;

//Response Arbiter
//Arbiter was Generated 
//LockAccess support Aribiter TYPE01
reg   EnArbiter;

always @(
         ARVALIDsi2mi or
         CtlData2RdchMux
        )
begin
    case(CtlData2RdchMux)
        //synopsys parallel_case full_case
        1'd0:    EnArbiter <= ARVALIDsi2mi[0];
        default: EnArbiter <= 1'b0;
    endcase
end

always  @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        CtlData2RdchMux <= 0;
    end
    else if((LockArbiter[1] | LockArbiter[5]) & !LockPort[SELMASTER_WID]) // STATE --> FUll_MASK
    begin                                    // STATE --> VMASK
        CtlData2RdchMux <= LockPort[SELMASTER_WID-1:0];
    end
    else if(!EnArbiter && !ReqFull && LockArbiter[0])
    begin
          if(ARVALIDsi2mi[0]) CtlData2RdchMux <= 1'd0;
    end
end

    //_______________________________________________________________


    //_______________________________________________________________
    // Arbiter Mux to Lock control
    reg     ARVALID2s;
    reg     [ARLOCK_WID-1:0]   ARLOCK2s;

   //Syn :: modify ELAB-292(senstivelist)
    always @(ARVALIDsi2mi or 
             
             ARLOCKsi02mi or

             CtlData2RdchMux 
         )   
    begin
        case(CtlData2RdchMux)
            // synopsys parallel_case full_case
            1'd0: 
            begin
                ARVALID2s <= ARVALIDsi2mi[0]; 
                ARLOCK2s  <= ARLOCKsi02mi;
            end
        endcase
    end
    //________________________________________________________

    // ADDRESS Channel Mux Demux
    //_______________________________________________________________
    wire   [SLAVEID_WID-1:0]  ARIDmi2s;    
    reg    [ADDR_WID-1:0]     ARADDRmi2s;
    reg    [ARLEN_WID-1:0]    ARLENmi2s;
    reg    [ARSIZE_WID-1:0]   ARSIZEmi2s;  
    reg    [ARBURST_WID-1:0]  ARBURSTmi2s; 
    reg    [ARLOCK_WID-1:0]   ARLOCKmi2s;  
    reg    [ARCACHE_WID-1:0]  ARCACHEmi2s; 
    reg    [ARPROT_WID-1:0]   ARPROTmi2s;  

    reg    [MASTER_NUM-1:0]    ARREADYmi2si;
    reg    ARVALIDmi2s;     

//MUX TYPE 02 was Generated 
always @(CtlData2RdchMux  or 
         ARREADYs2mi   or
         EnARREADYMUXn
        )
begin

   case({EnARREADYMUXn, CtlData2RdchMux })
   //synopsys parallel_case full_case
        2'd0:   
            begin
                 ARREADYmi2si[0] <= ARREADYs2mi ;
            end
         default:
            begin
                ARREADYmi2si[0] <= 1'b0;
            end
   endcase
end

    always @(//0
             ARVALIDsi2mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARVALIDmi2s <= ARVALIDsi2mi[0]; 
            default:   
                    ARVALIDmi2s <= 1'b0; 
        endcase
    end

    always @(//1
             ARADDRsi02mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARADDRmi2s  <= ARADDRsi02mi;
            default:
                    ARADDRmi2s  <= 0;
        endcase
    end

    always @(//2
             ARLENsi02mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARLENmi2s  <= ARLENsi02mi;
            default:
                    ARLENmi2s  <= 0;
        endcase
    end

    always @(//3
             ARSIZEsi02mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARSIZEmi2s  <= ARSIZEsi02mi;
            default:
                    ARSIZEmi2s  <= 0;
        endcase
    end    

    always @(//4
             ARBURSTsi02mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARBURSTmi2s  <= ARBURSTsi02mi;
            default:
                    ARBURSTmi2s  <= 0;
        endcase
    end    

    always @(//5
             ARLOCKsi02mi or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARLOCKmi2s  <= ARLOCKsi02mi;
            default:
                    ARLOCKmi2s  <= 0;
        endcase
    end        

    always @(//6
             ARCACHEsi02mi    or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARCACHEmi2s  <= ARCACHEsi02mi;
            default:
                    ARCACHEmi2s  <= 0;
        endcase
    end        

    always @(//7
             ARPROTsi02mi    or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   ARPROTmi2s  <= ARPROTsi02mi;
            default:
                    ARPROTmi2s  <= 0;
        endcase
    end        



    reg     [MASTERID_WID-1:0]  regARIDmi2s;
    assign  ARIDmi2s = {regARIDmi2s, CtlData2RdchMux};

    always @(//8
             ARIDsi02mi    or    
             EnARMUXn or
             CtlData2RdchMux
            )
    begin
        case({EnARMUXn, CtlData2RdchMux})
            // synopsys parallel_case full_case
            2'd0:   regARIDmi2s  <= ARIDsi02mi;
            default:
                    regARIDmi2s  <= 0;
        endcase
    end        

    //_______________________________________________________________
        

    // Read data Channel Mux Demux
    //_______________________________________________________________
    

    reg   [MASTER_NUM-1:0]  RVALIDmi2si;  
    reg   [MASTER_NUM-1:0]  RLASTmi2si;  
    reg   RREADYmi2s; 

    //Number 0
    wire  [MASTERID_WID-1:0]RIDmi2si0;     
    wire  [RRESP_WID-1:0]   RRESPmi2si0;   
    wire  [BUS_WID-1:0]     RDATAmi2si0;

    assign  RIDmi2si0 = RIDs2mi[(SLAVEID_WID-1):SELMASTER_WID];    
    assign  RRESPmi2si0 = RRESPs2mi;
    assign  RDATAmi2si0 = RDATAs2mi;


    //0
    always  @( RIDs2mi[(SELMASTER_WID-1):0] or
               RREADYsi2mi 
             )
    begin
        case(RIDs2mi[(SELMASTER_WID-1):0])
            // synopsys parallel_case full_case
            2'd0:   RREADYmi2s <= RREADYsi2mi[0]; //0
            default:     RREADYmi2s <= 1'b0;
        endcase
    end

//1
//MUX TYPE 01 was Generated 
always @(RIDs2mi[(SELMASTER_WID-1):0]  or 
         RVALIDs2mi  )
begin

   case(RIDs2mi[(SELMASTER_WID-1):0] )
   //synopsys parallel_case full_case
        1'd0:   
            begin
                 RVALIDmi2si[0] <= RVALIDs2mi ;
            end
         default:
            begin
                RVALIDmi2si[0] <= 1'b0;
            end
   endcase
end

//2
//MUX TYPE 01 was Generated 
always @(RIDs2mi[(SELMASTER_WID-1):0]  or 
         RLASTs2mi  )
begin

   case(RIDs2mi[(SELMASTER_WID-1):0] )
   //synopsys parallel_case full_case
        1'd0:   
            begin
                 RLASTmi2si[0] <= RLASTs2mi ;
            end
         default:
            begin
                RLASTmi2si[0] <= 1'b0;
            end
   endcase
end

    //_______________________________________________________________
    

    //Request Counter block
    //_______________________________________________________________


    wire    ARREADY2ReqCnt = (EnARREADYMUXn == 1'b0) ? ARREADYs2mi:1'b0;
    APB0_ReqCnt U0ReqCnt(

    .ACLK(ACLK),
    .ARESETn(ARESETn),

    .ARVALID(ARVALIDmi2s),
    .ARREADY(ARREADY2ReqCnt),

    .RVALID(RVALIDs2mi),
    .RREADY(RREADYmi2s),
    .RLAST(RLASTs2mi),

    .DataCNTEmpty(DataCntEmptyRdmi2Wrmi),
    .DataCNTFull(ReqFull)
);

    //_______________________________________________________________


    //Locked access control block
    //_______________________________________________________________
    
    
APB0_LockCtlRdmi
U0LockCtlRdmi(

        .ACLK(ACLK),
        .ARESETn(ARESETn),

        .ReqIntEmpty(ReadIntEmptyWrmi2Rdmi),
        .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi2Wrmi),

        .ALOCK(ARLOCK2s),
        .AVALID(ARVALID2s),
        .OVALID(AWVALID),

        .LockPort(LockPort),

        .Lock_in(Lock2Rdmi),
        .UnLock_in(UnLock2Rdmi),

        .Lock_out(Lock2Wrmi),
        .UnLock_out(UnLock2Wrmi),

        .CtlData(CtlData2RdchMux),
        //WriteChannel mux CtlData2WrchMux
        //ReadChannel  mux CtlData2RdchMux

        .EnAMUXn(EnARMUXn),
        .EnAREADYMUXn(EnARREADYMUXn),
        .LockArbiter(LockArbiter)

        );
    //_______________________________________________________________

    
endmodule
//Code_END
