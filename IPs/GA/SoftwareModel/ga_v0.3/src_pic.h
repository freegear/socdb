/****************************************************

   Header of the Calc. source pixel position

   file name : src_pic.h
   created by gtlee
   data : 2006.9.27

   note :
         
   history :

****************************************************/

//==================================================
// global







#ifdef  __SRC_PIC__
//==================================================
// Local







#else 
//==================================================
// External






#endif
