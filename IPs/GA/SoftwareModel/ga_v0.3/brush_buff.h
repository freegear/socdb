/****************************************************

   header of brush pattern buffer and etc

   file name : brush_buff.h
   created by gtlee
   data : 2006.10.11

   note :
         
   history :

****************************************************/

//==================================================
// global







#ifdef  __BRUSH_BUFF__
//==================================================
// Local




#else 
//==================================================
// External






#endif
