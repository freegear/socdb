/****************************************************

   header of calc. destination picture

   file name : dst_pic.h
   created by gtlee
   data : 2006.9.29

   note :
         
   history :

****************************************************/


//==================================================
// global







#ifdef  __DST_PIC__
//==================================================
// Local







#else 
//==================================================
// External






#endif
