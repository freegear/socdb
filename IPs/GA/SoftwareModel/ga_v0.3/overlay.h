/****************************************************

   header of a overlay pixels

   file name : overlay.h
   created by gtlee
   data : 2006.10.20

   note : 
         
   history :

****************************************************/

//==================================================
// global























#ifdef    __OVERLAY__
//==================================================
// Local








#else // not __OVERLAY__
//==================================================
// External










#endif // __OVERLAY__

