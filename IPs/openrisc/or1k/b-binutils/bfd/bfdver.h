#define BFD_VERSION_DATE 20050612
#define BFD_VERSION 216010000
#define BFD_VERSION_STRING "2.16.1"
