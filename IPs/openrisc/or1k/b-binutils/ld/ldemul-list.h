/* This file is automatically generated.  DO NOT EDIT! */
extern ld_emulation_xfer_type ld_or32elf_emulation;

#define EMULATION_LIST \
  &ld_or32elf_emulation, \
  0
