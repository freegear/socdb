/* This file is machine generated.  Do not edit.  */
static const char *const srcdir = 
"../../gcc-3.4.4/gcc"
;
static const char *const lang_files[] = {
"../../gcc-3.4.4/gcc/c-lang.c", 
"../../gcc-3.4.4/gcc/c-parse.in", 
"../../gcc-3.4.4/gcc/c-tree.h", 
"../../gcc-3.4.4/gcc/c-decl.c", 
"../../gcc-3.4.4/gcc/c-common.c", 
"../../gcc-3.4.4/gcc/c-common.h", 
"../../gcc-3.4.4/gcc/c-pragma.c", 
"../../gcc-3.4.4/gcc/c-objc-common.c", 
NULL};
static const char *const langs_for_lang_files[] = {
"c", 
"c", 
"c", 
"c", 
"c", 
"c", 
"c", 
"c", 
NULL};
static const char *const all_files[] = {
"../../gcc-3.4.4/gcc/input.h", 
"../../gcc-3.4.4/gcc/coretypes.h", 
"../../gcc-3.4.4/gcc/cpplib.h", 
"auto-host.h", 
"../../gcc-3.4.4/gcc/../include/ansidecl.h", 
"../../gcc-3.4.4/gcc/config/or32/or32.h", 
"../../gcc-3.4.4/gcc/config/dbxelf.h", 
"../../gcc-3.4.4/gcc/config/elfos.h", 
"../../gcc-3.4.4/gcc/config/or32/or32.h", 
"../../gcc-3.4.4/gcc/config/or32/elf.h", 
"../../gcc-3.4.4/gcc/config/or32/linux-gas.h", 
"../../gcc-3.4.4/gcc/config/or32/linux-elf.h", 
"../../gcc-3.4.4/gcc/defaults.h", 
"../../gcc-3.4.4/gcc/../include/hashtab.h", 
"../../gcc-3.4.4/gcc/../include/splay-tree.h", 
"../../gcc-3.4.4/gcc/bitmap.h", 
"../../gcc-3.4.4/gcc/coverage.c", 
"../../gcc-3.4.4/gcc/function.h", 
"../../gcc-3.4.4/gcc/rtl.h", 
"../../gcc-3.4.4/gcc/optabs.h", 
"../../gcc-3.4.4/gcc/tree.h", 
"../../gcc-3.4.4/gcc/libfuncs.h", 
"../../gcc-3.4.4/gcc/hashtable.h", 
"../../gcc-3.4.4/gcc/real.h", 
"../../gcc-3.4.4/gcc/varray.h", 
"../../gcc-3.4.4/gcc/insn-addr.h", 
"../../gcc-3.4.4/gcc/cselib.h", 
"../../gcc-3.4.4/gcc/basic-block.h", 
"../../gcc-3.4.4/gcc/cgraph.h", 
"../../gcc-3.4.4/gcc/c-common.h", 
"../../gcc-3.4.4/gcc/c-tree.h", 
"../../gcc-3.4.4/gcc/alias.c", 
"../../gcc-3.4.4/gcc/bitmap.c", 
"../../gcc-3.4.4/gcc/cselib.c", 
"../../gcc-3.4.4/gcc/cgraph.c", 
"../../gcc-3.4.4/gcc/dbxout.c", 
"../../gcc-3.4.4/gcc/dwarf2out.c", 
"../../gcc-3.4.4/gcc/dwarf2asm.c", 
"../../gcc-3.4.4/gcc/dojump.c", 
"../../gcc-3.4.4/gcc/emit-rtl.c", 
"../../gcc-3.4.4/gcc/except.c", 
"../../gcc-3.4.4/gcc/explow.c", 
"../../gcc-3.4.4/gcc/expr.c", 
"../../gcc-3.4.4/gcc/fold-const.c", 
"../../gcc-3.4.4/gcc/function.c", 
"../../gcc-3.4.4/gcc/gcse.c", 
"../../gcc-3.4.4/gcc/integrate.c", 
"../../gcc-3.4.4/gcc/lists.c", 
"../../gcc-3.4.4/gcc/optabs.c", 
"../../gcc-3.4.4/gcc/profile.c", 
"../../gcc-3.4.4/gcc/ra-build.c", 
"../../gcc-3.4.4/gcc/regclass.c", 
"../../gcc-3.4.4/gcc/reg-stack.c", 
"../../gcc-3.4.4/gcc/cfglayout.c", 
"../../gcc-3.4.4/gcc/langhooks.c", 
"../../gcc-3.4.4/gcc/sdbout.c", 
"../../gcc-3.4.4/gcc/stmt.c", 
"../../gcc-3.4.4/gcc/stor-layout.c", 
"../../gcc-3.4.4/gcc/stringpool.c", 
"../../gcc-3.4.4/gcc/tree.c", 
"../../gcc-3.4.4/gcc/varasm.c", 
"../../gcc-3.4.4/gcc/config/or32/or32.c", 
"../../gcc-3.4.4/gcc/c-lang.c", 
"../../gcc-3.4.4/gcc/c-parse.in", 
"../../gcc-3.4.4/gcc/c-tree.h", 
"../../gcc-3.4.4/gcc/c-decl.c", 
"../../gcc-3.4.4/gcc/c-common.c", 
"../../gcc-3.4.4/gcc/c-common.h", 
"../../gcc-3.4.4/gcc/c-pragma.c", 
"../../gcc-3.4.4/gcc/c-objc-common.c", 
 NULL};
static const char *const lang_dir_names[] = { "c", 
NULL};
