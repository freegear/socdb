
	.global _environ
_environ:
	.word	0

