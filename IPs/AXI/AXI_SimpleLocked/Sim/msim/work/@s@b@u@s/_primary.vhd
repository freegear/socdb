library verilog;
use verilog.vl_types.all;
entity SBUS is
    generic(
        BUS_WID         : integer := 32;
        ADDR_WID        : integer := 32;
        ID_WID          : integer := 4;
        AWLEN_WID       : integer := 4;
        AWSIZE_WID      : integer := 3;
        AWBURST_WID     : integer := 2;
        AWLOCK_WID      : integer := 2;
        AWCACHE_WID     : integer := 4;
        AWPROT_WID      : integer := 3;
        WSTRB_WID       : integer := 4;
        BRESP_WID       : integer := 2;
        RRESP_WID       : integer := 2;
        ARLEN_WID       : integer := 4;
        ARSIZE_WID      : integer := 3;
        ARBURST_WID     : integer := 2;
        ARLOCK_WID      : integer := 2;
        ARCACHE_WID     : integer := 4;
        ARPROT_WID      : integer := 3;
        MASTER_WID      : integer := 4;
        SLAVE_WID       : integer := 3;
        SLAVE_NUM       : integer := 6;
        MASTER_NUM      : integer := 4;
        SLAVECNTWID     : integer := 5
    );
    port(
        ACLK            : in     vl_logic;
        ARESETn         : in     vl_logic;
        AWIDm02si0      : in     vl_logic_vector;
        AWADDRm02si0    : in     vl_logic_vector;
        AWLENm02si0     : in     vl_logic_vector;
        AWSIZEm02si0    : in     vl_logic_vector;
        AWBURSTm02si0   : in     vl_logic_vector;
        AWLOCKm02si0    : in     vl_logic_vector;
        AWCACHEm02si0   : in     vl_logic_vector;
        AWPROTm02si0    : in     vl_logic_vector;
        AWVALIDm02si0   : in     vl_logic;
        AWREADYsi02m0   : out    vl_logic;
        WIDm02si0       : in     vl_logic_vector;
        WDATAm02si0     : in     vl_logic_vector;
        WSTRBm02si0     : in     vl_logic_vector;
        WLASTm02si0     : in     vl_logic;
        WVALIDm02si0    : in     vl_logic;
        WREADYsi02m0    : out    vl_logic;
        BIDsi02m0       : out    vl_logic_vector;
        BRESPsi02m0     : out    vl_logic_vector;
        BVALIDsi02m0    : out    vl_logic;
        BREADYm02si0    : in     vl_logic;
        AWIDm12si1      : in     vl_logic_vector;
        AWADDRm12si1    : in     vl_logic_vector;
        AWLENm12si1     : in     vl_logic_vector;
        AWSIZEm12si1    : in     vl_logic_vector;
        AWBURSTm12si1   : in     vl_logic_vector;
        AWLOCKm12si1    : in     vl_logic_vector;
        AWCACHEm12si1   : in     vl_logic_vector;
        AWPROTm12si1    : in     vl_logic_vector;
        AWVALIDm12si1   : in     vl_logic;
        AWREADYsi12m1   : out    vl_logic;
        WIDm12si1       : in     vl_logic_vector;
        WDATAm12si1     : in     vl_logic_vector;
        WSTRBm12si1     : in     vl_logic_vector;
        WLASTm12si1     : in     vl_logic;
        WVALIDm12si1    : in     vl_logic;
        WREADYsi12m1    : out    vl_logic;
        BIDsi12m1       : out    vl_logic_vector;
        BRESPsi12m1     : out    vl_logic_vector;
        BVALIDsi12m1    : out    vl_logic;
        BREADYm12si1    : in     vl_logic;
        AWIDm22si2      : in     vl_logic_vector;
        AWADDRm22si2    : in     vl_logic_vector;
        AWLENm22si2     : in     vl_logic_vector;
        AWSIZEm22si2    : in     vl_logic_vector;
        AWBURSTm22si2   : in     vl_logic_vector;
        AWLOCKm22si2    : in     vl_logic_vector;
        AWCACHEm22si2   : in     vl_logic_vector;
        AWPROTm22si2    : in     vl_logic_vector;
        AWVALIDm22si2   : in     vl_logic;
        AWREADYsi22m2   : out    vl_logic;
        WIDm22si2       : in     vl_logic_vector;
        WDATAm22si2     : in     vl_logic_vector;
        WSTRBm22si2     : in     vl_logic_vector;
        WLASTm22si2     : in     vl_logic;
        WVALIDm22si2    : in     vl_logic;
        WREADYsi22m2    : out    vl_logic;
        BIDsi22m2       : out    vl_logic_vector;
        BRESPsi22m2     : out    vl_logic_vector;
        BVALIDsi22m2    : out    vl_logic;
        BREADYm22si2    : in     vl_logic;
        AWIDm32si3      : in     vl_logic_vector;
        AWADDRm32si3    : in     vl_logic_vector;
        AWLENm32si3     : in     vl_logic_vector;
        AWSIZEm32si3    : in     vl_logic_vector;
        AWBURSTm32si3   : in     vl_logic_vector;
        AWLOCKm32si3    : in     vl_logic_vector;
        AWCACHEm32si3   : in     vl_logic_vector;
        AWPROTm32si3    : in     vl_logic_vector;
        AWVALIDm32si3   : in     vl_logic;
        AWREADYsi32m3   : out    vl_logic;
        WIDm32si3       : in     vl_logic_vector;
        WDATAm32si3     : in     vl_logic_vector;
        WSTRBm32si3     : in     vl_logic_vector;
        WLASTm32si3     : in     vl_logic;
        WVALIDm32si3    : in     vl_logic;
        WREADYsi32m3    : out    vl_logic;
        BIDsi32m3       : out    vl_logic_vector;
        BRESPsi32m3     : out    vl_logic_vector;
        BVALIDsi32m3    : out    vl_logic;
        BREADYm32si3    : in     vl_logic;
        AWIDmi02s0      : out    vl_logic_vector;
        AWADDRmi02s0    : out    vl_logic_vector;
        AWLENmi02s0     : out    vl_logic_vector;
        AWSIZEmi02s0    : out    vl_logic_vector;
        AWBURSTmi02s0   : out    vl_logic_vector;
        AWLOCKmi02s0    : out    vl_logic_vector;
        AWCACHEmi02s0   : out    vl_logic_vector;
        AWPROTmi02s0    : out    vl_logic_vector;
        AWVALIDmi02s0   : out    vl_logic;
        AWREADYs02mi0   : in     vl_logic;
        WIDmi02s0       : out    vl_logic_vector;
        WDATAmi02s0     : out    vl_logic_vector;
        WSTRBmi02s0     : out    vl_logic_vector;
        WLASTmi02s0     : out    vl_logic;
        WVALIDmi02s0    : out    vl_logic;
        WREADYs02mi0    : in     vl_logic;
        BIDs02mi0       : in     vl_logic_vector;
        BRESPs02mi0     : in     vl_logic_vector;
        BVALIDs02mi0    : in     vl_logic;
        BREADYmi02s0    : out    vl_logic;
        AWIDmi12s1      : out    vl_logic_vector;
        AWADDRmi12s1    : out    vl_logic_vector;
        AWLENmi12s1     : out    vl_logic_vector;
        AWSIZEmi12s1    : out    vl_logic_vector;
        AWBURSTmi12s1   : out    vl_logic_vector;
        AWLOCKmi12s1    : out    vl_logic_vector;
        AWCACHEmi12s1   : out    vl_logic_vector;
        AWPROTmi12s1    : out    vl_logic_vector;
        AWVALIDmi12s1   : out    vl_logic;
        AWREADYs12mi1   : in     vl_logic;
        WIDmi12s1       : out    vl_logic_vector;
        WDATAmi12s1     : out    vl_logic_vector;
        WSTRBmi12s1     : out    vl_logic_vector;
        WLASTmi12s1     : out    vl_logic;
        WVALIDmi12s1    : out    vl_logic;
        WREADYs12mi1    : in     vl_logic;
        BIDs12mi1       : in     vl_logic_vector;
        BRESPs12mi1     : in     vl_logic_vector;
        BVALIDs12mi1    : in     vl_logic;
        BREADYmi12s1    : out    vl_logic;
        AWIDmi22s2      : out    vl_logic_vector;
        AWADDRmi22s2    : out    vl_logic_vector;
        AWLENmi22s2     : out    vl_logic_vector;
        AWSIZEmi22s2    : out    vl_logic_vector;
        AWBURSTmi22s2   : out    vl_logic_vector;
        AWLOCKmi22s2    : out    vl_logic_vector;
        AWCACHEmi22s2   : out    vl_logic_vector;
        AWPROTmi22s2    : out    vl_logic_vector;
        AWVALIDmi22s2   : out    vl_logic;
        AWREADYs22mi2   : in     vl_logic;
        WIDmi22s2       : out    vl_logic_vector;
        WDATAmi22s2     : out    vl_logic_vector;
        WSTRBmi22s2     : out    vl_logic_vector;
        WLASTmi22s2     : out    vl_logic;
        WVALIDmi22s2    : out    vl_logic;
        WREADYs22mi2    : in     vl_logic;
        BIDs22mi2       : in     vl_logic_vector;
        BRESPs22mi2     : in     vl_logic_vector;
        BVALIDs22mi2    : in     vl_logic;
        BREADYmi22s2    : out    vl_logic;
        AWIDmi32s3      : out    vl_logic_vector;
        AWADDRmi32s3    : out    vl_logic_vector;
        AWLENmi32s3     : out    vl_logic_vector;
        AWSIZEmi32s3    : out    vl_logic_vector;
        AWBURSTmi32s3   : out    vl_logic_vector;
        AWLOCKmi32s3    : out    vl_logic_vector;
        AWCACHEmi32s3   : out    vl_logic_vector;
        AWPROTmi32s3    : out    vl_logic_vector;
        AWVALIDmi32s3   : out    vl_logic;
        AWREADYs32mi3   : in     vl_logic;
        WIDmi32s3       : out    vl_logic_vector;
        WDATAmi32s3     : out    vl_logic_vector;
        WSTRBmi32s3     : out    vl_logic_vector;
        WLASTmi32s3     : out    vl_logic;
        WVALIDmi32s3    : out    vl_logic;
        WREADYs32mi3    : in     vl_logic;
        BIDs32mi3       : in     vl_logic_vector;
        BRESPs32mi3     : in     vl_logic_vector;
        BVALIDs32mi3    : in     vl_logic;
        BREADYmi32s3    : out    vl_logic;
        AWIDmi42s4      : out    vl_logic_vector;
        AWADDRmi42s4    : out    vl_logic_vector;
        AWLENmi42s4     : out    vl_logic_vector;
        AWSIZEmi42s4    : out    vl_logic_vector;
        AWBURSTmi42s4   : out    vl_logic_vector;
        AWLOCKmi42s4    : out    vl_logic_vector;
        AWCACHEmi42s4   : out    vl_logic_vector;
        AWPROTmi42s4    : out    vl_logic_vector;
        AWVALIDmi42s4   : out    vl_logic;
        AWREADYs42mi4   : in     vl_logic;
        WIDmi42s4       : out    vl_logic_vector;
        WDATAmi42s4     : out    vl_logic_vector;
        WSTRBmi42s4     : out    vl_logic_vector;
        WLASTmi42s4     : out    vl_logic;
        WVALIDmi42s4    : out    vl_logic;
        WREADYs42mi4    : in     vl_logic;
        BIDs42mi4       : in     vl_logic_vector;
        BRESPs42mi4     : in     vl_logic_vector;
        BVALIDs42mi4    : in     vl_logic;
        BREADYmi42s4    : out    vl_logic;
        AWIDmi52s5      : out    vl_logic_vector;
        AWADDRmi52s5    : out    vl_logic_vector;
        AWLENmi52s5     : out    vl_logic_vector;
        AWSIZEmi52s5    : out    vl_logic_vector;
        AWBURSTmi52s5   : out    vl_logic_vector;
        AWLOCKmi52s5    : out    vl_logic_vector;
        AWCACHEmi52s5   : out    vl_logic_vector;
        AWPROTmi52s5    : out    vl_logic_vector;
        AWVALIDmi52s5   : out    vl_logic;
        AWREADYs52mi5   : in     vl_logic;
        WIDmi52s5       : out    vl_logic_vector;
        WDATAmi52s5     : out    vl_logic_vector;
        WSTRBmi52s5     : out    vl_logic_vector;
        WLASTmi52s5     : out    vl_logic;
        WVALIDmi52s5    : out    vl_logic;
        WREADYs52mi5    : in     vl_logic;
        BIDs52mi5       : in     vl_logic_vector;
        BRESPs52mi5     : in     vl_logic_vector;
        BVALIDs52mi5    : in     vl_logic;
        BREADYmi52s5    : out    vl_logic;
        ARIDm02si0      : in     vl_logic_vector;
        ARADDRm02si0    : in     vl_logic_vector;
        ARLENm02si0     : in     vl_logic_vector;
        ARSIZEm02si0    : in     vl_logic_vector;
        ARBURSTm02si0   : in     vl_logic_vector;
        ARLOCKm02si0    : in     vl_logic_vector;
        ARCACHEm02si0   : in     vl_logic_vector;
        ARPROTm02si0    : in     vl_logic_vector;
        ARVALIDm02si0   : in     vl_logic;
        ARREADYsi02m0   : out    vl_logic;
        RIDsi02m0       : out    vl_logic_vector;
        RRESPsi02m0     : out    vl_logic_vector;
        RDATAsi02m0     : out    vl_logic_vector;
        RLASTsi02m0     : out    vl_logic;
        RVALIDsi02m0    : out    vl_logic;
        RREADYm02si0    : in     vl_logic;
        ARIDm12si1      : in     vl_logic_vector;
        ARADDRm12si1    : in     vl_logic_vector;
        ARLENm12si1     : in     vl_logic_vector;
        ARSIZEm12si1    : in     vl_logic_vector;
        ARBURSTm12si1   : in     vl_logic_vector;
        ARLOCKm12si1    : in     vl_logic_vector;
        ARCACHEm12si1   : in     vl_logic_vector;
        ARPROTm12si1    : in     vl_logic_vector;
        ARVALIDm12si1   : in     vl_logic;
        ARREADYsi12m1   : out    vl_logic;
        RIDsi12m1       : out    vl_logic_vector;
        RRESPsi12m1     : out    vl_logic_vector;
        RDATAsi12m1     : out    vl_logic_vector;
        RLASTsi12m1     : out    vl_logic;
        RVALIDsi12m1    : out    vl_logic;
        RREADYm12si1    : in     vl_logic;
        ARIDm22si2      : in     vl_logic_vector;
        ARADDRm22si2    : in     vl_logic_vector;
        ARLENm22si2     : in     vl_logic_vector;
        ARSIZEm22si2    : in     vl_logic_vector;
        ARBURSTm22si2   : in     vl_logic_vector;
        ARLOCKm22si2    : in     vl_logic_vector;
        ARCACHEm22si2   : in     vl_logic_vector;
        ARPROTm22si2    : in     vl_logic_vector;
        ARVALIDm22si2   : in     vl_logic;
        ARREADYsi22m2   : out    vl_logic;
        RIDsi22m2       : out    vl_logic_vector;
        RRESPsi22m2     : out    vl_logic_vector;
        RDATAsi22m2     : out    vl_logic_vector;
        RLASTsi22m2     : out    vl_logic;
        RVALIDsi22m2    : out    vl_logic;
        RREADYm22si2    : in     vl_logic;
        ARIDm32si3      : in     vl_logic_vector;
        ARADDRm32si3    : in     vl_logic_vector;
        ARLENm32si3     : in     vl_logic_vector;
        ARSIZEm32si3    : in     vl_logic_vector;
        ARBURSTm32si3   : in     vl_logic_vector;
        ARLOCKm32si3    : in     vl_logic_vector;
        ARCACHEm32si3   : in     vl_logic_vector;
        ARPROTm32si3    : in     vl_logic_vector;
        ARVALIDm32si3   : in     vl_logic;
        ARREADYsi32m3   : out    vl_logic;
        RIDsi32m3       : out    vl_logic_vector;
        RRESPsi32m3     : out    vl_logic_vector;
        RDATAsi32m3     : out    vl_logic_vector;
        RLASTsi32m3     : out    vl_logic;
        RVALIDsi32m3    : out    vl_logic;
        RREADYm32si3    : in     vl_logic;
        ARIDmi02s0      : out    vl_logic_vector;
        ARADDRmi02s0    : out    vl_logic_vector;
        ARLENmi02s0     : out    vl_logic_vector;
        ARSIZEmi02s0    : out    vl_logic_vector;
        ARBURSTmi02s0   : out    vl_logic_vector;
        ARLOCKmi02s0    : out    vl_logic_vector;
        ARCACHEmi02s0   : out    vl_logic_vector;
        ARPROTmi02s0    : out    vl_logic_vector;
        ARVALIDmi02s0   : out    vl_logic;
        ARREADYs02mi0   : in     vl_logic;
        RIDs02mi0       : in     vl_logic_vector;
        RRESPs02mi0     : in     vl_logic_vector;
        RDATAs02mi0     : in     vl_logic_vector;
        RLASTs02mi0     : in     vl_logic;
        RVALIDs02mi0    : in     vl_logic;
        RREADYmi02s0    : out    vl_logic;
        ARIDmi12s1      : out    vl_logic_vector;
        ARADDRmi12s1    : out    vl_logic_vector;
        ARLENmi12s1     : out    vl_logic_vector;
        ARSIZEmi12s1    : out    vl_logic_vector;
        ARBURSTmi12s1   : out    vl_logic_vector;
        ARLOCKmi12s1    : out    vl_logic_vector;
        ARCACHEmi12s1   : out    vl_logic_vector;
        ARPROTmi12s1    : out    vl_logic_vector;
        ARVALIDmi12s1   : out    vl_logic;
        ARREADYs12mi1   : in     vl_logic;
        RIDs12mi1       : in     vl_logic_vector;
        RRESPs12mi1     : in     vl_logic_vector;
        RDATAs12mi1     : in     vl_logic_vector;
        RLASTs12mi1     : in     vl_logic;
        RVALIDs12mi1    : in     vl_logic;
        RREADYmi12s1    : out    vl_logic;
        ARIDmi22s2      : out    vl_logic_vector;
        ARADDRmi22s2    : out    vl_logic_vector;
        ARLENmi22s2     : out    vl_logic_vector;
        ARSIZEmi22s2    : out    vl_logic_vector;
        ARBURSTmi22s2   : out    vl_logic_vector;
        ARLOCKmi22s2    : out    vl_logic_vector;
        ARCACHEmi22s2   : out    vl_logic_vector;
        ARPROTmi22s2    : out    vl_logic_vector;
        ARVALIDmi22s2   : out    vl_logic;
        ARREADYs22mi2   : in     vl_logic;
        RIDs22mi2       : in     vl_logic_vector;
        RRESPs22mi2     : in     vl_logic_vector;
        RDATAs22mi2     : in     vl_logic_vector;
        RLASTs22mi2     : in     vl_logic;
        RVALIDs22mi2    : in     vl_logic;
        RREADYmi22s2    : out    vl_logic;
        ARIDmi32s3      : out    vl_logic_vector;
        ARADDRmi32s3    : out    vl_logic_vector;
        ARLENmi32s3     : out    vl_logic_vector;
        ARSIZEmi32s3    : out    vl_logic_vector;
        ARBURSTmi32s3   : out    vl_logic_vector;
        ARLOCKmi32s3    : out    vl_logic_vector;
        ARCACHEmi32s3   : out    vl_logic_vector;
        ARPROTmi32s3    : out    vl_logic_vector;
        ARVALIDmi32s3   : out    vl_logic;
        ARREADYs32mi3   : in     vl_logic;
        RIDs32mi3       : in     vl_logic_vector;
        RRESPs32mi3     : in     vl_logic_vector;
        RDATAs32mi3     : in     vl_logic_vector;
        RLASTs32mi3     : in     vl_logic;
        RVALIDs32mi3    : in     vl_logic;
        RREADYmi32s3    : out    vl_logic;
        ARIDmi42s4      : out    vl_logic_vector;
        ARADDRmi42s4    : out    vl_logic_vector;
        ARLENmi42s4     : out    vl_logic_vector;
        ARSIZEmi42s4    : out    vl_logic_vector;
        ARBURSTmi42s4   : out    vl_logic_vector;
        ARLOCKmi42s4    : out    vl_logic_vector;
        ARCACHEmi42s4   : out    vl_logic_vector;
        ARPROTmi42s4    : out    vl_logic_vector;
        ARVALIDmi42s4   : out    vl_logic;
        ARREADYs42mi4   : in     vl_logic;
        RIDs42mi4       : in     vl_logic_vector;
        RRESPs42mi4     : in     vl_logic_vector;
        RDATAs42mi4     : in     vl_logic_vector;
        RLASTs42mi4     : in     vl_logic;
        RVALIDs42mi4    : in     vl_logic;
        RREADYmi42s4    : out    vl_logic;
        ARIDmi52s5      : out    vl_logic_vector;
        ARADDRmi52s5    : out    vl_logic_vector;
        ARLENmi52s5     : out    vl_logic_vector;
        ARSIZEmi52s5    : out    vl_logic_vector;
        ARBURSTmi52s5   : out    vl_logic_vector;
        ARLOCKmi52s5    : out    vl_logic_vector;
        ARCACHEmi52s5   : out    vl_logic_vector;
        ARPROTmi52s5    : out    vl_logic_vector;
        ARVALIDmi52s5   : out    vl_logic;
        ARREADYs52mi5   : in     vl_logic;
        RIDs52mi5       : in     vl_logic_vector;
        RRESPs52mi5     : in     vl_logic_vector;
        RDATAs52mi5     : in     vl_logic_vector;
        RLASTs52mi5     : in     vl_logic;
        RVALIDs52mi5    : in     vl_logic;
        RREADYmi52s5    : out    vl_logic
    );
end SBUS;
