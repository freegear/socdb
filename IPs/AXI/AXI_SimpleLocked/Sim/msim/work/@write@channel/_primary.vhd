library verilog;
use verilog.vl_types.all;
entity WriteChannel is
    generic(
        BUS_WID         : integer := 32;
        ADDR_WID        : integer := 32;
        ID_WID          : integer := 4;
        AWLEN_WID       : integer := 4;
        AWSIZE_WID      : integer := 3;
        AWBURST_WID     : integer := 2;
        AWLOCK_WID      : integer := 2;
        AWCACHE_WID     : integer := 4;
        AWPROT_WID      : integer := 3;
        WSTRB_WID       : integer := 4;
        BRESP_WID       : integer := 2;
        RRESP_WID       : integer := 2;
        ARLEN_WID       : integer := 4;
        ARSIZE_WID      : integer := 3;
        ARBURST_WID     : integer := 2;
        ARLOCK_WID      : integer := 2;
        ARCACHE_WID     : integer := 4;
        ARPROT_WID      : integer := 3;
        MASTER_WID      : integer := 4;
        SLAVE_WID       : integer := 3;
        SLAVE_NUM       : integer := 6;
        MASTER_NUM      : integer := 4;
        SLAVECNTWID     : integer := 5
    );
    port(
        ACLK            : in     vl_logic;
        ARESETn         : in     vl_logic;
        AWIDm02si0      : in     vl_logic_vector;
        AWADDRm02si0    : in     vl_logic_vector;
        AWLENm02si0     : in     vl_logic_vector;
        AWSIZEm02si0    : in     vl_logic_vector;
        AWBURSTm02si0   : in     vl_logic_vector;
        AWLOCKm02si0    : in     vl_logic_vector;
        AWCACHEm02si0   : in     vl_logic_vector;
        AWPROTm02si0    : in     vl_logic_vector;
        AWVALIDm02si0   : in     vl_logic;
        AWREADYsi02m0   : out    vl_logic;
        WIDm02si0       : in     vl_logic_vector;
        WDATAm02si0     : in     vl_logic_vector;
        WSTRBm02si0     : in     vl_logic_vector;
        WLASTm02si0     : in     vl_logic;
        WVALIDm02si0    : in     vl_logic;
        WREADYsi02m0    : out    vl_logic;
        BIDsi02m0       : out    vl_logic_vector;
        BRESPsi02m0     : out    vl_logic_vector;
        BVALIDsi02m0    : out    vl_logic;
        BREADYm02si0    : in     vl_logic;
        AWIDm12si1      : in     vl_logic_vector;
        AWADDRm12si1    : in     vl_logic_vector;
        AWLENm12si1     : in     vl_logic_vector;
        AWSIZEm12si1    : in     vl_logic_vector;
        AWBURSTm12si1   : in     vl_logic_vector;
        AWLOCKm12si1    : in     vl_logic_vector;
        AWCACHEm12si1   : in     vl_logic_vector;
        AWPROTm12si1    : in     vl_logic_vector;
        AWVALIDm12si1   : in     vl_logic;
        AWREADYsi12m1   : out    vl_logic;
        WIDm12si1       : in     vl_logic_vector;
        WDATAm12si1     : in     vl_logic_vector;
        WSTRBm12si1     : in     vl_logic_vector;
        WLASTm12si1     : in     vl_logic;
        WVALIDm12si1    : in     vl_logic;
        WREADYsi12m1    : out    vl_logic;
        BIDsi12m1       : out    vl_logic_vector;
        BRESPsi12m1     : out    vl_logic_vector;
        BVALIDsi12m1    : out    vl_logic;
        BREADYm12si1    : in     vl_logic;
        AWIDm22si2      : in     vl_logic_vector;
        AWADDRm22si2    : in     vl_logic_vector;
        AWLENm22si2     : in     vl_logic_vector;
        AWSIZEm22si2    : in     vl_logic_vector;
        AWBURSTm22si2   : in     vl_logic_vector;
        AWLOCKm22si2    : in     vl_logic_vector;
        AWCACHEm22si2   : in     vl_logic_vector;
        AWPROTm22si2    : in     vl_logic_vector;
        AWVALIDm22si2   : in     vl_logic;
        AWREADYsi22m2   : out    vl_logic;
        WIDm22si2       : in     vl_logic_vector;
        WDATAm22si2     : in     vl_logic_vector;
        WSTRBm22si2     : in     vl_logic_vector;
        WLASTm22si2     : in     vl_logic;
        WVALIDm22si2    : in     vl_logic;
        WREADYsi22m2    : out    vl_logic;
        BIDsi22m2       : out    vl_logic_vector;
        BRESPsi22m2     : out    vl_logic_vector;
        BVALIDsi22m2    : out    vl_logic;
        BREADYm22si2    : in     vl_logic;
        AWIDm32si3      : in     vl_logic_vector;
        AWADDRm32si3    : in     vl_logic_vector;
        AWLENm32si3     : in     vl_logic_vector;
        AWSIZEm32si3    : in     vl_logic_vector;
        AWBURSTm32si3   : in     vl_logic_vector;
        AWLOCKm32si3    : in     vl_logic_vector;
        AWCACHEm32si3   : in     vl_logic_vector;
        AWPROTm32si3    : in     vl_logic_vector;
        AWVALIDm32si3   : in     vl_logic;
        AWREADYsi32m3   : out    vl_logic;
        WIDm32si3       : in     vl_logic_vector;
        WDATAm32si3     : in     vl_logic_vector;
        WSTRBm32si3     : in     vl_logic_vector;
        WLASTm32si3     : in     vl_logic;
        WVALIDm32si3    : in     vl_logic;
        WREADYsi32m3    : out    vl_logic;
        BIDsi32m3       : out    vl_logic_vector;
        BRESPsi32m3     : out    vl_logic_vector;
        BVALIDsi32m3    : out    vl_logic;
        BREADYm32si3    : in     vl_logic;
        AWIDmi02s0      : out    vl_logic_vector;
        AWADDRmi02s0    : out    vl_logic_vector;
        AWLENmi02s0     : out    vl_logic_vector;
        AWSIZEmi02s0    : out    vl_logic_vector;
        AWBURSTmi02s0   : out    vl_logic_vector;
        AWLOCKmi02s0    : out    vl_logic_vector;
        AWCACHEmi02s0   : out    vl_logic_vector;
        AWPROTmi02s0    : out    vl_logic_vector;
        AWVALIDmi02s0   : out    vl_logic;
        AWREADYs02mi0   : in     vl_logic;
        WIDmi02s0       : out    vl_logic_vector;
        WDATAmi02s0     : out    vl_logic_vector;
        WSTRBmi02s0     : out    vl_logic_vector;
        WLASTmi02s0     : out    vl_logic;
        WVALIDmi02s0    : out    vl_logic;
        WREADYs02mi0    : in     vl_logic;
        BIDs02mi0       : in     vl_logic_vector;
        BRESPs02mi0     : in     vl_logic_vector;
        BVALIDs02mi0    : in     vl_logic;
        BREADYmi02s0    : out    vl_logic;
        AWIDmi12s1      : out    vl_logic_vector;
        AWADDRmi12s1    : out    vl_logic_vector;
        AWLENmi12s1     : out    vl_logic_vector;
        AWSIZEmi12s1    : out    vl_logic_vector;
        AWBURSTmi12s1   : out    vl_logic_vector;
        AWLOCKmi12s1    : out    vl_logic_vector;
        AWCACHEmi12s1   : out    vl_logic_vector;
        AWPROTmi12s1    : out    vl_logic_vector;
        AWVALIDmi12s1   : out    vl_logic;
        AWREADYs12mi1   : in     vl_logic;
        WIDmi12s1       : out    vl_logic_vector;
        WDATAmi12s1     : out    vl_logic_vector;
        WSTRBmi12s1     : out    vl_logic_vector;
        WLASTmi12s1     : out    vl_logic;
        WVALIDmi12s1    : out    vl_logic;
        WREADYs12mi1    : in     vl_logic;
        BIDs12mi1       : in     vl_logic_vector;
        BRESPs12mi1     : in     vl_logic_vector;
        BVALIDs12mi1    : in     vl_logic;
        BREADYmi12s1    : out    vl_logic;
        AWIDmi22s2      : out    vl_logic_vector;
        AWADDRmi22s2    : out    vl_logic_vector;
        AWLENmi22s2     : out    vl_logic_vector;
        AWSIZEmi22s2    : out    vl_logic_vector;
        AWBURSTmi22s2   : out    vl_logic_vector;
        AWLOCKmi22s2    : out    vl_logic_vector;
        AWCACHEmi22s2   : out    vl_logic_vector;
        AWPROTmi22s2    : out    vl_logic_vector;
        AWVALIDmi22s2   : out    vl_logic;
        AWREADYs22mi2   : in     vl_logic;
        WIDmi22s2       : out    vl_logic_vector;
        WDATAmi22s2     : out    vl_logic_vector;
        WSTRBmi22s2     : out    vl_logic_vector;
        WLASTmi22s2     : out    vl_logic;
        WVALIDmi22s2    : out    vl_logic;
        WREADYs22mi2    : in     vl_logic;
        BIDs22mi2       : in     vl_logic_vector;
        BRESPs22mi2     : in     vl_logic_vector;
        BVALIDs22mi2    : in     vl_logic;
        BREADYmi22s2    : out    vl_logic;
        AWIDmi32s3      : out    vl_logic_vector;
        AWADDRmi32s3    : out    vl_logic_vector;
        AWLENmi32s3     : out    vl_logic_vector;
        AWSIZEmi32s3    : out    vl_logic_vector;
        AWBURSTmi32s3   : out    vl_logic_vector;
        AWLOCKmi32s3    : out    vl_logic_vector;
        AWCACHEmi32s3   : out    vl_logic_vector;
        AWPROTmi32s3    : out    vl_logic_vector;
        AWVALIDmi32s3   : out    vl_logic;
        AWREADYs32mi3   : in     vl_logic;
        WIDmi32s3       : out    vl_logic_vector;
        WDATAmi32s3     : out    vl_logic_vector;
        WSTRBmi32s3     : out    vl_logic_vector;
        WLASTmi32s3     : out    vl_logic;
        WVALIDmi32s3    : out    vl_logic;
        WREADYs32mi3    : in     vl_logic;
        BIDs32mi3       : in     vl_logic_vector;
        BRESPs32mi3     : in     vl_logic_vector;
        BVALIDs32mi3    : in     vl_logic;
        BREADYmi32s3    : out    vl_logic;
        AWIDmi42s4      : out    vl_logic_vector;
        AWADDRmi42s4    : out    vl_logic_vector;
        AWLENmi42s4     : out    vl_logic_vector;
        AWSIZEmi42s4    : out    vl_logic_vector;
        AWBURSTmi42s4   : out    vl_logic_vector;
        AWLOCKmi42s4    : out    vl_logic_vector;
        AWCACHEmi42s4   : out    vl_logic_vector;
        AWPROTmi42s4    : out    vl_logic_vector;
        AWVALIDmi42s4   : out    vl_logic;
        AWREADYs42mi4   : in     vl_logic;
        WIDmi42s4       : out    vl_logic_vector;
        WDATAmi42s4     : out    vl_logic_vector;
        WSTRBmi42s4     : out    vl_logic_vector;
        WLASTmi42s4     : out    vl_logic;
        WVALIDmi42s4    : out    vl_logic;
        WREADYs42mi4    : in     vl_logic;
        BIDs42mi4       : in     vl_logic_vector;
        BRESPs42mi4     : in     vl_logic_vector;
        BVALIDs42mi4    : in     vl_logic;
        BREADYmi42s4    : out    vl_logic;
        AWIDmi52s5      : out    vl_logic_vector;
        AWADDRmi52s5    : out    vl_logic_vector;
        AWLENmi52s5     : out    vl_logic_vector;
        AWSIZEmi52s5    : out    vl_logic_vector;
        AWBURSTmi52s5   : out    vl_logic_vector;
        AWLOCKmi52s5    : out    vl_logic_vector;
        AWCACHEmi52s5   : out    vl_logic_vector;
        AWPROTmi52s5    : out    vl_logic_vector;
        AWVALIDmi52s5   : out    vl_logic;
        AWREADYs52mi5   : in     vl_logic;
        WIDmi52s5       : out    vl_logic_vector;
        WDATAmi52s5     : out    vl_logic_vector;
        WSTRBmi52s5     : out    vl_logic_vector;
        WLASTmi52s5     : out    vl_logic;
        WVALIDmi52s5    : out    vl_logic;
        WREADYs52mi5    : in     vl_logic;
        BIDs52mi5       : in     vl_logic_vector;
        BRESPs52mi5     : in     vl_logic_vector;
        BVALIDs52mi5    : in     vl_logic;
        BREADYmi52s5    : out    vl_logic;
        Lock2wrmi0      : in     vl_logic;
        Lock2wrmi1      : in     vl_logic;
        Lock2wrmi2      : in     vl_logic;
        Lock2wrmi3      : in     vl_logic;
        Lock2wrmi4      : in     vl_logic;
        Lock2wrmi5      : in     vl_logic;
        Lock2rdmi0      : out    vl_logic;
        Lock2rdmi1      : out    vl_logic;
        Lock2rdmi2      : out    vl_logic;
        Lock2rdmi3      : out    vl_logic;
        Lock2rdmi4      : out    vl_logic;
        Lock2rdmi5      : out    vl_logic;
        UnLock2wrmi0    : in     vl_logic;
        UnLock2wrmi1    : in     vl_logic;
        UnLock2wrmi2    : in     vl_logic;
        UnLock2wrmi3    : in     vl_logic;
        UnLock2wrmi4    : in     vl_logic;
        UnLock2wrmi5    : in     vl_logic;
        UnLock2rdmi0    : out    vl_logic;
        UnLock2rdmi1    : out    vl_logic;
        UnLock2rdmi2    : out    vl_logic;
        UnLock2rdmi3    : out    vl_logic;
        UnLock2rdmi4    : out    vl_logic;
        UnLock2rdmi5    : out    vl_logic;
        ARVALIDmi02s0   : in     vl_logic;
        ARVALIDmi12s1   : in     vl_logic;
        ARVALIDmi22s2   : in     vl_logic;
        ARVALIDmi32s3   : in     vl_logic;
        ARVALIDmi42s4   : in     vl_logic;
        ARVALIDmi52s5   : in     vl_logic;
        LockPort2wrmi0  : in     vl_logic_vector;
        LockPort2wrmi1  : in     vl_logic_vector;
        LockPort2wrmi2  : in     vl_logic_vector;
        LockPort2wrmi3  : in     vl_logic_vector;
        LockPort2wrmi4  : in     vl_logic_vector;
        LockPort2wrmi5  : in     vl_logic_vector;
        ReadIntEmptyWrmi02Rdmi0: out    vl_logic;
        ReadIntEmptyWrmi12Rdmi1: out    vl_logic;
        ReadIntEmptyWrmi22Rdmi2: out    vl_logic;
        ReadIntEmptyWrmi32Rdmi3: out    vl_logic;
        ReadIntEmptyWrmi42Rdmi4: out    vl_logic;
        ReadIntEmptyWrmi52Rdmi5: out    vl_logic;
        DataCntEmptyRdmi02Wrmi0: in     vl_logic;
        DataCntEmptyRdmi12Wrmi1: in     vl_logic;
        DataCntEmptyRdmi22Wrmi2: in     vl_logic;
        DataCntEmptyRdmi32Wrmi3: in     vl_logic;
        DataCntEmptyRdmi42Wrmi4: in     vl_logic;
        DataCntEmptyRdmi52Wrmi5: in     vl_logic;
        CtlDataWrite2Lock0: out    vl_logic_vector;
        CtlDataWrite2Lock1: out    vl_logic_vector;
        CtlDataWrite2Lock2: out    vl_logic_vector;
        CtlDataWrite2Lock3: out    vl_logic_vector;
        CtlDataWrite2Lock4: out    vl_logic_vector;
        CtlDataWrite2Lock5: out    vl_logic_vector
    );
end WriteChannel;
