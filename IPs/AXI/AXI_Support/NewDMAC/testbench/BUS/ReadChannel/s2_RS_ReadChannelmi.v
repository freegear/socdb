// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReadChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : ReadChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
//Syn 253:: modify ELAB-292(senstivelist)

`timescale 1 ns/ 10ps
module  s2_RS_ReadChannelmi(
    
    //Global signal
    ACLK    ,
    ARESETn ,

    //For slave 
    //Read address channel
    ARIDmi2s    ,
    ARADDRmi2s  ,
    ARLENmi2s   ,
    ARSIZEmi2s  ,
    ARBURSTmi2s ,
    ARLOCKmi2s  ,
    ARCACHEmi2s ,
    ARPROTmi2s  ,

    ARVALIDmi2s ,
    ARREADYs2mi ,

    //Read data channel
    RIDs2mi     ,
    RRESPs2mi   ,
    RDATAs2mi   ,
    RVALIDs2mi  ,
    RLASTs2mi   ,
    RREADYmi2s  ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////

    //Master0
    //Read address channel
    //____________________________________
    ARIDsi02mi    ,
    ARADDRsi02mi  ,
    ARLENsi02mi   ,
    ARSIZEsi02mi  ,
    ARBURSTsi02mi ,
    ARLOCKsi02mi  ,
    ARCACHEsi02mi ,
    ARPROTsi02mi  ,

    //Master1
    //Read address channel
    //____________________________________
    ARIDsi12mi    ,
    ARADDRsi12mi  ,
    ARLENsi12mi   ,
    ARSIZEsi12mi  ,
    ARBURSTsi12mi ,
    ARLOCKsi12mi  ,
    ARCACHEsi12mi ,
    ARPROTsi12mi  ,

    //Master2
    //Read address channel
    //____________________________________
    ARIDsi22mi    ,
    ARADDRsi22mi  ,
    ARLENsi22mi   ,
    ARSIZEsi22mi  ,
    ARBURSTsi22mi ,
    ARLOCKsi22mi  ,
    ARCACHEsi22mi ,
    ARPROTsi22mi  ,

    //Master3
    //Read address channel
    //____________________________________
    ARIDsi32mi    ,
    ARADDRsi32mi  ,
    ARLENsi32mi   ,
    ARSIZEsi32mi  ,
    ARBURSTsi32mi ,
    ARLOCKsi32mi  ,
    ARCACHEsi32mi ,
    ARPROTsi32mi  ,

////////////////////////////

    //Master 0/1/2/3 etc...
    ARVALIDsi2mi  ,
    ARREADYmi2si  ,

    //Read data channel
    RIDmi2si0     ,
    RRESPmi2si0   ,
    RDATAmi2si0   ,
    RIDmi2si1     ,
    RRESPmi2si1   ,
    RDATAmi2si1   ,
    RIDmi2si2     ,
    RRESPmi2si2   ,
    RDATAmi2si2   ,
    RIDmi2si3     ,
    RRESPmi2si3   ,
    RDATAmi2si3   ,
////////////////////////////

    RVALIDmi2si  ,
    RLASTmi2si  ,
    RREADYsi2mi,

//LOCKSig_START
    //Lock control
    //____________________________________
    
    Lock2Rdmi,
    UnLock2Rdmi,
    Lock2Wrmi,
    UnLock2Wrmi,
    AWVALID,
    LockPort,
    ReadIntEmptyWrmi2Rdmi,
    DataCntEmptyRdmi2Wrmi,
    CtlDataRead2Lock
    
    //____________________________________
//LOCKSig_END

    );
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 3;
parameter RdPermit_SLAVECNTWID= 3;
parameter ARSIZE_WID= 3;

    input   ACLK;
    input   ARESETn;

    // For slave 
    // 2s (Slave)
    output   [SLAVEID_WID-1:0]  ARIDmi2s;    
    output   [ADDR_WID-1:0]     ARADDRmi2s;
    output   [ARLEN_WID-1:0]    ARLENmi2s;
    output   [ARSIZE_WID-1:0]   ARSIZEmi2s;  
    output   [ARBURST_WID-1:0]  ARBURSTmi2s; 
    output   [ARLOCK_WID-1:0]   ARLOCKmi2s;  
    output   [ARCACHE_WID-1:0]  ARCACHEmi2s; 
    output   [ARPROT_WID-1:0]   ARPROTmi2s;  

    output   ARVALIDmi2s; 
    input    ARREADYs2mi; 
    
    //Read data channel
    input   [SLAVEID_WID-1:0] RIDs2mi;     
    input   [RRESP_WID-1:0]   RRESPs2mi;   
    input   [BUS_WID-1:0]     RDATAs2mi;
    input   RLASTs2mi;
    input   RVALIDs2mi;  
    output  RREADYmi2s;  

    //From SI(slave interface)
    
    //Master0
    //__________________________________________________
    input   [MASTERID_WID-1:0]  ARIDsi02mi;    
    input   [ADDR_WID-1:0]     ARADDRsi02mi;
    input   [ARLEN_WID-1:0]    ARLENsi02mi;
    input   [ARSIZE_WID-1:0]   ARSIZEsi02mi;  
    input   [ARBURST_WID-1:0]  ARBURSTsi02mi; 
    input   [ARLOCK_WID-1:0]   ARLOCKsi02mi;  
    input   [ARCACHE_WID-1:0]  ARCACHEsi02mi; 
    input   [ARPROT_WID-1:0]   ARPROTsi02mi; 

    
    //Master1
    //__________________________________________________
    input   [MASTERID_WID-1:0]  ARIDsi12mi;    
    input   [ADDR_WID-1:0]     ARADDRsi12mi;
    input   [ARLEN_WID-1:0]    ARLENsi12mi;
    input   [ARSIZE_WID-1:0]   ARSIZEsi12mi;  
    input   [ARBURST_WID-1:0]  ARBURSTsi12mi; 
    input   [ARLOCK_WID-1:0]   ARLOCKsi12mi;  
    input   [ARCACHE_WID-1:0]  ARCACHEsi12mi; 
    input   [ARPROT_WID-1:0]   ARPROTsi12mi; 

    
    //Master2
    //__________________________________________________
    input   [MASTERID_WID-1:0]  ARIDsi22mi;    
    input   [ADDR_WID-1:0]     ARADDRsi22mi;
    input   [ARLEN_WID-1:0]    ARLENsi22mi;
    input   [ARSIZE_WID-1:0]   ARSIZEsi22mi;  
    input   [ARBURST_WID-1:0]  ARBURSTsi22mi; 
    input   [ARLOCK_WID-1:0]   ARLOCKsi22mi;  
    input   [ARCACHE_WID-1:0]  ARCACHEsi22mi; 
    input   [ARPROT_WID-1:0]   ARPROTsi22mi; 

    
    //Master3
    //__________________________________________________
    input   [MASTERID_WID-1:0]  ARIDsi32mi;    
    input   [ADDR_WID-1:0]     ARADDRsi32mi;
    input   [ARLEN_WID-1:0]    ARLENsi32mi;
    input   [ARSIZE_WID-1:0]   ARSIZEsi32mi;  
    input   [ARBURST_WID-1:0]  ARBURSTsi32mi; 
    input   [ARLOCK_WID-1:0]   ARLOCKsi32mi;  
    input   [ARCACHE_WID-1:0]  ARCACHEsi32mi; 
    input   [ARPROT_WID-1:0]   ARPROTsi32mi; 

////////////////////////////


    input   [MASTER_NUM-1:0]    ARVALIDsi2mi;
    output  [MASTER_NUM-1:0]    ARREADYmi2si;

    //Read data channel
    output   [MASTERID_WID-1:0] RIDmi2si0;     
    output   [RRESP_WID-1:0]    RRESPmi2si0;   
    output   [BUS_WID-1:0]      RDATAmi2si0;

    output   [MASTERID_WID-1:0] RIDmi2si1;     
    output   [RRESP_WID-1:0]    RRESPmi2si1;   
    output   [BUS_WID-1:0]      RDATAmi2si1;

    output   [MASTERID_WID-1:0] RIDmi2si2;     
    output   [RRESP_WID-1:0]    RRESPmi2si2;   
    output   [BUS_WID-1:0]      RDATAmi2si2;

    output   [MASTERID_WID-1:0] RIDmi2si3;     
    output   [RRESP_WID-1:0]    RRESPmi2si3;   
    output   [BUS_WID-1:0]      RDATAmi2si3;

////////////////////////////

    output   [MASTER_NUM-1:0]   RVALIDmi2si;  
    output   [MASTER_NUM-1:0]   RLASTmi2si;  
    input    [MASTER_NUM-1:0]   RREADYsi2mi;    
    

//LOCKSig_START
    //Lock signal
    input    Lock2Rdmi;
    input    UnLock2Rdmi;
    input    AWVALID;
    input    [SELMASTER_WID-1:0]LockPort;
    input    ReadIntEmptyWrmi2Rdmi;

    //output   [MASTER_WID-1:0]CtlDataRead2Lock;
    output   [SELMASTER_WID-1:0]CtlDataRead2Lock;
    output   DataCntEmptyRdmi2Wrmi;

    output   Lock2Wrmi;
    output   UnLock2Wrmi;

    wire    DataCntEmptyRdmi2Wrmi;
    wire    EnARMUXn      ;
    wire    EnARREADYMUXn ;
    wire    [5:0]   LockArbiter   ;
//LOCKSig_END



//////////////////////////////////////////////////

//////////////////////////////////////////////////




//Master module     
//__________________________________________________

s2_ReadChannelmi
s2_ReadChannelmi(

    //Global signal
    .ACLK    (ACLK    ),
    .ARESETn (ARESETn ),

    //For slave 
    //Read address channel
    .ARIDmi2s    ( ARIDmi2s    ),
    .ARADDRmi2s  ( ARADDRmi2s  ),
    .ARLENmi2s   ( ARLENmi2s   ),
    .ARSIZEmi2s  ( ARSIZEmi2s  ),
    .ARBURSTmi2s ( ARBURSTmi2s ),
    .ARLOCKmi2s  ( ARLOCKmi2s  ),
    .ARCACHEmi2s ( ARCACHEmi2s ),
    .ARPROTmi2s  ( ARPROTmi2s  ),

    .ARVALIDmi2s ( ARVALIDmi2s ),
    .ARREADYs2mi ( ARREADYs2mi ),

    //Read data channel
    .RIDs2mi     ( RIDs2mi     ),
    .RRESPs2mi   ( RRESPs2mi   ),
    .RDATAs2mi   ( RDATAs2mi   ),

    .RVALIDs2mi  ( RVALIDs2mi  ),
    .RLASTs2mi   ( RLASTs2mi   ),
    .RREADYmi2s  ( RREADYmi2s  ),

    //Master 0/1/2/3
    .ARVALIDsi2mi( ARVALIDsi2mi  ),
    .ARREADYmi2si( ARREADYmi2si  ),

    .RVALIDmi2si ( RVALIDmi2si  ),
    .RLASTmi2si  ( RLASTmi2si   ),
    .RREADYsi2mi ( RREADYsi2mi  ),


//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 0
    //Write address channel

    .ARIDsi02mi    ( ARIDsi02mi    ),
    .ARADDRsi02mi  ( ARADDRsi02mi  ),
    .ARLENsi02mi   ( ARLENsi02mi   ),
    .ARSIZEsi02mi  ( ARSIZEsi02mi  ),
    .ARBURSTsi02mi ( ARBURSTsi02mi ),
    .ARLOCKsi02mi  ( ARLOCKsi02mi  ),
    .ARCACHEsi02mi ( ARCACHEsi02mi ),
    .ARPROTsi02mi  ( ARPROTsi02mi  ),

    .RIDmi2si0    ( RIDmi2si0    ),
    .RRESPmi2si0  ( RRESPmi2si0  ),
    .RDATAmi2si0  ( RDATAmi2si0  ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 1
    //Write address channel

    .ARIDsi12mi    ( ARIDsi12mi    ),
    .ARADDRsi12mi  ( ARADDRsi12mi  ),
    .ARLENsi12mi   ( ARLENsi12mi   ),
    .ARSIZEsi12mi  ( ARSIZEsi12mi  ),
    .ARBURSTsi12mi ( ARBURSTsi12mi ),
    .ARLOCKsi12mi  ( ARLOCKsi12mi  ),
    .ARCACHEsi12mi ( ARCACHEsi12mi ),
    .ARPROTsi12mi  ( ARPROTsi12mi  ),

    .RIDmi2si1    ( RIDmi2si1    ),
    .RRESPmi2si1  ( RRESPmi2si1  ),
    .RDATAmi2si1  ( RDATAmi2si1  ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 2
    //Write address channel

    .ARIDsi22mi    ( ARIDsi22mi    ),
    .ARADDRsi22mi  ( ARADDRsi22mi  ),
    .ARLENsi22mi   ( ARLENsi22mi   ),
    .ARSIZEsi22mi  ( ARSIZEsi22mi  ),
    .ARBURSTsi22mi ( ARBURSTsi22mi ),
    .ARLOCKsi22mi  ( ARLOCKsi22mi  ),
    .ARCACHEsi22mi ( ARCACHEsi22mi ),
    .ARPROTsi22mi  ( ARPROTsi22mi  ),

    .RIDmi2si2    ( RIDmi2si2    ),
    .RRESPmi2si2  ( RRESPmi2si2  ),
    .RDATAmi2si2  ( RDATAmi2si2  ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 3
    //Write address channel

    .ARIDsi32mi    ( ARIDsi32mi    ),
    .ARADDRsi32mi  ( ARADDRsi32mi  ),
    .ARLENsi32mi   ( ARLENsi32mi   ),
    .ARSIZEsi32mi  ( ARSIZEsi32mi  ),
    .ARBURSTsi32mi ( ARBURSTsi32mi ),
    .ARLOCKsi32mi  ( ARLOCKsi32mi  ),
    .ARCACHEsi32mi ( ARCACHEsi32mi ),
    .ARPROTsi32mi  ( ARPROTsi32mi  ),

    .RIDmi2si3    ( RIDmi2si3    ),
    .RRESPmi2si3  ( RRESPmi2si3  ),
    .RDATAmi2si3  ( RDATAmi2si3  ),

////////////////////////////

//Lock control
    .Lock2Wrmi(Lock2Wrmi),
    .UnLock2Wrmi(UnLock2Wrmi),

    .Lock2Rdmi(Lock2Rdmi),
    .UnLock2Rdmi(UnLock2Rdmi),

    .AWVALID(AWVALID),

    .LockPort(LockPort),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi2Rdmi),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi2Wrmi),
    .CtlDataRead2Lock    (CtlDataRead2Lock    )
    );
endmodule
