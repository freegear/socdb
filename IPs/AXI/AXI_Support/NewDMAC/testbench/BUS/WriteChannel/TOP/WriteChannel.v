// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannel.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel TOP Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code

`timescale 1 ns/ 10ps
module  WriteChannel(


    //_______________________________________________________________
    //For Master 0
    //Write address channel
    AWIDm02si0    ,
    AWADDRm02si0  ,
    AWLENm02si0   ,
    AWSIZEm02si0  ,
    AWBURSTm02si0 ,
    AWLOCKm02si0  ,
    AWCACHEm02si0 ,
    AWPROTm02si0  ,

    AWVALIDm02si0 ,
    AWREADYsi02m0 ,

    //Write data channel
    WIDm02si0     ,
    WDATAm02si0   ,
    WSTRBm02si0   ,
    WLASTm02si0   ,
    WVALIDm02si0  ,
    WREADYsi02m0  ,

    //Write response channel
    BIDsi02m0     ,
    BRESPsi02m0   ,
    BVALIDsi02m0  ,
    BREADYm02si0  ,

    //_______________________________________________________________
    //For Master 1
    //Write address channel
    AWIDm12si1    ,
    AWADDRm12si1  ,
    AWLENm12si1   ,
    AWSIZEm12si1  ,
    AWBURSTm12si1 ,
    AWLOCKm12si1  ,
    AWCACHEm12si1 ,
    AWPROTm12si1  ,

    AWVALIDm12si1 ,
    AWREADYsi12m1 ,

    //Write data channel
    WIDm12si1     ,
    WDATAm12si1   ,
    WSTRBm12si1   ,
    WLASTm12si1   ,
    WVALIDm12si1  ,
    WREADYsi12m1  ,

    //Write response channel
    BIDsi12m1     ,
    BRESPsi12m1   ,
    BVALIDsi12m1  ,
    BREADYm12si1  ,

    //_______________________________________________________________
    //For Master 2
    //Write address channel
    AWIDm22si2    ,
    AWADDRm22si2  ,
    AWLENm22si2   ,
    AWSIZEm22si2  ,
    AWBURSTm22si2 ,
    AWLOCKm22si2  ,
    AWCACHEm22si2 ,
    AWPROTm22si2  ,

    AWVALIDm22si2 ,
    AWREADYsi22m2 ,

    //Write data channel
    WIDm22si2     ,
    WDATAm22si2   ,
    WSTRBm22si2   ,
    WLASTm22si2   ,
    WVALIDm22si2  ,
    WREADYsi22m2  ,

    //Write response channel
    BIDsi22m2     ,
    BRESPsi22m2   ,
    BVALIDsi22m2  ,
    BREADYm22si2  ,

    //_______________________________________________________________
    //For Master 3
    //Write address channel
    AWIDm32si3    ,
    AWADDRm32si3  ,
    AWLENm32si3   ,
    AWSIZEm32si3  ,
    AWBURSTm32si3 ,
    AWLOCKm32si3  ,
    AWCACHEm32si3 ,
    AWPROTm32si3  ,

    AWVALIDm32si3 ,
    AWREADYsi32m3 ,

    //Write data channel
    WIDm32si3     ,
    WDATAm32si3   ,
    WSTRBm32si3   ,
    WLASTm32si3   ,
    WVALIDm32si3  ,
    WREADYsi32m3  ,

    //Write response channel
    BIDsi32m3     ,
    BRESPsi32m3   ,
    BVALIDsi32m3  ,
    BREADYm32si3  ,


    
    //_______________________________________________________________
    //For Slave 0
    //Write address channel
    AWIDmi02s0    ,
    AWADDRmi02s0  ,
    AWLENmi02s0   ,
    AWSIZEmi02s0  ,
    AWBURSTmi02s0 ,
    AWLOCKmi02s0  ,
    AWCACHEmi02s0 ,
    AWPROTmi02s0  ,

    AWVALIDmi02s0 ,
    AWREADYs02mi0 ,

    //Write data channel
    WIDmi02s0     ,
    WDATAmi02s0   ,
    WSTRBmi02s0   ,
    WLASTmi02s0   ,
    WVALIDmi02s0  ,
    WREADYs02mi0  ,

    //Write response channel
    BIDs02mi0     ,
    BRESPs02mi0   ,
    BVALIDs02mi0  ,
    BREADYmi02s0  ,
    
    //_______________________________________________________________
    //For Slave 1
    //Write address channel
    AWIDmi12s1    ,
    AWADDRmi12s1  ,
    AWLENmi12s1   ,
    AWSIZEmi12s1  ,
    AWBURSTmi12s1 ,
    AWLOCKmi12s1  ,
    AWCACHEmi12s1 ,
    AWPROTmi12s1  ,

    AWVALIDmi12s1 ,
    AWREADYs12mi1 ,

    //Write data channel
    WIDmi12s1     ,
    WDATAmi12s1   ,
    WSTRBmi12s1   ,
    WLASTmi12s1   ,
    WVALIDmi12s1  ,
    WREADYs12mi1  ,

    //Write response channel
    BIDs12mi1     ,
    BRESPs12mi1   ,
    BVALIDs12mi1  ,
    BREADYmi12s1  ,
    
    //_______________________________________________________________
    //For Slave 2
    //Write address channel
    AWIDmi22s2    ,
    AWADDRmi22s2  ,
    AWLENmi22s2   ,
    AWSIZEmi22s2  ,
    AWBURSTmi22s2 ,
    AWLOCKmi22s2  ,
    AWCACHEmi22s2 ,
    AWPROTmi22s2  ,

    AWVALIDmi22s2 ,
    AWREADYs22mi2 ,

    //Write data channel
    WIDmi22s2     ,
    WDATAmi22s2   ,
    WSTRBmi22s2   ,
    WLASTmi22s2   ,
    WVALIDmi22s2  ,
    WREADYs22mi2  ,

    //Write response channel
    BIDs22mi2     ,
    BRESPs22mi2   ,
    BVALIDs22mi2  ,
    BREADYmi22s2  ,
    
    //_______________________________________________________________
    //For Slave 3
    //Write address channel
    AWIDmi32s3    ,
    AWADDRmi32s3  ,
    AWLENmi32s3   ,
    AWSIZEmi32s3  ,
    AWBURSTmi32s3 ,
    AWLOCKmi32s3  ,
    AWCACHEmi32s3 ,
    AWPROTmi32s3  ,

    AWVALIDmi32s3 ,
    AWREADYs32mi3 ,

    //Write data channel
    WIDmi32s3     ,
    WDATAmi32s3   ,
    WSTRBmi32s3   ,
    WLASTmi32s3   ,
    WVALIDmi32s3  ,
    WREADYs32mi3  ,

    //Write response channel
    BIDs32mi3     ,
    BRESPs32mi3   ,
    BVALIDs32mi3  ,
    BREADYmi32s3  ,
    
    //_______________________________________________________________
    //For Slave 4
    //Write address channel
    AWIDmi42s4    ,
    AWADDRmi42s4  ,
    AWLENmi42s4   ,
    AWSIZEmi42s4  ,
    AWBURSTmi42s4 ,
    AWLOCKmi42s4  ,
    AWCACHEmi42s4 ,
    AWPROTmi42s4  ,

    AWVALIDmi42s4 ,
    AWREADYs42mi4 ,

    //Write data channel
    WIDmi42s4     ,
    WDATAmi42s4   ,
    WSTRBmi42s4   ,
    WLASTmi42s4   ,
    WVALIDmi42s4  ,
    WREADYs42mi4  ,

    //Write response channel
    BIDs42mi4     ,
    BRESPs42mi4   ,
    BVALIDs42mi4  ,
    BREADYmi42s4  ,
    
    //_______________________________________________________________
    //For Slave 5
    //Write address channel
    AWIDmi52s5    ,
    AWADDRmi52s5  ,
    AWLENmi52s5   ,
    AWSIZEmi52s5  ,
    AWBURSTmi52s5 ,
    AWLOCKmi52s5  ,
    AWCACHEmi52s5 ,
    AWPROTmi52s5  ,

    AWVALIDmi52s5 ,
    AWREADYs52mi5 ,

    //Write data channel
    WIDmi52s5     ,
    WDATAmi52s5   ,
    WSTRBmi52s5   ,
    WLASTmi52s5   ,
    WVALIDmi52s5  ,
    WREADYs52mi5  ,

    //Write response channel
    BIDs52mi5     ,
    BRESPs52mi5   ,
    BVALIDs52mi5  ,
    BREADYmi52s5  ,


    //Lock Access
    //_______________________________________________________________

    Lock2wrmi0,
    Lock2wrmi1,
    Lock2wrmi2,
    Lock2wrmi3,
    Lock2wrmi4,
    Lock2wrmi5,

    Lock2rdmi0,
    Lock2rdmi1,
    Lock2rdmi2,
    Lock2rdmi3,
    Lock2rdmi4,
    Lock2rdmi5,

    UnLock2wrmi0,
    UnLock2wrmi1,
    UnLock2wrmi2,
    UnLock2wrmi3,
    UnLock2wrmi4,
    UnLock2wrmi5,

    UnLock2rdmi0,
    UnLock2rdmi1,
    UnLock2rdmi2,
    UnLock2rdmi3,
    UnLock2rdmi4,
    UnLock2rdmi5,

    ARVALIDmi02s0,
    ARVALIDmi12s1,
    ARVALIDmi22s2,
    ARVALIDmi32s3,
    ARVALIDmi42s4,
    ARVALIDmi52s5,

    LockPort2wrmi0,
    LockPort2wrmi1,
    LockPort2wrmi2,
    LockPort2wrmi3,
    LockPort2wrmi4,
    LockPort2wrmi5,

    ReadIntEmptyWrmi02Rdmi0,
    ReadIntEmptyWrmi12Rdmi1,
    ReadIntEmptyWrmi22Rdmi2,
    ReadIntEmptyWrmi32Rdmi3,
    ReadIntEmptyWrmi42Rdmi4,
    ReadIntEmptyWrmi52Rdmi5,

    DataCntEmptyRdmi02Wrmi0,
    DataCntEmptyRdmi12Wrmi1,
    DataCntEmptyRdmi22Wrmi2,
    DataCntEmptyRdmi32Wrmi3,
    DataCntEmptyRdmi42Wrmi4,
    DataCntEmptyRdmi52Wrmi5,

    CtlDataWrite2Lock0,
    CtlDataWrite2Lock1,
    CtlDataWrite2Lock2,
    CtlDataWrite2Lock3,
    CtlDataWrite2Lock4,
    CtlDataWrite2Lock5,

    ACLK    ,
    ARESETn 
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 3;
parameter RdPermit_SLAVECNTWID= 3;
parameter ARSIZE_WID= 3;
parameter MASTERID0_WID = 4 ;
parameter MASTERID1_WID = 4 ;
parameter MASTERID2_WID = 4 ;
parameter MASTERID3_WID = 4 ;
parameter MAXMASTERID_WID = 4 ;
parameter BLANKMASTERID0_WID = 0 ;
parameter BLANKMASTERID1_WID = 0 ;
parameter BLANKMASTERID2_WID = 0 ;
parameter BLANKMASTERID3_WID = 0 ;
parameter SLAVEID0_WID = 6 ;
parameter SLAVEID1_WID = 6 ;
parameter SLAVEID2_WID = 6 ;
parameter SLAVEID3_WID = 6 ;
parameter SLAVEID4_WID = 6 ;
parameter SLAVEID5_WID = 7 ;
parameter SELMASTER0_WID = 2 ;
parameter SELMASTER1_WID = 2 ;
parameter SELMASTER2_WID = 2 ;
parameter SELMASTER3_WID = 2 ;
parameter SELMASTER4_WID = 2 ;
parameter SELMASTER5_WID = 3 ;
parameter SLAVE_MASTERID0_WID = 4 ;
parameter SLAVE_MASTERID1_WID = 4 ;
parameter SLAVE_MASTERID2_WID = 4 ;
parameter SLAVE_MASTERID3_WID = 4 ;
parameter SLAVE_MASTERID4_WID = 4 ;
parameter SLAVE_MASTERID5_WID = 4 ;
    

    input   ACLK;
    input   ARESETn;  

    //Lock Access
    //_______________________________________________________________


    //Slave 0
    //_____________________________________
    input   Lock2wrmi0;
    input   UnLock2wrmi0;
    output  Lock2rdmi0;
    output  UnLock2rdmi0;
    input   ARVALIDmi02s0;
    input   [SELMASTER0_WID-1:0]LockPort2wrmi0;
    output  ReadIntEmptyWrmi02Rdmi0;
    input   DataCntEmptyRdmi02Wrmi0;
    output  [SELMASTER0_WID-1:0]CtlDataWrite2Lock0;

    //Slave 1
    //_____________________________________
    input   Lock2wrmi1;
    input   UnLock2wrmi1;
    output  Lock2rdmi1;
    output  UnLock2rdmi1;
    input   ARVALIDmi12s1;
    input   [SELMASTER1_WID-1:0]LockPort2wrmi1;
    output  ReadIntEmptyWrmi12Rdmi1;
    input   DataCntEmptyRdmi12Wrmi1;
    output  [SELMASTER1_WID-1:0]CtlDataWrite2Lock1;

    //Slave 2
    //_____________________________________
    input   Lock2wrmi2;
    input   UnLock2wrmi2;
    output  Lock2rdmi2;
    output  UnLock2rdmi2;
    input   ARVALIDmi22s2;
    input   [SELMASTER2_WID-1:0]LockPort2wrmi2;
    output  ReadIntEmptyWrmi22Rdmi2;
    input   DataCntEmptyRdmi22Wrmi2;
    output  [SELMASTER2_WID-1:0]CtlDataWrite2Lock2;

    //Slave 3
    //_____________________________________
    input   Lock2wrmi3;
    input   UnLock2wrmi3;
    output  Lock2rdmi3;
    output  UnLock2rdmi3;
    input   ARVALIDmi32s3;
    input   [SELMASTER3_WID-1:0]LockPort2wrmi3;
    output  ReadIntEmptyWrmi32Rdmi3;
    input   DataCntEmptyRdmi32Wrmi3;
    output  [SELMASTER3_WID-1:0]CtlDataWrite2Lock3;

    //Slave 4
    //_____________________________________
    input   Lock2wrmi4;
    input   UnLock2wrmi4;
    output  Lock2rdmi4;
    output  UnLock2rdmi4;
    input   ARVALIDmi42s4;
    input   [SELMASTER4_WID-1:0]LockPort2wrmi4;
    output  ReadIntEmptyWrmi42Rdmi4;
    input   DataCntEmptyRdmi42Wrmi4;
    output  [SELMASTER4_WID-1:0]CtlDataWrite2Lock4;

    //Slave 5
    //_____________________________________
    input   Lock2wrmi5;
    input   UnLock2wrmi5;
    output  Lock2rdmi5;
    output  UnLock2rdmi5;
    input   ARVALIDmi52s5;
    input   [SELMASTER5_WID-1:0]LockPort2wrmi5;
    output  ReadIntEmptyWrmi52Rdmi5;
    input   DataCntEmptyRdmi52Wrmi5;
    output  [SELMASTER5_WID-1:0]CtlDataWrite2Lock5;
    //_______________________________________________________________

    //SlaveInterface
    //_______________________________________________________________

    //For Master 0
    //Write address channel
    input   [MASTERID0_WID-1:0]   AWIDm02si0;    
    input   [ADDR_WID-1:0]          AWADDRm02si0;
    input   [AWLEN_WID-1:0]         AWLENm02si0;
    input   [AWSIZE_WID-1:0]        AWSIZEm02si0;  
    input   [AWBURST_WID-1:0]       AWBURSTm02si0; 
    input   [AWLOCK_WID-1:0]        AWLOCKm02si0;  
    input   [AWCACHE_WID-1:0]       AWCACHEm02si0; 
    input   [AWPROT_WID-1:0]        AWPROTm02si0;  

    input   AWVALIDm02si0; 
    output  AWREADYsi02m0; 

    //Write data channel
    input   [MASTERID0_WID-1:0]   WIDm02si0;     
    input   [BUS_WID-1:0]           WDATAm02si0;   
    input   [WSTRB_WID-1:0]         WSTRBm02si0;   
    input   WLASTm02si0;   
    input   WVALIDm02si0;  
    output  WREADYsi02m0;  

    //Write response channel
    output   [MASTERID0_WID-1:0]  BIDsi02m0;     
    output   [BRESP_WID-1:0]        BRESPsi02m0;   
    output   BVALIDsi02m0;  
    input    BREADYm02si0;  
    //For Master 1
    //Write address channel
    input   [MASTERID1_WID-1:0]   AWIDm12si1;    
    input   [ADDR_WID-1:0]          AWADDRm12si1;
    input   [AWLEN_WID-1:0]         AWLENm12si1;
    input   [AWSIZE_WID-1:0]        AWSIZEm12si1;  
    input   [AWBURST_WID-1:0]       AWBURSTm12si1; 
    input   [AWLOCK_WID-1:0]        AWLOCKm12si1;  
    input   [AWCACHE_WID-1:0]       AWCACHEm12si1; 
    input   [AWPROT_WID-1:0]        AWPROTm12si1;  

    input   AWVALIDm12si1; 
    output  AWREADYsi12m1; 

    //Write data channel
    input   [MASTERID1_WID-1:0]   WIDm12si1;     
    input   [BUS_WID-1:0]           WDATAm12si1;   
    input   [WSTRB_WID-1:0]         WSTRBm12si1;   
    input   WLASTm12si1;   
    input   WVALIDm12si1;  
    output  WREADYsi12m1;  

    //Write response channel
    output   [MASTERID1_WID-1:0]  BIDsi12m1;     
    output   [BRESP_WID-1:0]        BRESPsi12m1;   
    output   BVALIDsi12m1;  
    input    BREADYm12si1;  
    //For Master 2
    //Write address channel
    input   [MASTERID2_WID-1:0]   AWIDm22si2;    
    input   [ADDR_WID-1:0]          AWADDRm22si2;
    input   [AWLEN_WID-1:0]         AWLENm22si2;
    input   [AWSIZE_WID-1:0]        AWSIZEm22si2;  
    input   [AWBURST_WID-1:0]       AWBURSTm22si2; 
    input   [AWLOCK_WID-1:0]        AWLOCKm22si2;  
    input   [AWCACHE_WID-1:0]       AWCACHEm22si2; 
    input   [AWPROT_WID-1:0]        AWPROTm22si2;  

    input   AWVALIDm22si2; 
    output  AWREADYsi22m2; 

    //Write data channel
    input   [MASTERID2_WID-1:0]   WIDm22si2;     
    input   [BUS_WID-1:0]           WDATAm22si2;   
    input   [WSTRB_WID-1:0]         WSTRBm22si2;   
    input   WLASTm22si2;   
    input   WVALIDm22si2;  
    output  WREADYsi22m2;  

    //Write response channel
    output   [MASTERID2_WID-1:0]  BIDsi22m2;     
    output   [BRESP_WID-1:0]        BRESPsi22m2;   
    output   BVALIDsi22m2;  
    input    BREADYm22si2;  
    //For Master 3
    //Write address channel
    input   [MASTERID3_WID-1:0]   AWIDm32si3;    
    input   [ADDR_WID-1:0]          AWADDRm32si3;
    input   [AWLEN_WID-1:0]         AWLENm32si3;
    input   [AWSIZE_WID-1:0]        AWSIZEm32si3;  
    input   [AWBURST_WID-1:0]       AWBURSTm32si3; 
    input   [AWLOCK_WID-1:0]        AWLOCKm32si3;  
    input   [AWCACHE_WID-1:0]       AWCACHEm32si3; 
    input   [AWPROT_WID-1:0]        AWPROTm32si3;  

    input   AWVALIDm32si3; 
    output  AWREADYsi32m3; 

    //Write data channel
    input   [MASTERID3_WID-1:0]   WIDm32si3;     
    input   [BUS_WID-1:0]           WDATAm32si3;   
    input   [WSTRB_WID-1:0]         WSTRBm32si3;   
    input   WLASTm32si3;   
    input   WVALIDm32si3;  
    output  WREADYsi32m3;  

    //Write response channel
    output   [MASTERID3_WID-1:0]  BIDsi32m3;     
    output   [BRESP_WID-1:0]        BRESPsi32m3;   
    output   BVALIDsi32m3;  
    input    BREADYm32si3;  


    //MasterInterface
    //_______________________________________________________________

    // For slave 0
    //__________________________________________________
    //Write address channel
    output   [SLAVEID0_WID-1:0]AWIDmi02s0;    
    output   [ADDR_WID-1:0]     AWADDRmi02s0;
    output   [AWLEN_WID-1:0]    AWLENmi02s0;
    output   [AWSIZE_WID-1:0]   AWSIZEmi02s0;  
    output   [AWBURST_WID-1:0]  AWBURSTmi02s0; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi02s0;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi02s0; 
    output   [AWPROT_WID-1:0]   AWPROTmi02s0;  

    output   AWVALIDmi02s0; 
    input    AWREADYs02mi0; 
    
    //Write data channel
    output   [SLAVEID0_WID-1:0]WIDmi02s0;     
    output   [BUS_WID-1:0]      WDATAmi02s0;   
    output   [WSTRB_WID-1:0]    WSTRBmi02s0;   
    output   WLASTmi02s0;   
    output   WVALIDmi02s0;  
    input    WREADYs02mi0; 

    //Write response channel
    input   [SLAVEID0_WID-1:0] BIDs02mi0;     
    input   [BRESP_WID-1:0]     BRESPs02mi0;   
    input   BVALIDs02mi0;  
    output  BREADYmi02s0;  

    // For slave 1
    //__________________________________________________
    //Write address channel
    output   [SLAVEID1_WID-1:0]AWIDmi12s1;    
    output   [ADDR_WID-1:0]     AWADDRmi12s1;
    output   [AWLEN_WID-1:0]    AWLENmi12s1;
    output   [AWSIZE_WID-1:0]   AWSIZEmi12s1;  
    output   [AWBURST_WID-1:0]  AWBURSTmi12s1; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi12s1;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi12s1; 
    output   [AWPROT_WID-1:0]   AWPROTmi12s1;  

    output   AWVALIDmi12s1; 
    input    AWREADYs12mi1; 
    
    //Write data channel
    output   [SLAVEID1_WID-1:0]WIDmi12s1;     
    output   [BUS_WID-1:0]      WDATAmi12s1;   
    output   [WSTRB_WID-1:0]    WSTRBmi12s1;   
    output   WLASTmi12s1;   
    output   WVALIDmi12s1;  
    input    WREADYs12mi1; 

    //Write response channel
    input   [SLAVEID1_WID-1:0] BIDs12mi1;     
    input   [BRESP_WID-1:0]     BRESPs12mi1;   
    input   BVALIDs12mi1;  
    output  BREADYmi12s1;  

    // For slave 2
    //__________________________________________________
    //Write address channel
    output   [SLAVEID2_WID-1:0]AWIDmi22s2;    
    output   [ADDR_WID-1:0]     AWADDRmi22s2;
    output   [AWLEN_WID-1:0]    AWLENmi22s2;
    output   [AWSIZE_WID-1:0]   AWSIZEmi22s2;  
    output   [AWBURST_WID-1:0]  AWBURSTmi22s2; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi22s2;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi22s2; 
    output   [AWPROT_WID-1:0]   AWPROTmi22s2;  

    output   AWVALIDmi22s2; 
    input    AWREADYs22mi2; 
    
    //Write data channel
    output   [SLAVEID2_WID-1:0]WIDmi22s2;     
    output   [BUS_WID-1:0]      WDATAmi22s2;   
    output   [WSTRB_WID-1:0]    WSTRBmi22s2;   
    output   WLASTmi22s2;   
    output   WVALIDmi22s2;  
    input    WREADYs22mi2; 

    //Write response channel
    input   [SLAVEID2_WID-1:0] BIDs22mi2;     
    input   [BRESP_WID-1:0]     BRESPs22mi2;   
    input   BVALIDs22mi2;  
    output  BREADYmi22s2;  

    // For slave 3
    //__________________________________________________
    //Write address channel
    output   [SLAVEID3_WID-1:0]AWIDmi32s3;    
    output   [ADDR_WID-1:0]     AWADDRmi32s3;
    output   [AWLEN_WID-1:0]    AWLENmi32s3;
    output   [AWSIZE_WID-1:0]   AWSIZEmi32s3;  
    output   [AWBURST_WID-1:0]  AWBURSTmi32s3; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi32s3;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi32s3; 
    output   [AWPROT_WID-1:0]   AWPROTmi32s3;  

    output   AWVALIDmi32s3; 
    input    AWREADYs32mi3; 
    
    //Write data channel
    output   [SLAVEID3_WID-1:0]WIDmi32s3;     
    output   [BUS_WID-1:0]      WDATAmi32s3;   
    output   [WSTRB_WID-1:0]    WSTRBmi32s3;   
    output   WLASTmi32s3;   
    output   WVALIDmi32s3;  
    input    WREADYs32mi3; 

    //Write response channel
    input   [SLAVEID3_WID-1:0] BIDs32mi3;     
    input   [BRESP_WID-1:0]     BRESPs32mi3;   
    input   BVALIDs32mi3;  
    output  BREADYmi32s3;  

    // For slave 4
    //__________________________________________________
    //Write address channel
    output   [SLAVEID4_WID-1:0]AWIDmi42s4;    
    output   [ADDR_WID-1:0]     AWADDRmi42s4;
    output   [AWLEN_WID-1:0]    AWLENmi42s4;
    output   [AWSIZE_WID-1:0]   AWSIZEmi42s4;  
    output   [AWBURST_WID-1:0]  AWBURSTmi42s4; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi42s4;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi42s4; 
    output   [AWPROT_WID-1:0]   AWPROTmi42s4;  

    output   AWVALIDmi42s4; 
    input    AWREADYs42mi4; 
    
    //Write data channel
    output   [SLAVEID4_WID-1:0]WIDmi42s4;     
    output   [BUS_WID-1:0]      WDATAmi42s4;   
    output   [WSTRB_WID-1:0]    WSTRBmi42s4;   
    output   WLASTmi42s4;   
    output   WVALIDmi42s4;  
    input    WREADYs42mi4; 

    //Write response channel
    input   [SLAVEID4_WID-1:0] BIDs42mi4;     
    input   [BRESP_WID-1:0]     BRESPs42mi4;   
    input   BVALIDs42mi4;  
    output  BREADYmi42s4;  

    // For slave 5
    //__________________________________________________
    //Write address channel
    output   [SLAVEID5_WID-1:0]AWIDmi52s5;    
    output   [ADDR_WID-1:0]     AWADDRmi52s5;
    output   [AWLEN_WID-1:0]    AWLENmi52s5;
    output   [AWSIZE_WID-1:0]   AWSIZEmi52s5;  
    output   [AWBURST_WID-1:0]  AWBURSTmi52s5; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi52s5;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi52s5; 
    output   [AWPROT_WID-1:0]   AWPROTmi52s5;  

    output   AWVALIDmi52s5; 
    input    AWREADYs52mi5; 
    
    //Write data channel
    output   [SLAVEID5_WID-1:0]WIDmi52s5;     
    output   [BUS_WID-1:0]      WDATAmi52s5;   
    output   [WSTRB_WID-1:0]    WSTRBmi52s5;   
    output   WLASTmi52s5;   
    output   WVALIDmi52s5;  
    input    WREADYs52mi5; 

    //Write response channel
    input   [SLAVEID5_WID-1:0] BIDs52mi5;     
    input   [BRESP_WID-1:0]     BRESPs52mi5;   
    input   BVALIDs52mi5;  
    output  BREADYmi52s5;  



//Master module wire were generated
//Master module 0 - 0
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi0 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi0;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi0 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi0};    
    wire  [BUS_WID-1:0]         WDATAsi02mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi0;  

//Master module wire were generated
//Master module 0 - 1
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi1 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi1;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi1 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi1};    
    wire  [BUS_WID-1:0]         WDATAsi02mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi1;  

//Master module wire were generated
//Master module 0 - 2
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi2 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi2;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi2 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi2};    
    wire  [BUS_WID-1:0]         WDATAsi02mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi2;  

//Master module wire were generated
//Master module 0 - 3
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi3 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi3;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi3 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi3};    
    wire  [BUS_WID-1:0]         WDATAsi02mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi3;  

//Master module wire were generated
//Master module 0 - 4
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi4 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi4;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi4 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi4};    
    wire  [BUS_WID-1:0]         WDATAsi02mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi4;  

//Master module wire were generated
//Master module 0 - 5
//_____________________________________________________________________

    wire  [MASTERID0_WID-1:0]  AWIDsi02mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi02mi5 = 
             {{BLANKMASTERID0_WID{1'b0}},AWIDsi02mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi02mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi02mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi02mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi02mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi02mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi02mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi02mi5;
    
    wire  [MASTERID0_WID-1:0]  WIDsi02mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi02mi5 =
             {{BLANKMASTERID0_WID{1'b0}},WIDsi02mi5};    
    wire  [BUS_WID-1:0]         WDATAsi02mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi02mi5;  

//Master module wire were generated
//Master module 1 - 0
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi0 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi0;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi0 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi0};    
    wire  [BUS_WID-1:0]         WDATAsi12mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi0;  

//Master module wire were generated
//Master module 1 - 1
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi1 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi1;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi1 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi1};    
    wire  [BUS_WID-1:0]         WDATAsi12mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi1;  

//Master module wire were generated
//Master module 1 - 2
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi2 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi2;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi2 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi2};    
    wire  [BUS_WID-1:0]         WDATAsi12mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi2;  

//Master module wire were generated
//Master module 1 - 3
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi3 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi3;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi3 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi3};    
    wire  [BUS_WID-1:0]         WDATAsi12mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi3;  

//Master module wire were generated
//Master module 1 - 4
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi4 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi4;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi4 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi4};    
    wire  [BUS_WID-1:0]         WDATAsi12mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi4;  

//Master module wire were generated
//Master module 1 - 5
//_____________________________________________________________________

    wire  [MASTERID1_WID-1:0]  AWIDsi12mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi12mi5 = 
             {{BLANKMASTERID1_WID{1'b0}},AWIDsi12mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi12mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi12mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi12mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi12mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi12mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi12mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi12mi5;
    
    wire  [MASTERID1_WID-1:0]  WIDsi12mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi12mi5 =
             {{BLANKMASTERID1_WID{1'b0}},WIDsi12mi5};    
    wire  [BUS_WID-1:0]         WDATAsi12mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi12mi5;  

//Master module wire were generated
//Master module 2 - 0
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi0 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi0;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi0 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi0};    
    wire  [BUS_WID-1:0]         WDATAsi22mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi0;  

//Master module wire were generated
//Master module 2 - 1
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi1 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi1;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi1 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi1};    
    wire  [BUS_WID-1:0]         WDATAsi22mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi1;  

//Master module wire were generated
//Master module 2 - 2
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi2 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi2;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi2 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi2};    
    wire  [BUS_WID-1:0]         WDATAsi22mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi2;  

//Master module wire were generated
//Master module 2 - 3
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi3 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi3;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi3 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi3};    
    wire  [BUS_WID-1:0]         WDATAsi22mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi3;  

//Master module wire were generated
//Master module 2 - 4
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi4 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi4;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi4 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi4};    
    wire  [BUS_WID-1:0]         WDATAsi22mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi4;  

//Master module wire were generated
//Master module 2 - 5
//_____________________________________________________________________

    wire  [MASTERID2_WID-1:0]  AWIDsi22mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi22mi5 = 
             {{BLANKMASTERID2_WID{1'b0}},AWIDsi22mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi22mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi22mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi22mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi22mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi22mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi22mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi22mi5;
    
    wire  [MASTERID2_WID-1:0]  WIDsi22mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi22mi5 =
             {{BLANKMASTERID2_WID{1'b0}},WIDsi22mi5};    
    wire  [BUS_WID-1:0]         WDATAsi22mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi22mi5;  

//Master module wire were generated
//Master module 3 - 0
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi0;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi0 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi0};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi0;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi0;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi0;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi0; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi0;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi0; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi0;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi0;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi0 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi0};    
    wire  [BUS_WID-1:0]         WDATAsi32mi0;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi0;  

//Master module wire were generated
//Master module 3 - 1
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi1;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi1 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi1};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi1;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi1;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi1;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi1; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi1;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi1; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi1;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi1;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi1 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi1};    
    wire  [BUS_WID-1:0]         WDATAsi32mi1;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi1;  

//Master module wire were generated
//Master module 3 - 2
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi2;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi2 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi2};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi2;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi2;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi2;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi2; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi2;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi2; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi2;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi2;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi2 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi2};    
    wire  [BUS_WID-1:0]         WDATAsi32mi2;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi2;  

//Master module wire were generated
//Master module 3 - 3
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi3;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi3 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi3};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi3;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi3;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi3;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi3; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi3;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi3; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi3;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi3;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi3 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi3};    
    wire  [BUS_WID-1:0]         WDATAsi32mi3;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi3;  

//Master module wire were generated
//Master module 3 - 4
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi4;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi4 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi4};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi4;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi4;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi4;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi4; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi4;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi4; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi4;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi4;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi4 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi4};    
    wire  [BUS_WID-1:0]         WDATAsi32mi4;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi4;  

//Master module wire were generated
//Master module 3 - 5
//_____________________________________________________________________

    wire  [MASTERID3_WID-1:0]  AWIDsi32mi5;    
    wire  [MAXMASTERID_WID-1:0] wAWIDsi32mi5 = 
             {{BLANKMASTERID3_WID{1'b0}},AWIDsi32mi5};    
    wire  [ADDR_WID-1:0]        AWADDRsi32mi5;  
    wire  [AWLEN_WID-1:0]       AWLENsi32mi5;   
    wire  [AWSIZE_WID-1:0]      AWSIZEsi32mi5;  
    wire  [AWBURST_WID-1:0]     AWBURSTsi32mi5; 
    wire  [AWLOCK_WID-1:0]      AWLOCKsi32mi5;  
    wire  [AWCACHE_WID-1:0]     AWCACHEsi32mi5; 
    wire  [AWPROT_WID-1:0]      AWPROTsi32mi5;
    
    wire  [MASTERID3_WID-1:0]  WIDsi32mi5;     
    wire  [MAXMASTERID_WID-1:0] wWIDsi32mi5 =
             {{BLANKMASTERID3_WID{1'b0}},WIDsi32mi5};    
    wire  [BUS_WID-1:0]         WDATAsi32mi5;   
    wire  [WSTRB_WID-1:0]       WSTRBsi32mi5;  



    wire    [SLAVE_NUM-1:0]     AWVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     WLASTsi02mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi02mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si0;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si0;
    wire    [SLAVE_NUM-1:0]     BREADYsi02mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi12mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si1;
    wire    [SLAVE_NUM-1:0]     WLASTsi12mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi12mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si1;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si1;
    wire    [SLAVE_NUM-1:0]     BREADYsi12mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi22mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si2;
    wire    [SLAVE_NUM-1:0]     WLASTsi22mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi22mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si2;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si2;
    wire    [SLAVE_NUM-1:0]     BREADYsi22mi;
    wire    [SLAVE_NUM-1:0]     AWVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     AWREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     WLASTsi32mi;
    wire    [SLAVE_NUM-1:0]     WVALIDsi32mi;
    wire    [SLAVE_NUM-1:0]     WREADYmi2si3;
    wire    [SLAVE_NUM-1:0]     BVALIDmi2si3;
    wire    [SLAVE_NUM-1:0]     BREADYsi32mi;
//_____________________________________________________________________

    //Slave Number 0(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si0;     
    wire   [BRESP_WID-1:0]               BRESPmi02si0; 
    //Slave Number 0(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si1;     
    wire   [BRESP_WID-1:0]               BRESPmi02si1; 
    //Slave Number 0(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si2;     
    wire   [BRESP_WID-1:0]               BRESPmi02si2; 
    //Slave Number 0(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID0_WID-1:0]   BIDmi02si3;     
    wire   [BRESP_WID-1:0]               BRESPmi02si3; 
    //Slave Number 1(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si0;     
    wire   [BRESP_WID-1:0]               BRESPmi12si0; 
    //Slave Number 1(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si1;     
    wire   [BRESP_WID-1:0]               BRESPmi12si1; 
    //Slave Number 1(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si2;     
    wire   [BRESP_WID-1:0]               BRESPmi12si2; 
    //Slave Number 1(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID1_WID-1:0]   BIDmi12si3;     
    wire   [BRESP_WID-1:0]               BRESPmi12si3; 
    //Slave Number 2(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si0;     
    wire   [BRESP_WID-1:0]               BRESPmi22si0; 
    //Slave Number 2(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si1;     
    wire   [BRESP_WID-1:0]               BRESPmi22si1; 
    //Slave Number 2(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si2;     
    wire   [BRESP_WID-1:0]               BRESPmi22si2; 
    //Slave Number 2(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID2_WID-1:0]   BIDmi22si3;     
    wire   [BRESP_WID-1:0]               BRESPmi22si3; 
    //Slave Number 3(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si0;     
    wire   [BRESP_WID-1:0]               BRESPmi32si0; 
    //Slave Number 3(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si1;     
    wire   [BRESP_WID-1:0]               BRESPmi32si1; 
    //Slave Number 3(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si2;     
    wire   [BRESP_WID-1:0]               BRESPmi32si2; 
    //Slave Number 3(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID3_WID-1:0]   BIDmi32si3;     
    wire   [BRESP_WID-1:0]               BRESPmi32si3; 
    //Slave Number 4(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si0;     
    wire   [BRESP_WID-1:0]               BRESPmi42si0; 
    //Slave Number 4(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si1;     
    wire   [BRESP_WID-1:0]               BRESPmi42si1; 
    //Slave Number 4(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si2;     
    wire   [BRESP_WID-1:0]               BRESPmi42si2; 
    //Slave Number 4(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID4_WID-1:0]   BIDmi42si3;     
    wire   [BRESP_WID-1:0]               BRESPmi42si3; 
    //Slave Number 5(slave interface) to 0 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si0;     
    wire   [BRESP_WID-1:0]               BRESPmi52si0; 
    //Slave Number 5(slave interface) to 1 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si1;     
    wire   [BRESP_WID-1:0]               BRESPmi52si1; 
    //Slave Number 5(slave interface) to 2 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si2;     
    wire   [BRESP_WID-1:0]               BRESPmi52si2; 
    //Slave Number 5(slave interface) to 3 (master interface)
    wire   [SLAVE_MASTERID5_WID-1:0]   BIDmi52si3;     
    wire   [BRESP_WID-1:0]               BRESPmi52si3; 

//Slave module wire were generated
//Slave module 0    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi02si;
    wire  [MASTER_NUM-1:0]    WREADYmi02si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi02si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi0;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi0;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi0;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi02si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi02si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi02si;

//Slave module wire were generated
//Slave module 1    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi12si;
    wire  [MASTER_NUM-1:0]    WREADYmi12si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi12si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi1;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi1;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi1;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi12si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi12si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi12si;

//Slave module wire were generated
//Slave module 2    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi22si;
    wire  [MASTER_NUM-1:0]    WREADYmi22si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi22si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi2;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi2;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi2;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi22si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi22si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi22si;

//Slave module wire were generated
//Slave module 3    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi32si;
    wire  [MASTER_NUM-1:0]    WREADYmi32si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi32si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi3;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi3;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi3;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi32si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi32si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi32si;

//Slave module wire were generated
//Slave module 4    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi42si;
    wire  [MASTER_NUM-1:0]    WREADYmi42si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi42si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi4;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi4;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi4;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi42si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi42si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi42si;

//Slave module wire were generated
//Slave module 5    
//_____________________________________________________________________

    wire  [MASTER_NUM-1:0]    AWREADYmi52si;
    wire  [MASTER_NUM-1:0]    WREADYmi52si;  
    wire  [MASTER_NUM-1:0]    BVALIDmi52si;

    wire  [MASTER_NUM-1:0]    AWVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WVALIDsi2mi5;
    wire  [MASTER_NUM-1:0]    WLASTsi2mi5;
    wire  [MASTER_NUM-1:0]    BREADYsi2mi5;

    wire  [MASTER_NUM-1:0]    SetAWREADYmi52si;
    wire  [MASTER_NUM-1:0]    SetWREADYmi52si;  
    wire  [MASTER_NUM-1:0]    SetBVALIDmi52si;


//MaserInterface to SlaveInterface Setting
//_____________________________________________________________________
//SlaveNum  [0]
/////////////////////////////
    assign SetAWREADYmi02si[0] = AWREADYmi02si[0]; 
    assign SetAWREADYmi02si[1] = AWREADYmi02si[1]; 
    assign SetAWREADYmi02si[2] = AWREADYmi02si[2]; 
    assign SetAWREADYmi02si[3] = AWREADYmi02si[3]; 
//SlaveNum  [1]
/////////////////////////////
    assign SetAWREADYmi12si[0] = AWREADYmi12si[0]; 
    assign SetAWREADYmi12si[1] = AWREADYmi12si[1]; 
    assign SetAWREADYmi12si[2] = AWREADYmi12si[2]; 
    assign SetAWREADYmi12si[3] = AWREADYmi12si[3]; 
//SlaveNum  [2]
/////////////////////////////
    assign SetAWREADYmi22si[0] = AWREADYmi22si[0]; 
    assign SetAWREADYmi22si[1] = AWREADYmi22si[1]; 
    assign SetAWREADYmi22si[2] = AWREADYmi22si[2]; 
    assign SetAWREADYmi22si[3] = AWREADYmi22si[3]; 
//SlaveNum  [3]
/////////////////////////////
    assign SetAWREADYmi32si[0] = AWREADYmi32si[0]; 
    assign SetAWREADYmi32si[1] = AWREADYmi32si[1]; 
    assign SetAWREADYmi32si[2] = AWREADYmi32si[2]; 
    assign SetAWREADYmi32si[3] = AWREADYmi32si[3]; 
//SlaveNum  [4]
/////////////////////////////
    assign SetAWREADYmi42si[0] = AWREADYmi42si[0]; 
    assign SetAWREADYmi42si[1] = AWREADYmi42si[1]; 
    assign SetAWREADYmi42si[2] = AWREADYmi42si[2]; 
    assign SetAWREADYmi42si[3] = AWREADYmi42si[3]; 
//SlaveNum  [5]
/////////////////////////////
    assign SetAWREADYmi52si[0] = AWREADYmi52si[0]; 
    assign SetAWREADYmi52si[1] = AWREADYmi52si[1]; 
    assign SetAWREADYmi52si[2] = AWREADYmi52si[2]; 
    assign SetAWREADYmi52si[3] = AWREADYmi52si[3]; 

//SlaveNum  [0]
/////////////////////////////
    assign  SetWREADYmi02si[0] = WREADYmi02si[0];   
    assign  SetWREADYmi02si[1] = WREADYmi02si[1];   
    assign  SetWREADYmi02si[2] = WREADYmi02si[2];   
    assign  SetWREADYmi02si[3] = WREADYmi02si[3];   
//SlaveNum  [1]
/////////////////////////////
    assign  SetWREADYmi12si[0] = WREADYmi12si[0];   
    assign  SetWREADYmi12si[1] = WREADYmi12si[1];   
    assign  SetWREADYmi12si[2] = WREADYmi12si[2];   
    assign  SetWREADYmi12si[3] = WREADYmi12si[3];   
//SlaveNum  [2]
/////////////////////////////
    assign  SetWREADYmi22si[0] = WREADYmi22si[0];   
    assign  SetWREADYmi22si[1] = WREADYmi22si[1];   
    assign  SetWREADYmi22si[2] = WREADYmi22si[2];   
    assign  SetWREADYmi22si[3] = WREADYmi22si[3];   
//SlaveNum  [3]
/////////////////////////////
    assign  SetWREADYmi32si[0] = WREADYmi32si[0];   
    assign  SetWREADYmi32si[1] = WREADYmi32si[1];   
    assign  SetWREADYmi32si[2] = WREADYmi32si[2];   
    assign  SetWREADYmi32si[3] = WREADYmi32si[3];   
//SlaveNum  [4]
/////////////////////////////
    assign  SetWREADYmi42si[0] = WREADYmi42si[0];   
    assign  SetWREADYmi42si[1] = WREADYmi42si[1];   
    assign  SetWREADYmi42si[2] = WREADYmi42si[2];   
    assign  SetWREADYmi42si[3] = WREADYmi42si[3];   
//SlaveNum  [5]
/////////////////////////////
    assign  SetWREADYmi52si[0] = WREADYmi52si[0];   
    assign  SetWREADYmi52si[1] = WREADYmi52si[1];   
    assign  SetWREADYmi52si[2] = WREADYmi52si[2];   
    assign  SetWREADYmi52si[3] = WREADYmi52si[3];   

//SlaveNum  [0]
/////////////////////////////
    assign SetBVALIDmi02si[0]  = BVALIDmi02si[0];
    assign SetBVALIDmi02si[1]  = BVALIDmi02si[1];
    assign SetBVALIDmi02si[2]  = BVALIDmi02si[2];
    assign SetBVALIDmi02si[3]  = BVALIDmi02si[3];
//SlaveNum  [1]
/////////////////////////////
    assign SetBVALIDmi12si[0]  = BVALIDmi12si[0];
    assign SetBVALIDmi12si[1]  = BVALIDmi12si[1];
    assign SetBVALIDmi12si[2]  = BVALIDmi12si[2];
    assign SetBVALIDmi12si[3]  = BVALIDmi12si[3];
//SlaveNum  [2]
/////////////////////////////
    assign SetBVALIDmi22si[0]  = BVALIDmi22si[0];
    assign SetBVALIDmi22si[1]  = BVALIDmi22si[1];
    assign SetBVALIDmi22si[2]  = BVALIDmi22si[2];
    assign SetBVALIDmi22si[3]  = BVALIDmi22si[3];
//SlaveNum  [3]
/////////////////////////////
    assign SetBVALIDmi32si[0]  = BVALIDmi32si[0];
    assign SetBVALIDmi32si[1]  = BVALIDmi32si[1];
    assign SetBVALIDmi32si[2]  = BVALIDmi32si[2];
    assign SetBVALIDmi32si[3]  = BVALIDmi32si[3];
//SlaveNum  [4]
/////////////////////////////
    assign SetBVALIDmi42si[0]  = BVALIDmi42si[0];
    assign SetBVALIDmi42si[1]  = BVALIDmi42si[1];
    assign SetBVALIDmi42si[2]  = BVALIDmi42si[2];
    assign SetBVALIDmi42si[3]  = BVALIDmi42si[3];
//SlaveNum  [5]
/////////////////////////////
    assign SetBVALIDmi52si[0]  = BVALIDmi52si[0];
    assign SetBVALIDmi52si[1]  = BVALIDmi52si[1];
    assign SetBVALIDmi52si[2]  = BVALIDmi52si[2];
    assign SetBVALIDmi52si[3]  = BVALIDmi52si[3];

//AWREADYmi2si///////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  AWREADYmi2si0[0] = SetAWREADYmi02si[0];
    assign  AWREADYmi2si0[1] = SetAWREADYmi12si[0];
    assign  AWREADYmi2si0[2] = SetAWREADYmi22si[0];
    assign  AWREADYmi2si0[3] = SetAWREADYmi32si[0];
    assign  AWREADYmi2si0[4] = SetAWREADYmi42si[0];
    assign  AWREADYmi2si0[5] = SetAWREADYmi52si[0];
//MasterNum  [1]
/////////////////////////////
    assign  AWREADYmi2si1[0] = SetAWREADYmi02si[1];
    assign  AWREADYmi2si1[1] = SetAWREADYmi12si[1];
    assign  AWREADYmi2si1[2] = SetAWREADYmi22si[1];
    assign  AWREADYmi2si1[3] = SetAWREADYmi32si[1];
    assign  AWREADYmi2si1[4] = SetAWREADYmi42si[1];
    assign  AWREADYmi2si1[5] = SetAWREADYmi52si[1];
//MasterNum  [2]
/////////////////////////////
    assign  AWREADYmi2si2[0] = SetAWREADYmi02si[2];
    assign  AWREADYmi2si2[1] = SetAWREADYmi12si[2];
    assign  AWREADYmi2si2[2] = SetAWREADYmi22si[2];
    assign  AWREADYmi2si2[3] = SetAWREADYmi32si[2];
    assign  AWREADYmi2si2[4] = SetAWREADYmi42si[2];
    assign  AWREADYmi2si2[5] = SetAWREADYmi52si[2];
//MasterNum  [3]
/////////////////////////////
    assign  AWREADYmi2si3[0] = SetAWREADYmi02si[3];
    assign  AWREADYmi2si3[1] = SetAWREADYmi12si[3];
    assign  AWREADYmi2si3[2] = SetAWREADYmi22si[3];
    assign  AWREADYmi2si3[3] = SetAWREADYmi32si[3];
    assign  AWREADYmi2si3[4] = SetAWREADYmi42si[3];
    assign  AWREADYmi2si3[5] = SetAWREADYmi52si[3];

//BVALIDmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  BVALIDmi2si0[0] = SetBVALIDmi02si[0];
    assign  BVALIDmi2si0[1] = SetBVALIDmi12si[0];
    assign  BVALIDmi2si0[2] = SetBVALIDmi22si[0];
    assign  BVALIDmi2si0[3] = SetBVALIDmi32si[0];
    assign  BVALIDmi2si0[4] = SetBVALIDmi42si[0];
    assign  BVALIDmi2si0[5] = SetBVALIDmi52si[0];
//MasterNum  [1]
/////////////////////////////
    assign  BVALIDmi2si1[0] = SetBVALIDmi02si[1];
    assign  BVALIDmi2si1[1] = SetBVALIDmi12si[1];
    assign  BVALIDmi2si1[2] = SetBVALIDmi22si[1];
    assign  BVALIDmi2si1[3] = SetBVALIDmi32si[1];
    assign  BVALIDmi2si1[4] = SetBVALIDmi42si[1];
    assign  BVALIDmi2si1[5] = SetBVALIDmi52si[1];
//MasterNum  [2]
/////////////////////////////
    assign  BVALIDmi2si2[0] = SetBVALIDmi02si[2];
    assign  BVALIDmi2si2[1] = SetBVALIDmi12si[2];
    assign  BVALIDmi2si2[2] = SetBVALIDmi22si[2];
    assign  BVALIDmi2si2[3] = SetBVALIDmi32si[2];
    assign  BVALIDmi2si2[4] = SetBVALIDmi42si[2];
    assign  BVALIDmi2si2[5] = SetBVALIDmi52si[2];
//MasterNum  [3]
/////////////////////////////
    assign  BVALIDmi2si3[0] = SetBVALIDmi02si[3];
    assign  BVALIDmi2si3[1] = SetBVALIDmi12si[3];
    assign  BVALIDmi2si3[2] = SetBVALIDmi22si[3];
    assign  BVALIDmi2si3[3] = SetBVALIDmi32si[3];
    assign  BVALIDmi2si3[4] = SetBVALIDmi42si[3];
    assign  BVALIDmi2si3[5] = SetBVALIDmi52si[3];

//WREADYmi2si////////////////////////
//MasterNum  [0]
/////////////////////////////
    assign  WREADYmi2si0[0] = SetWREADYmi02si[0];
    assign  WREADYmi2si0[1] = SetWREADYmi12si[0];
    assign  WREADYmi2si0[2] = SetWREADYmi22si[0];
    assign  WREADYmi2si0[3] = SetWREADYmi32si[0];
    assign  WREADYmi2si0[4] = SetWREADYmi42si[0];
    assign  WREADYmi2si0[5] = SetWREADYmi52si[0];
//MasterNum  [1]
/////////////////////////////
    assign  WREADYmi2si1[0] = SetWREADYmi02si[1];
    assign  WREADYmi2si1[1] = SetWREADYmi12si[1];
    assign  WREADYmi2si1[2] = SetWREADYmi22si[1];
    assign  WREADYmi2si1[3] = SetWREADYmi32si[1];
    assign  WREADYmi2si1[4] = SetWREADYmi42si[1];
    assign  WREADYmi2si1[5] = SetWREADYmi52si[1];
//MasterNum  [2]
/////////////////////////////
    assign  WREADYmi2si2[0] = SetWREADYmi02si[2];
    assign  WREADYmi2si2[1] = SetWREADYmi12si[2];
    assign  WREADYmi2si2[2] = SetWREADYmi22si[2];
    assign  WREADYmi2si2[3] = SetWREADYmi32si[2];
    assign  WREADYmi2si2[4] = SetWREADYmi42si[2];
    assign  WREADYmi2si2[5] = SetWREADYmi52si[2];
//MasterNum  [3]
/////////////////////////////
    assign  WREADYmi2si3[0] = SetWREADYmi02si[3];
    assign  WREADYmi2si3[1] = SetWREADYmi12si[3];
    assign  WREADYmi2si3[2] = SetWREADYmi22si[3];
    assign  WREADYmi2si3[3] = SetWREADYmi32si[3];
    assign  WREADYmi2si3[4] = SetWREADYmi42si[3];
    assign  WREADYmi2si3[5] = SetWREADYmi52si[3];

//_____________________________________________________________________


//SlaveInterface to MasterInterface Setting
//_____________________________________________________________________

//AWVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  AWVALIDsi2mi0[0] = AWVALIDsi02mi[0];
    assign  AWVALIDsi2mi0[1] = AWVALIDsi12mi[0];
    assign  AWVALIDsi2mi0[2] = AWVALIDsi22mi[0];
    assign  AWVALIDsi2mi0[3] = AWVALIDsi32mi[0];
//SlaveNum  [1]
/////////////////////////////
    assign  AWVALIDsi2mi1[0] = AWVALIDsi02mi[1];
    assign  AWVALIDsi2mi1[1] = AWVALIDsi12mi[1];
    assign  AWVALIDsi2mi1[2] = AWVALIDsi22mi[1];
    assign  AWVALIDsi2mi1[3] = AWVALIDsi32mi[1];
//SlaveNum  [2]
/////////////////////////////
    assign  AWVALIDsi2mi2[0] = AWVALIDsi02mi[2];
    assign  AWVALIDsi2mi2[1] = AWVALIDsi12mi[2];
    assign  AWVALIDsi2mi2[2] = AWVALIDsi22mi[2];
    assign  AWVALIDsi2mi2[3] = AWVALIDsi32mi[2];
//SlaveNum  [3]
/////////////////////////////
    assign  AWVALIDsi2mi3[0] = AWVALIDsi02mi[3];
    assign  AWVALIDsi2mi3[1] = AWVALIDsi12mi[3];
    assign  AWVALIDsi2mi3[2] = AWVALIDsi22mi[3];
    assign  AWVALIDsi2mi3[3] = AWVALIDsi32mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  AWVALIDsi2mi4[0] = AWVALIDsi02mi[4];
    assign  AWVALIDsi2mi4[1] = AWVALIDsi12mi[4];
    assign  AWVALIDsi2mi4[2] = AWVALIDsi22mi[4];
    assign  AWVALIDsi2mi4[3] = AWVALIDsi32mi[4];
//SlaveNum  [5]
/////////////////////////////
    assign  AWVALIDsi2mi5[0] = AWVALIDsi02mi[5];
    assign  AWVALIDsi2mi5[1] = AWVALIDsi12mi[5];
    assign  AWVALIDsi2mi5[2] = AWVALIDsi22mi[5];
    assign  AWVALIDsi2mi5[3] = AWVALIDsi32mi[5];

//WVALIDsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WVALIDsi2mi0[0] = WVALIDsi02mi[0];
    assign  WVALIDsi2mi0[1] = WVALIDsi12mi[0];
    assign  WVALIDsi2mi0[2] = WVALIDsi22mi[0];
    assign  WVALIDsi2mi0[3] = WVALIDsi32mi[0];
//SlaveNum  [1]
/////////////////////////////
    assign  WVALIDsi2mi1[0] = WVALIDsi02mi[1];
    assign  WVALIDsi2mi1[1] = WVALIDsi12mi[1];
    assign  WVALIDsi2mi1[2] = WVALIDsi22mi[1];
    assign  WVALIDsi2mi1[3] = WVALIDsi32mi[1];
//SlaveNum  [2]
/////////////////////////////
    assign  WVALIDsi2mi2[0] = WVALIDsi02mi[2];
    assign  WVALIDsi2mi2[1] = WVALIDsi12mi[2];
    assign  WVALIDsi2mi2[2] = WVALIDsi22mi[2];
    assign  WVALIDsi2mi2[3] = WVALIDsi32mi[2];
//SlaveNum  [3]
/////////////////////////////
    assign  WVALIDsi2mi3[0] = WVALIDsi02mi[3];
    assign  WVALIDsi2mi3[1] = WVALIDsi12mi[3];
    assign  WVALIDsi2mi3[2] = WVALIDsi22mi[3];
    assign  WVALIDsi2mi3[3] = WVALIDsi32mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  WVALIDsi2mi4[0] = WVALIDsi02mi[4];
    assign  WVALIDsi2mi4[1] = WVALIDsi12mi[4];
    assign  WVALIDsi2mi4[2] = WVALIDsi22mi[4];
    assign  WVALIDsi2mi4[3] = WVALIDsi32mi[4];
//SlaveNum  [5]
/////////////////////////////
    assign  WVALIDsi2mi5[0] = WVALIDsi02mi[5];
    assign  WVALIDsi2mi5[1] = WVALIDsi12mi[5];
    assign  WVALIDsi2mi5[2] = WVALIDsi22mi[5];
    assign  WVALIDsi2mi5[3] = WVALIDsi32mi[5];

//WLASTsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  WLASTsi2mi0[0] = WLASTsi02mi[0];
    assign  WLASTsi2mi0[1] = WLASTsi12mi[0];
    assign  WLASTsi2mi0[2] = WLASTsi22mi[0];
    assign  WLASTsi2mi0[3] = WLASTsi32mi[0];
//SlaveNum  [1]
/////////////////////////////
    assign  WLASTsi2mi1[0] = WLASTsi02mi[1];
    assign  WLASTsi2mi1[1] = WLASTsi12mi[1];
    assign  WLASTsi2mi1[2] = WLASTsi22mi[1];
    assign  WLASTsi2mi1[3] = WLASTsi32mi[1];
//SlaveNum  [2]
/////////////////////////////
    assign  WLASTsi2mi2[0] = WLASTsi02mi[2];
    assign  WLASTsi2mi2[1] = WLASTsi12mi[2];
    assign  WLASTsi2mi2[2] = WLASTsi22mi[2];
    assign  WLASTsi2mi2[3] = WLASTsi32mi[2];
//SlaveNum  [3]
/////////////////////////////
    assign  WLASTsi2mi3[0] = WLASTsi02mi[3];
    assign  WLASTsi2mi3[1] = WLASTsi12mi[3];
    assign  WLASTsi2mi3[2] = WLASTsi22mi[3];
    assign  WLASTsi2mi3[3] = WLASTsi32mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  WLASTsi2mi4[0] = WLASTsi02mi[4];
    assign  WLASTsi2mi4[1] = WLASTsi12mi[4];
    assign  WLASTsi2mi4[2] = WLASTsi22mi[4];
    assign  WLASTsi2mi4[3] = WLASTsi32mi[4];
//SlaveNum  [5]
/////////////////////////////
    assign  WLASTsi2mi5[0] = WLASTsi02mi[5];
    assign  WLASTsi2mi5[1] = WLASTsi12mi[5];
    assign  WLASTsi2mi5[2] = WLASTsi22mi[5];
    assign  WLASTsi2mi5[3] = WLASTsi32mi[5];

//BREADYsi2mi////////////////////////
//SlaveNum  [0]
/////////////////////////////
    assign  BREADYsi2mi0[0] = BREADYsi02mi[0];
    assign  BREADYsi2mi0[1] = BREADYsi12mi[0];
    assign  BREADYsi2mi0[2] = BREADYsi22mi[0];
    assign  BREADYsi2mi0[3] = BREADYsi32mi[0];
//SlaveNum  [1]
/////////////////////////////
    assign  BREADYsi2mi1[0] = BREADYsi02mi[1];
    assign  BREADYsi2mi1[1] = BREADYsi12mi[1];
    assign  BREADYsi2mi1[2] = BREADYsi22mi[1];
    assign  BREADYsi2mi1[3] = BREADYsi32mi[1];
//SlaveNum  [2]
/////////////////////////////
    assign  BREADYsi2mi2[0] = BREADYsi02mi[2];
    assign  BREADYsi2mi2[1] = BREADYsi12mi[2];
    assign  BREADYsi2mi2[2] = BREADYsi22mi[2];
    assign  BREADYsi2mi2[3] = BREADYsi32mi[2];
//SlaveNum  [3]
/////////////////////////////
    assign  BREADYsi2mi3[0] = BREADYsi02mi[3];
    assign  BREADYsi2mi3[1] = BREADYsi12mi[3];
    assign  BREADYsi2mi3[2] = BREADYsi22mi[3];
    assign  BREADYsi2mi3[3] = BREADYsi32mi[3];
//SlaveNum  [4]
/////////////////////////////
    assign  BREADYsi2mi4[0] = BREADYsi02mi[4];
    assign  BREADYsi2mi4[1] = BREADYsi12mi[4];
    assign  BREADYsi2mi4[2] = BREADYsi22mi[4];
    assign  BREADYsi2mi4[3] = BREADYsi32mi[4];
//SlaveNum  [5]
/////////////////////////////
    assign  BREADYsi2mi5[0] = BREADYsi02mi[5];
    assign  BREADYsi2mi5[1] = BREADYsi12mi[5];
    assign  BREADYsi2mi5[2] = BREADYsi22mi[5];
    assign  BREADYsi2mi5[3] = BREADYsi32mi[5];

//_____________________________________________________________________



//Master module 0    
//________________________________________________________________________

m0_RS_WriteChannelsi
m0_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm02si0),
    .AWADDRm2si  (AWADDRm02si0),
    .AWLENm2si   (AWLENm02si0),
    .AWSIZEm2si  (AWSIZEm02si0),
    .AWBURSTm2si (AWBURSTm02si0),
    .AWLOCKm2si  (AWLOCKm02si0),
    .AWCACHEm2si (AWCACHEm02si0),
    .AWPROTm2si  (AWPROTm02si0),

    .AWVALIDm2si (AWVALIDm02si0),
    .AWREADYsi2m (AWREADYsi02m0),

    //Write data channel
    .WIDm2si     (WIDm02si0),
    .WDATAm2si   (WDATAm02si0),
    .WSTRBm2si   (WSTRBm02si0),
    .WLASTm2si   (WLASTm02si0),
    .WVALIDm2si  (WVALIDm02si0),
    .WREADYsi2m  (WREADYsi02m0),

    //Write response channel
    .BIDsi2m     (BIDsi02m0),
    .BRESPsi2m   (BRESPsi02m0),
    .BVALIDsi2m  (BVALIDsi02m0),
    .BREADYm2si  (BREADYm02si0),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi02mi0),
    .AWADDRsi2mi0  (AWADDRsi02mi0),
    .AWLENsi2mi0   (AWLENsi02mi0),
    .AWSIZEsi2mi0  (AWSIZEsi02mi0),
    .AWBURSTsi2mi0 (AWBURSTsi02mi0),
    .AWLOCKsi2mi0  (AWLOCKsi02mi0),
    .AWCACHEsi2mi0 (AWCACHEsi02mi0),
    .AWPROTsi2mi0  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi02mi0),
    .WDATAsi2mi0   (WDATAsi02mi0),
    .WSTRBsi2mi0   (WSTRBsi02mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si0[MASTERID0_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi02mi1),
    .AWADDRsi2mi1  (AWADDRsi02mi1),
    .AWLENsi2mi1   (AWLENsi02mi1),
    .AWSIZEsi2mi1  (AWSIZEsi02mi1),
    .AWBURSTsi2mi1 (AWBURSTsi02mi1),
    .AWLOCKsi2mi1  (AWLOCKsi02mi1),
    .AWCACHEsi2mi1 (AWCACHEsi02mi1),
    .AWPROTsi2mi1  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi02mi1),
    .WDATAsi2mi1   (WDATAsi02mi1),
    .WSTRBsi2mi1   (WSTRBsi02mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si0[MASTERID0_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi02mi2),
    .AWADDRsi2mi2  (AWADDRsi02mi2),
    .AWLENsi2mi2   (AWLENsi02mi2),
    .AWSIZEsi2mi2  (AWSIZEsi02mi2),
    .AWBURSTsi2mi2 (AWBURSTsi02mi2),
    .AWLOCKsi2mi2  (AWLOCKsi02mi2),
    .AWCACHEsi2mi2 (AWCACHEsi02mi2),
    .AWPROTsi2mi2  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi02mi2),
    .WDATAsi2mi2   (WDATAsi02mi2),
    .WSTRBsi2mi2   (WSTRBsi02mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si0[MASTERID0_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi02mi3),
    .AWADDRsi2mi3  (AWADDRsi02mi3),
    .AWLENsi2mi3   (AWLENsi02mi3),
    .AWSIZEsi2mi3  (AWSIZEsi02mi3),
    .AWBURSTsi2mi3 (AWBURSTsi02mi3),
    .AWLOCKsi2mi3  (AWLOCKsi02mi3),
    .AWCACHEsi2mi3 (AWCACHEsi02mi3),
    .AWPROTsi2mi3  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi02mi3),
    .WDATAsi2mi3   (WDATAsi02mi3),
    .WSTRBsi2mi3   (WSTRBsi02mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si0[MASTERID0_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi02mi4),
    .AWADDRsi2mi4  (AWADDRsi02mi4),
    .AWLENsi2mi4   (AWLENsi02mi4),
    .AWSIZEsi2mi4  (AWSIZEsi02mi4),
    .AWBURSTsi2mi4 (AWBURSTsi02mi4),
    .AWLOCKsi2mi4  (AWLOCKsi02mi4),
    .AWCACHEsi2mi4 (AWCACHEsi02mi4),
    .AWPROTsi2mi4  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi02mi4),
    .WDATAsi2mi4   (WDATAsi02mi4),
    .WSTRBsi2mi4   (WSTRBsi02mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si0[MASTERID0_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si0),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi02mi5),
    .AWADDRsi2mi5  (AWADDRsi02mi5),
    .AWLENsi2mi5   (AWLENsi02mi5),
    .AWSIZEsi2mi5  (AWSIZEsi02mi5),
    .AWBURSTsi2mi5 (AWBURSTsi02mi5),
    .AWLOCKsi2mi5  (AWLOCKsi02mi5),
    .AWCACHEsi2mi5 (AWCACHEsi02mi5),
    .AWPROTsi2mi5  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi02mi5),
    .WDATAsi2mi5   (WDATAsi02mi5),
    .WSTRBsi2mi5   (WSTRBsi02mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si0[MASTERID0_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si0),

    .AWVALIDsi2mi (AWVALIDsi02mi),
    .AWREADYmi2si (AWREADYmi2si0),

    .WLASTsi2mi   (WLASTsi02mi),
    .WVALIDsi2mi  (WVALIDsi02mi),
    .WREADYmi2si  (WREADYmi2si0),

    .BVALIDmi2si    (BVALIDmi2si0),
    .BREADYsi2mi    (BREADYsi02mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 1    
//________________________________________________________________________

m1_RS_WriteChannelsi
m1_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm12si1),
    .AWADDRm2si  (AWADDRm12si1),
    .AWLENm2si   (AWLENm12si1),
    .AWSIZEm2si  (AWSIZEm12si1),
    .AWBURSTm2si (AWBURSTm12si1),
    .AWLOCKm2si  (AWLOCKm12si1),
    .AWCACHEm2si (AWCACHEm12si1),
    .AWPROTm2si  (AWPROTm12si1),

    .AWVALIDm2si (AWVALIDm12si1),
    .AWREADYsi2m (AWREADYsi12m1),

    //Write data channel
    .WIDm2si     (WIDm12si1),
    .WDATAm2si   (WDATAm12si1),
    .WSTRBm2si   (WSTRBm12si1),
    .WLASTm2si   (WLASTm12si1),
    .WVALIDm2si  (WVALIDm12si1),
    .WREADYsi2m  (WREADYsi12m1),

    //Write response channel
    .BIDsi2m     (BIDsi12m1),
    .BRESPsi2m   (BRESPsi12m1),
    .BVALIDsi2m  (BVALIDsi12m1),
    .BREADYm2si  (BREADYm12si1),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi12mi0),
    .AWADDRsi2mi0  (AWADDRsi12mi0),
    .AWLENsi2mi0   (AWLENsi12mi0),
    .AWSIZEsi2mi0  (AWSIZEsi12mi0),
    .AWBURSTsi2mi0 (AWBURSTsi12mi0),
    .AWLOCKsi2mi0  (AWLOCKsi12mi0),
    .AWCACHEsi2mi0 (AWCACHEsi12mi0),
    .AWPROTsi2mi0  (AWPROTsi12mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi12mi0),
    .WDATAsi2mi0   (WDATAsi12mi0),
    .WSTRBsi2mi0   (WSTRBsi12mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si1[MASTERID1_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi12mi1),
    .AWADDRsi2mi1  (AWADDRsi12mi1),
    .AWLENsi2mi1   (AWLENsi12mi1),
    .AWSIZEsi2mi1  (AWSIZEsi12mi1),
    .AWBURSTsi2mi1 (AWBURSTsi12mi1),
    .AWLOCKsi2mi1  (AWLOCKsi12mi1),
    .AWCACHEsi2mi1 (AWCACHEsi12mi1),
    .AWPROTsi2mi1  (AWPROTsi12mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi12mi1),
    .WDATAsi2mi1   (WDATAsi12mi1),
    .WSTRBsi2mi1   (WSTRBsi12mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si1[MASTERID1_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi12mi2),
    .AWADDRsi2mi2  (AWADDRsi12mi2),
    .AWLENsi2mi2   (AWLENsi12mi2),
    .AWSIZEsi2mi2  (AWSIZEsi12mi2),
    .AWBURSTsi2mi2 (AWBURSTsi12mi2),
    .AWLOCKsi2mi2  (AWLOCKsi12mi2),
    .AWCACHEsi2mi2 (AWCACHEsi12mi2),
    .AWPROTsi2mi2  (AWPROTsi12mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi12mi2),
    .WDATAsi2mi2   (WDATAsi12mi2),
    .WSTRBsi2mi2   (WSTRBsi12mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si1[MASTERID1_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi12mi3),
    .AWADDRsi2mi3  (AWADDRsi12mi3),
    .AWLENsi2mi3   (AWLENsi12mi3),
    .AWSIZEsi2mi3  (AWSIZEsi12mi3),
    .AWBURSTsi2mi3 (AWBURSTsi12mi3),
    .AWLOCKsi2mi3  (AWLOCKsi12mi3),
    .AWCACHEsi2mi3 (AWCACHEsi12mi3),
    .AWPROTsi2mi3  (AWPROTsi12mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi12mi3),
    .WDATAsi2mi3   (WDATAsi12mi3),
    .WSTRBsi2mi3   (WSTRBsi12mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si1[MASTERID1_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi12mi4),
    .AWADDRsi2mi4  (AWADDRsi12mi4),
    .AWLENsi2mi4   (AWLENsi12mi4),
    .AWSIZEsi2mi4  (AWSIZEsi12mi4),
    .AWBURSTsi2mi4 (AWBURSTsi12mi4),
    .AWLOCKsi2mi4  (AWLOCKsi12mi4),
    .AWCACHEsi2mi4 (AWCACHEsi12mi4),
    .AWPROTsi2mi4  (AWPROTsi12mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi12mi4),
    .WDATAsi2mi4   (WDATAsi12mi4),
    .WSTRBsi2mi4   (WSTRBsi12mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si1[MASTERID1_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si1),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi12mi5),
    .AWADDRsi2mi5  (AWADDRsi12mi5),
    .AWLENsi2mi5   (AWLENsi12mi5),
    .AWSIZEsi2mi5  (AWSIZEsi12mi5),
    .AWBURSTsi2mi5 (AWBURSTsi12mi5),
    .AWLOCKsi2mi5  (AWLOCKsi12mi5),
    .AWCACHEsi2mi5 (AWCACHEsi12mi5),
    .AWPROTsi2mi5  (AWPROTsi12mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi12mi5),
    .WDATAsi2mi5   (WDATAsi12mi5),
    .WSTRBsi2mi5   (WSTRBsi12mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si1[MASTERID1_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si1),

    .AWVALIDsi2mi (AWVALIDsi12mi),
    .AWREADYmi2si (AWREADYmi2si1),

    .WLASTsi2mi   (WLASTsi12mi),
    .WVALIDsi2mi  (WVALIDsi12mi),
    .WREADYmi2si  (WREADYmi2si1),

    .BVALIDmi2si    (BVALIDmi2si1),
    .BREADYsi2mi    (BREADYsi12mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 2    
//________________________________________________________________________

m2_RS_WriteChannelsi
m2_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm22si2),
    .AWADDRm2si  (AWADDRm22si2),
    .AWLENm2si   (AWLENm22si2),
    .AWSIZEm2si  (AWSIZEm22si2),
    .AWBURSTm2si (AWBURSTm22si2),
    .AWLOCKm2si  (AWLOCKm22si2),
    .AWCACHEm2si (AWCACHEm22si2),
    .AWPROTm2si  (AWPROTm22si2),

    .AWVALIDm2si (AWVALIDm22si2),
    .AWREADYsi2m (AWREADYsi22m2),

    //Write data channel
    .WIDm2si     (WIDm22si2),
    .WDATAm2si   (WDATAm22si2),
    .WSTRBm2si   (WSTRBm22si2),
    .WLASTm2si   (WLASTm22si2),
    .WVALIDm2si  (WVALIDm22si2),
    .WREADYsi2m  (WREADYsi22m2),

    //Write response channel
    .BIDsi2m     (BIDsi22m2),
    .BRESPsi2m   (BRESPsi22m2),
    .BVALIDsi2m  (BVALIDsi22m2),
    .BREADYm2si  (BREADYm22si2),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi22mi0),
    .AWADDRsi2mi0  (AWADDRsi22mi0),
    .AWLENsi2mi0   (AWLENsi22mi0),
    .AWSIZEsi2mi0  (AWSIZEsi22mi0),
    .AWBURSTsi2mi0 (AWBURSTsi22mi0),
    .AWLOCKsi2mi0  (AWLOCKsi22mi0),
    .AWCACHEsi2mi0 (AWCACHEsi22mi0),
    .AWPROTsi2mi0  (AWPROTsi22mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi22mi0),
    .WDATAsi2mi0   (WDATAsi22mi0),
    .WSTRBsi2mi0   (WSTRBsi22mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si2[MASTERID2_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi22mi1),
    .AWADDRsi2mi1  (AWADDRsi22mi1),
    .AWLENsi2mi1   (AWLENsi22mi1),
    .AWSIZEsi2mi1  (AWSIZEsi22mi1),
    .AWBURSTsi2mi1 (AWBURSTsi22mi1),
    .AWLOCKsi2mi1  (AWLOCKsi22mi1),
    .AWCACHEsi2mi1 (AWCACHEsi22mi1),
    .AWPROTsi2mi1  (AWPROTsi22mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi22mi1),
    .WDATAsi2mi1   (WDATAsi22mi1),
    .WSTRBsi2mi1   (WSTRBsi22mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si2[MASTERID2_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi22mi2),
    .AWADDRsi2mi2  (AWADDRsi22mi2),
    .AWLENsi2mi2   (AWLENsi22mi2),
    .AWSIZEsi2mi2  (AWSIZEsi22mi2),
    .AWBURSTsi2mi2 (AWBURSTsi22mi2),
    .AWLOCKsi2mi2  (AWLOCKsi22mi2),
    .AWCACHEsi2mi2 (AWCACHEsi22mi2),
    .AWPROTsi2mi2  (AWPROTsi22mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi22mi2),
    .WDATAsi2mi2   (WDATAsi22mi2),
    .WSTRBsi2mi2   (WSTRBsi22mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si2[MASTERID2_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi22mi3),
    .AWADDRsi2mi3  (AWADDRsi22mi3),
    .AWLENsi2mi3   (AWLENsi22mi3),
    .AWSIZEsi2mi3  (AWSIZEsi22mi3),
    .AWBURSTsi2mi3 (AWBURSTsi22mi3),
    .AWLOCKsi2mi3  (AWLOCKsi22mi3),
    .AWCACHEsi2mi3 (AWCACHEsi22mi3),
    .AWPROTsi2mi3  (AWPROTsi22mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi22mi3),
    .WDATAsi2mi3   (WDATAsi22mi3),
    .WSTRBsi2mi3   (WSTRBsi22mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si2[MASTERID2_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi22mi4),
    .AWADDRsi2mi4  (AWADDRsi22mi4),
    .AWLENsi2mi4   (AWLENsi22mi4),
    .AWSIZEsi2mi4  (AWSIZEsi22mi4),
    .AWBURSTsi2mi4 (AWBURSTsi22mi4),
    .AWLOCKsi2mi4  (AWLOCKsi22mi4),
    .AWCACHEsi2mi4 (AWCACHEsi22mi4),
    .AWPROTsi2mi4  (AWPROTsi22mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi22mi4),
    .WDATAsi2mi4   (WDATAsi22mi4),
    .WSTRBsi2mi4   (WSTRBsi22mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si2[MASTERID2_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si2),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi22mi5),
    .AWADDRsi2mi5  (AWADDRsi22mi5),
    .AWLENsi2mi5   (AWLENsi22mi5),
    .AWSIZEsi2mi5  (AWSIZEsi22mi5),
    .AWBURSTsi2mi5 (AWBURSTsi22mi5),
    .AWLOCKsi2mi5  (AWLOCKsi22mi5),
    .AWCACHEsi2mi5 (AWCACHEsi22mi5),
    .AWPROTsi2mi5  (AWPROTsi22mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi22mi5),
    .WDATAsi2mi5   (WDATAsi22mi5),
    .WSTRBsi2mi5   (WSTRBsi22mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si2[MASTERID2_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si2),

    .AWVALIDsi2mi (AWVALIDsi22mi),
    .AWREADYmi2si (AWREADYmi2si2),

    .WLASTsi2mi   (WLASTsi22mi),
    .WVALIDsi2mi  (WVALIDsi22mi),
    .WREADYmi2si  (WREADYmi2si2),

    .BVALIDmi2si    (BVALIDmi2si2),
    .BREADYsi2mi    (BREADYsi22mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Master module 3    
//________________________________________________________________________

m3_RS_WriteChannelsi
m3_RS_WriteChannelsi(

    //For Master
    //Write address channel
    ///////////////////////////////////////////////
    .AWIDm2si    (AWIDm32si3),
    .AWADDRm2si  (AWADDRm32si3),
    .AWLENm2si   (AWLENm32si3),
    .AWSIZEm2si  (AWSIZEm32si3),
    .AWBURSTm2si (AWBURSTm32si3),
    .AWLOCKm2si  (AWLOCKm32si3),
    .AWCACHEm2si (AWCACHEm32si3),
    .AWPROTm2si  (AWPROTm32si3),

    .AWVALIDm2si (AWVALIDm32si3),
    .AWREADYsi2m (AWREADYsi32m3),

    //Write data channel
    .WIDm2si     (WIDm32si3),
    .WDATAm2si   (WDATAm32si3),
    .WSTRBm2si   (WSTRBm32si3),
    .WLASTm2si   (WLASTm32si3),
    .WVALIDm2si  (WVALIDm32si3),
    .WREADYsi2m  (WREADYsi32m3),

    //Write response channel
    .BIDsi2m     (BIDsi32m3),
    .BRESPsi2m   (BRESPsi32m3),
    .BVALIDsi2m  (BVALIDsi32m3),
    .BREADYm2si  (BREADYm32si3),

    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi0    (AWIDsi32mi0),
    .AWADDRsi2mi0  (AWADDRsi32mi0),
    .AWLENsi2mi0   (AWLENsi32mi0),
    .AWSIZEsi2mi0  (AWSIZEsi32mi0),
    .AWBURSTsi2mi0 (AWBURSTsi32mi0),
    .AWLOCKsi2mi0  (AWLOCKsi32mi0),
    .AWCACHEsi2mi0 (AWCACHEsi32mi0),
    .AWPROTsi2mi0  (AWPROTsi32mi0),

    //Write data channel
    .WIDsi2mi0     (WIDsi32mi0),
    .WDATAsi2mi0   (WDATAsi32mi0),
    .WSTRBsi2mi0   (WSTRBsi32mi0),

    //Write response channel

    //Slave Number 0
    .BIDmi02si     (BIDmi02si3[MASTERID3_WID-1:0]),
    .BRESPmi02si   (BRESPmi02si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi1    (AWIDsi32mi1),
    .AWADDRsi2mi1  (AWADDRsi32mi1),
    .AWLENsi2mi1   (AWLENsi32mi1),
    .AWSIZEsi2mi1  (AWSIZEsi32mi1),
    .AWBURSTsi2mi1 (AWBURSTsi32mi1),
    .AWLOCKsi2mi1  (AWLOCKsi32mi1),
    .AWCACHEsi2mi1 (AWCACHEsi32mi1),
    .AWPROTsi2mi1  (AWPROTsi32mi1),

    //Write data channel
    .WIDsi2mi1     (WIDsi32mi1),
    .WDATAsi2mi1   (WDATAsi32mi1),
    .WSTRBsi2mi1   (WSTRBsi32mi1),

    //Write response channel

    //Slave Number 1
    .BIDmi12si     (BIDmi12si3[MASTERID3_WID-1:0]),
    .BRESPmi12si   (BRESPmi12si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi2    (AWIDsi32mi2),
    .AWADDRsi2mi2  (AWADDRsi32mi2),
    .AWLENsi2mi2   (AWLENsi32mi2),
    .AWSIZEsi2mi2  (AWSIZEsi32mi2),
    .AWBURSTsi2mi2 (AWBURSTsi32mi2),
    .AWLOCKsi2mi2  (AWLOCKsi32mi2),
    .AWCACHEsi2mi2 (AWCACHEsi32mi2),
    .AWPROTsi2mi2  (AWPROTsi32mi2),

    //Write data channel
    .WIDsi2mi2     (WIDsi32mi2),
    .WDATAsi2mi2   (WDATAsi32mi2),
    .WSTRBsi2mi2   (WSTRBsi32mi2),

    //Write response channel

    //Slave Number 2
    .BIDmi22si     (BIDmi22si3[MASTERID3_WID-1:0]),
    .BRESPmi22si   (BRESPmi22si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi3    (AWIDsi32mi3),
    .AWADDRsi2mi3  (AWADDRsi32mi3),
    .AWLENsi2mi3   (AWLENsi32mi3),
    .AWSIZEsi2mi3  (AWSIZEsi32mi3),
    .AWBURSTsi2mi3 (AWBURSTsi32mi3),
    .AWLOCKsi2mi3  (AWLOCKsi32mi3),
    .AWCACHEsi2mi3 (AWCACHEsi32mi3),
    .AWPROTsi2mi3  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi2mi3     (WIDsi32mi3),
    .WDATAsi2mi3   (WDATAsi32mi3),
    .WSTRBsi2mi3   (WSTRBsi32mi3),

    //Write response channel

    //Slave Number 3
    .BIDmi32si     (BIDmi32si3[MASTERID3_WID-1:0]),
    .BRESPmi32si   (BRESPmi32si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi4    (AWIDsi32mi4),
    .AWADDRsi2mi4  (AWADDRsi32mi4),
    .AWLENsi2mi4   (AWLENsi32mi4),
    .AWSIZEsi2mi4  (AWSIZEsi32mi4),
    .AWBURSTsi2mi4 (AWBURSTsi32mi4),
    .AWLOCKsi2mi4  (AWLOCKsi32mi4),
    .AWCACHEsi2mi4 (AWCACHEsi32mi4),
    .AWPROTsi2mi4  (AWPROTsi32mi4),

    //Write data channel
    .WIDsi2mi4     (WIDsi32mi4),
    .WDATAsi2mi4   (WDATAsi32mi4),
    .WSTRBsi2mi4   (WSTRBsi32mi4),

    //Write response channel

    //Slave Number 4
    .BIDmi42si     (BIDmi42si3[MASTERID3_WID-1:0]),
    .BRESPmi42si   (BRESPmi42si3),
    ///////////////////////////////////////////////
    //For Master interface
    //Write address channel
    .AWIDsi2mi5    (AWIDsi32mi5),
    .AWADDRsi2mi5  (AWADDRsi32mi5),
    .AWLENsi2mi5   (AWLENsi32mi5),
    .AWSIZEsi2mi5  (AWSIZEsi32mi5),
    .AWBURSTsi2mi5 (AWBURSTsi32mi5),
    .AWLOCKsi2mi5  (AWLOCKsi32mi5),
    .AWCACHEsi2mi5 (AWCACHEsi32mi5),
    .AWPROTsi2mi5  (AWPROTsi32mi5),

    //Write data channel
    .WIDsi2mi5     (WIDsi32mi5),
    .WDATAsi2mi5   (WDATAsi32mi5),
    .WSTRBsi2mi5   (WSTRBsi32mi5),

    //Write response channel

    //Slave Number 5
    .BIDmi52si     (BIDmi52si3[MASTERID3_WID-1:0]),
    .BRESPmi52si   (BRESPmi52si3),

    .AWVALIDsi2mi (AWVALIDsi32mi),
    .AWREADYmi2si (AWREADYmi2si3),

    .WLASTsi2mi   (WLASTsi32mi),
    .WVALIDsi2mi  (WVALIDsi32mi),
    .WREADYmi2si  (WREADYmi2si3),

    .BVALIDmi2si    (BVALIDmi2si3),
    .BREADYsi2mi    (BREADYsi32mi),

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn)
);

//Slave module 0    
//___________________________________________________________________________

s0_RS_WriteChannelmi
s0_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi02s0),
    .AWADDRmi2s  (AWADDRmi02s0),
    .AWLENmi2s   (AWLENmi02s0),
    .AWSIZEmi2s  (AWSIZEmi02s0),
    .AWBURSTmi2s (AWBURSTmi02s0),
    .AWLOCKmi2s  (AWLOCKmi02s0),
    .AWCACHEmi2s (AWCACHEmi02s0),
    .AWPROTmi2s  (AWPROTmi02s0),

    .AWVALIDmi2s (AWVALIDmi02s0),
    .AWREADYs2mi (AWREADYs02mi0),

    //Write data channel
    .WIDmi2s     (WIDmi02s0),
    .WDATAmi2s   (WDATAmi02s0),
    .WSTRBmi2s   (WSTRBmi02s0),
    .WLASTmi2s   (WLASTmi02s0),
    .WVALIDmi2s  (WVALIDmi02s0),
    .WREADYs2mi  (WREADYs02mi0),

    //Write response channel
    .BIDs2mi     (BIDs02mi0),
    .BRESPs2mi   (BRESPs02mi0),
    .BVALIDs2mi  (BVALIDs02mi0),
    .BREADYmi2s  (BREADYmi02s0),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi0),
    .AWLENsi02mi   (AWLENsi02mi0),
    .AWSIZEsi02mi  (AWSIZEsi02mi0),
    .AWBURSTsi02mi (AWBURSTsi02mi0),
    .AWLOCKsi02mi  (AWLOCKsi02mi0),
    .AWCACHEsi02mi (AWCACHEsi02mi0),
    .AWPROTsi02mi  (AWPROTsi02mi0),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi0),   
    .WSTRBsi02mi (WSTRBsi02mi0),   

    //Write response channel
    .BIDmi2si0     (BIDmi02si0),
    .BRESPmi2si0   (BRESPmi02si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi0),
    .AWLENsi12mi   (AWLENsi12mi0),
    .AWSIZEsi12mi  (AWSIZEsi12mi0),
    .AWBURSTsi12mi (AWBURSTsi12mi0),
    .AWLOCKsi12mi  (AWLOCKsi12mi0),
    .AWCACHEsi12mi (AWCACHEsi12mi0),
    .AWPROTsi12mi  (AWPROTsi12mi0),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi0),   
    .WSTRBsi12mi (WSTRBsi12mi0),   

    //Write response channel
    .BIDmi2si1     (BIDmi02si1),
    .BRESPmi2si1   (BRESPmi02si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi0),
    .AWLENsi22mi   (AWLENsi22mi0),
    .AWSIZEsi22mi  (AWSIZEsi22mi0),
    .AWBURSTsi22mi (AWBURSTsi22mi0),
    .AWLOCKsi22mi  (AWLOCKsi22mi0),
    .AWCACHEsi22mi (AWCACHEsi22mi0),
    .AWPROTsi22mi  (AWPROTsi22mi0),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi0),   
    .WSTRBsi22mi (WSTRBsi22mi0),   

    //Write response channel
    .BIDmi2si2     (BIDmi02si2),
    .BRESPmi2si2   (BRESPmi02si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi0[SLAVE_MASTERID0_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi0),
    .AWLENsi32mi   (AWLENsi32mi0),
    .AWSIZEsi32mi  (AWSIZEsi32mi0),
    .AWBURSTsi32mi (AWBURSTsi32mi0),
    .AWLOCKsi32mi  (AWLOCKsi32mi0),
    .AWCACHEsi32mi (AWCACHEsi32mi0),
    .AWPROTsi32mi  (AWPROTsi32mi0),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi0[SLAVE_MASTERID0_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi0),   
    .WSTRBsi32mi (WSTRBsi32mi0),   

    //Write response channel
    .BIDmi2si3     (BIDmi02si3),
    .BRESPmi2si3   (BRESPmi02si3),

    .BVALIDmi2si  (BVALIDmi02si),
    .BREADYsi2mi   (BREADYsi2mi0),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi0),
    .AWREADYmi2si  (AWREADYmi02si),
    .WLASTsi2mi    (WLASTsi2mi0),
    .WVALIDsi2mi   (WVALIDsi2mi0),
    .WREADYmi2si   (WREADYmi02si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi0),
    .UnLock2Wrmi(UnLock2wrmi0),

    .Lock2Rdmi(Lock2rdmi0),
    .UnLock2Rdmi(UnLock2rdmi0),

    .ARVALID(ARVALIDmi02s0),
    .LockPort(LockPort2wrmi0),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi02Rdmi0),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi02Wrmi0),
    .CtlDataWrite2Lock(CtlDataWrite2Lock0)
    ////////////////////////////////////////

    );

//Slave module 1    
//___________________________________________________________________________

s1_RS_WriteChannelmi
s1_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi12s1),
    .AWADDRmi2s  (AWADDRmi12s1),
    .AWLENmi2s   (AWLENmi12s1),
    .AWSIZEmi2s  (AWSIZEmi12s1),
    .AWBURSTmi2s (AWBURSTmi12s1),
    .AWLOCKmi2s  (AWLOCKmi12s1),
    .AWCACHEmi2s (AWCACHEmi12s1),
    .AWPROTmi2s  (AWPROTmi12s1),

    .AWVALIDmi2s (AWVALIDmi12s1),
    .AWREADYs2mi (AWREADYs12mi1),

    //Write data channel
    .WIDmi2s     (WIDmi12s1),
    .WDATAmi2s   (WDATAmi12s1),
    .WSTRBmi2s   (WSTRBmi12s1),
    .WLASTmi2s   (WLASTmi12s1),
    .WVALIDmi2s  (WVALIDmi12s1),
    .WREADYs2mi  (WREADYs12mi1),

    //Write response channel
    .BIDs2mi     (BIDs12mi1),
    .BRESPs2mi   (BRESPs12mi1),
    .BVALIDs2mi  (BVALIDs12mi1),
    .BREADYmi2s  (BREADYmi12s1),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi1),
    .AWLENsi02mi   (AWLENsi02mi1),
    .AWSIZEsi02mi  (AWSIZEsi02mi1),
    .AWBURSTsi02mi (AWBURSTsi02mi1),
    .AWLOCKsi02mi  (AWLOCKsi02mi1),
    .AWCACHEsi02mi (AWCACHEsi02mi1),
    .AWPROTsi02mi  (AWPROTsi02mi1),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi1),   
    .WSTRBsi02mi (WSTRBsi02mi1),   

    //Write response channel
    .BIDmi2si0     (BIDmi12si0),
    .BRESPmi2si0   (BRESPmi12si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi1),
    .AWLENsi12mi   (AWLENsi12mi1),
    .AWSIZEsi12mi  (AWSIZEsi12mi1),
    .AWBURSTsi12mi (AWBURSTsi12mi1),
    .AWLOCKsi12mi  (AWLOCKsi12mi1),
    .AWCACHEsi12mi (AWCACHEsi12mi1),
    .AWPROTsi12mi  (AWPROTsi12mi1),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi1),   
    .WSTRBsi12mi (WSTRBsi12mi1),   

    //Write response channel
    .BIDmi2si1     (BIDmi12si1),
    .BRESPmi2si1   (BRESPmi12si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi1),
    .AWLENsi22mi   (AWLENsi22mi1),
    .AWSIZEsi22mi  (AWSIZEsi22mi1),
    .AWBURSTsi22mi (AWBURSTsi22mi1),
    .AWLOCKsi22mi  (AWLOCKsi22mi1),
    .AWCACHEsi22mi (AWCACHEsi22mi1),
    .AWPROTsi22mi  (AWPROTsi22mi1),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi1),   
    .WSTRBsi22mi (WSTRBsi22mi1),   

    //Write response channel
    .BIDmi2si2     (BIDmi12si2),
    .BRESPmi2si2   (BRESPmi12si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi1[SLAVE_MASTERID1_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi1),
    .AWLENsi32mi   (AWLENsi32mi1),
    .AWSIZEsi32mi  (AWSIZEsi32mi1),
    .AWBURSTsi32mi (AWBURSTsi32mi1),
    .AWLOCKsi32mi  (AWLOCKsi32mi1),
    .AWCACHEsi32mi (AWCACHEsi32mi1),
    .AWPROTsi32mi  (AWPROTsi32mi1),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi1[SLAVE_MASTERID1_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi1),   
    .WSTRBsi32mi (WSTRBsi32mi1),   

    //Write response channel
    .BIDmi2si3     (BIDmi12si3),
    .BRESPmi2si3   (BRESPmi12si3),

    .BVALIDmi2si  (BVALIDmi12si),
    .BREADYsi2mi   (BREADYsi2mi1),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi1),
    .AWREADYmi2si  (AWREADYmi12si),
    .WLASTsi2mi    (WLASTsi2mi1),
    .WVALIDsi2mi   (WVALIDsi2mi1),
    .WREADYmi2si   (WREADYmi12si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi1),
    .UnLock2Wrmi(UnLock2wrmi1),

    .Lock2Rdmi(Lock2rdmi1),
    .UnLock2Rdmi(UnLock2rdmi1),

    .ARVALID(ARVALIDmi12s1),
    .LockPort(LockPort2wrmi1),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi12Rdmi1),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi12Wrmi1),
    .CtlDataWrite2Lock(CtlDataWrite2Lock1)
    ////////////////////////////////////////

    );

//Slave module 2    
//___________________________________________________________________________

s2_RS_WriteChannelmi
s2_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi22s2),
    .AWADDRmi2s  (AWADDRmi22s2),
    .AWLENmi2s   (AWLENmi22s2),
    .AWSIZEmi2s  (AWSIZEmi22s2),
    .AWBURSTmi2s (AWBURSTmi22s2),
    .AWLOCKmi2s  (AWLOCKmi22s2),
    .AWCACHEmi2s (AWCACHEmi22s2),
    .AWPROTmi2s  (AWPROTmi22s2),

    .AWVALIDmi2s (AWVALIDmi22s2),
    .AWREADYs2mi (AWREADYs22mi2),

    //Write data channel
    .WIDmi2s     (WIDmi22s2),
    .WDATAmi2s   (WDATAmi22s2),
    .WSTRBmi2s   (WSTRBmi22s2),
    .WLASTmi2s   (WLASTmi22s2),
    .WVALIDmi2s  (WVALIDmi22s2),
    .WREADYs2mi  (WREADYs22mi2),

    //Write response channel
    .BIDs2mi     (BIDs22mi2),
    .BRESPs2mi   (BRESPs22mi2),
    .BVALIDs2mi  (BVALIDs22mi2),
    .BREADYmi2s  (BREADYmi22s2),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi2),
    .AWLENsi02mi   (AWLENsi02mi2),
    .AWSIZEsi02mi  (AWSIZEsi02mi2),
    .AWBURSTsi02mi (AWBURSTsi02mi2),
    .AWLOCKsi02mi  (AWLOCKsi02mi2),
    .AWCACHEsi02mi (AWCACHEsi02mi2),
    .AWPROTsi02mi  (AWPROTsi02mi2),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi2),   
    .WSTRBsi02mi (WSTRBsi02mi2),   

    //Write response channel
    .BIDmi2si0     (BIDmi22si0),
    .BRESPmi2si0   (BRESPmi22si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi2),
    .AWLENsi12mi   (AWLENsi12mi2),
    .AWSIZEsi12mi  (AWSIZEsi12mi2),
    .AWBURSTsi12mi (AWBURSTsi12mi2),
    .AWLOCKsi12mi  (AWLOCKsi12mi2),
    .AWCACHEsi12mi (AWCACHEsi12mi2),
    .AWPROTsi12mi  (AWPROTsi12mi2),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi2),   
    .WSTRBsi12mi (WSTRBsi12mi2),   

    //Write response channel
    .BIDmi2si1     (BIDmi22si1),
    .BRESPmi2si1   (BRESPmi22si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi2),
    .AWLENsi22mi   (AWLENsi22mi2),
    .AWSIZEsi22mi  (AWSIZEsi22mi2),
    .AWBURSTsi22mi (AWBURSTsi22mi2),
    .AWLOCKsi22mi  (AWLOCKsi22mi2),
    .AWCACHEsi22mi (AWCACHEsi22mi2),
    .AWPROTsi22mi  (AWPROTsi22mi2),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi2),   
    .WSTRBsi22mi (WSTRBsi22mi2),   

    //Write response channel
    .BIDmi2si2     (BIDmi22si2),
    .BRESPmi2si2   (BRESPmi22si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi2[SLAVE_MASTERID2_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi2),
    .AWLENsi32mi   (AWLENsi32mi2),
    .AWSIZEsi32mi  (AWSIZEsi32mi2),
    .AWBURSTsi32mi (AWBURSTsi32mi2),
    .AWLOCKsi32mi  (AWLOCKsi32mi2),
    .AWCACHEsi32mi (AWCACHEsi32mi2),
    .AWPROTsi32mi  (AWPROTsi32mi2),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi2[SLAVE_MASTERID2_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi2),   
    .WSTRBsi32mi (WSTRBsi32mi2),   

    //Write response channel
    .BIDmi2si3     (BIDmi22si3),
    .BRESPmi2si3   (BRESPmi22si3),

    .BVALIDmi2si  (BVALIDmi22si),
    .BREADYsi2mi   (BREADYsi2mi2),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi2),
    .AWREADYmi2si  (AWREADYmi22si),
    .WLASTsi2mi    (WLASTsi2mi2),
    .WVALIDsi2mi   (WVALIDsi2mi2),
    .WREADYmi2si   (WREADYmi22si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi2),
    .UnLock2Wrmi(UnLock2wrmi2),

    .Lock2Rdmi(Lock2rdmi2),
    .UnLock2Rdmi(UnLock2rdmi2),

    .ARVALID(ARVALIDmi22s2),
    .LockPort(LockPort2wrmi2),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi22Rdmi2),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi22Wrmi2),
    .CtlDataWrite2Lock(CtlDataWrite2Lock2)
    ////////////////////////////////////////

    );

//Slave module 3    
//___________________________________________________________________________

s3_RS_WriteChannelmi
s3_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi32s3),
    .AWADDRmi2s  (AWADDRmi32s3),
    .AWLENmi2s   (AWLENmi32s3),
    .AWSIZEmi2s  (AWSIZEmi32s3),
    .AWBURSTmi2s (AWBURSTmi32s3),
    .AWLOCKmi2s  (AWLOCKmi32s3),
    .AWCACHEmi2s (AWCACHEmi32s3),
    .AWPROTmi2s  (AWPROTmi32s3),

    .AWVALIDmi2s (AWVALIDmi32s3),
    .AWREADYs2mi (AWREADYs32mi3),

    //Write data channel
    .WIDmi2s     (WIDmi32s3),
    .WDATAmi2s   (WDATAmi32s3),
    .WSTRBmi2s   (WSTRBmi32s3),
    .WLASTmi2s   (WLASTmi32s3),
    .WVALIDmi2s  (WVALIDmi32s3),
    .WREADYs2mi  (WREADYs32mi3),

    //Write response channel
    .BIDs2mi     (BIDs32mi3),
    .BRESPs2mi   (BRESPs32mi3),
    .BVALIDs2mi  (BVALIDs32mi3),
    .BREADYmi2s  (BREADYmi32s3),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi3),
    .AWLENsi02mi   (AWLENsi02mi3),
    .AWSIZEsi02mi  (AWSIZEsi02mi3),
    .AWBURSTsi02mi (AWBURSTsi02mi3),
    .AWLOCKsi02mi  (AWLOCKsi02mi3),
    .AWCACHEsi02mi (AWCACHEsi02mi3),
    .AWPROTsi02mi  (AWPROTsi02mi3),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi3),   
    .WSTRBsi02mi (WSTRBsi02mi3),   

    //Write response channel
    .BIDmi2si0     (BIDmi32si0),
    .BRESPmi2si0   (BRESPmi32si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi3),
    .AWLENsi12mi   (AWLENsi12mi3),
    .AWSIZEsi12mi  (AWSIZEsi12mi3),
    .AWBURSTsi12mi (AWBURSTsi12mi3),
    .AWLOCKsi12mi  (AWLOCKsi12mi3),
    .AWCACHEsi12mi (AWCACHEsi12mi3),
    .AWPROTsi12mi  (AWPROTsi12mi3),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi3),   
    .WSTRBsi12mi (WSTRBsi12mi3),   

    //Write response channel
    .BIDmi2si1     (BIDmi32si1),
    .BRESPmi2si1   (BRESPmi32si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi3),
    .AWLENsi22mi   (AWLENsi22mi3),
    .AWSIZEsi22mi  (AWSIZEsi22mi3),
    .AWBURSTsi22mi (AWBURSTsi22mi3),
    .AWLOCKsi22mi  (AWLOCKsi22mi3),
    .AWCACHEsi22mi (AWCACHEsi22mi3),
    .AWPROTsi22mi  (AWPROTsi22mi3),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi3),   
    .WSTRBsi22mi (WSTRBsi22mi3),   

    //Write response channel
    .BIDmi2si2     (BIDmi32si2),
    .BRESPmi2si2   (BRESPmi32si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi3),
    .AWLENsi32mi   (AWLENsi32mi3),
    .AWSIZEsi32mi  (AWSIZEsi32mi3),
    .AWBURSTsi32mi (AWBURSTsi32mi3),
    .AWLOCKsi32mi  (AWLOCKsi32mi3),
    .AWCACHEsi32mi (AWCACHEsi32mi3),
    .AWPROTsi32mi  (AWPROTsi32mi3),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi3[SLAVE_MASTERID3_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi3),   
    .WSTRBsi32mi (WSTRBsi32mi3),   

    //Write response channel
    .BIDmi2si3     (BIDmi32si3),
    .BRESPmi2si3   (BRESPmi32si3),

    .BVALIDmi2si  (BVALIDmi32si),
    .BREADYsi2mi   (BREADYsi2mi3),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi3),
    .AWREADYmi2si  (AWREADYmi32si),
    .WLASTsi2mi    (WLASTsi2mi3),
    .WVALIDsi2mi   (WVALIDsi2mi3),
    .WREADYmi2si   (WREADYmi32si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi3),
    .UnLock2Wrmi(UnLock2wrmi3),

    .Lock2Rdmi(Lock2rdmi3),
    .UnLock2Rdmi(UnLock2rdmi3),

    .ARVALID(ARVALIDmi32s3),
    .LockPort(LockPort2wrmi3),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi32Rdmi3),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi32Wrmi3),
    .CtlDataWrite2Lock(CtlDataWrite2Lock3)
    ////////////////////////////////////////

    );

//Slave module 4    
//___________________________________________________________________________

s4_RS_WriteChannelmi
s4_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi42s4),
    .AWADDRmi2s  (AWADDRmi42s4),
    .AWLENmi2s   (AWLENmi42s4),
    .AWSIZEmi2s  (AWSIZEmi42s4),
    .AWBURSTmi2s (AWBURSTmi42s4),
    .AWLOCKmi2s  (AWLOCKmi42s4),
    .AWCACHEmi2s (AWCACHEmi42s4),
    .AWPROTmi2s  (AWPROTmi42s4),

    .AWVALIDmi2s (AWVALIDmi42s4),
    .AWREADYs2mi (AWREADYs42mi4),

    //Write data channel
    .WIDmi2s     (WIDmi42s4),
    .WDATAmi2s   (WDATAmi42s4),
    .WSTRBmi2s   (WSTRBmi42s4),
    .WLASTmi2s   (WLASTmi42s4),
    .WVALIDmi2s  (WVALIDmi42s4),
    .WREADYs2mi  (WREADYs42mi4),

    //Write response channel
    .BIDs2mi     (BIDs42mi4),
    .BRESPs2mi   (BRESPs42mi4),
    .BVALIDs2mi  (BVALIDs42mi4),
    .BREADYmi2s  (BREADYmi42s4),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi4),
    .AWLENsi02mi   (AWLENsi02mi4),
    .AWSIZEsi02mi  (AWSIZEsi02mi4),
    .AWBURSTsi02mi (AWBURSTsi02mi4),
    .AWLOCKsi02mi  (AWLOCKsi02mi4),
    .AWCACHEsi02mi (AWCACHEsi02mi4),
    .AWPROTsi02mi  (AWPROTsi02mi4),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi4),   
    .WSTRBsi02mi (WSTRBsi02mi4),   

    //Write response channel
    .BIDmi2si0     (BIDmi42si0),
    .BRESPmi2si0   (BRESPmi42si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi4),
    .AWLENsi12mi   (AWLENsi12mi4),
    .AWSIZEsi12mi  (AWSIZEsi12mi4),
    .AWBURSTsi12mi (AWBURSTsi12mi4),
    .AWLOCKsi12mi  (AWLOCKsi12mi4),
    .AWCACHEsi12mi (AWCACHEsi12mi4),
    .AWPROTsi12mi  (AWPROTsi12mi4),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi4),   
    .WSTRBsi12mi (WSTRBsi12mi4),   

    //Write response channel
    .BIDmi2si1     (BIDmi42si1),
    .BRESPmi2si1   (BRESPmi42si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi4),
    .AWLENsi22mi   (AWLENsi22mi4),
    .AWSIZEsi22mi  (AWSIZEsi22mi4),
    .AWBURSTsi22mi (AWBURSTsi22mi4),
    .AWLOCKsi22mi  (AWLOCKsi22mi4),
    .AWCACHEsi22mi (AWCACHEsi22mi4),
    .AWPROTsi22mi  (AWPROTsi22mi4),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi4),   
    .WSTRBsi22mi (WSTRBsi22mi4),   

    //Write response channel
    .BIDmi2si2     (BIDmi42si2),
    .BRESPmi2si2   (BRESPmi42si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi4[SLAVE_MASTERID4_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi4),
    .AWLENsi32mi   (AWLENsi32mi4),
    .AWSIZEsi32mi  (AWSIZEsi32mi4),
    .AWBURSTsi32mi (AWBURSTsi32mi4),
    .AWLOCKsi32mi  (AWLOCKsi32mi4),
    .AWCACHEsi32mi (AWCACHEsi32mi4),
    .AWPROTsi32mi  (AWPROTsi32mi4),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi4[SLAVE_MASTERID4_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi4),   
    .WSTRBsi32mi (WSTRBsi32mi4),   

    //Write response channel
    .BIDmi2si3     (BIDmi42si3),
    .BRESPmi2si3   (BRESPmi42si3),

    .BVALIDmi2si  (BVALIDmi42si),
    .BREADYsi2mi   (BREADYsi2mi4),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi4),
    .AWREADYmi2si  (AWREADYmi42si),
    .WLASTsi2mi    (WLASTsi2mi4),
    .WVALIDsi2mi   (WVALIDsi2mi4),
    .WREADYmi2si   (WREADYmi42si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi4),
    .UnLock2Wrmi(UnLock2wrmi4),

    .Lock2Rdmi(Lock2rdmi4),
    .UnLock2Rdmi(UnLock2rdmi4),

    .ARVALID(ARVALIDmi42s4),
    .LockPort(LockPort2wrmi4),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi42Rdmi4),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi42Wrmi4),
    .CtlDataWrite2Lock(CtlDataWrite2Lock4)
    ////////////////////////////////////////

    );

//Slave module 5    
//___________________________________________________________________________

default_RS_WriteChannelmi
default_RS_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK),
    .ARESETn (ARESETn),

    //For slave 
    //////////////////////////////////////////////
    //Write address channel
    .AWIDmi2s    (AWIDmi52s5),
    .AWADDRmi2s  (AWADDRmi52s5),
    .AWLENmi2s   (AWLENmi52s5),
    .AWSIZEmi2s  (AWSIZEmi52s5),
    .AWBURSTmi2s (AWBURSTmi52s5),
    .AWLOCKmi2s  (AWLOCKmi52s5),
    .AWCACHEmi2s (AWCACHEmi52s5),
    .AWPROTmi2s  (AWPROTmi52s5),

    .AWVALIDmi2s (AWVALIDmi52s5),
    .AWREADYs2mi (AWREADYs52mi5),

    //Write data channel
    .WIDmi2s     (WIDmi52s5),
    .WDATAmi2s   (WDATAmi52s5),
    .WSTRBmi2s   (WSTRBmi52s5),
    .WLASTmi2s   (WLASTmi52s5),
    .WVALIDmi2s  (WVALIDmi52s5),
    .WREADYs2mi  (WREADYs52mi5),

    //Write response channel
    .BIDs2mi     (BIDs52mi5),
    .BRESPs2mi   (BRESPs52mi5),
    .BVALIDs2mi  (BVALIDs52mi5),
    .BREADYmi2s  (BREADYmi52s5),

    //////////////////////////////////////////////

    //Master Number 0
    //Write address channel
    .AWIDsi02mi    (wAWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi02mi  (AWADDRsi02mi5),
    .AWLENsi02mi   (AWLENsi02mi5),
    .AWSIZEsi02mi  (AWSIZEsi02mi5),
    .AWBURSTsi02mi (AWBURSTsi02mi5),
    .AWLOCKsi02mi  (AWLOCKsi02mi5),
    .AWCACHEsi02mi (AWCACHEsi02mi5),
    .AWPROTsi02mi  (AWPROTsi02mi5),

    //Write data channel
    .WIDsi02mi   (wWIDsi02mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi02mi (WDATAsi02mi5),   
    .WSTRBsi02mi (WSTRBsi02mi5),   

    //Write response channel
    .BIDmi2si0     (BIDmi52si0),
    .BRESPmi2si0   (BRESPmi52si0),
    //Master Number 1
    //Write address channel
    .AWIDsi12mi    (wAWIDsi12mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi12mi  (AWADDRsi12mi5),
    .AWLENsi12mi   (AWLENsi12mi5),
    .AWSIZEsi12mi  (AWSIZEsi12mi5),
    .AWBURSTsi12mi (AWBURSTsi12mi5),
    .AWLOCKsi12mi  (AWLOCKsi12mi5),
    .AWCACHEsi12mi (AWCACHEsi12mi5),
    .AWPROTsi12mi  (AWPROTsi12mi5),

    //Write data channel
    .WIDsi12mi   (wWIDsi12mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi12mi (WDATAsi12mi5),   
    .WSTRBsi12mi (WSTRBsi12mi5),   

    //Write response channel
    .BIDmi2si1     (BIDmi52si1),
    .BRESPmi2si1   (BRESPmi52si1),
    //Master Number 2
    //Write address channel
    .AWIDsi22mi    (wAWIDsi22mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi22mi  (AWADDRsi22mi5),
    .AWLENsi22mi   (AWLENsi22mi5),
    .AWSIZEsi22mi  (AWSIZEsi22mi5),
    .AWBURSTsi22mi (AWBURSTsi22mi5),
    .AWLOCKsi22mi  (AWLOCKsi22mi5),
    .AWCACHEsi22mi (AWCACHEsi22mi5),
    .AWPROTsi22mi  (AWPROTsi22mi5),

    //Write data channel
    .WIDsi22mi   (wWIDsi22mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi22mi (WDATAsi22mi5),   
    .WSTRBsi22mi (WSTRBsi22mi5),   

    //Write response channel
    .BIDmi2si2     (BIDmi52si2),
    .BRESPmi2si2   (BRESPmi52si2),
    //Master Number 3
    //Write address channel
    .AWIDsi32mi    (wAWIDsi32mi5[SLAVE_MASTERID5_WID-1:0]),
    .AWADDRsi32mi  (AWADDRsi32mi5),
    .AWLENsi32mi   (AWLENsi32mi5),
    .AWSIZEsi32mi  (AWSIZEsi32mi5),
    .AWBURSTsi32mi (AWBURSTsi32mi5),
    .AWLOCKsi32mi  (AWLOCKsi32mi5),
    .AWCACHEsi32mi (AWCACHEsi32mi5),
    .AWPROTsi32mi  (AWPROTsi32mi5),

    //Write data channel
    .WIDsi32mi   (wWIDsi32mi5[SLAVE_MASTERID5_WID-1:0]),     
    .WDATAsi32mi (WDATAsi32mi5),   
    .WSTRBsi32mi (WSTRBsi32mi5),   

    //Write response channel
    .BIDmi2si3     (BIDmi52si3),
    .BRESPmi2si3   (BRESPmi52si3),

    .BVALIDmi2si  (BVALIDmi52si),
    .BREADYsi2mi   (BREADYsi2mi5),
    //////////////////////////////////////////////
    
    //Master 0/1/2/3 and so on...
    .AWVALIDsi2mi  (AWVALIDsi2mi5),
    .AWREADYmi2si  (AWREADYmi52si),
    .WLASTsi2mi    (WLASTsi2mi5),
    .WVALIDsi2mi   (WVALIDsi2mi5),
    .WREADYmi2si   (WREADYmi52si),

    //Lock access
    ////////////////////////////////////////
    .Lock2Wrmi(Lock2wrmi5),
    .UnLock2Wrmi(UnLock2wrmi5),

    .Lock2Rdmi(Lock2rdmi5),
    .UnLock2Rdmi(UnLock2rdmi5),

    .ARVALID(ARVALIDmi52s5),
    .LockPort(LockPort2wrmi5),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi52Rdmi5),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi52Wrmi5),
    .CtlDataWrite2Lock(CtlDataWrite2Lock5)
    ////////////////////////////////////////

    );

endmodule
