// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : WriteChannelsi.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : WriteChannel SlaveInterface Block
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
// 531 :: Ver 1.2 inserting data channel mask signal  ( WENn )
// Syn 309 :: modify ELAB-292(senstivelist)

`timescale 1 ns/ 10ps
module  s1_RS_WriteChannelmi(
    
    //Global signal
    ACLK    ,
    ARESETn ,

    //For slave 
    //Write address channel
    AWIDmi2s    ,
    AWADDRmi2s  ,
    AWLENmi2s   ,
    AWSIZEmi2s  ,
    AWBURSTmi2s ,
    AWLOCKmi2s  ,
    AWCACHEmi2s ,
    AWPROTmi2s  ,

    AWVALIDmi2s ,
    AWREADYs2mi ,

    //Write data channel
    WIDmi2s     ,
    WDATAmi2s   ,
    WSTRBmi2s   ,
    WLASTmi2s   ,
    WVALIDmi2s  ,
    WREADYs2mi  ,

    //Write response channel
    BIDs2mi     ,
    BRESPs2mi   ,
    BVALIDs2mi  ,
    BREADYmi2s  ,

    //Slave interface signal
    /////////////////////////////////////////////////////////////


//INOUT_STATE00_START
    //Master0
    //Write address channel
    //____________________________________
    AWIDsi02mi    ,
    AWADDRsi02mi  ,
    AWLENsi02mi   ,
    AWSIZEsi02mi  ,
    AWBURSTsi02mi ,
    AWLOCKsi02mi  ,
    AWCACHEsi02mi ,
    AWPROTsi02mi  ,
    //____________________________________
    //Write data channel
    WIDsi02mi   ,     
    WDATAsi02mi ,   
    WSTRBsi02mi , 

    //Master1
    //Write address channel
    //____________________________________
    AWIDsi12mi    ,
    AWADDRsi12mi  ,
    AWLENsi12mi   ,
    AWSIZEsi12mi  ,
    AWBURSTsi12mi ,
    AWLOCKsi12mi  ,
    AWCACHEsi12mi ,
    AWPROTsi12mi  ,
    //____________________________________
    //Write data channel
    WIDsi12mi   ,     
    WDATAsi12mi ,   
    WSTRBsi12mi , 

    //Master2
    //Write address channel
    //____________________________________
    AWIDsi22mi    ,
    AWADDRsi22mi  ,
    AWLENsi22mi   ,
    AWSIZEsi22mi  ,
    AWBURSTsi22mi ,
    AWLOCKsi22mi  ,
    AWCACHEsi22mi ,
    AWPROTsi22mi  ,
    //____________________________________
    //Write data channel
    WIDsi22mi   ,     
    WDATAsi22mi ,   
    WSTRBsi22mi , 

    //Master3
    //Write address channel
    //____________________________________
    AWIDsi32mi    ,
    AWADDRsi32mi  ,
    AWLENsi32mi   ,
    AWSIZEsi32mi  ,
    AWBURSTsi32mi ,
    AWLOCKsi32mi  ,
    AWCACHEsi32mi ,
    AWPROTsi32mi  ,
    //____________________________________
    //Write data channel
    WIDsi32mi   ,     
    WDATAsi32mi ,   
    WSTRBsi32mi , 

////////////////////////////
    //____________________________________
    //Write response channel

    BIDmi2si0     ,
    BRESPmi2si0   ,

    BIDmi2si1     ,
    BRESPmi2si1   ,

    BIDmi2si2     ,
    BRESPmi2si2   ,

    BIDmi2si3     ,
    BRESPmi2si3   ,

////////////////////////////
    
    BVALIDmi2si  ,
    BREADYsi2mi,
    //____________________________________
    

//LOCKSig_START
    //Lock control
    //____________________________________
    Lock2Wrmi,
    UnLock2Wrmi,

    Lock2Rdmi,
    UnLock2Rdmi,
    ARVALID,

    LockPort,
    ReadIntEmptyWrmi2Rdmi,
    DataCntEmptyRdmi2Wrmi,
    CtlDataWrite2Lock,
    //____________________________________
//LOCKSig_END

    //Master 0/1/2/3
    AWVALIDsi2mi  ,
    AWREADYmi2si  ,

    //Master 0/1/2/3
    WLASTsi2mi   ,
    WVALIDsi2mi  ,

    //output 1port
    WREADYmi2si  
    );
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 3;
parameter RdPermit_SLAVECNTWID= 3;
parameter ARSIZE_WID= 3;


    input   ACLK;
    input   ARESETn;

    // For slave 
    // 2s (Slave)
    output   [SLAVEID_WID-1:0]  AWIDmi2s;    
    output   [ADDR_WID-1:0]     AWADDRmi2s;
    output   [AWLEN_WID-1:0]    AWLENmi2s;
    output   [AWSIZE_WID-1:0]   AWSIZEmi2s;  
    output   [AWBURST_WID-1:0]  AWBURSTmi2s; 
    output   [AWLOCK_WID-1:0]   AWLOCKmi2s;  
    output   [AWCACHE_WID-1:0]  AWCACHEmi2s; 
    output   [AWPROT_WID-1:0]   AWPROTmi2s;  

    output   AWVALIDmi2s; 
    input    AWREADYs2mi; 
    

    //Write data channel
    output   [SLAVEID_WID-1:0]       WIDmi2s;     
    output   [BUS_WID-1:0]      WDATAmi2s;   
    output   [WSTRB_WID-1:0]    WSTRBmi2s;   
    output   WLASTmi2s;   
    output   WVALIDmi2s;  
    input    WREADYs2mi; 

    //Write response channel
    input   [SLAVEID_WID-1:0]      BIDs2mi;     
    input   [BRESP_WID-1:0]   BRESPs2mi;   
    input   BVALIDs2mi;  
    output  BREADYmi2s;  

    
    //Master0
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi02mi;    
    input   [ADDR_WID-1:0]     AWADDRsi02mi;
    input   [AWLEN_WID-1:0]    AWLENsi02mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi02mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi02mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi02mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi02mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi02mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi02mi;     
    input   [BUS_WID-1:0]  WDATAsi02mi;   
    input   [WSTRB_WID-1:0]WSTRBsi02mi;   
    //__________________________________________________

    
    //Master1
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi12mi;    
    input   [ADDR_WID-1:0]     AWADDRsi12mi;
    input   [AWLEN_WID-1:0]    AWLENsi12mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi12mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi12mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi12mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi12mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi12mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi12mi;     
    input   [BUS_WID-1:0]  WDATAsi12mi;   
    input   [WSTRB_WID-1:0]WSTRBsi12mi;   
    //__________________________________________________

    
    //Master2
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi22mi;    
    input   [ADDR_WID-1:0]     AWADDRsi22mi;
    input   [AWLEN_WID-1:0]    AWLENsi22mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi22mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi22mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi22mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi22mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi22mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi22mi;     
    input   [BUS_WID-1:0]  WDATAsi22mi;   
    input   [WSTRB_WID-1:0]WSTRBsi22mi;   
    //__________________________________________________

    
    //Master3
    //Write address channel
    //__________________________________________________
    input   [MASTERID_WID-1:0]       AWIDsi32mi;    
    input   [ADDR_WID-1:0]     AWADDRsi32mi;
    input   [AWLEN_WID-1:0]    AWLENsi32mi;
    input   [AWSIZE_WID-1:0]   AWSIZEsi32mi;  
    input   [AWBURST_WID-1:0]  AWBURSTsi32mi; 
    input   [AWLOCK_WID-1:0]   AWLOCKsi32mi;  
    input   [AWCACHE_WID-1:0]  AWCACHEsi32mi; 
    input   [AWPROT_WID-1:0]   AWPROTsi32mi; 

    //Write data channel
    input   [MASTERID_WID-1:0]   WIDsi32mi;     
    input   [BUS_WID-1:0]  WDATAsi32mi;   
    input   [WSTRB_WID-1:0]WSTRBsi32mi;   
    //__________________________________________________

////////////////////////////

    input   [MASTER_NUM-1:0]AWVALIDsi2mi;
    output  [MASTER_NUM-1:0]AWREADYmi2si;

    input   [MASTER_NUM-1:0]WLASTsi2mi;   
    input   [MASTER_NUM-1:0]WVALIDsi2mi;  
    output  [MASTER_NUM-1:0]WREADYmi2si;  

    //Write response channel
    output   [MASTERID_WID-1:0]    BIDmi2si0;     
    output   [BRESP_WID-1:0] BRESPmi2si0;   

    output   [MASTERID_WID-1:0]    BIDmi2si1;     
    output   [BRESP_WID-1:0] BRESPmi2si1;   

    output   [MASTERID_WID-1:0]    BIDmi2si2;     
    output   [BRESP_WID-1:0] BRESPmi2si2;   

    output   [MASTERID_WID-1:0]    BIDmi2si3;     
    output   [BRESP_WID-1:0] BRESPmi2si3;   

////////////////////////////

    output   [MASTER_NUM-1:0]BVALIDmi2si;  
    input    [MASTER_NUM-1:0]BREADYsi2mi;    
    //__________________________________________________


//LOCKSig_START
    //Lock signal
    input    Lock2Wrmi;
    input    UnLock2Wrmi;
    input    ARVALID;
    input    DataCntEmptyRdmi2Wrmi;
    input    [SELMASTER_WID-1:0]LockPort;

    output   [SELMASTER_WID-1:0]CtlDataWrite2Lock;
    output   ReadIntEmptyWrmi2Rdmi;

    output   Lock2Rdmi;
    output   UnLock2Rdmi;
//LOCKSig_END




//////////////////////////////////////////////////

//////////////////////////////////////////////////


//Master module     
//__________________________________________________

s1_WriteChannelmi
s1_WriteChannelmi(

    //Global signal
    .ACLK    (ACLK    ),
    .ARESETn (ARESETn ),

    //For slave 
    //Write address channel
    .AWIDmi2s    ( AWIDmi2s    ),
    .AWADDRmi2s  ( AWADDRmi2s  ),
    .AWLENmi2s   ( AWLENmi2s   ),
    .AWSIZEmi2s  ( AWSIZEmi2s  ),
    .AWBURSTmi2s ( AWBURSTmi2s ),
    .AWLOCKmi2s  ( AWLOCKmi2s  ),
    .AWCACHEmi2s ( AWCACHEmi2s ),
    .AWPROTmi2s  ( AWPROTmi2s  ),

    .AWVALIDmi2s ( AWVALIDmi2s ),
    .AWREADYs2mi ( AWREADYs2mi ),

    //Write data channel
    .WIDmi2s     ( WIDmi2s     ),
    .WDATAmi2s   ( WDATAmi2s   ),
    .WSTRBmi2s   ( WSTRBmi2s   ),
    .WLASTmi2s   ( WLASTmi2s   ),
    .WVALIDmi2s  ( WVALIDmi2s  ),
    .WREADYs2mi  ( WREADYs2mi  ),

    //Write response channel
    .BIDs2mi     ( BIDs2mi     ),
    .BRESPs2mi   ( BRESPs2mi   ),
    .BVALIDs2mi  ( BVALIDs2mi  ),
    .BREADYmi2s  ( BREADYmi2s  ),

    //Slave interface signal
    //Master 0/1/2/3
    .AWVALIDsi2mi  ( AWVALIDsi2mi  ),
    .AWREADYmi2si  ( AWREADYmi2si  ),

    //Master 0/1/2/3
    .WLASTsi2mi   ( WLASTsi2mi   ),
    .WVALIDsi2mi  ( WVALIDsi2mi  ),

    //output 1port
    .WREADYmi2si  ( WREADYmi2si  ),

    .BVALIDmi2si  ( BVALIDmi2si  ),
    .BREADYsi2mi  ( BREADYsi2mi),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 0
    //Write address channel
    .AWIDsi02mi    ( AWIDsi02mi    ),
    .AWADDRsi02mi  ( AWADDRsi02mi  ),
    .AWLENsi02mi   ( AWLENsi02mi   ),
    .AWSIZEsi02mi  ( AWSIZEsi02mi  ),
    .AWBURSTsi02mi ( AWBURSTsi02mi ),
    .AWLOCKsi02mi  ( AWLOCKsi02mi  ),
    .AWCACHEsi02mi ( AWCACHEsi02mi ),
    .AWPROTsi02mi  ( AWPROTsi02mi  ),

    //Write data channel
    .WIDsi02mi   ( WIDsi02mi   ),     
    .WDATAsi02mi ( WDATAsi02mi ),   
    .WSTRBsi02mi ( WSTRBsi02mi ),   

    //Write response channel
    .BIDmi2si0     ( BIDmi2si0     ),
    .BRESPmi2si0   ( BRESPmi2si0   ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 1
    //Write address channel
    .AWIDsi12mi    ( AWIDsi12mi    ),
    .AWADDRsi12mi  ( AWADDRsi12mi  ),
    .AWLENsi12mi   ( AWLENsi12mi   ),
    .AWSIZEsi12mi  ( AWSIZEsi12mi  ),
    .AWBURSTsi12mi ( AWBURSTsi12mi ),
    .AWLOCKsi12mi  ( AWLOCKsi12mi  ),
    .AWCACHEsi12mi ( AWCACHEsi12mi ),
    .AWPROTsi12mi  ( AWPROTsi12mi  ),

    //Write data channel
    .WIDsi12mi   ( WIDsi12mi   ),     
    .WDATAsi12mi ( WDATAsi12mi ),   
    .WSTRBsi12mi ( WSTRBsi12mi ),   

    //Write response channel
    .BIDmi2si1     ( BIDmi2si1     ),
    .BRESPmi2si1   ( BRESPmi2si1   ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 2
    //Write address channel
    .AWIDsi22mi    ( AWIDsi22mi    ),
    .AWADDRsi22mi  ( AWADDRsi22mi  ),
    .AWLENsi22mi   ( AWLENsi22mi   ),
    .AWSIZEsi22mi  ( AWSIZEsi22mi  ),
    .AWBURSTsi22mi ( AWBURSTsi22mi ),
    .AWLOCKsi22mi  ( AWLOCKsi22mi  ),
    .AWCACHEsi22mi ( AWCACHEsi22mi ),
    .AWPROTsi22mi  ( AWPROTsi22mi  ),

    //Write data channel
    .WIDsi22mi   ( WIDsi22mi   ),     
    .WDATAsi22mi ( WDATAsi22mi ),   
    .WSTRBsi22mi ( WSTRBsi22mi ),   

    //Write response channel
    .BIDmi2si2     ( BIDmi2si2     ),
    .BRESPmi2si2   ( BRESPmi2si2   ),

//STATE06_START
    ///////////////////////////////////////////////
    //For Master interface  Master Number = 3
    //Write address channel
    .AWIDsi32mi    ( AWIDsi32mi    ),
    .AWADDRsi32mi  ( AWADDRsi32mi  ),
    .AWLENsi32mi   ( AWLENsi32mi   ),
    .AWSIZEsi32mi  ( AWSIZEsi32mi  ),
    .AWBURSTsi32mi ( AWBURSTsi32mi ),
    .AWLOCKsi32mi  ( AWLOCKsi32mi  ),
    .AWCACHEsi32mi ( AWCACHEsi32mi ),
    .AWPROTsi32mi  ( AWPROTsi32mi  ),

    //Write data channel
    .WIDsi32mi   ( WIDsi32mi   ),     
    .WDATAsi32mi ( WDATAsi32mi ),   
    .WSTRBsi32mi ( WSTRBsi32mi ),   

    //Write response channel
    .BIDmi2si3     ( BIDmi2si3     ),
    .BRESPmi2si3   ( BRESPmi2si3   ),

////////////////////////////

    //Lock control
    .Lock2Wrmi(Lock2Wrmi),
    .UnLock2Wrmi(UnLock2Wrmi),

    .Lock2Rdmi(Lock2Rdmi),
    .UnLock2Rdmi(UnLock2Rdmi),

    .ARVALID(ARVALID),

    .LockPort(LockPort),
    .ReadIntEmptyWrmi2Rdmi(ReadIntEmptyWrmi2Rdmi),
    .DataCntEmptyRdmi2Wrmi(DataCntEmptyRdmi2Wrmi),
    .CtlDataWrite2Lock    (CtlDataWrite2Lock    )
    );
endmodule
//STATE_END
