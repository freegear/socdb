 // =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : ReqInterBuff.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Request and interrupt buffer 
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  s2_ReqInterBuff(
    ACLK,
    ARESETn,

    AWVALID,
    AWREADY,
    MASTERNUM,
    BVALID,
    BREADY,
    CtlData,

    ReqFull,
    ReqEmpty,
    //Ver 1.6 added
    NxReqEmpty
);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 3;
parameter RdPermit_SLAVECNTWID= 3;
parameter ARSIZE_WID= 3;
    input   ACLK;
    input   ARESETn;
    input   AWVALID;
    input   AWREADY;
    input   BVALID;
    input   BREADY;
    output  ReqFull;
    output  ReqEmpty;
    //Ver 1.7 added
    output  NxReqEmpty;
    input   [SELMASTER_WID -1:0] MASTERNUM;
    output  [SELMASTER_WID -1:0] CtlData;

    //_________________________________________________________
    //Request FIFO
        reg    [SELMASTER_WID -1:0] rREQBUFF0;
        reg    [SELMASTER_WID -1:0] rREQBUFF1;
        reg    [SELMASTER_WID -1:0] rREQBUFF2;
        reg    [SELMASTER_WID -1:0] rREQBUFF3;
        reg    [SELMASTER_WID -1:0] rREQBUFF4;
        reg    [SELMASTER_WID -1:0] rREQBUFF5;
        reg    [SELMASTER_WID -1:0] rREQBUFF6;
        reg    [SELMASTER_WID -1:0] rREQBUFF7;
        reg    [SELMASTER_WID -1:0] rREQBUFF8;
        reg    [SELMASTER_WID -1:0] rREQBUFF9;
        reg    [SELMASTER_WID -1:0] rREQBUFF10;
        reg    [SELMASTER_WID -1:0] rREQBUFF11;
        reg    [SELMASTER_WID -1:0] rREQBUFF12;
        reg    [SELMASTER_WID -1:0] rREQBUFF13;
        reg    [SELMASTER_WID -1:0] rREQBUFF14;
        reg    [SELMASTER_WID -1:0] rREQBUFF15;
    //_________________________________________________________

    //_________________________________________________________
    //FIFO point
    reg     [Wr_REQDEPTH_WID-1:0] WrPoint;
    reg     [Wr_REQDEPTH_WID-1:0] RdPoint;
    //_________________________________________________________

    wire    [SELMASTER_WID -1:0] CtlData;
    reg     [SELMASTER_WID -1:0] rREQBUFF;
    reg     ReqFull;
    reg     ReqEmpty;

    wire    WrPointUp = AWVALID & AWREADY;
    wire    RdPointUp = BVALID  & BREADY;

    //Ver1.7 modified
    assign  CtlData = (ReqEmpty) ? MASTERNUM : rREQBUFF;

    //_________________________________________________________
    //CtlData update
    
    always @(
                rREQBUFF0 or 
                rREQBUFF1 or 
                rREQBUFF2 or 
                rREQBUFF3 or 
                rREQBUFF4 or 
                rREQBUFF5 or 
                rREQBUFF6 or 
                rREQBUFF7 or 
                rREQBUFF8 or 
                rREQBUFF9 or 
                rREQBUFF10 or 
                rREQBUFF11 or 
                rREQBUFF12 or 
                rREQBUFF13 or 
                rREQBUFF14 or 
                rREQBUFF15 or 
                RdPoint
            )
    begin
        case(RdPoint)
            4'd0:   rREQBUFF <= rREQBUFF0;
            4'd1:   rREQBUFF <= rREQBUFF1;
            4'd2:   rREQBUFF <= rREQBUFF2;
            4'd3:   rREQBUFF <= rREQBUFF3;
            4'd4:   rREQBUFF <= rREQBUFF4;
            4'd5:   rREQBUFF <= rREQBUFF5;
            4'd6:   rREQBUFF <= rREQBUFF6;
            4'd7:   rREQBUFF <= rREQBUFF7;
            4'd8:   rREQBUFF <= rREQBUFF8;
            4'd9:   rREQBUFF <= rREQBUFF9;
            4'd10:   rREQBUFF <= rREQBUFF10;
            4'd11:   rREQBUFF <= rREQBUFF11;
            4'd12:   rREQBUFF <= rREQBUFF12;
            4'd13:   rREQBUFF <= rREQBUFF13;
            4'd14:   rREQBUFF <= rREQBUFF14;
            4'd15:   rREQBUFF <= rREQBUFF15;
        endcase
    end
    //_________________________________________________________

    //_________________________________________________________
    //FIFO Conuter gen.
    
    wire     [Wr_REQDEPTH_WID-1:0] NxWrPoint = WrPoint + 1;
    wire     [Wr_REQDEPTH_WID-1:0] NxRdPoint = RdPoint + 1;

    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            WrPoint <= 0;
        else if(WrPointUp)
            WrPoint <= NxWrPoint;
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            RdPoint <= 0;
        else if(RdPointUp)
            RdPoint <= NxRdPoint;
    end

    //_________________________________________________________
    //Request full gen.
    always  @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
        begin
            ReqFull  <= 1'b0;
        end
        else
        begin//Ver 1.4
            if(WrPointUp & RdPointUp)
                ReqFull <= ReqFull;
            else if(WrPointUp && (NxWrPoint == RdPoint))
                ReqFull <= 1'b1;
            else if(RdPointUp & ReqFull )//& (WrPoint != NxRdPoint))
                ReqFull <= 1'b0;
        end
    end

    //_________________________________________________________
    //Request Empty gen.
    assign  NxReqEmpty = (WrPoint == NxRdPoint) ? 1'b1 : 1'b0;
    always  @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
        begin
            ReqEmpty  <= 1'b1;
        end
        else
        begin // Ver 1.4
            if(RdPointUp & WrPointUp)
                ReqEmpty <= ReqEmpty;
            else if(RdPointUp && (WrPoint == NxRdPoint))
                ReqEmpty <= 1'b1;
            else if(WrPointUp & ReqEmpty)//(NxWrPoint != RdPoint))
                ReqEmpty <= 1'b0;
        end
    end


    //_________________________________________________________
    //Request FIFO Update
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF0 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd0))
                rREQBUFF0 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF1 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd1))
                rREQBUFF1 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF2 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd2))
                rREQBUFF2 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF3 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd3))
                rREQBUFF3 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF4 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd4))
                rREQBUFF4 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF5 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd5))
                rREQBUFF5 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF6 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd6))
                rREQBUFF6 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF7 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd7))
                rREQBUFF7 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF8 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd8))
                rREQBUFF8 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF9 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd9))
                rREQBUFF9 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF10 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd10))
                rREQBUFF10 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF11 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd11))
                rREQBUFF11 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF12 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd12))
                rREQBUFF12 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF13 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd13))
                rREQBUFF13 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF14 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd14))
                rREQBUFF14 <= MASTERNUM;
        end
    end
    always @(posedge ACLK or negedge ARESETn)
    begin
        if(!ARESETn)
            rREQBUFF15 <= 0;
        else
        begin
            if(WrPointUp & !ReqFull && (WrPoint == 4'd15))
                rREQBUFF15 <= MASTERNUM;
        end
    end
    //_________________________________________________________
    
endmodule 
