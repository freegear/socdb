// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SANGHWA MICRO Technology
// ALL RIGHTS RESERVED SANGHWA MICRO Technology
// -----------------------------------------------------------------
// Version and Release information: S-AXI bus Ver 0.1 
//                                  generated by AXI_GEN0.1 
// 
// File Name           : PermitCtl.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Advanced mode Permit control block 
//                       from AXI_AdvancedLocked directory 
//                       
//  ----------------------------------------------------------------
//START//notice :: don't modify this code
`timescale 1 ns/ 10ps
module  WRCH_m1_PermitCtl(

    ACLK    ,
    ARESETn ,
    SlaveNum,

    SID,
    AREADY,
    AVALID,

    WID,
    WREADY,
    WVALID,
    WLAST,

    LID,
    LAST, 
    READY,
    RVALID,

    CtlData2datach  ,
    CtlData2writech 
    //Mask2resch

);
parameter BUS_WID = 32;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 4;
parameter SLAVEID_WID= 6;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 4;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 3;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 6;
parameter MASTER_NUM= 4;
parameter SELMASTER_WID= 2;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 3;
parameter RdPermit_SLAVECNTWID= 3;
parameter ARSIZE_WID= 3;

//Code_START
input   ACLK;
input   ARESETn;
input   AREADY;
input   LAST;
input   AVALID;
input   RVALID;
input   [MASTERID_WID-1:0]    SID;  
input   [MASTERID_WID-1:0]    LID;  
input   [MASTERID_WID-1:0]    WID;  

input   [SLAVE_WID-1:0] SlaveNum;
input   READY;  

output  [SLAVE_WID  :0] CtlData2datach;
output  [SLAVE_WID  :0] CtlData2writech;

input   WREADY;
input   WVALID;
input   WLAST;

//BUFFER 
reg [SLAVE_WID-1:0] ID0SlaveBuffer;
reg [SLAVE_WID-1:0] ID1SlaveBuffer;
reg [SLAVE_WID-1:0] ID2SlaveBuffer;
reg [SLAVE_WID-1:0] ID3SlaveBuffer;
reg [SLAVE_WID-1:0] ID4SlaveBuffer;
reg [SLAVE_WID-1:0] ID5SlaveBuffer;
reg [SLAVE_WID-1:0] ID6SlaveBuffer;
reg [SLAVE_WID-1:0] ID7SlaveBuffer;
reg [SLAVE_WID-1:0] ID8SlaveBuffer;
reg [SLAVE_WID-1:0] ID9SlaveBuffer;
reg [SLAVE_WID-1:0] ID10SlaveBuffer;
reg [SLAVE_WID-1:0] ID11SlaveBuffer;
reg [SLAVE_WID-1:0] ID12SlaveBuffer;
reg [SLAVE_WID-1:0] ID13SlaveBuffer;
reg [SLAVE_WID-1:0] ID14SlaveBuffer;
reg [SLAVE_WID-1:0] ID15SlaveBuffer;

reg [WrPermit_SLAVECNTWID-1:0]   ID0SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID1SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID2SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID3SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID4SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID5SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID6SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID7SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID8SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID9SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID10SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID11SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID12SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID13SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID14SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]   ID15SlaveCnt;
reg [WrPermit_SLAVECNTWID-1:0]  WIDSlaveCnt; //don't move code




//Arbiter Mask signal
reg     [SLAVE_WID-1:0] WIDSlaveBuffer;

wire    EnWIDSlaveCnt = (WIDSlaveCnt > 0) ? 1'b1 : 1'b0;

//ver 1.9
wire   ID0SlaveCntFull = (ID0SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID1SlaveCntFull = (ID1SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID2SlaveCntFull = (ID2SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID3SlaveCntFull = (ID3SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID4SlaveCntFull = (ID4SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID5SlaveCntFull = (ID5SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID6SlaveCntFull = (ID6SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID7SlaveCntFull = (ID7SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID8SlaveCntFull = (ID8SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID9SlaveCntFull = (ID9SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID10SlaveCntFull = (ID10SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID11SlaveCntFull = (ID11SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID12SlaveCntFull = (ID12SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID13SlaveCntFull = (ID13SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID14SlaveCntFull = (ID14SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;
wire   ID15SlaveCntFull = (ID15SlaveCnt == {WrPermit_SLAVECNTWID{1'b1}}) ? 1'b1 : 1'b0;


//________________________________________________________________________
//Control Data channel 

always  @(
            ID0SlaveBuffer or
            ID1SlaveBuffer or
            ID2SlaveBuffer or
            ID3SlaveBuffer or
            ID4SlaveBuffer or
            ID5SlaveBuffer or
            ID6SlaveBuffer or
            ID7SlaveBuffer or
            ID8SlaveBuffer or
            ID9SlaveBuffer or
            ID10SlaveBuffer or
            ID11SlaveBuffer or
            ID12SlaveBuffer or
            ID13SlaveBuffer or
            ID14SlaveBuffer or
            ID15SlaveBuffer or
            WID
        )
begin
    case(WID)
    //synopsys parallel_case full_case
    4'd0:   WIDSlaveBuffer = ID0SlaveBuffer;
    4'd1:   WIDSlaveBuffer = ID1SlaveBuffer;
    4'd2:   WIDSlaveBuffer = ID2SlaveBuffer;
    4'd3:   WIDSlaveBuffer = ID3SlaveBuffer;
    4'd4:   WIDSlaveBuffer = ID4SlaveBuffer;
    4'd5:   WIDSlaveBuffer = ID5SlaveBuffer;
    4'd6:   WIDSlaveBuffer = ID6SlaveBuffer;
    4'd7:   WIDSlaveBuffer = ID7SlaveBuffer;
    4'd8:   WIDSlaveBuffer = ID8SlaveBuffer;
    4'd9:   WIDSlaveBuffer = ID9SlaveBuffer;
    4'd10:   WIDSlaveBuffer = ID10SlaveBuffer;
    4'd11:   WIDSlaveBuffer = ID11SlaveBuffer;
    4'd12:   WIDSlaveBuffer = ID12SlaveBuffer;
    4'd13:   WIDSlaveBuffer = ID13SlaveBuffer;
    4'd14:   WIDSlaveBuffer = ID14SlaveBuffer;
    4'd15:   WIDSlaveBuffer = ID15SlaveBuffer;
    endcase
end

//Bug Fixed______2006/7/12
always  @(
            ID0SlaveCnt or
            ID1SlaveCnt or
            ID2SlaveCnt or
            ID3SlaveCnt or
            ID4SlaveCnt or
            ID5SlaveCnt or
            ID6SlaveCnt or
            ID7SlaveCnt or
            ID8SlaveCnt or
            ID9SlaveCnt or
            ID10SlaveCnt or
            ID11SlaveCnt or
            ID12SlaveCnt or
            ID13SlaveCnt or
            ID14SlaveCnt or
            ID15SlaveCnt or
            WID
        )
begin
    case(WID)
    //synopsys parallel_case full_case
    4'd0:   WIDSlaveCnt = ID0SlaveCnt;
    4'd1:   WIDSlaveCnt = ID1SlaveCnt;
    4'd2:   WIDSlaveCnt = ID2SlaveCnt;
    4'd3:   WIDSlaveCnt = ID3SlaveCnt;
    4'd4:   WIDSlaveCnt = ID4SlaveCnt;
    4'd5:   WIDSlaveCnt = ID5SlaveCnt;
    4'd6:   WIDSlaveCnt = ID6SlaveCnt;
    4'd7:   WIDSlaveCnt = ID7SlaveCnt;
    4'd8:   WIDSlaveCnt = ID8SlaveCnt;
    4'd9:   WIDSlaveCnt = ID9SlaveCnt;
    4'd10:   WIDSlaveCnt = ID10SlaveCnt;
    4'd11:   WIDSlaveCnt = ID11SlaveCnt;
    4'd12:   WIDSlaveCnt = ID12SlaveCnt;
    4'd13:   WIDSlaveCnt = ID13SlaveCnt;
    4'd14:   WIDSlaveCnt = ID14SlaveCnt;
    4'd15:   WIDSlaveCnt = ID15SlaveCnt;
    endcase
end


//________________________________________________________________________

// 2^MASTER_WID -> ID0 ~ ID15
//________________________________________________________________________
//SlaveBuffer update ID0 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID0SlaveBuffer <= 0;
    end
    else
    begin
        if(ID0SlaveCnt == 0 && AVALID)
            ID0SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID1 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID1SlaveBuffer <= 0;
    end
    else
    begin
        if(ID1SlaveCnt == 0 && AVALID)
            ID1SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID2 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID2SlaveBuffer <= 0;
    end
    else
    begin
        if(ID2SlaveCnt == 0 && AVALID)
            ID2SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID3 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID3SlaveBuffer <= 0;
    end
    else
    begin
        if(ID3SlaveCnt == 0 && AVALID)
            ID3SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID4 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID4SlaveBuffer <= 0;
    end
    else
    begin
        if(ID4SlaveCnt == 0 && AVALID)
            ID4SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID5 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID5SlaveBuffer <= 0;
    end
    else
    begin
        if(ID5SlaveCnt == 0 && AVALID)
            ID5SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID6 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID6SlaveBuffer <= 0;
    end
    else
    begin
        if(ID6SlaveCnt == 0 && AVALID)
            ID6SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID7 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID7SlaveBuffer <= 0;
    end
    else
    begin
        if(ID7SlaveCnt == 0 && AVALID)
            ID7SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID8 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID8SlaveBuffer <= 0;
    end
    else
    begin
        if(ID8SlaveCnt == 0 && AVALID)
            ID8SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID9 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID9SlaveBuffer <= 0;
    end
    else
    begin
        if(ID9SlaveCnt == 0 && AVALID)
            ID9SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID10 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID10SlaveBuffer <= 0;
    end
    else
    begin
        if(ID10SlaveCnt == 0 && AVALID)
            ID10SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID11 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID11SlaveBuffer <= 0;
    end
    else
    begin
        if(ID11SlaveCnt == 0 && AVALID)
            ID11SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID12 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID12SlaveBuffer <= 0;
    end
    else
    begin
        if(ID12SlaveCnt == 0 && AVALID)
            ID12SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID13 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID13SlaveBuffer <= 0;
    end
    else
    begin
        if(ID13SlaveCnt == 0 && AVALID)
            ID13SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID14 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID14SlaveBuffer <= 0;
    end
    else
    begin
        if(ID14SlaveCnt == 0 && AVALID)
            ID14SlaveBuffer <= SlaveNum;
    end
end
//SlaveBuffer update ID15 
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID15SlaveBuffer <= 0;
    end
    else
    begin
        if(ID15SlaveCnt == 0 && AVALID)
            ID15SlaveBuffer <= SlaveNum;
    end
end


//________________________________________________________________________
//SlaveCnt
//Enable
wire    ID0EnCNTup = ((SID == 0) && (SlaveNum == ID0SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID1EnCNTup = ((SID == 1) && (SlaveNum == ID1SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID2EnCNTup = ((SID == 2) && (SlaveNum == ID2SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID3EnCNTup = ((SID == 3) && (SlaveNum == ID3SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID4EnCNTup = ((SID == 4) && (SlaveNum == ID4SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID5EnCNTup = ((SID == 5) && (SlaveNum == ID5SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID6EnCNTup = ((SID == 6) && (SlaveNum == ID6SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID7EnCNTup = ((SID == 7) && (SlaveNum == ID7SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID8EnCNTup = ((SID == 8) && (SlaveNum == ID8SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID9EnCNTup = ((SID == 9) && (SlaveNum == ID9SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID10EnCNTup = ((SID == 10) && (SlaveNum == ID10SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID11EnCNTup = ((SID == 11) && (SlaveNum == ID11SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID12EnCNTup = ((SID == 12) && (SlaveNum == ID12SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID13EnCNTup = ((SID == 13) && (SlaveNum == ID13SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID14EnCNTup = ((SID == 14) && (SlaveNum == ID14SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID15EnCNTup = ((SID == 15) && (SlaveNum == ID15SlaveBuffer)) ? 1'b1 : 1'b0;
wire    ID0EnCNTdn =  (LID == 0) ? 1'b1 : 1'b0;
wire    ID1EnCNTdn =  (LID == 1) ? 1'b1 : 1'b0;
wire    ID2EnCNTdn =  (LID == 2) ? 1'b1 : 1'b0;
wire    ID3EnCNTdn =  (LID == 3) ? 1'b1 : 1'b0;
wire    ID4EnCNTdn =  (LID == 4) ? 1'b1 : 1'b0;
wire    ID5EnCNTdn =  (LID == 5) ? 1'b1 : 1'b0;
wire    ID6EnCNTdn =  (LID == 6) ? 1'b1 : 1'b0;
wire    ID7EnCNTdn =  (LID == 7) ? 1'b1 : 1'b0;
wire    ID8EnCNTdn =  (LID == 8) ? 1'b1 : 1'b0;
wire    ID9EnCNTdn =  (LID == 9) ? 1'b1 : 1'b0;
wire    ID10EnCNTdn =  (LID == 10) ? 1'b1 : 1'b0;
wire    ID11EnCNTdn =  (LID == 11) ? 1'b1 : 1'b0;
wire    ID12EnCNTdn =  (LID == 12) ? 1'b1 : 1'b0;
wire    ID13EnCNTdn =  (LID == 13) ? 1'b1 : 1'b0;
wire    ID14EnCNTdn =  (LID == 14) ? 1'b1 : 1'b0;
wire    ID15EnCNTdn =  (LID == 15) ? 1'b1 : 1'b0;

//________________________________________________________________________

wire    CNTup = (AREADY & AVALID);
wire    CNTdn = (LAST   & READY & RVALID);

reg     CNTdn_1p;

always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
        CNTdn_1p <= 1'b0;
    else
        CNTdn_1p <= CNTdn;
end


//________________________________________________________________________
//ID0 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID0SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID0EnCNTup & CNTdn & ID0EnCNTdn)
            ID0SlaveCnt <= ID0SlaveCnt;
        else if(CNTup & ID0EnCNTup & !ID0SlaveCntFull)
            ID0SlaveCnt <= ID0SlaveCnt + 1;
        else if(CNTdn & ID0EnCNTdn)
            ID0SlaveCnt <= ID0SlaveCnt - 1;
    end
end

//ID1 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID1SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID1EnCNTup & CNTdn & ID1EnCNTdn)
            ID1SlaveCnt <= ID1SlaveCnt;
        else if(CNTup & ID1EnCNTup & !ID1SlaveCntFull)
            ID1SlaveCnt <= ID1SlaveCnt + 1;
        else if(CNTdn & ID1EnCNTdn)
            ID1SlaveCnt <= ID1SlaveCnt - 1;
    end
end

//ID2 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID2SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID2EnCNTup & CNTdn & ID2EnCNTdn)
            ID2SlaveCnt <= ID2SlaveCnt;
        else if(CNTup & ID2EnCNTup & !ID2SlaveCntFull)
            ID2SlaveCnt <= ID2SlaveCnt + 1;
        else if(CNTdn & ID2EnCNTdn)
            ID2SlaveCnt <= ID2SlaveCnt - 1;
    end
end

//ID3 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID3SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID3EnCNTup & CNTdn & ID3EnCNTdn)
            ID3SlaveCnt <= ID3SlaveCnt;
        else if(CNTup & ID3EnCNTup & !ID3SlaveCntFull)
            ID3SlaveCnt <= ID3SlaveCnt + 1;
        else if(CNTdn & ID3EnCNTdn)
            ID3SlaveCnt <= ID3SlaveCnt - 1;
    end
end

//ID4 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID4SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID4EnCNTup & CNTdn & ID4EnCNTdn)
            ID4SlaveCnt <= ID4SlaveCnt;
        else if(CNTup & ID4EnCNTup & !ID4SlaveCntFull)
            ID4SlaveCnt <= ID4SlaveCnt + 1;
        else if(CNTdn & ID4EnCNTdn)
            ID4SlaveCnt <= ID4SlaveCnt - 1;
    end
end

//ID5 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID5SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID5EnCNTup & CNTdn & ID5EnCNTdn)
            ID5SlaveCnt <= ID5SlaveCnt;
        else if(CNTup & ID5EnCNTup & !ID5SlaveCntFull)
            ID5SlaveCnt <= ID5SlaveCnt + 1;
        else if(CNTdn & ID5EnCNTdn)
            ID5SlaveCnt <= ID5SlaveCnt - 1;
    end
end

//ID6 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID6SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID6EnCNTup & CNTdn & ID6EnCNTdn)
            ID6SlaveCnt <= ID6SlaveCnt;
        else if(CNTup & ID6EnCNTup & !ID6SlaveCntFull)
            ID6SlaveCnt <= ID6SlaveCnt + 1;
        else if(CNTdn & ID6EnCNTdn)
            ID6SlaveCnt <= ID6SlaveCnt - 1;
    end
end

//ID7 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID7SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID7EnCNTup & CNTdn & ID7EnCNTdn)
            ID7SlaveCnt <= ID7SlaveCnt;
        else if(CNTup & ID7EnCNTup & !ID7SlaveCntFull)
            ID7SlaveCnt <= ID7SlaveCnt + 1;
        else if(CNTdn & ID7EnCNTdn)
            ID7SlaveCnt <= ID7SlaveCnt - 1;
    end
end

//ID8 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID8SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID8EnCNTup & CNTdn & ID8EnCNTdn)
            ID8SlaveCnt <= ID8SlaveCnt;
        else if(CNTup & ID8EnCNTup & !ID8SlaveCntFull)
            ID8SlaveCnt <= ID8SlaveCnt + 1;
        else if(CNTdn & ID8EnCNTdn)
            ID8SlaveCnt <= ID8SlaveCnt - 1;
    end
end

//ID9 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID9SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID9EnCNTup & CNTdn & ID9EnCNTdn)
            ID9SlaveCnt <= ID9SlaveCnt;
        else if(CNTup & ID9EnCNTup & !ID9SlaveCntFull)
            ID9SlaveCnt <= ID9SlaveCnt + 1;
        else if(CNTdn & ID9EnCNTdn)
            ID9SlaveCnt <= ID9SlaveCnt - 1;
    end
end

//ID10 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID10SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID10EnCNTup & CNTdn & ID10EnCNTdn)
            ID10SlaveCnt <= ID10SlaveCnt;
        else if(CNTup & ID10EnCNTup & !ID10SlaveCntFull)
            ID10SlaveCnt <= ID10SlaveCnt + 1;
        else if(CNTdn & ID10EnCNTdn)
            ID10SlaveCnt <= ID10SlaveCnt - 1;
    end
end

//ID11 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID11SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID11EnCNTup & CNTdn & ID11EnCNTdn)
            ID11SlaveCnt <= ID11SlaveCnt;
        else if(CNTup & ID11EnCNTup & !ID11SlaveCntFull)
            ID11SlaveCnt <= ID11SlaveCnt + 1;
        else if(CNTdn & ID11EnCNTdn)
            ID11SlaveCnt <= ID11SlaveCnt - 1;
    end
end

//ID12 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID12SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID12EnCNTup & CNTdn & ID12EnCNTdn)
            ID12SlaveCnt <= ID12SlaveCnt;
        else if(CNTup & ID12EnCNTup & !ID12SlaveCntFull)
            ID12SlaveCnt <= ID12SlaveCnt + 1;
        else if(CNTdn & ID12EnCNTdn)
            ID12SlaveCnt <= ID12SlaveCnt - 1;
    end
end

//ID13 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID13SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID13EnCNTup & CNTdn & ID13EnCNTdn)
            ID13SlaveCnt <= ID13SlaveCnt;
        else if(CNTup & ID13EnCNTup & !ID13SlaveCntFull)
            ID13SlaveCnt <= ID13SlaveCnt + 1;
        else if(CNTdn & ID13EnCNTdn)
            ID13SlaveCnt <= ID13SlaveCnt - 1;
    end
end

//ID14 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID14SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID14EnCNTup & CNTdn & ID14EnCNTdn)
            ID14SlaveCnt <= ID14SlaveCnt;
        else if(CNTup & ID14EnCNTup & !ID14SlaveCntFull)
            ID14SlaveCnt <= ID14SlaveCnt + 1;
        else if(CNTdn & ID14EnCNTdn)
            ID14SlaveCnt <= ID14SlaveCnt - 1;
    end
end

//ID15 Slave Counter
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        ID15SlaveCnt <= 0;
    end
    else
    begin
        if(CNTup & ID15EnCNTup & CNTdn & ID15EnCNTdn)
            ID15SlaveCnt <= ID15SlaveCnt;
        else if(CNTup & ID15EnCNTup & !ID15SlaveCntFull)
            ID15SlaveCnt <= ID15SlaveCnt + 1;
        else if(CNTdn & ID15EnCNTdn)
            ID15SlaveCnt <= ID15SlaveCnt - 1;
    end
end

//________________________________________________________________________


//MUX state

reg     InMUX;

always  @(
            ID0EnCNTup or
            ID1EnCNTup or
            ID2EnCNTup or
            ID3EnCNTup or
            ID4EnCNTup or
            ID5EnCNTup or
            ID6EnCNTup or
            ID7EnCNTup or
            ID8EnCNTup or
            ID9EnCNTup or
            ID10EnCNTup or
            ID11EnCNTup or
            ID12EnCNTup or
            ID13EnCNTup or
            ID14EnCNTup or
            ID15EnCNTup or
            AVALID  
        )
begin
    if(AVALID & (
            ID0EnCNTup |
            ID1EnCNTup |
            ID2EnCNTup |
            ID3EnCNTup |
            ID4EnCNTup |
            ID5EnCNTup |
            ID6EnCNTup |
            ID7EnCNTup |
            ID8EnCNTup |
            ID9EnCNTup |
            ID10EnCNTup |
            ID11EnCNTup |
            ID12EnCNTup |
            ID13EnCNTup |
            ID14EnCNTup |
            ID15EnCNTup  
       ))
        InMUX <= 1'b1;
    else
        InMUX <= 1'b0;
end

//MUX 
reg     [SLAVE_WID-1:0] SIDSlaveBuffer;
//Ver 1.9
reg     SIDSlaveFull;
wire    EnData;
//Ver 1.9
assign  CtlData2writech[SLAVE_WID]     = SIDSlaveFull ? 1'b0 : InMUX; 
assign  CtlData2writech[SLAVE_WID-1:0] = SIDSlaveBuffer;

assign  CtlData2datach[SLAVE_WID-1:0]  = WIDSlaveBuffer[SLAVE_WID-1:0];
assign  CtlData2datach[SLAVE_WID]      = EnData;

reg [2:0]StateWID;
reg [2:0]NxStateWID;


parameter WR_WID = 0,
          HOLD_WID = 1,
          WAIT_WID = 2;

assign  EnData = StateWID[WR_WID];
always @(posedge ACLK or negedge ARESETn)
begin
    if(!ARESETn)
    begin
        StateWID[WR_WID]    <= 1'b1;
        StateWID[HOLD_WID]  <= 1'b0;
        StateWID[WAIT_WID]  <= 1'b0;
    end
    else
    begin
        StateWID <= NxStateWID;
    end
end

//Ver 1.6 Wdata permit control modified
always @(
            CNTdn_1p or
            EnWIDSlaveCnt or
            WREADY or WVALID or WLAST or
            WID or SID or StateWID
        )
begin
    NxStateWID <= 0;
    case(1'b1)
        
        StateWID[WR_WID]:
            if(WREADY & WVALID & WLAST)
                NxStateWID[HOLD_WID]<= 1'b1;
            else
                NxStateWID[WR_WID]  <= 1'b1;

        StateWID[HOLD_WID]:
            if(CNTdn_1p & EnWIDSlaveCnt)
                NxStateWID[WR_WID]  <= 1'b1;
            else if(CNTdn_1p & !EnWIDSlaveCnt)
                NxStateWID[WAIT_WID]  <= 1'b1;
            else
                NxStateWID[HOLD_WID]<= 1'b1;

        StateWID[WAIT_WID]:
            if(EnWIDSlaveCnt)
                NxStateWID[WR_WID]  <= 1'b1;
            else if(!EnWIDSlaveCnt && (SID==WID))
                NxStateWID[WR_WID]  <= 1'b1;
            else
                NxStateWID[WAIT_WID]  <= 1'b1;

        default:
                NxStateWID[WR_WID]  <= 1'b1;
    endcase
end

always  @(
            ID0SlaveBuffer or
            ID1SlaveBuffer or
            ID2SlaveBuffer or
            ID3SlaveBuffer or
            ID4SlaveBuffer or
            ID5SlaveBuffer or
            ID6SlaveBuffer or
            ID7SlaveBuffer or
            ID8SlaveBuffer or
            ID9SlaveBuffer or
            ID10SlaveBuffer or
            ID11SlaveBuffer or
            ID12SlaveBuffer or
            ID13SlaveBuffer or
            ID14SlaveBuffer or
            ID15SlaveBuffer or
            SID
        )
begin
    case(SID)
    //synopsys parallel_case full_case
        4'd0:   SIDSlaveBuffer = ID0SlaveBuffer;
        4'd1:   SIDSlaveBuffer = ID1SlaveBuffer;
        4'd2:   SIDSlaveBuffer = ID2SlaveBuffer;
        4'd3:   SIDSlaveBuffer = ID3SlaveBuffer;
        4'd4:   SIDSlaveBuffer = ID4SlaveBuffer;
        4'd5:   SIDSlaveBuffer = ID5SlaveBuffer;
        4'd6:   SIDSlaveBuffer = ID6SlaveBuffer;
        4'd7:   SIDSlaveBuffer = ID7SlaveBuffer;
        4'd8:   SIDSlaveBuffer = ID8SlaveBuffer;
        4'd9:   SIDSlaveBuffer = ID9SlaveBuffer;
        4'd10:   SIDSlaveBuffer = ID10SlaveBuffer;
        4'd11:   SIDSlaveBuffer = ID11SlaveBuffer;
        4'd12:   SIDSlaveBuffer = ID12SlaveBuffer;
        4'd13:   SIDSlaveBuffer = ID13SlaveBuffer;
        4'd14:   SIDSlaveBuffer = ID14SlaveBuffer;
        4'd15:   SIDSlaveBuffer = ID15SlaveBuffer;
    endcase
end

//Ver 1.9
always  @(
            ID0SlaveCntFull or
            ID1SlaveCntFull or
            ID2SlaveCntFull or
            ID3SlaveCntFull or
            ID4SlaveCntFull or
            ID5SlaveCntFull or
            ID6SlaveCntFull or
            ID7SlaveCntFull or
            ID8SlaveCntFull or
            ID9SlaveCntFull or
            ID10SlaveCntFull or
            ID11SlaveCntFull or
            ID12SlaveCntFull or
            ID13SlaveCntFull or
            ID14SlaveCntFull or
            ID15SlaveCntFull or
            SID
        )
begin
    case(SID)
    //synopsys parallel_case full_case
        4'd0:   SIDSlaveFull = ID0SlaveCntFull;
        4'd1:   SIDSlaveFull = ID1SlaveCntFull;
        4'd2:   SIDSlaveFull = ID2SlaveCntFull;
        4'd3:   SIDSlaveFull = ID3SlaveCntFull;
        4'd4:   SIDSlaveFull = ID4SlaveCntFull;
        4'd5:   SIDSlaveFull = ID5SlaveCntFull;
        4'd6:   SIDSlaveFull = ID6SlaveCntFull;
        4'd7:   SIDSlaveFull = ID7SlaveCntFull;
        4'd8:   SIDSlaveFull = ID8SlaveCntFull;
        4'd9:   SIDSlaveFull = ID9SlaveCntFull;
        4'd10:   SIDSlaveFull = ID10SlaveCntFull;
        4'd11:   SIDSlaveFull = ID11SlaveCntFull;
        4'd12:   SIDSlaveFull = ID12SlaveCntFull;
        4'd13:   SIDSlaveFull = ID13SlaveCntFull;
        4'd14:   SIDSlaveFull = ID14SlaveCntFull;
        4'd15:   SIDSlaveFull = ID15SlaveCntFull;
    endcase
end


endmodule
