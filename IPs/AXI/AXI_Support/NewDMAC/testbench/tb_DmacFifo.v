/*****************************************************************
		         DmacFifo Simple testbench
*****************************************************************/
`timescale 1 ns/ 10ps
module tb;

// Clock & Reset generator
parameter CLK_HALFPERIOD=5;
parameter UNITDELAY=1;
reg ACLK;
reg ARESETn;

always #CLK_HALFPERIOD	ACLK = ~ACLK;
initial ACLK=0;

initial
begin
	ARESETn 	= 0;     // reset
	repeat(10) @(posedge ACLK);
	ARESETn	= 1;
end

task check;
	input true;
	begin
		if(!true)
		begin
			$display($time, "Check Failed");
			$stop;
		end
	end
endtask
`define WORD 2'b10
`define HWORD 2'b01
`define BYTE 2'b00

// signals
reg         FifoReset;
reg  [1:0]  SrcWidth;
reg  [31:0] DataIn;
reg         WriteEn;
reg  [1:0]  SrcAddr;
reg  [1:0]  DstWidth;
wire [31:0] DataOut;
wire [3:0]  DataMask;
reg         ReadEn;
reg  [1:0]  DstAddr;

reg  [4:0]  NumByte;

task FIFO_RESET;
	begin
		WriteEn = 0;
		ReadEn = 0;
		FifoReset = 1;
		@(posedge ACLK);
		#UNITDELAY;
		FifoReset = 0;
	end
endtask

task FIFO_WRITE;
	input [31:0] WriteData;
	begin
		WriteEn = 1;
		DataIn = WriteData;
		@(posedge ACLK);
		#UNITDELAY;
		WriteEn = 0;
	end
endtask

task FIFO_READ;
	input [31:0] ReadDataExpected;
	input [3:0]  ReadDataMask;
	reg   [31:0] Mask32bit;
	begin
		Mask32bit = {{8{ReadDataMask[3]}}, {8{ReadDataMask[2]}}, {8{ReadDataMask[1]}}, {8{ReadDataMask[0]}}};
		check((DataOut&Mask32bit) === (ReadDataExpected&Mask32bit));
		check(DataMask === ReadDataMask);
		ReadEn = 1;
		@(posedge ACLK);
		#UNITDELAY;
		ReadEn = 0;
	end
endtask

initial
begin
	repeat(1) @(posedge ACLK);
	WriteEn = 0;
	ReadEn = 0;
	while(ARESETn != 1) @(posedge ACLK);
	#UNITDELAY;

	// WORD-to-WORD
	SrcWidth = `WORD;
	SrcAddr  = 2'b00;
	DstWidth = `WORD;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_READ(32'h03020100, 4'b1111);
	FIFO_READ(32'h07060504, 4'b1111);
	FIFO_READ(32'h0b0a0908, 4'b1111);
	FIFO_READ(32'h0f0e0d0c, 4'b1111);
	FIFO_READ(32'h13121110, 4'b1111);
	FIFO_READ(32'h17161514, 4'b1111);
	FIFO_READ(32'h1b1a1918, 4'b1111);
	FIFO_READ(32'h1f1e1d1c, 4'b1111);

	// unaligned WORD-to-unaligned WORD
	SrcWidth = `WORD;
	SrcAddr  = 2'b01;
	DstWidth = `WORD;
	DstAddr  = 2'b10;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_WRITE(32'h23222120);
	FIFO_READ(32'h02010000, 4'b1100);
	FIFO_READ(32'h06050403, 4'b1111);
	FIFO_READ(32'h0a090807, 4'b1111);
	FIFO_READ(32'h0e0d0c0b, 4'b1111);
	FIFO_READ(32'h1211100f, 4'b1111);
	FIFO_READ(32'h16151413, 4'b1111);
	FIFO_READ(32'h1a191817, 4'b1111);
	FIFO_READ(32'h1e1d1c1b, 4'b1111);
	FIFO_READ(32'h0000201f, 4'b0011);

	// WORD-to-HWORD
	SrcWidth = `WORD;
	SrcAddr  = 2'b00;
	DstWidth = `HWORD;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_READ(32'h00000100,4'b0011);
	FIFO_READ(32'h00000302,4'b0011);
	FIFO_READ(32'h00000504,4'b0011);
	FIFO_READ(32'h00000706,4'b0011);
	FIFO_READ(32'h00000908,4'b0011);
	FIFO_READ(32'h00000b0a,4'b0011);
	FIFO_READ(32'h00000d0c,4'b0011);
	FIFO_READ(32'h00000f0e,4'b0011);
	FIFO_READ(32'h00001110,4'b0011);
	FIFO_READ(32'h00001312,4'b0011);
	FIFO_READ(32'h00001514,4'b0011);
	FIFO_READ(32'h00001716,4'b0011);
	FIFO_READ(32'h00001918,4'b0011);
	FIFO_READ(32'h00001b1a,4'b0011);
	FIFO_READ(32'h00001d1c,4'b0011);
	FIFO_READ(32'h00001f1e,4'b0011);

	// unaligned WORD-to-HWORD
	SrcWidth = `WORD;
	SrcAddr  = 2'b10;
	DstWidth = `HWORD;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_WRITE(32'h23222120);
	FIFO_READ(32'h00000302,4'b0011);
	FIFO_READ(32'h00000504,4'b0011);
	FIFO_READ(32'h00000706,4'b0011);
	FIFO_READ(32'h00000908,4'b0011);
	FIFO_READ(32'h00000b0a,4'b0011);
	FIFO_READ(32'h00000d0c,4'b0011);
	FIFO_READ(32'h00000f0e,4'b0011);
	FIFO_READ(32'h00001110,4'b0011);
	FIFO_READ(32'h00001312,4'b0011);
	FIFO_READ(32'h00001514,4'b0011);
	FIFO_READ(32'h00001716,4'b0011);
	FIFO_READ(32'h00001918,4'b0011);
	FIFO_READ(32'h00001b1a,4'b0011);
	FIFO_READ(32'h00001d1c,4'b0011);
	FIFO_READ(32'h00001f1e,4'b0011);
	FIFO_READ(32'h00002120,4'b0011);

	// HWORD-to-WORD
	SrcWidth = `HWORD;
	SrcAddr  = 2'b00;
	DstWidth = `WORD;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h00000100);
	FIFO_WRITE(32'h00000302);
	FIFO_WRITE(32'h00000504);
	FIFO_WRITE(32'h00000706);
	FIFO_WRITE(32'h00000908);
	FIFO_WRITE(32'h00000b0a);
	FIFO_WRITE(32'h00000d0c);
	FIFO_WRITE(32'h00000f0e);
	FIFO_WRITE(32'h00001110);
	FIFO_WRITE(32'h00001312);
	FIFO_WRITE(32'h00001514);
	FIFO_WRITE(32'h00001716);
	FIFO_WRITE(32'h00001918);
	FIFO_WRITE(32'h00001b1a);
	FIFO_WRITE(32'h00001d1c);
	FIFO_WRITE(32'h00001f1e);
	FIFO_READ(32'h03020100, 4'b1111);
	FIFO_READ(32'h07060504, 4'b1111);
	FIFO_READ(32'h0b0a0908, 4'b1111);
	FIFO_READ(32'h0f0e0d0c, 4'b1111);
	FIFO_READ(32'h13121110, 4'b1111);
	FIFO_READ(32'h17161514, 4'b1111);
	FIFO_READ(32'h1b1a1918, 4'b1111);
	FIFO_READ(32'h1f1e1d1c, 4'b1111);

	// HWORD-to-unaigned WORD
	SrcWidth = `HWORD;
	SrcAddr  = 2'b00;
	DstWidth = `WORD;
	DstAddr  = 2'b10;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h00000100);
	FIFO_WRITE(32'h00000302);
	FIFO_WRITE(32'h00000504);
	FIFO_WRITE(32'h00000706);
	FIFO_WRITE(32'h00000908);
	FIFO_WRITE(32'h00000b0a);
	FIFO_WRITE(32'h00000d0c);
	FIFO_WRITE(32'h00000f0e);
	FIFO_WRITE(32'h00001110);
	FIFO_WRITE(32'h00001312);
	FIFO_WRITE(32'h00001514);
	FIFO_WRITE(32'h00001716);
	FIFO_WRITE(32'h00001918);
	FIFO_WRITE(32'h00001b1a);
	FIFO_WRITE(32'h00001d1c);
	FIFO_WRITE(32'h00001f1e);
	FIFO_READ(32'h01000000, 4'b1100);
	FIFO_READ(32'h05040302, 4'b1111);
	FIFO_READ(32'h09080706, 4'b1111);
	FIFO_READ(32'h0d0c0b0a, 4'b1111);
	FIFO_READ(32'h11100f0e, 4'b1111);
	FIFO_READ(32'h15141312, 4'b1111);
	FIFO_READ(32'h19181716, 4'b1111);
	FIFO_READ(32'h1d1c1b1a, 4'b1111);
	FIFO_READ(32'h00001f1e, 4'b0011);

	// WORD-to-BYTE
	SrcWidth = `WORD;
	SrcAddr  = 2'b00;
	DstWidth = `BYTE;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_READ(32'h00000000,4'b0001);
	FIFO_READ(32'h00000001,4'b0001);
	FIFO_READ(32'h00000002,4'b0001);
	FIFO_READ(32'h00000003,4'b0001);
	FIFO_READ(32'h00000004,4'b0001);
	FIFO_READ(32'h00000005,4'b0001);
	FIFO_READ(32'h00000006,4'b0001);
	FIFO_READ(32'h00000007,4'b0001);
	FIFO_READ(32'h00000008,4'b0001);
	FIFO_READ(32'h00000009,4'b0001);
	FIFO_READ(32'h0000000a,4'b0001);
	FIFO_READ(32'h0000000b,4'b0001);
	FIFO_READ(32'h0000000c,4'b0001);
	FIFO_READ(32'h0000000d,4'b0001);
	FIFO_READ(32'h0000000e,4'b0001);
	FIFO_READ(32'h0000000f,4'b0001);
	FIFO_READ(32'h00000010,4'b0001);
	FIFO_READ(32'h00000011,4'b0001);
	FIFO_READ(32'h00000012,4'b0001);
	FIFO_READ(32'h00000013,4'b0001);
	FIFO_READ(32'h00000014,4'b0001);
	FIFO_READ(32'h00000015,4'b0001);
	FIFO_READ(32'h00000016,4'b0001);
	FIFO_READ(32'h00000017,4'b0001);
	FIFO_READ(32'h00000018,4'b0001);
	FIFO_READ(32'h00000019,4'b0001);
	FIFO_READ(32'h0000001a,4'b0001);
	FIFO_READ(32'h0000001b,4'b0001);
	FIFO_READ(32'h0000001c,4'b0001);
	FIFO_READ(32'h0000001d,4'b0001);
	FIFO_READ(32'h0000001e,4'b0001);
	FIFO_READ(32'h0000001f,4'b0001);

	// unaligned WORD-to-BYTE
	SrcWidth = `WORD;
	SrcAddr  = 2'b01;
	DstWidth = `BYTE;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_WRITE(32'h23222120);
	FIFO_READ(32'h00000001,4'b0001);
	FIFO_READ(32'h00000002,4'b0001);
	FIFO_READ(32'h00000003,4'b0001);
	FIFO_READ(32'h00000004,4'b0001);
	FIFO_READ(32'h00000005,4'b0001);
	FIFO_READ(32'h00000006,4'b0001);
	FIFO_READ(32'h00000007,4'b0001);
	FIFO_READ(32'h00000008,4'b0001);
	FIFO_READ(32'h00000009,4'b0001);
	FIFO_READ(32'h0000000a,4'b0001);
	FIFO_READ(32'h0000000b,4'b0001);
	FIFO_READ(32'h0000000c,4'b0001);
	FIFO_READ(32'h0000000d,4'b0001);
	FIFO_READ(32'h0000000e,4'b0001);
	FIFO_READ(32'h0000000f,4'b0001);
	FIFO_READ(32'h00000010,4'b0001);
	FIFO_READ(32'h00000011,4'b0001);
	FIFO_READ(32'h00000012,4'b0001);
	FIFO_READ(32'h00000013,4'b0001);
	FIFO_READ(32'h00000014,4'b0001);
	FIFO_READ(32'h00000015,4'b0001);
	FIFO_READ(32'h00000016,4'b0001);
	FIFO_READ(32'h00000017,4'b0001);
	FIFO_READ(32'h00000018,4'b0001);
	FIFO_READ(32'h00000019,4'b0001);
	FIFO_READ(32'h0000001a,4'b0001);
	FIFO_READ(32'h0000001b,4'b0001);
	FIFO_READ(32'h0000001c,4'b0001);
	FIFO_READ(32'h0000001d,4'b0001);
	FIFO_READ(32'h0000001e,4'b0001);
	FIFO_READ(32'h0000001f,4'b0001);
	FIFO_READ(32'h00000020,4'b0001);

	// unaligned WORD-to-BYTE
	SrcWidth = `WORD;
	SrcAddr  = 2'b10;
	DstWidth = `BYTE;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h03020100);
	FIFO_WRITE(32'h07060504);
	FIFO_WRITE(32'h0b0a0908);
	FIFO_WRITE(32'h0f0e0d0c);
	FIFO_WRITE(32'h13121110);
	FIFO_WRITE(32'h17161514);
	FIFO_WRITE(32'h1b1a1918);
	FIFO_WRITE(32'h1f1e1d1c);
	FIFO_WRITE(32'h23222120);
	FIFO_READ(32'h00000002,4'b0001);
	FIFO_READ(32'h00000003,4'b0001);
	FIFO_READ(32'h00000004,4'b0001);
	FIFO_READ(32'h00000005,4'b0001);
	FIFO_READ(32'h00000006,4'b0001);
	FIFO_READ(32'h00000007,4'b0001);
	FIFO_READ(32'h00000008,4'b0001);
	FIFO_READ(32'h00000009,4'b0001);
	FIFO_READ(32'h0000000a,4'b0001);
	FIFO_READ(32'h0000000b,4'b0001);
	FIFO_READ(32'h0000000c,4'b0001);
	FIFO_READ(32'h0000000d,4'b0001);
	FIFO_READ(32'h0000000e,4'b0001);
	FIFO_READ(32'h0000000f,4'b0001);
	FIFO_READ(32'h00000010,4'b0001);
	FIFO_READ(32'h00000011,4'b0001);
	FIFO_READ(32'h00000012,4'b0001);
	FIFO_READ(32'h00000013,4'b0001);
	FIFO_READ(32'h00000014,4'b0001);
	FIFO_READ(32'h00000015,4'b0001);
	FIFO_READ(32'h00000016,4'b0001);
	FIFO_READ(32'h00000017,4'b0001);
	FIFO_READ(32'h00000018,4'b0001);
	FIFO_READ(32'h00000019,4'b0001);
	FIFO_READ(32'h0000001a,4'b0001);
	FIFO_READ(32'h0000001b,4'b0001);
	FIFO_READ(32'h0000001c,4'b0001);
	FIFO_READ(32'h0000001d,4'b0001);
	FIFO_READ(32'h0000001e,4'b0001);
	FIFO_READ(32'h0000001f,4'b0001);
	FIFO_READ(32'h00000020,4'b0001);
	FIFO_READ(32'h00000021,4'b0001);

	// BYTE-to-WORD
	SrcWidth = `BYTE;
	SrcAddr  = 2'b10;
	DstWidth = `WORD;
	DstAddr  = 2'b00;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h00000000);
	FIFO_WRITE(32'h00000001);
	FIFO_WRITE(32'h00000002);
	FIFO_WRITE(32'h00000003);
	FIFO_WRITE(32'h00000004);
	FIFO_WRITE(32'h00000005);
	FIFO_WRITE(32'h00000006);
	FIFO_WRITE(32'h00000007);
	FIFO_WRITE(32'h00000008);
	FIFO_WRITE(32'h00000009);
	FIFO_WRITE(32'h0000000a);
	FIFO_WRITE(32'h0000000b);
	FIFO_WRITE(32'h0000000c);
	FIFO_WRITE(32'h0000000d);
	FIFO_WRITE(32'h0000000e);
	FIFO_WRITE(32'h0000000f);
	FIFO_WRITE(32'h00000010);
	FIFO_WRITE(32'h00000011);
	FIFO_WRITE(32'h00000012);
	FIFO_WRITE(32'h00000013);
	FIFO_WRITE(32'h00000014);
	FIFO_WRITE(32'h00000015);
	FIFO_WRITE(32'h00000016);
	FIFO_WRITE(32'h00000017);
	FIFO_WRITE(32'h00000018);
	FIFO_WRITE(32'h00000019);
	FIFO_WRITE(32'h0000001a);
	FIFO_WRITE(32'h0000001b);
	FIFO_WRITE(32'h0000001c);
	FIFO_WRITE(32'h0000001d);
	FIFO_WRITE(32'h0000001e);
	FIFO_WRITE(32'h0000001f);
	FIFO_READ(32'h03020100, 4'b1111);
	FIFO_READ(32'h07060504, 4'b1111);
	FIFO_READ(32'h0b0a0908, 4'b1111);
	FIFO_READ(32'h0f0e0d0c, 4'b1111);
	FIFO_READ(32'h13121110, 4'b1111);
	FIFO_READ(32'h17161514, 4'b1111);
	FIFO_READ(32'h1b1a1918, 4'b1111);
	FIFO_READ(32'h1f1e1d1c, 4'b1111);

	// BYTE-to-unaligned WORD : trailing bytes
	SrcWidth = `BYTE;
	SrcAddr  = 2'b11;
	DstWidth = `WORD;
	DstAddr  = 2'b11;
	NumByte  = 5'd5;
	FIFO_RESET;
	FIFO_WRITE(32'h00000000);
	FIFO_WRITE(32'h00000001);
	FIFO_WRITE(32'h00000002);
	FIFO_WRITE(32'h00000003);
	FIFO_WRITE(32'h00000004);
	FIFO_WRITE(32'h00000005);
	FIFO_READ(32'h00000000, 4'b1000);
	FIFO_READ(32'h04030201, 4'b1111);
	FIFO_READ(32'h00000005, 4'b0001);

	// unaligned HWORD-to-BYTE
	SrcWidth = `HWORD;
	SrcAddr  = 2'b01;
	DstWidth = `BYTE;
	DstAddr  = 2'b11;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h00000100);
	FIFO_WRITE(32'h00000302);
	FIFO_WRITE(32'h00000504);
	FIFO_WRITE(32'h00000706);
	FIFO_WRITE(32'h00000908);
	FIFO_WRITE(32'h00000b0a);
	FIFO_WRITE(32'h00000d0c);
	FIFO_WRITE(32'h00000f0e);
	FIFO_WRITE(32'h00001110);
	FIFO_WRITE(32'h00001312);
	FIFO_WRITE(32'h00001514);
	FIFO_WRITE(32'h00001716);
	FIFO_WRITE(32'h00001918);
	FIFO_WRITE(32'h00001b1a);
	FIFO_WRITE(32'h00001d1c);
	FIFO_WRITE(32'h00001f1e);
	FIFO_WRITE(32'h00002120);
	FIFO_READ(32'h00000001,4'b0001);
	FIFO_READ(32'h00000002,4'b0001);
	FIFO_READ(32'h00000003,4'b0001);
	FIFO_READ(32'h00000004,4'b0001);
	FIFO_READ(32'h00000005,4'b0001);
	FIFO_READ(32'h00000006,4'b0001);
	FIFO_READ(32'h00000007,4'b0001);
	FIFO_READ(32'h00000008,4'b0001);
	FIFO_READ(32'h00000009,4'b0001);
	FIFO_READ(32'h0000000a,4'b0001);
	FIFO_READ(32'h0000000b,4'b0001);
	FIFO_READ(32'h0000000c,4'b0001);
	FIFO_READ(32'h0000000d,4'b0001);
	FIFO_READ(32'h0000000e,4'b0001);
	FIFO_READ(32'h0000000f,4'b0001);
	FIFO_READ(32'h00000010,4'b0001);
	FIFO_READ(32'h00000011,4'b0001);
	FIFO_READ(32'h00000012,4'b0001);
	FIFO_READ(32'h00000013,4'b0001);
	FIFO_READ(32'h00000014,4'b0001);
	FIFO_READ(32'h00000015,4'b0001);
	FIFO_READ(32'h00000016,4'b0001);
	FIFO_READ(32'h00000017,4'b0001);
	FIFO_READ(32'h00000018,4'b0001);
	FIFO_READ(32'h00000019,4'b0001);
	FIFO_READ(32'h0000001a,4'b0001);
	FIFO_READ(32'h0000001b,4'b0001);
	FIFO_READ(32'h0000001c,4'b0001);
	FIFO_READ(32'h0000001d,4'b0001);
	FIFO_READ(32'h0000001e,4'b0001);
	FIFO_READ(32'h0000001f,4'b0001);
	FIFO_READ(32'h00000020,4'b0001);

	// unaligned HWORD-to-unaligned HWORD(small transfer lead to error)
	SrcWidth = `HWORD;
	SrcAddr  = 2'b01;
	DstWidth = `HWORD;
	DstAddr  = 2'b01;
	NumByte  = 5'd31;
	FIFO_RESET;
	FIFO_WRITE(32'h00000100);
	FIFO_WRITE(32'h00000302);
	FIFO_WRITE(32'h00000504);
	FIFO_WRITE(32'h00000706);
	FIFO_WRITE(32'h00000908);
	FIFO_WRITE(32'h00000b0a);
	FIFO_WRITE(32'h00000d0c);
	FIFO_WRITE(32'h00000f0e);
	FIFO_WRITE(32'h00001110);
	FIFO_WRITE(32'h00001312);
	FIFO_WRITE(32'h00001514);
	FIFO_WRITE(32'h00001716);
	FIFO_WRITE(32'h00001918);
	FIFO_WRITE(32'h00001b1a);
	FIFO_WRITE(32'h00001d1c);
	FIFO_WRITE(32'h00001f1e);
	FIFO_WRITE(32'h00002120);
	FIFO_READ(32'h00000100, 4'b0010);
	FIFO_READ(32'h00000302, 4'b0011);
	FIFO_READ(32'h00000504, 4'b0011);
	FIFO_READ(32'h00000706, 4'b0011);
	FIFO_READ(32'h00000908, 4'b0011);
	FIFO_READ(32'h00000b0a, 4'b0011);
	FIFO_READ(32'h00000d0c, 4'b0011);
	FIFO_READ(32'h00000f0e, 4'b0011);
	FIFO_READ(32'h00001110, 4'b0011);
	FIFO_READ(32'h00001312, 4'b0011);
	FIFO_READ(32'h00001514, 4'b0011);
	FIFO_READ(32'h00001716, 4'b0011);
	FIFO_READ(32'h00001918, 4'b0011);
	FIFO_READ(32'h00001b1a, 4'b0011);
	FIFO_READ(32'h00001d1c, 4'b0011);
	FIFO_READ(32'h00001f1e, 4'b0011);
	FIFO_READ(32'h00002120, 4'b0001);

	$finish;
end

DmacFifo DmacFifo
(
		.ACLK(ACLK),

		.FifoReset(FifoReset),
		.NumByte(NumByte),

		.SrcWidth(SrcWidth),
		.DataIn(DataIn),
		.WriteEn(WriteEn),
		.SrcAddr(SrcAddr),

		.DstWidth(DstWidth),
		.DataOut(DataOut),
		.DataMask(DataMask),
		.ReadEn(ReadEn),
		.DstAddr(DstAddr)
);

endmodule

