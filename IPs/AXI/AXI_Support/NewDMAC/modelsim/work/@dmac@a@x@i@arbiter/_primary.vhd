library verilog;
use verilog.vl_types.all;
entity dmacaxiarbiter is
    port(
        aclk            : in     vl_logic;
        aresetn         : in     vl_logic;
        arvalid0        : in     vl_logic;
        arready0        : out    vl_logic;
        araddr0         : in     vl_logic_vector(31 downto 0);
        arlen0          : in     vl_logic_vector(3 downto 0);
        arsize0         : in     vl_logic_vector(2 downto 0);
        arburst0        : in     vl_logic_vector(1 downto 0);
        rdata0          : out    vl_logic_vector(31 downto 0);
        rresp0          : out    vl_logic_vector(1 downto 0);
        rlast0          : out    vl_logic;
        rvalid0         : out    vl_logic;
        rready0         : in     vl_logic;
        awvalid0        : in     vl_logic;
        awready0        : out    vl_logic;
        awaddr0         : in     vl_logic_vector(31 downto 0);
        awlen0          : in     vl_logic_vector(3 downto 0);
        awsize0         : in     vl_logic_vector(2 downto 0);
        awburst0        : in     vl_logic_vector(1 downto 0);
        wdata0          : in     vl_logic_vector(31 downto 0);
        wstrb0          : in     vl_logic_vector(3 downto 0);
        wlast0          : in     vl_logic;
        wvalid0         : in     vl_logic;
        wready0         : out    vl_logic;
        bresp0          : out    vl_logic_vector(1 downto 0);
        bvalid0         : out    vl_logic;
        bready0         : in     vl_logic;
        arvalid1        : in     vl_logic;
        arready1        : out    vl_logic;
        araddr1         : in     vl_logic_vector(31 downto 0);
        arlen1          : in     vl_logic_vector(3 downto 0);
        arsize1         : in     vl_logic_vector(2 downto 0);
        arburst1        : in     vl_logic_vector(1 downto 0);
        rdata1          : out    vl_logic_vector(31 downto 0);
        rresp1          : out    vl_logic_vector(1 downto 0);
        rlast1          : out    vl_logic;
        rvalid1         : out    vl_logic;
        rready1         : in     vl_logic;
        awvalid1        : in     vl_logic;
        awready1        : out    vl_logic;
        awaddr1         : in     vl_logic_vector(31 downto 0);
        awlen1          : in     vl_logic_vector(3 downto 0);
        awsize1         : in     vl_logic_vector(2 downto 0);
        awburst1        : in     vl_logic_vector(1 downto 0);
        wdata1          : in     vl_logic_vector(31 downto 0);
        wstrb1          : in     vl_logic_vector(3 downto 0);
        wlast1          : in     vl_logic;
        wvalid1         : in     vl_logic;
        wready1         : out    vl_logic;
        bresp1          : out    vl_logic_vector(1 downto 0);
        bvalid1         : out    vl_logic;
        bready1         : in     vl_logic;
        arid            : out    vl_logic;
        arvalid         : out    vl_logic;
        arready         : in     vl_logic;
        araddr          : out    vl_logic_vector(31 downto 0);
        arlen           : out    vl_logic_vector(3 downto 0);
        arsize          : out    vl_logic_vector(2 downto 0);
        arburst         : out    vl_logic_vector(1 downto 0);
        rid             : in     vl_logic;
        rdata           : in     vl_logic_vector(31 downto 0);
        rresp           : in     vl_logic_vector(1 downto 0);
        rlast           : in     vl_logic;
        rvalid          : in     vl_logic;
        rready          : out    vl_logic;
        awid            : out    vl_logic;
        awvalid         : out    vl_logic;
        awready         : in     vl_logic;
        awaddr          : out    vl_logic_vector(31 downto 0);
        awlen           : out    vl_logic_vector(3 downto 0);
        awsize          : out    vl_logic_vector(2 downto 0);
        awburst         : out    vl_logic_vector(1 downto 0);
        wid             : out    vl_logic;
        wdata           : out    vl_logic_vector(31 downto 0);
        wstrb           : out    vl_logic_vector(3 downto 0);
        wlast           : out    vl_logic;
        wvalid          : out    vl_logic;
        wready          : in     vl_logic;
        bid             : in     vl_logic;
        bresp           : in     vl_logic_vector(1 downto 0);
        bvalid          : in     vl_logic;
        bready          : out    vl_logic
    );
end dmacaxiarbiter;
