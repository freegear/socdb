library verilog;
use verilog.vl_types.all;
entity axidmac is
    port(
        aclk            : in     vl_logic;
        aresetn         : in     vl_logic;
        paddr           : in     vl_logic_vector(11 downto 2);
        pwrite          : in     vl_logic;
        psel            : in     vl_logic;
        penable         : in     vl_logic;
        prdata          : out    vl_logic_vector(31 downto 0);
        pwdata          : in     vl_logic_vector(31 downto 0);
        pready          : out    vl_logic;
        awaddr1         : out    vl_logic_vector(31 downto 0);
        awlen1          : out    vl_logic_vector(3 downto 0);
        awsize1         : out    vl_logic_vector(2 downto 0);
        awburst1        : out    vl_logic_vector(1 downto 0);
        awlock1         : out    vl_logic_vector(1 downto 0);
        awcache1        : out    vl_logic_vector(3 downto 0);
        awprot1         : out    vl_logic_vector(2 downto 0);
        awvalid1        : out    vl_logic;
        awready1        : in     vl_logic;
        wdata1          : out    vl_logic_vector(31 downto 0);
        wstrb1          : out    vl_logic_vector(3 downto 0);
        wlast1          : out    vl_logic;
        wvalid1         : out    vl_logic;
        wready1         : in     vl_logic;
        bresp1          : in     vl_logic_vector(1 downto 0);
        bvalid1         : in     vl_logic;
        bready1         : out    vl_logic;
        araddr1         : out    vl_logic_vector(31 downto 0);
        arlen1          : out    vl_logic_vector(3 downto 0);
        arsize1         : out    vl_logic_vector(2 downto 0);
        arburst1        : out    vl_logic_vector(1 downto 0);
        arlock1         : out    vl_logic_vector(1 downto 0);
        arcache1        : out    vl_logic_vector(3 downto 0);
        arprot1         : out    vl_logic_vector(2 downto 0);
        arvalid1        : out    vl_logic;
        arready1        : in     vl_logic;
        rdata1          : in     vl_logic_vector(31 downto 0);
        rresp1          : in     vl_logic_vector(1 downto 0);
        rlast1          : in     vl_logic;
        rvalid1         : in     vl_logic;
        rready1         : out    vl_logic;
        awaddr2         : out    vl_logic_vector(31 downto 0);
        awlen2          : out    vl_logic_vector(3 downto 0);
        awsize2         : out    vl_logic_vector(2 downto 0);
        awburst2        : out    vl_logic_vector(1 downto 0);
        awlock2         : out    vl_logic_vector(1 downto 0);
        awcache2        : out    vl_logic_vector(3 downto 0);
        awprot2         : out    vl_logic_vector(2 downto 0);
        awvalid2        : out    vl_logic;
        awready2        : in     vl_logic;
        wdata2          : out    vl_logic_vector(31 downto 0);
        wstrb2          : out    vl_logic_vector(3 downto 0);
        wlast2          : out    vl_logic;
        wvalid2         : out    vl_logic;
        wready2         : in     vl_logic;
        bresp2          : in     vl_logic_vector(1 downto 0);
        bvalid2         : in     vl_logic;
        bready2         : out    vl_logic;
        araddr2         : out    vl_logic_vector(31 downto 0);
        arlen2          : out    vl_logic_vector(3 downto 0);
        arsize2         : out    vl_logic_vector(2 downto 0);
        arburst2        : out    vl_logic_vector(1 downto 0);
        arlock2         : out    vl_logic_vector(1 downto 0);
        arcache2        : out    vl_logic_vector(3 downto 0);
        arprot2         : out    vl_logic_vector(2 downto 0);
        arvalid2        : out    vl_logic;
        arready2        : in     vl_logic;
        rdata2          : in     vl_logic_vector(31 downto 0);
        rresp2          : in     vl_logic_vector(1 downto 0);
        rlast2          : in     vl_logic;
        rvalid2         : in     vl_logic;
        rready2         : out    vl_logic;
        dmacbreq        : in     vl_logic_vector(15 downto 0);
        dmaclbreq       : in     vl_logic_vector(15 downto 0);
        dmacsreq        : in     vl_logic_vector(15 downto 0);
        dmaclsreq       : in     vl_logic_vector(15 downto 0);
        dmacclr         : out    vl_logic_vector(15 downto 0);
        dmactc          : out    vl_logic_vector(15 downto 0);
        dmacinterr      : out    vl_logic;
        dmacinttc       : out    vl_logic;
        dmacintr        : out    vl_logic
    );
end axidmac;
