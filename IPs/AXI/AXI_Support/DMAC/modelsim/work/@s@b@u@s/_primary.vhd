library verilog;
use verilog.vl_types.all;
entity sbus is
    generic(
        bus_wid         : integer := 32;
        addr_wid        : integer := 32;
        id_wid          : integer := 4;
        awlen_wid       : integer := 4;
        awsize_wid      : integer := 3;
        awburst_wid     : integer := 2;
        awlock_wid      : integer := 2;
        awcache_wid     : integer := 4;
        awprot_wid      : integer := 3;
        wstrb_wid       : integer := 4;
        bresp_wid       : integer := 2;
        rresp_wid       : integer := 2;
        arlen_wid       : integer := 4;
        arsize_wid      : integer := 3;
        arburst_wid     : integer := 2;
        arlock_wid      : integer := 2;
        arcache_wid     : integer := 4;
        arprot_wid      : integer := 3;
        master_wid      : integer := 4;
        slave_wid       : integer := 3;
        slave_num       : integer := 6;
        master_num      : integer := 4;
        slavecntwid     : integer := 5;
        reqdepth_wid    : integer := 2
    );
    port(
        aclk            : in     vl_logic;
        aresetn         : in     vl_logic;
        awidm02si0      : in     vl_logic_vector;
        awaddrm02si0    : in     vl_logic_vector;
        awlenm02si0     : in     vl_logic_vector;
        awsizem02si0    : in     vl_logic_vector;
        awburstm02si0   : in     vl_logic_vector;
        awlockm02si0    : in     vl_logic_vector;
        awcachem02si0   : in     vl_logic_vector;
        awprotm02si0    : in     vl_logic_vector;
        awvalidm02si0   : in     vl_logic;
        awreadysi02m0   : out    vl_logic;
        widm02si0       : in     vl_logic_vector;
        wdatam02si0     : in     vl_logic_vector;
        wstrbm02si0     : in     vl_logic_vector;
        wlastm02si0     : in     vl_logic;
        wvalidm02si0    : in     vl_logic;
        wreadysi02m0    : out    vl_logic;
        bidsi02m0       : out    vl_logic_vector;
        brespsi02m0     : out    vl_logic_vector;
        bvalidsi02m0    : out    vl_logic;
        breadym02si0    : in     vl_logic;
        awidm12si1      : in     vl_logic_vector;
        awaddrm12si1    : in     vl_logic_vector;
        awlenm12si1     : in     vl_logic_vector;
        awsizem12si1    : in     vl_logic_vector;
        awburstm12si1   : in     vl_logic_vector;
        awlockm12si1    : in     vl_logic_vector;
        awcachem12si1   : in     vl_logic_vector;
        awprotm12si1    : in     vl_logic_vector;
        awvalidm12si1   : in     vl_logic;
        awreadysi12m1   : out    vl_logic;
        widm12si1       : in     vl_logic_vector;
        wdatam12si1     : in     vl_logic_vector;
        wstrbm12si1     : in     vl_logic_vector;
        wlastm12si1     : in     vl_logic;
        wvalidm12si1    : in     vl_logic;
        wreadysi12m1    : out    vl_logic;
        bidsi12m1       : out    vl_logic_vector;
        brespsi12m1     : out    vl_logic_vector;
        bvalidsi12m1    : out    vl_logic;
        breadym12si1    : in     vl_logic;
        awidm22si2      : in     vl_logic_vector;
        awaddrm22si2    : in     vl_logic_vector;
        awlenm22si2     : in     vl_logic_vector;
        awsizem22si2    : in     vl_logic_vector;
        awburstm22si2   : in     vl_logic_vector;
        awlockm22si2    : in     vl_logic_vector;
        awcachem22si2   : in     vl_logic_vector;
        awprotm22si2    : in     vl_logic_vector;
        awvalidm22si2   : in     vl_logic;
        awreadysi22m2   : out    vl_logic;
        widm22si2       : in     vl_logic_vector;
        wdatam22si2     : in     vl_logic_vector;
        wstrbm22si2     : in     vl_logic_vector;
        wlastm22si2     : in     vl_logic;
        wvalidm22si2    : in     vl_logic;
        wreadysi22m2    : out    vl_logic;
        bidsi22m2       : out    vl_logic_vector;
        brespsi22m2     : out    vl_logic_vector;
        bvalidsi22m2    : out    vl_logic;
        breadym22si2    : in     vl_logic;
        awidm32si3      : in     vl_logic_vector;
        awaddrm32si3    : in     vl_logic_vector;
        awlenm32si3     : in     vl_logic_vector;
        awsizem32si3    : in     vl_logic_vector;
        awburstm32si3   : in     vl_logic_vector;
        awlockm32si3    : in     vl_logic_vector;
        awcachem32si3   : in     vl_logic_vector;
        awprotm32si3    : in     vl_logic_vector;
        awvalidm32si3   : in     vl_logic;
        awreadysi32m3   : out    vl_logic;
        widm32si3       : in     vl_logic_vector;
        wdatam32si3     : in     vl_logic_vector;
        wstrbm32si3     : in     vl_logic_vector;
        wlastm32si3     : in     vl_logic;
        wvalidm32si3    : in     vl_logic;
        wreadysi32m3    : out    vl_logic;
        bidsi32m3       : out    vl_logic_vector;
        brespsi32m3     : out    vl_logic_vector;
        bvalidsi32m3    : out    vl_logic;
        breadym32si3    : in     vl_logic;
        awidmi02s0      : out    vl_logic_vector;
        awaddrmi02s0    : out    vl_logic_vector;
        awlenmi02s0     : out    vl_logic_vector;
        awsizemi02s0    : out    vl_logic_vector;
        awburstmi02s0   : out    vl_logic_vector;
        awlockmi02s0    : out    vl_logic_vector;
        awcachemi02s0   : out    vl_logic_vector;
        awprotmi02s0    : out    vl_logic_vector;
        awvalidmi02s0   : out    vl_logic;
        awreadys02mi0   : in     vl_logic;
        widmi02s0       : out    vl_logic_vector;
        wdatami02s0     : out    vl_logic_vector;
        wstrbmi02s0     : out    vl_logic_vector;
        wlastmi02s0     : out    vl_logic;
        wvalidmi02s0    : out    vl_logic;
        wreadys02mi0    : in     vl_logic;
        bids02mi0       : in     vl_logic_vector;
        bresps02mi0     : in     vl_logic_vector;
        bvalids02mi0    : in     vl_logic;
        breadymi02s0    : out    vl_logic;
        awidmi12s1      : out    vl_logic_vector;
        awaddrmi12s1    : out    vl_logic_vector;
        awlenmi12s1     : out    vl_logic_vector;
        awsizemi12s1    : out    vl_logic_vector;
        awburstmi12s1   : out    vl_logic_vector;
        awlockmi12s1    : out    vl_logic_vector;
        awcachemi12s1   : out    vl_logic_vector;
        awprotmi12s1    : out    vl_logic_vector;
        awvalidmi12s1   : out    vl_logic;
        awreadys12mi1   : in     vl_logic;
        widmi12s1       : out    vl_logic_vector;
        wdatami12s1     : out    vl_logic_vector;
        wstrbmi12s1     : out    vl_logic_vector;
        wlastmi12s1     : out    vl_logic;
        wvalidmi12s1    : out    vl_logic;
        wreadys12mi1    : in     vl_logic;
        bids12mi1       : in     vl_logic_vector;
        bresps12mi1     : in     vl_logic_vector;
        bvalids12mi1    : in     vl_logic;
        breadymi12s1    : out    vl_logic;
        awidmi22s2      : out    vl_logic_vector;
        awaddrmi22s2    : out    vl_logic_vector;
        awlenmi22s2     : out    vl_logic_vector;
        awsizemi22s2    : out    vl_logic_vector;
        awburstmi22s2   : out    vl_logic_vector;
        awlockmi22s2    : out    vl_logic_vector;
        awcachemi22s2   : out    vl_logic_vector;
        awprotmi22s2    : out    vl_logic_vector;
        awvalidmi22s2   : out    vl_logic;
        awreadys22mi2   : in     vl_logic;
        widmi22s2       : out    vl_logic_vector;
        wdatami22s2     : out    vl_logic_vector;
        wstrbmi22s2     : out    vl_logic_vector;
        wlastmi22s2     : out    vl_logic;
        wvalidmi22s2    : out    vl_logic;
        wreadys22mi2    : in     vl_logic;
        bids22mi2       : in     vl_logic_vector;
        bresps22mi2     : in     vl_logic_vector;
        bvalids22mi2    : in     vl_logic;
        breadymi22s2    : out    vl_logic;
        awidmi32s3      : out    vl_logic_vector;
        awaddrmi32s3    : out    vl_logic_vector;
        awlenmi32s3     : out    vl_logic_vector;
        awsizemi32s3    : out    vl_logic_vector;
        awburstmi32s3   : out    vl_logic_vector;
        awlockmi32s3    : out    vl_logic_vector;
        awcachemi32s3   : out    vl_logic_vector;
        awprotmi32s3    : out    vl_logic_vector;
        awvalidmi32s3   : out    vl_logic;
        awreadys32mi3   : in     vl_logic;
        widmi32s3       : out    vl_logic_vector;
        wdatami32s3     : out    vl_logic_vector;
        wstrbmi32s3     : out    vl_logic_vector;
        wlastmi32s3     : out    vl_logic;
        wvalidmi32s3    : out    vl_logic;
        wreadys32mi3    : in     vl_logic;
        bids32mi3       : in     vl_logic_vector;
        bresps32mi3     : in     vl_logic_vector;
        bvalids32mi3    : in     vl_logic;
        breadymi32s3    : out    vl_logic;
        awidmi42s4      : out    vl_logic_vector;
        awaddrmi42s4    : out    vl_logic_vector;
        awlenmi42s4     : out    vl_logic_vector;
        awsizemi42s4    : out    vl_logic_vector;
        awburstmi42s4   : out    vl_logic_vector;
        awlockmi42s4    : out    vl_logic_vector;
        awcachemi42s4   : out    vl_logic_vector;
        awprotmi42s4    : out    vl_logic_vector;
        awvalidmi42s4   : out    vl_logic;
        awreadys42mi4   : in     vl_logic;
        widmi42s4       : out    vl_logic_vector;
        wdatami42s4     : out    vl_logic_vector;
        wstrbmi42s4     : out    vl_logic_vector;
        wlastmi42s4     : out    vl_logic;
        wvalidmi42s4    : out    vl_logic;
        wreadys42mi4    : in     vl_logic;
        bids42mi4       : in     vl_logic_vector;
        bresps42mi4     : in     vl_logic_vector;
        bvalids42mi4    : in     vl_logic;
        breadymi42s4    : out    vl_logic;
        awidmi52s5      : out    vl_logic_vector;
        awaddrmi52s5    : out    vl_logic_vector;
        awlenmi52s5     : out    vl_logic_vector;
        awsizemi52s5    : out    vl_logic_vector;
        awburstmi52s5   : out    vl_logic_vector;
        awlockmi52s5    : out    vl_logic_vector;
        awcachemi52s5   : out    vl_logic_vector;
        awprotmi52s5    : out    vl_logic_vector;
        awvalidmi52s5   : out    vl_logic;
        awreadys52mi5   : in     vl_logic;
        widmi52s5       : out    vl_logic_vector;
        wdatami52s5     : out    vl_logic_vector;
        wstrbmi52s5     : out    vl_logic_vector;
        wlastmi52s5     : out    vl_logic;
        wvalidmi52s5    : out    vl_logic;
        wreadys52mi5    : in     vl_logic;
        bids52mi5       : in     vl_logic_vector;
        bresps52mi5     : in     vl_logic_vector;
        bvalids52mi5    : in     vl_logic;
        breadymi52s5    : out    vl_logic;
        aridm02si0      : in     vl_logic_vector;
        araddrm02si0    : in     vl_logic_vector;
        arlenm02si0     : in     vl_logic_vector;
        arsizem02si0    : in     vl_logic_vector;
        arburstm02si0   : in     vl_logic_vector;
        arlockm02si0    : in     vl_logic_vector;
        arcachem02si0   : in     vl_logic_vector;
        arprotm02si0    : in     vl_logic_vector;
        arvalidm02si0   : in     vl_logic;
        arreadysi02m0   : out    vl_logic;
        ridsi02m0       : out    vl_logic_vector;
        rrespsi02m0     : out    vl_logic_vector;
        rdatasi02m0     : out    vl_logic_vector;
        rlastsi02m0     : out    vl_logic;
        rvalidsi02m0    : out    vl_logic;
        rreadym02si0    : in     vl_logic;
        aridm12si1      : in     vl_logic_vector;
        araddrm12si1    : in     vl_logic_vector;
        arlenm12si1     : in     vl_logic_vector;
        arsizem12si1    : in     vl_logic_vector;
        arburstm12si1   : in     vl_logic_vector;
        arlockm12si1    : in     vl_logic_vector;
        arcachem12si1   : in     vl_logic_vector;
        arprotm12si1    : in     vl_logic_vector;
        arvalidm12si1   : in     vl_logic;
        arreadysi12m1   : out    vl_logic;
        ridsi12m1       : out    vl_logic_vector;
        rrespsi12m1     : out    vl_logic_vector;
        rdatasi12m1     : out    vl_logic_vector;
        rlastsi12m1     : out    vl_logic;
        rvalidsi12m1    : out    vl_logic;
        rreadym12si1    : in     vl_logic;
        aridm22si2      : in     vl_logic_vector;
        araddrm22si2    : in     vl_logic_vector;
        arlenm22si2     : in     vl_logic_vector;
        arsizem22si2    : in     vl_logic_vector;
        arburstm22si2   : in     vl_logic_vector;
        arlockm22si2    : in     vl_logic_vector;
        arcachem22si2   : in     vl_logic_vector;
        arprotm22si2    : in     vl_logic_vector;
        arvalidm22si2   : in     vl_logic;
        arreadysi22m2   : out    vl_logic;
        ridsi22m2       : out    vl_logic_vector;
        rrespsi22m2     : out    vl_logic_vector;
        rdatasi22m2     : out    vl_logic_vector;
        rlastsi22m2     : out    vl_logic;
        rvalidsi22m2    : out    vl_logic;
        rreadym22si2    : in     vl_logic;
        aridm32si3      : in     vl_logic_vector;
        araddrm32si3    : in     vl_logic_vector;
        arlenm32si3     : in     vl_logic_vector;
        arsizem32si3    : in     vl_logic_vector;
        arburstm32si3   : in     vl_logic_vector;
        arlockm32si3    : in     vl_logic_vector;
        arcachem32si3   : in     vl_logic_vector;
        arprotm32si3    : in     vl_logic_vector;
        arvalidm32si3   : in     vl_logic;
        arreadysi32m3   : out    vl_logic;
        ridsi32m3       : out    vl_logic_vector;
        rrespsi32m3     : out    vl_logic_vector;
        rdatasi32m3     : out    vl_logic_vector;
        rlastsi32m3     : out    vl_logic;
        rvalidsi32m3    : out    vl_logic;
        rreadym32si3    : in     vl_logic;
        aridmi02s0      : out    vl_logic_vector;
        araddrmi02s0    : out    vl_logic_vector;
        arlenmi02s0     : out    vl_logic_vector;
        arsizemi02s0    : out    vl_logic_vector;
        arburstmi02s0   : out    vl_logic_vector;
        arlockmi02s0    : out    vl_logic_vector;
        arcachemi02s0   : out    vl_logic_vector;
        arprotmi02s0    : out    vl_logic_vector;
        arvalidmi02s0   : out    vl_logic;
        arreadys02mi0   : in     vl_logic;
        rids02mi0       : in     vl_logic_vector;
        rresps02mi0     : in     vl_logic_vector;
        rdatas02mi0     : in     vl_logic_vector;
        rlasts02mi0     : in     vl_logic;
        rvalids02mi0    : in     vl_logic;
        rreadymi02s0    : out    vl_logic;
        aridmi12s1      : out    vl_logic_vector;
        araddrmi12s1    : out    vl_logic_vector;
        arlenmi12s1     : out    vl_logic_vector;
        arsizemi12s1    : out    vl_logic_vector;
        arburstmi12s1   : out    vl_logic_vector;
        arlockmi12s1    : out    vl_logic_vector;
        arcachemi12s1   : out    vl_logic_vector;
        arprotmi12s1    : out    vl_logic_vector;
        arvalidmi12s1   : out    vl_logic;
        arreadys12mi1   : in     vl_logic;
        rids12mi1       : in     vl_logic_vector;
        rresps12mi1     : in     vl_logic_vector;
        rdatas12mi1     : in     vl_logic_vector;
        rlasts12mi1     : in     vl_logic;
        rvalids12mi1    : in     vl_logic;
        rreadymi12s1    : out    vl_logic;
        aridmi22s2      : out    vl_logic_vector;
        araddrmi22s2    : out    vl_logic_vector;
        arlenmi22s2     : out    vl_logic_vector;
        arsizemi22s2    : out    vl_logic_vector;
        arburstmi22s2   : out    vl_logic_vector;
        arlockmi22s2    : out    vl_logic_vector;
        arcachemi22s2   : out    vl_logic_vector;
        arprotmi22s2    : out    vl_logic_vector;
        arvalidmi22s2   : out    vl_logic;
        arreadys22mi2   : in     vl_logic;
        rids22mi2       : in     vl_logic_vector;
        rresps22mi2     : in     vl_logic_vector;
        rdatas22mi2     : in     vl_logic_vector;
        rlasts22mi2     : in     vl_logic;
        rvalids22mi2    : in     vl_logic;
        rreadymi22s2    : out    vl_logic;
        aridmi32s3      : out    vl_logic_vector;
        araddrmi32s3    : out    vl_logic_vector;
        arlenmi32s3     : out    vl_logic_vector;
        arsizemi32s3    : out    vl_logic_vector;
        arburstmi32s3   : out    vl_logic_vector;
        arlockmi32s3    : out    vl_logic_vector;
        arcachemi32s3   : out    vl_logic_vector;
        arprotmi32s3    : out    vl_logic_vector;
        arvalidmi32s3   : out    vl_logic;
        arreadys32mi3   : in     vl_logic;
        rids32mi3       : in     vl_logic_vector;
        rresps32mi3     : in     vl_logic_vector;
        rdatas32mi3     : in     vl_logic_vector;
        rlasts32mi3     : in     vl_logic;
        rvalids32mi3    : in     vl_logic;
        rreadymi32s3    : out    vl_logic;
        aridmi42s4      : out    vl_logic_vector;
        araddrmi42s4    : out    vl_logic_vector;
        arlenmi42s4     : out    vl_logic_vector;
        arsizemi42s4    : out    vl_logic_vector;
        arburstmi42s4   : out    vl_logic_vector;
        arlockmi42s4    : out    vl_logic_vector;
        arcachemi42s4   : out    vl_logic_vector;
        arprotmi42s4    : out    vl_logic_vector;
        arvalidmi42s4   : out    vl_logic;
        arreadys42mi4   : in     vl_logic;
        rids42mi4       : in     vl_logic_vector;
        rresps42mi4     : in     vl_logic_vector;
        rdatas42mi4     : in     vl_logic_vector;
        rlasts42mi4     : in     vl_logic;
        rvalids42mi4    : in     vl_logic;
        rreadymi42s4    : out    vl_logic;
        aridmi52s5      : out    vl_logic_vector;
        araddrmi52s5    : out    vl_logic_vector;
        arlenmi52s5     : out    vl_logic_vector;
        arsizemi52s5    : out    vl_logic_vector;
        arburstmi52s5   : out    vl_logic_vector;
        arlockmi52s5    : out    vl_logic_vector;
        arcachemi52s5   : out    vl_logic_vector;
        arprotmi52s5    : out    vl_logic_vector;
        arvalidmi52s5   : out    vl_logic;
        arreadys52mi5   : in     vl_logic;
        rids52mi5       : in     vl_logic_vector;
        rresps52mi5     : in     vl_logic_vector;
        rdatas52mi5     : in     vl_logic_vector;
        rlasts52mi5     : in     vl_logic;
        rvalids52mi5    : in     vl_logic;
        rreadymi52s5    : out    vl_logic
    );
end sbus;
