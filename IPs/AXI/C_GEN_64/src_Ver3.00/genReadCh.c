// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from RichenTech
// ALL RIGHTS RESERVED RichenTech 
// -----------------------------------------------------------------
// Version and Release information: NetWorkBus Ver 0.2
//                                  generated by NetWorkBus Gen 0.2 
// File Name           : genReadCh.c 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Read Channel generate function module
//  ----------------------------------------------------------------


//  =================================================================
//    Include 
//  ----------------------------------------------------------------

#include <stdio.h>
#include "Bus.h"
#include "genDef.h"
#include "MkFile.h"
#include "genReadCh.h"

//  =================================================================
//  Variable declaraion
//  ----------------------------------------------------------------

const char *HeaderReadChannelSI = {"\
// =================================================================\n\
//  This confidential and proprietary software may be used only as\n\
//  authorised by a licensing agreement from RichenTech           \n\
//  ALL RIGHTS RESERVED RichenTech                                \n\
// -----------------------------------------------------------------\n\
// Version and Release information: NetWorkBus Ver 0.2              \n\
//                                  generated by NetWorkBus Gen 0.2 \n\
// \n\
// File Name           : ReadChannelsi.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : ReadChannel SlaveInterface Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};

const char *HeaderReadChannelMI = {"\
// =================================================================\n\
//  This confidential and proprietary software may be used only as\n\
//  authorised by a licensing agreement from RichenTech           \n\
//  ALL RIGHTS RESERVED RichenTech                                \n\
// -----------------------------------------------------------------\n\
// Version and Release information: NetWorkBus Ver 0.2              \n\
//                                  generated by NetWorkBus Gen 0.2 \n\
// \n\
// File Name           : ReadChannelmi.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : ReadChannel Master Interface Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};

const char *HeaderReadChannel = {"\
// =================================================================\n\
//  This confidential and proprietary software may be used only as\n\
//  authorised by a licensing agreement from RichenTech           \n\
//  ALL RIGHTS RESERVED RichenTech                                \n\
// -----------------------------------------------------------------\n\
// Version and Release information: NetWorkBus Ver 0.2              \n\
//                                  generated by NetWorkBus Gen 0.2 \n\
// \n\
// File Name           : ReadChannel.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : ReadChannel TOP Block\n\
//                       \n\
//  ----------------------------------------------------------------\n"};

      
//  ----------------------------------------------------------------
//  Read channel top module generation 
//
//  unsigned int mkReadTOPInOutPort(struct codeLine *head_ptr
//  ----------------------------------------------------------------

unsigned int mkReadTOPInOutPort(struct codeLine *head_ptr, int *MaxZero)
{
    char *fileName;
    char *buff;
    FILE *Fp;
    int  i, endSlaveNum, endMasterNum;
    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;

    buff = (char *)malloc(sizeof(char) *120);
    fileName = (char *)malloc(sizeof(char) *120);
    strcpy(fileName, "./dataSample/ReadChannel/InOutPart.v");

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    //inout definition
    mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);

    //INOUT_STATE00 START process
    //mkBuffChange(Fp, head_ptr, endMasterNum, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 11);  //Read Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);

    //INOUT_STATE01 START process
    //mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 10);  //Read Channel Slave
    mkBeforeStr(Fp, head_ptr, INOUT_STATE02_START);

    //INOUT_STATE02 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE03_START);

    //INOUT_STATE03 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE04_START);

    //INOUT_STATE04 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE05_START);

    //INOUT_STATE05 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE06_START);

    //INOUT_STATE06 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE07_START);

    //INOUT_STATE07 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE08_START);

    //INOUT_STATE08 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE09_START);

    //INOUT_STATE09 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE10_START);

    //INOUT_STATE10 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }


    int MAXID=0;
    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter MASTERID%d_WID = %d ;\n", 
                              i, ValMASTER[i].readidwid );
        if(ValMASTER[i].readidwid>MAXID) MAXID = ValMASTER[i].readidwid;
        inDataLink(head_ptr, buff);
    }

    sprintf(buff, "parameter MAXMASTERID_WID = %d ;\n", MAXID); 
    inDataLink(head_ptr, buff);

    for(i=0; endMasterNum >i; i++)
    {
        sprintf(buff, "parameter BLANKMASTERID%d_WID = %d ;\n", 
                              i, MAXID - ValMASTER[i].readidwid );

        if((MAXID - ValMASTER[i].readidwid) == 0)   MaxZero[i] = 1;
        else                                        MaxZero[i] = 0;

        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVEID%d_WID = %d ;\n", 
                              i, ValSLAVE[i].readidwid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SELMASTER%d_WID = %d ;\n", 
        //2006-9-8-ID-WIDTH-FIXED
                              i, ValSLAVE[i].SelReadWid );
        inDataLink(head_ptr, buff);
    }

    for(i=0; endSlaveNum+1 >i; i++)
    {
        sprintf(buff, "parameter SLAVE_MASTERID%d_WID = %d ;\n", 
        //2006-9-8-ID-WIDTH-FIXED
                i, (ValSLAVE[i].readidwid - ValSLAVE[i].SelReadWid));
        inDataLink(head_ptr, buff);
    }

    mkBeforeStr(Fp, head_ptr, INOUT_STATE11_START);
    //__________________________________________________________ 

    //INOUT_STATE11 START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE12_START);

    //INOUT_STATE12 START process
    //mkBuffChange(Fp, head_ptr, endMasterNum, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 11);  //Read Channel Master
    mkBeforeStr(Fp, head_ptr, INOUT_STATE13_START);

    //INOUT_STATE13 START process
    //mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkTBusModule(Fp, head_ptr, 10);  //Read Channel Slave
    mkBeforeStr(Fp, head_ptr, INOUT_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);
    return BUS_ERROR_NONE;    
}


//  ----------------------------------------------------------------
//  Read channel inouptut port generation
//
//  unsigned int mkReadInOutPort( DefMaster *VAL_MASTER,
//                                DefSlave  *VAL_SLAVE,
//                              struct codeLine *head_ptr,
//                              int SlaveMaster)
//  ----------------------------------------------------------------

unsigned int mkReadInOutPort( DefMaster *VAL_MASTER,
                              DefSlave  *VAL_SLAVE,
                              struct codeLine *head_ptr,
                              int SlaveMaster)
{
    char *fileName;
    char *buff, *Name;
    FILE *Fp;
    int  i;
    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;
    buff = (char *)malloc(sizeof(char) *120);
    fileName = (char *)malloc(sizeof(char) *120);
    Name = (char *)malloc(sizeof(char) *120);

    if(SlaveMaster == 0)
    {
        strcpy(Name, VAL_MASTER->name);
        strcpy(fileName, 
                "./dataSample/ReadChannel_SlaveInterface/InOutPart.v");
    }
    else if(SlaveMaster == 1)
    {
        strcpy(Name, VAL_SLAVE->name);
        strcpy(fileName, 
                "./dataSample/ReadChannel_MasterInterface/InOutPart.v");
    }
    else if(SlaveMaster == 10)
    {
        sprintf(Name, "%s_RS", VAL_MASTER->name);
        strcpy(fileName, 
                "./dataSample/ReadChannel_SlaveInterface/InOutPart.v");

        IDEnable        = VAL_MASTER->ReadChPort.IDEnable;
        LockEnable      = VAL_MASTER->ReadChPort.LockEnable;
        CacheEnable     = VAL_MASTER->ReadChPort.CacheEnable;
        ProtectEnable   = VAL_MASTER->ReadChPort.ProtectEnable;

    }
    else if(SlaveMaster == 11)
    {
        sprintf(Name, "%s_RS", VAL_SLAVE->name);
        strcpy(fileName, 
                "./dataSample/ReadChannel_MasterInterface/InOutPart.v");

        LockEnable      = VAL_SLAVE->ReadChPort.LockEnable;
        CacheEnable     = VAL_SLAVE->ReadChPort.CacheEnable;
        ProtectEnable   = VAL_SLAVE->ReadChPort.ProtectEnable;
    }


    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }
    //__________________________________________________________ InOutPort

    //inout definition
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", Name);

        if(SlaveMaster == 0 || SlaveMaster == 1)
        {
            if(strcmp(buff,INOUT_STATE00_START)==0) break;
        }
        else if(SlaveMaster == 10) 
        {   // port configuration enable disable
            // 2006-8-17-Port disable
            if(strcmp(buff,"//ENABLE_ID\n")==0) break;
        }
        else if(SlaveMaster == 11)
            if(strcmp(buff,"//ENABLE_LOCK\n")==0) break;

        inDataLink(head_ptr, buff);
    }

    // 2006-8-17-Port disable -----------------> Start
    if(SlaveMaster == 10 || SlaveMaster == 11)
    {

        //Enable ID WIDTH
        if(strcmp(buff, "//ENABLE_ID\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(IDEnable == ENABLE)
                inDataLink(head_ptr, buff);

            while(1)
            {
                fgets(buff, (sizeof(char)*120), Fp);
                if(strcmp(buff,"//ENABLE_LOCK\n")==0) break;
                inDataLink(head_ptr,buff);
            }
        }

        //Lockport generation
        if(strcmp(buff,"//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(CacheEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //Read Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            if(IDEnable == ENABLE)
            {
                fgets(buff, (sizeof(char)*120), Fp);
                inDataLink(head_ptr, buff);
            }
            else
                fgets(buff, (sizeof(char)*120), Fp);
        }

        mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);
    }
    // 2006-8-17-Port disable -----------------> End


    //INOUT_STATE00 START process  
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, (SlaveMaster+100));
    mkBeforeStr(Fp, head_ptr, INOUT_STATE00_START);
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, (SlaveMaster+100));
    mkBeforeStr(Fp, head_ptr, DEF_STATE);

    //__________________________________________________________ Def
    for(i=0; MAX_PARAMETER > i; i++)
    {
        int temp;
        temp = sprintf(buff, "%s %s;\n", PARA[i][0], PARA[i][1]);
        if(temp == -1)
        {
            printf("Error sprintf process :: Buffer remove ");
            free(buff);
            free(fileName);
            return FILE_PROCESS_ERROR;
        }
        inDataLink(head_ptr, buff);
    }

    // 2006-8-17-Port disable
    if(SlaveMaster == 10 || SlaveMaster == 11)
    {

        if(SlaveMaster == 10)
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
        else
            mkBeforeStr(Fp, head_ptr, "//ENABLE_LOCK\n");


        if(SlaveMaster == 10) //Enable ID
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable == ENABLE)
                inDataLink(head_ptr, buff);
            else
            {
                sprintf(buff, "    wire   [MASTERID_WID-1:0] ARIDm2si = 1'b0;\n");
                inDataLink(head_ptr, buff);
            }
            fgets(buff, (sizeof(char)*120), Fp);
        }
        else //Enable lock prot
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }


        //Lockport generation
        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(LockEnable == ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);

            if(CacheEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable== ENABLE)
                inDataLink(head_ptr, buff);

            fgets(buff, (sizeof(char)*120), Fp);
        }

        //Read Channel Master port
        if(SlaveMaster == 10)
        {
            //Enable ID WIDTH
            mkBeforeStr(Fp, head_ptr, "//ENABLE_ID\n");
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable == ENABLE)
                inDataLink(head_ptr, buff);
            else
            {
                sprintf(buff,"     wire    [MASTERID_WID-1:0] RIDsi2m;\n");
                inDataLink(head_ptr, buff);
            }

            //fgets(buff, (sizeof(char)*120), Fp);

        }
        mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);
    }
    else
        mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);

    //INOUT_STATE01 START process
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster+100);
    mkBeforeStr(Fp, head_ptr, INOUT_STATE01_START);
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, SlaveMaster+100);
    mkBeforeStr(Fp, head_ptr, INOUT_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(fileName);
        return FILE_PROCESS_ERROR;
    }

    free(buff);
    free(fileName);
    return BUS_ERROR_NONE;
}

//  ----------------------------------------------------------------
//  Read channel
//
//  unsigned int genReadCh(char *OutFileName)
//  ----------------------------------------------------------------

unsigned int genReadCh(char *OutFileName)
{
    FILE *Fp;
    char *fileName = "./dataSample/ReadChannel/CodePart.v";
    struct codeLine *head_ptr = NULL;
    int    endSlaveNum, endMasterNum;
    int    *MaxZero;

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    endSlaveNum  = (int)ValMAIN.SlaveNumber;
    endMasterNum = (int)ValMAIN.MasterNumber;
    MaxZero      = (int *)malloc(sizeof(int) * endMasterNum);

    //__________________________________________________ InOutput/def
    mkReadTOPInOutPort(head_ptr, MaxZero);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process 0
    mkBuffChangeWire(Fp, head_ptr, 
                    endMasterNum, endSlaveNum+1, STATE_END, 1+100);
    mkBeforeStr(Fp, head_ptr, STATE00_START);
    //STATE00_START process 1
    mkBuffChangeENSI(Fp, head_ptr, endMasterNum, STATE_END, NULL, 1);//Read
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    //mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBuffChangeWire(Fp, head_ptr, endSlaveNum+1, endMasterNum, STATE_END, 100);
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02_START process
    mkBuffChange(Fp, head_ptr, endSlaveNum+1, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process
    mkChannelLink(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04_START process
    mkChannelLink(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    mkChannelLink(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process
    mkChannelLinkMi2Si(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE09_START);

    //STATE09_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, STATE10_START);

    //STATE10_START process
    mkChannelLinkSi2Mi(Fp, head_ptr, 1);
    mkBeforeStr(Fp, head_ptr, MASTER_MODULE_GEN);

    //MASTER_MODULE_GEN process
    mkModule(head_ptr, 11); // make ReadChannel master module
    mkBeforeStr(Fp, head_ptr, SLAVE_MODULE_GEN);


    //SLAVE_MODULE_GEN process
    mkModule(head_ptr, 10); // make ReadChannel slave module
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        return FILE_PROCESS_ERROR;
    }
    printLink(head_ptr);
    fprintLink(head_ptr, (char *)HeaderReadChannel,  OutFileName);

    return BUS_ERROR_NONE;
}


//  ----------------------------------------------------------------
//  Read channel Master interface(Slave port)
//
//  unsigned int genReadChMi(char *OutFileName,
//                         DefMaster *VAL_MASTER, DefSlave *VAL_SLAVE)
//  ----------------------------------------------------------------

unsigned int genReadChMi(char *OutFileName,
                         DefMaster *VAL_MASTER, DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/ReadChannel_MasterInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;
    int masterPriority[MAXMASTER];

    char selMasterWid[5];
    char selMasterWidadd1[5];

    //2006-9-8-ID-WIDTH-FIXED
    ///////////////////////////////////////////////////////////
    sprintf(selMasterWid, "%d", VAL_SLAVE->SelReadWid);
    sprintf(selMasterWidadd1, "%d", VAL_SLAVE->SelReadWid+1);
    ///////////////////////////////////////////////////////////

    endi = (int)ValMAIN.MasterNumber;
    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START\n");

    int *ConnectMaster;
    int ConnectCNT = 0;

    ConnectMaster = (int *)malloc(sizeof(int) * MAXSLAVE);
    /*
     * ConnectMaster[??] = 1 --> connect
     * ConnectMaster[??] = 0 --> non-connect
     * ConnectMaster[??] = 2 --> end
     */

    ConnectCNT = getConnectMaster(VAL_SLAVE, ConnectMaster, 1);

////////////////////////////////////////////////////////////////////////////
//Priority Setting /////////////////////////////////////////////////////////
////////////////////////////////////////////////////////////////////////////

    //Priority value////////
    int liveMaster ;
    int liveMasterCnt;
    j = 0;
    liveMasterCnt = 0;
    int tempMasterPriority[MAXMASTER];
    ///////////////////////

    for(i=0; (int)ValMAIN.MasterNumber>i; i++)
        if(ConnectMaster[i] == 1)
        {
            tempMasterPriority[j++] = i; // insert master number
        }

    endj = j;

    for(i=0; (int)ValMAIN.MasterNumber>i; i++)
    {
        for(j=0; endj>j; j++)
        {

            if(strcmp(VAL_SLAVE->OperateArbiter.PriorityMaster[i],
               ValMASTER[tempMasterPriority[j]].name)==0) 
            {
                masterPriority[liveMasterCnt++] = tempMasterPriority[j];
            }
        }
    }

    //setting error display function
    if(liveMasterCnt != endj)
    {
        printf("ERROR:: priority setting are not sufficient in %s\n", 
                VAL_SLAVE->name);
        printf("or have invalide setting name"); 
        return  BUS_ERROR_INVALID_PARA;
    }

    for(j=0; endj>j; j++)
    {
        for(i=0; endj>i; i++)
        {
            if(tempMasterPriority[i] == masterPriority[j] )
            {
                masterPriority[j] = i;
            }
        }
    }

////////////////////////////////////////////////////////////////////////////


    //__________________________________________________ InOutput/def
    mkReadInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 1);
    
    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    
    mkBeforeStr(Fp, head_ptr, ARBITER_GEN_START);
    /*
    mkBeforeStr(Fp, head_ptr, STATE00_START);
    mkBuffChange(Fp, head_ptr, ConnectCNT, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr,  ARBITER_GEN_START);
    */

    //ARBITER_GEN_START process
    //printf("selMasterWid->%s\n", selMasterWid);
    //mkArbiter(Fp, head_ptr, ConnectCNT,VAL_MASTER, (char *)selMasterWid, NULL, NULL);
    mkArbiter(Fp, head_ptr, ConnectCNT,VAL_MASTER, 
              (char *)selMasterWid, NULL, masterPriority,
              VAL_SLAVE->OperateArbiter.method);
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, "//STATE_END\n",  "?WID?", 
                      (char *)selMasterWid, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GEN_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE02_START);


    //STATE02_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03_START process 1
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04_START process
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process 2
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE06_START);

    //STATE06_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE07_START);


    //STATE07_START process 3
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE09_START);


    //STATE09_START process 4
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE10_START);

    //STATE10_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE11_START);

    //STATE11_START process 5
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE12_START);

    //STATE12_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE13_START);


    //STATE13_START process 6
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE14_START);

    //STATE14_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE15_START);

    //STATE15_START process 7
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE16_START);

    //STATE16_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE17_START);


    //STATE17_START process 8
    mkBuffChange(Fp, head_ptr, ConnectCNT, NULL, NULL);
    mkBeforeStr(Fp, head_ptr, STATE18_START);

    //STATE18_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, STATE19_START);

    //STATE19_START process 
    mkBuffChange(Fp, head_ptr, ConnectCNT, STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE20_START);
    
    //STATE20_START process 
    mkBuffChangeSt2St(Fp, head_ptr, ConnectCNT, NULL,  "?WID?", 
                      (char *)selMasterWidadd1, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, NULL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);

    //MUX_GET_START process
    //mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, ConnectMaster);
    mkMUX(Fp, head_ptr, ConnectCNT, selMasterWid, NULL);
    //mkBeforeStr(Fp, head_ptr, "//Code_END\n");

    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);
        inDataLink(head_ptr, buff);
        if(strcmp(buff,Code_END)==0) 
            break;
    }

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, (char *)HeaderReadChannelMI, OutFileName);
    free(buff);

    return BUS_ERROR_NONE;
}

//  ----------------------------------------------------------------
//  Read channel Slave interface(Master port)
//
//  unsigned int genReadChSi(char *OutFileName, 
//                         DefMaster *VAL_MASTER, DefSlave *VAL_SLAVE)
//  ----------------------------------------------------------------

unsigned int genReadChSi(char *OutFileName, 
                         DefMaster *VAL_MASTER, DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/ReadChannel_SlaveInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;
    char slaveWid[4];

    sprintf(slaveWid, "%d", (int)DefBit(ValMAIN.SlaveNumber + 1));
    endi = (int)ValMAIN.SlaveNumber;
    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    int *ConnectSlave;

    ConnectSlave = (int *)malloc(sizeof(int) * MAXSLAVE);
    /*
     * ConnectSlave[??] = 1 --> connect
     * ConnectSlave[??] = 0 --> non-connect
     * ConnectSlave[??] = 2 --> end
     */
    for(i=0;endi>i;i++)
        ConnectSlave[i] = (int)0;

    getConnectSlave(VAL_MASTER, ConnectSlave);

    //__________________________________________________ InOutput/def
    mkReadInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 0);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        free(ConnectSlave);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code
    

    mkBeforeStr(Fp, head_ptr, STATE00_START);
    mkBuffChange(Fp, head_ptr, endi+1, STATE_END, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  MUX_GEN_START);

    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00_START process
    mkBuffChangeSt2St(Fp, head_ptr, (endi+1), NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, ADDRDECODER_GEN_START);

    //get the address name
    fgets(buff, sizeof(char)*100, Fp);
    rmNewLine(buff);

    //ADDRDECODER_GEN_START process
    mkAddrDecoder(buff, head_ptr, endi, slaveWid, VAL_MASTER, VAL_SLAVE); 
                  //buff --> address name
    mkBeforeStr(Fp, head_ptr, ARBITER_GEN_START);

    //ARBITER_GEN_START process
    mkArbiter(Fp, head_ptr, endi,VAL_MASTER, (char *)slaveWid,ConnectSlave, NULL, NORMAL);
    mkBeforeStr(Fp, head_ptr, MUX_GEN_START);


    //MUX_GET_START process
    mkMUX(Fp, head_ptr, endi, slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01_START process
    mkBuffChange(Fp, head_ptr, endi+1, NULL, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  STATE02_START);

    //STATE02_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE03_START);


    //STATE03_START process
    mkBuffChange(Fp, head_ptr, endi+1, NULL, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  STATE04_START);

    //STATE04_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05_START process
    mkBuffChange(Fp, head_ptr, endi+1, NULL, ConnectSlave);
    mkBeforeStr(Fp, head_ptr,  STATE06_START);

    //STATE06_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE07_START);

    //STATE07_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    mkBeforeStr(Fp, head_ptr, STATE08_START);

    //STATE08_START process
    mkBuffChangeSt2St(Fp, head_ptr, endi+1, NULL,  "?WID?", 
                      (char *)slaveWid, ConnectSlave);
    while(1)
    {
        fgets(buff, (sizeof(char)*80), Fp);
        changeStr(buff,buff, "?NAME?", VAL_MASTER->name);
        inDataLink(head_ptr, buff);
        if(strcmp(buff,Code_END)==0) 
            break;
    }

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(ConnectSlave);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, (char *)HeaderReadChannelSI,  OutFileName);

    free(buff);
    free(ConnectSlave);

    return BUS_ERROR_NONE;
}



//  ----------------------------------------------------------------
//  Read channel register slice block (Slave interface)
//  ----------------------------------------------------------------
unsigned int genReadRsSi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{
    FILE *Fp;
    char *fileName = "./dataSample/RegisterSlice/ReadChannel_SlaveInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j,k;

    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable, IDEnable;

    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    IDEnable        = VAL_MASTER->ReadChPort.IDEnable;
    LockEnable      = VAL_MASTER->ReadChPort.LockEnable;
    CacheEnable     = VAL_MASTER->ReadChPort.CacheEnable;
    ProtectEnable   = VAL_MASTER->ReadChPort.ProtectEnable;

    //__________________________________________________ InOutput/def
    mkReadInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 10);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    /*
    unsigned int modeMtoSi;  // 0 = disable / 1=Full / 2=Forward
    unsigned int RegisterSliceMtoSi;
    unsigned int modeSitoMi;
    unsigned int RegisterSliceSitoMi;
    */

    //STATE00 ---> generation wire 
    /////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    if(VAL_MASTER->modeMtoSi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_MASTER->RegisterSliceMtoSi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_MASTER->RegisterSliceMtoSi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 ---> generation module
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, VAL_MASTER, NULL, 1);
    mkBeforeStr(Fp, head_ptr, STATE02_START);


    //STATE02 ---> generation wire
    /////////////////////////////////////////////////////////////
    mkRsWire(Fp, head_ptr, VAL_MASTER, NULL, 11);
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 ---> generation wire 
    /////////////////////////////////////////////////////////////
    if(VAL_MASTER->modeSitoMi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_MASTER->RegisterSliceSitoMi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_MASTER->RegisterSliceSitoMi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, VAL_MASTER, NULL, 11);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05 ---> generation module 
    /////////////////////////////////////////////////////////////
    while(1)
    {
        char ReqNum[4];
        char ReqNum1[4];

        fgets(buff, (sizeof(char)*120), Fp);
        if(strcmp(buff,STATE_END)==0) 
            break;
        changeStr(buff,buff, "?NAME?", VAL_MASTER->name);


        sprintf(ReqNum, "w%d",VAL_MASTER->RegisterSliceMtoSi-1); 
        sprintf(ReqNum1, "w%d",VAL_MASTER->RegisterSliceSitoMi-1); 


        // 2006-8-17-Port disable
        //Lockport generation

        if(strcmp(buff, "//ENABLE_ID\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(IDEnable != ENABLE)
                strcpy(buff, "    .ARIDm2si    (1'b0),\n");
        }

        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff, "    .ARLOCKm2si  ({ARLOCK_WID{1'b0}}),\n");
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff, "    .ARCACHEm2si ({ARCACHE_WID{1'b0}}),\n");
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff, "    .ARPROTm2si  ({ARPROT_WID{1'b0}}),\n");
        }

        if(VAL_MASTER->modeMtoSi == 0)//none resgister slice
            changeStr(buff,buff, "?0?", " ");
        else if(VAL_MASTER->RegisterSliceMtoSi == 0) 
            changeStr(buff,buff, "?0?", " ");
        else
            changeStr(buff,buff, "?0?", ReqNum);
        
        if(VAL_MASTER->modeSitoMi == 0)//none resgister slice
            changeStr(buff,buff, "?1?", " ");
        else if(VAL_MASTER->RegisterSliceSitoMi == 0) 
            changeStr(buff,buff, "?1?", " ");
        else
            changeStr(buff,buff, "?1?", ReqNum1);

        inDataLink(head_ptr, buff);
    }
    fgets(buff, (sizeof(char)*120), Fp);

    //STATE06 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, 10+100);
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        //free(ConnectSlave);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, (char *)HeaderReadChannelMI,  OutFileName);

    free(buff);

    return BUS_ERROR_NONE;
}// end of genReadRsSi



//  ----------------------------------------------------------------
//  Read channel register slice block (Master interface)
//  ----------------------------------------------------------------
unsigned int genReadRsMi(char *OutFileName, DefMaster *VAL_MASTER ,
                    DefSlave *VAL_SLAVE)
{

    FILE *Fp;
    char *fileName = "./dataSample/RegisterSlice/ReadChannel_MasterInterface/CodePart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j,k;

    int LockEnable, CacheEnable, ProtectEnable, WstrbEnable;

    buff = (char *)malloc(sizeof(char) *100);
    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);
    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    LockEnable      = VAL_SLAVE->ReadChPort.LockEnable;
    CacheEnable     = VAL_SLAVE->ReadChPort.CacheEnable;
    ProtectEnable   = VAL_SLAVE->ReadChPort.ProtectEnable;

    int *ConnectMaster;
    int ConnectCnt;
    ConnectMaster = (int *)malloc(sizeof(int) * MAXMASTER);
    ConnectCnt = getConnectMaster(VAL_SLAVE, ConnectMaster, 1);


    //__________________________________________________ InOutput/def
    mkReadInOutPort(VAL_MASTER, VAL_SLAVE, head_ptr, 11);

    //__________________________________________________________ Open
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        free(ConnectMaster);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }
    //STATE00 ---> generation wire 
    /////////////////////////////////////////////////////////////
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    if(VAL_SLAVE->modeStoMi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_SLAVE->RegisterSliceStoMi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_SLAVE->RegisterSliceStoMi, 
                STATE_END, NULL);
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 ---> generation module
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, NULL, VAL_SLAVE, 1); //toS interface
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 ---> generation wire
    /////////////////////////////////////////////////////////////
    mkRsWire(Fp, head_ptr, NULL, VAL_SLAVE, 11); //Mi2Si interface
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 ---> generation wire 
    /////////////////////////////////////////////////////////////
    if(VAL_SLAVE->modeMitoSi == 0)      //none resgister slice
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else if(VAL_SLAVE->RegisterSliceMitoSi == 0) 
        mkBuffChange(Fp, head_ptr, 0, STATE_END, NULL);
    else
        mkBuffChange(Fp, head_ptr, VAL_SLAVE->RegisterSliceMitoSi, 
                STATE_END, NULL);

    mkBeforeStr(Fp, head_ptr, STATE04_START);

    //STATE04 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkRsModule(Fp, head_ptr, NULL, VAL_SLAVE, 11);
    mkBeforeStr(Fp, head_ptr, STATE05_START);

    //STATE05 ---> generation module 
    /////////////////////////////////////////////////////////////
    while(1)
    {
        char ReqNum[4];
        char ReqNum1[4];

        fgets(buff, (sizeof(char)*120), Fp);
        if(strcmp(buff,STATE_END)==0) 
            break;
        changeStr(buff,buff, "?NAME?", VAL_SLAVE->name);


        sprintf(ReqNum, "w%d",VAL_SLAVE->RegisterSliceStoMi-1); 
        sprintf(ReqNum1, "w%d",VAL_SLAVE->RegisterSliceMitoSi-1); 


        // 2006-8-22-Port disable
        //Lockport generation
        if(strcmp(buff, "//ENABLE_LOCK\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(LockEnable != ENABLE)
                strcpy(buff, "    .ARLOCKmi2s  (), //Disable_LOCK_port\n");
        }

        //CACHE port generation
        if(strcmp(buff, "//ENABLE_CACHE\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(CacheEnable != ENABLE)
                strcpy(buff, "    .ARCACHEmi2s (), //Disable_cache_port\n");
        }

        //PROT port generation
        if(strcmp(buff,"//ENABLE_PROT\n") == 0)
        {
            fgets(buff, (sizeof(char)*120), Fp);
            if(ProtectEnable != ENABLE)
                strcpy(buff, "    .ARPROTmi2s  (), //Disable_protect_port\n");
        }


        if(VAL_SLAVE->modeStoMi == 0)//none resgister slice
            changeStr(buff,buff, "?0?", " ");
        else if(VAL_SLAVE->RegisterSliceStoMi == 0) 
            changeStr(buff,buff, "?0?", " ");
        else
            changeStr(buff,buff, "?0?", ReqNum);

        if(VAL_SLAVE->modeMitoSi == 0)//none resgister slice
            changeStr(buff,buff, "?1?", " ");
        else if(VAL_SLAVE->RegisterSliceMitoSi == 0) 
            changeStr(buff,buff, "?1?", " ");
        else
            changeStr(buff,buff, "?1?", ReqNum1);

        
        inDataLink(head_ptr, buff);
    }
    fgets(buff, (sizeof(char)*120), Fp);

    //STATE06 ---> generation module 
    /////////////////////////////////////////////////////////////
    mkSlaveMasterChange(Fp, VAL_MASTER, VAL_SLAVE, head_ptr, 11+100);
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buff);
        free(ConnectMaster);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr,(char *)HeaderReadChannelSI,  OutFileName);

    free(buff);
    free(ConnectMaster);

    return BUS_ERROR_NONE;

}// the End of genReadRsMi

