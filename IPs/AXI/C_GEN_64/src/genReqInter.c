
// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from SiliconGear
// ALL RIGHTS RESERVED SiliconGear 
// -----------------------------------------------------------------
// Version and Release information: NetWorkBus Ver 0.2
// File Name           : genReqInter.c 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : Request interleving function block gen.
//                       in Write Ch. slave port block
//  ----------------------------------------------------------------


//  =================================================================
//    Include 
//  ----------------------------------------------------------------
#include <stdio.h>
#include <math.h>
#include <stdlib.h>
#include <string.h>
#include "Bus.h"
#include "genReqInter.h"
#include "MkFile.h"


//  =================================================================
//    Definistion  
//  ----------------------------------------------------------------

const char *HeaderReqInter = {" \
// =================================================================\n\
//  This confidential and proprietary software may be used only as\n\
//  authorised by a licensing agreement from SiliconGear           \n\
//  ALL RIGHTS RESERVED SiliconGear                                \n\
// -----------------------------------------------------------------\n\
// Version and Release information: NetWorkBus Ver 0.2              \n\
//                                  generated by NetWorkBus Gen 0.2 \n\
// \n\
// File Name           : ReqInterBuff.v \n\
// File Revision       : 0.1 \n\
//  ----------------------------------------------------------------\n\
//  Purpose            : Request and interrupt buffer \n\
//                       \n\
//  ----------------------------------------------------------------\n"};

//  =================================================================
//  Function declaration
//  ----------------------------------------------------------------

extern unsigned int mkSimpleInOutPort(char *fileName, 
                         struct codeLine *start_ptr, char *Name);

extern unsigned int mkBeforeStr(FILE *Fp, struct codeLine *start_ptr, char *In);

extern unsigned int mkBuffChange(FILE *Fp, struct codeLine *head_ptr, 
                          int endi, char *FINDSTR, 
                          int *Connect);

extern unsigned int mkBuffChangeSt2St(FILE *Fp, struct codeLine *head_ptr, 
                               int endi, char *FINDSTR,
                               char *st1, char *st2,
                               int *Connect);
extern void printLink(struct codeLine *);
extern unsigned int fprintLink(struct codeLine *, char *, char *);


//  ----------------------------------------------------------------
//  Request interleaving buffer block gen. function
//
//  unsigned int genReqInter(char *OutFileName, DefSlave *VAL_SLAVE)
//  ----------------------------------------------------------------

unsigned int genReqInter(char *OutFileName, DefSlave *VAL_SLAVE)
{

    FILE *Fp;
    char *fileName = "./dataSample/ReqInterBuff/InOutPart.v";
    char *buff;
    struct codeLine *head_ptr = NULL;
    int i,j;
    int endi, endj;

    buff = (char *)malloc(sizeof(char) *120);

    head_ptr = malloc(sizeof(struct codeLine));
    head_ptr->code = (char *)malloc(sizeof(char) * 120);


    head_ptr->next_ptr = NULL;
    strcpy(head_ptr->code,"//START");

    mkSimpleInOutPort(fileName, head_ptr, VAL_SLAVE->name);

    //__________________________________________________________ Open
    fileName = "./dataSample/ReqInterBuff/CodePart.v";
    if ( (Fp = fopen(fileName, "r" )) == NULL ) {
        free(buff);
        printf ("\nError opening file [%s]\n",fileName);
        return FILE_PROCESS_ERROR;
    }

    //__________________________________________________________ Code

    char WrIssuCAP[4];
    char *buffOut;

    endi = (int)pow(2.0,(double)VAL_SLAVE->WriteIssuingCap);
    sprintf(WrIssuCAP, "%d",VAL_SLAVE->WriteIssuingCap);
    fgets(buff, (sizeof(char)*100), Fp);
    buffOut = (char *)malloc(sizeof(char)*100);

    //inout definition
    mkBeforeStr(Fp, head_ptr, STATE00_START);

    //STATE00 START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE00 END process
    mkBeforeStr(Fp, head_ptr, STATE01_START);

    //STATE01 START process
    mkBuffChange(Fp, head_ptr, endi, NULL, NULL);

    //STATE01 END process
    mkBeforeStr(Fp, head_ptr, STATE02_START);

    //STATE02 START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, NULL, 
                      "RdPointWID", (char *)WrIssuCAP, NULL);

    //STATE02 END process
    mkBeforeStr(Fp, head_ptr, STATE03_START);

    //STATE03 START process
    mkBuffChangeSt2St(Fp, head_ptr, endi, STATE03_END, 
                      "RdPointWID", (char *)WrIssuCAP, NULL);
    
    //End process
    mkBeforeStr(Fp, head_ptr, Code_END);

    //__________________________________________________________ Close
    if(fclose(Fp) !=0){
        printf("Error Close file[%s] \n",fileName);
        free(buffOut);
        free(buff);
        return FILE_PROCESS_ERROR;
    }

    printLink(head_ptr);
    fprintLink(head_ptr, (char *)HeaderReqInter, OutFileName);

    free(buffOut);
    free(buff);
    return 0;
}// end genReqInter
