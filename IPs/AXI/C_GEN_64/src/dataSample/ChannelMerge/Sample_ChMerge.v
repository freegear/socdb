// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from RichenTech
// ALL RIGHTS RESERVED RichenTech 
// -----------------------------------------------------------------
// Version and Release information: NetWorkBus Ver 0.2
//                                  generated by NetWorkBus Gen 0.2 
// 
// File Name           : DDR_ChMerge.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : for sharing write channel address
//                       and read channel address                       
//  ----------------------------------------------------------------


`timescale 1ns/10ps

module DDR_ChMerge
(
		ACLK     , 
		ARESETn  , 

// =================================================================
//  Slave connection
// -----------------------------------------------------------------
		// Write Address Channel
        AWID    ,
        AWADDR  ,
        AWLEN   ,
        AWSIZE  ,
        AWBURST ,
        AWLOCK  ,
        AWCACHE ,
        AWPROT  ,
        AWVALID ,
        AWREADY ,

		// Write Data Channel
		WID      ,
		WDATA    ,
		WSTRB    ,
		WLAST    ,
		WVALID   ,
		WREADY   ,

		// Write Response Channel
		BID      ,
		BRESP    ,
		BVALID   ,
		BREADY   ,

		// Read Address Channel
        ARID     ,
        ARADDR   ,
        ARLEN    ,
        ARSIZE   ,
        ARBURST  ,
        ARLOCK   ,
        ARCACHE  ,
        ARPROT   ,
        ARVALID  ,
        ARREADY  ,


		// Read Data Channel
		RID      ,
		RDATA    ,
		RRESP    ,
		RLAST    ,
		RVALID   ,
		RREADY   ,

// =================================================================
//  Bus connection
// -----------------------------------------------------------------

		// Write Address Channel
		AWID2merge     ,
		AWADDR2merge   ,
		AWLEN2merge    ,
		AWSIZE2merge   ,
		AWBURST2merge  ,
        AWLOCK2merge   ,
        AWCACHE2merge  ,
        AWPROT2merge   ,
		AWVALID2merge  ,
		AWREADY2merge  ,

		// Write Data Channel
		WID2merge      ,
		WDATA2merge    ,
		WSTRB2merge    ,
		WLAST2merge    ,
		WVALID2merge   ,
		WREADY2merge   ,

		// Write Response Channel
		BID2merge      ,
		BRESP2merge    ,
		BVALID2merge   ,
		BREADY2merge   ,

		// Read Address Channel
		ARID2merge     ,
		ARADDR2merge   ,
		ARLEN2merge    ,
		ARSIZE2merge   ,
		ARBURST2merge  ,
        ARLOCK2merge   ,
        ARCACHE2merge  ,
        ARPROT2merge   ,
		ARVALID2merge  ,
		ARREADY2merge  ,

		// Read Data Channel
		RID2merge      ,
		RDATA2merge    ,
		RRESP2merge    ,
		RLAST2merge    ,
		RVALID2merge   ,
		RREADY2merge   
);

// =================================================================
//  Parameter
// -----------------------------------------------------------------

parameter BUS_WID = 64;
parameter ADDR_WID= 32;
parameter MASTERID_WID= 2;
parameter SLAVEID_WID= 5;
parameter AWLEN_WID= 4;
parameter AWSIZE_WID= 3;
parameter AWBURST_WID= 2;
parameter AWLOCK_WID= 2;
parameter AWCACHE_WID= 4;
parameter AWPROT_WID= 3;
parameter WSTRB_WID= 8;
parameter BRESP_WID= 2;
parameter RRESP_WID= 2;
parameter ARLEN_WID= 4;
parameter ARBURST_WID= 2;
parameter ARLOCK_WID= 2;
parameter ARCACHE_WID= 4;
parameter ARPROT_WID= 3;
parameter MASTER_WID= 4;
parameter SLAVE_WID= 3;
parameter SLAVE_NUM= 7;
parameter MASTER_NUM= 8;
parameter SELMASTER_WID= 3;
parameter Wr_REQDEPTH_WID= 4;
parameter Rd_REQDEPTH_WID= 4;
parameter WrPermit_SLAVECNTWID= 1;
parameter RdPermit_SLAVECNTWID= 1;
parameter ARSIZE_WID= 3;
parameter WRITECHID0_WID = 1 ;
parameter WRITECHID1_WID = 1 ;
parameter WRITECHID2_WID = 2 ;
parameter WRITECHID3_WID = 1 ;
parameter WRITECHID4_WID = 1 ;
parameter WRITECHID5_WID = 1 ;
parameter WRITECHID6_WID = 1 ;
parameter WRITECHID7_WID = 1 ;
parameter READCHID0_WID = 1 ;
parameter READCHID1_WID = 1 ;
parameter READCHID2_WID = 2 ;
parameter READCHID3_WID = 1 ;
parameter READCHID4_WID = 1 ;
parameter READCHID5_WID = 1 ;
parameter READCHID6_WID = 1 ;
parameter READCHID7_WID = 1 ;
parameter WR_SLAVEID0_WID = 4 ;
parameter WR_SLAVEID1_WID = 2 ;
parameter WR_SLAVEID2_WID = 2 ;
parameter WR_SLAVEID3_WID = 4 ;
parameter WR_SLAVEID4_WID = 4 ;
parameter WR_SLAVEID5_WID = 3 ;
parameter WR_SLAVEID6_WID = 4 ;
parameter RD_SLAVEID0_WID = 5 ;
parameter RD_SLAVEID1_WID = 2 ;
parameter RD_SLAVEID2_WID = 2 ;
parameter RD_SLAVEID3_WID = 5 ;
parameter RD_SLAVEID4_WID = 5 ;
parameter RD_SLAVEID5_WID = 3 ;
parameter RD_SLAVEID6_WID = 5 ;
parameter SELMASTER0_WID = 3 ;
parameter SELMASTER1_WID = 1 ;
parameter SELMASTER2_WID = 1 ;
parameter SELMASTER3_WID = 3 ;
parameter SELMASTER4_WID = 3 ;
parameter SELMASTER5_WID = 2 ;
parameter SELMASTER6_WID = 3 ;
parameter SELWRITE0_WID = 3 ;
parameter SELREAD0_WID = 3 ;
parameter SELWRITE1_WID = 1 ;
parameter SELREAD1_WID = 1 ;
parameter SELWRITE2_WID = 1 ;
parameter SELREAD2_WID = 1 ;
parameter SELWRITE3_WID = 3 ;
parameter SELREAD3_WID = 3 ;
parameter SELWRITE4_WID = 3 ;
parameter SELREAD4_WID = 3 ;
parameter SELWRITE5_WID = 2 ;
parameter SELREAD5_WID = 2 ;
parameter SELWRITE6_WID = 3 ;
parameter SELREAD6_WID = 3 ;
parameter SLAVE_WRITEID0_WID = 1 ;
parameter SLAVE_WRITEID1_WID = 1 ;
parameter SLAVE_WRITEID2_WID = 1 ;
parameter SLAVE_WRITEID3_WID = 1 ;
parameter SLAVE_WRITEID4_WID = 1 ;
parameter SLAVE_WRITEID5_WID = 1 ;
parameter SLAVE_WRITEID6_WID = 1 ;
parameter SLAVE_READID0_WID = 2 ;
parameter SLAVE_READID1_WID = 1 ;
parameter SLAVE_READID2_WID = 1 ;
parameter SLAVE_READID3_WID = 2 ;
parameter SLAVE_READID4_WID = 2 ;
parameter SLAVE_READID5_WID = 1 ;
parameter SLAVE_READID6_WID = 2 ;

parameter WID_WIDTH = WR_SLAVEID0_WID; 
parameter RID_WIDTH = RD_SLAVEID0_WID;
parameter MAXID_WID = (WID_WIDTH >= RID_WIDTH) ? WID_WIDTH : RID_WIDTH;
parameter NUM_BYTE  = BUS_WID/8;
parameter PRIORITY_WCH_RCHB = 1;

// =================================================================
//  input output definition
// -----------------------------------------------------------------
input  ACLK;
input  ARESETn;

// to slave
output [WID_WIDTH-1:0]  AWID;
output [ADDR_WID-1:0]   AWADDR;
output [AWLEN_WID-1:0]  AWLEN;
output [AWSIZE_WID-1:0] AWSIZE;
output [AWBURST_WID-1:0]AWBURST;
output [AWLOCK_WID-1:0] AWLOCK;
output [AWCACHE_WID-1:0]AWCACHE;
output [AWPROT_WID-1:0] AWPROT;
output                  AWVALID;
input                   AWREADY;

output [WID_WIDTH-1:0]  WID;
output [BUS_WID-1:0]    WDATA;
output [NUM_BYTE-1:0]   WSTRB;
output                  WLAST;
output                  WVALID;
input                   WREADY;


input  [WID_WIDTH-1:0]  BID;
input  [BRESP_WID-1:0]  BRESP;
input                   BVALID;
output                  BREADY;

output [RID_WIDTH-1:0]  ARID;
output [ADDR_WID-1:0]   ARADDR;
output [ARLEN_WID-1:0]  ARLEN;
output [ARSIZE_WID-1:0] ARSIZE;
output [ARBURST_WID-1:0]ARBURST;
output [ARLOCK_WID-1:0] ARLOCK;
output [ARCACHE_WID-1:0]ARCACHE;
output [ARPROT_WID-1:0] ARPROT;
output                  ARVALID;
input                   ARREADY;

input  [RID_WIDTH-1:0]  RID;
input  [BUS_WID-1:0]    RDATA;
input  [RRESP_WID-1:0]  RRESP;
input                   RLAST;
input                   RVALID;
output                  RREADY;

//from Bus
//Write address channel
input   [WID_WIDTH-1:0]    AWID2merge;    
input   [ADDR_WID-1:0]     AWADDR2merge;
input   [AWLEN_WID-1:0]    AWLEN2merge;
input   [AWSIZE_WID-1:0]   AWSIZE2merge;  
input   [AWBURST_WID-1:0]  AWBURST2merge; 
//ENABLE_LOCK
input   [AWLOCK_WID-1:0]   AWLOCK2merge;  
//ENABLE_CACHE
input   [AWCACHE_WID-1:0]  AWCACHE2merge; 
//ENABLE_PROT
input   [AWPROT_WID-1:0]   AWPROT2merge;  
input   AWVALID2merge; 
output  AWREADY2merge; 
    
//Write data channel
input   [WID_WIDTH-1:0]    WID2merge;     
input   [BUS_WID-1:0]      WDATA2merge;   
//ENABLE_WSTRB
input   [WSTRB_WID-1:0]    WSTRB2merge;   
input   WLAST2merge;   
input   WVALID2merge;  
output  WREADY2merge; 

//Write response channel
output   [WID_WIDTH-1:0]   BID2merge;     
output   [BRESP_WID-1:0]   BRESP2merge;   
output   BVALID2merge;  
input    BREADY2merge;  


//Read address channel
input   [RID_WIDTH-1:0]    ARID2merge;    
input   [ADDR_WID-1:0]     ARADDR2merge;
input   [ARLEN_WID-1:0]    ARLEN2merge;
input   [ARSIZE_WID-1:0]   ARSIZE2merge;  
input   [ARBURST_WID-1:0]  ARBURST2merge; 
//ENABLE_LOCK
input   [ARLOCK_WID-1:0]   ARLOCK2merge;  
//ENABLE_CACHE
input   [ARCACHE_WID-1:0] ARCACHE2merge; 
//ENABLE_PROT
input   [ARPROT_WID-1:0]  ARPROT2merge;  
input   ARVALID2merge; 
output  ARREADY2merge; 
    
//Read data channel
output   [RID_WIDTH-1:0]   RID2merge;     
output   [RRESP_WID-1:0]   RRESP2merge;   
output   [BUS_WID-1:0]     RDATA2merge;
output   RLAST2merge;
output   RVALID2merge;  
input    RREADY2merge;  

// =================================================================
//  Wire & Register Define
// -----------------------------------------------------------------

reg [SELMASTER_WID-1:0] SelWID;
reg [SELMASTER_WID-1:0] SelRID;
reg [SELMASTER_WID-1:0] PriWID;
reg [SELMASTER_WID-1:0] PriRID;

reg HighPriority_WR_RDB; 
reg [2:0] CrState;
reg [2:0] NxState;

reg AWREADY2merge; 
reg ARREADY2merge; 
reg AWVALID;
reg ARVALID;

// ==============================================================================
//  Merge Channel State 
// ------------------------------------------------------------------------------

parameter IDLE = 0;
parameter WRR  = 1;
parameter RDR  = 2;
parameter CrStateIDLE = 3'd1;
parameter CrStateWRR  = 3'd2;
parameter CrStateRDR  = 3'd4;

always @(AWVALID2merge or ARVALID2merge or 
         AWVALID or AWREADY or
         ARVALID or ARREADY or
         CrState
        ) begin

    NxState = 0;
    case(1'b1) 
        CrState[IDLE]: 
            begin
                //Write channel priority is higher then Read channel priority
                if(ARVALID2merge & AWVALID2merge & HighPriority_WR_RDB)       
                    NxState[WRR] = 1'b1;
                //Read channel priority is higher then Write channel priority
                else if(ARVALID2merge & AWVALID2merge & !HighPriority_WR_RDB) 
                    NxState[RDR] = 1'b1;
                //Read Channel
                else if(ARVALID2merge & !AWVALID2merge) 
                    NxState[RDR]  = 1'b1;
                //Write Channel
                else if(!ARVALID2merge & AWVALID2merge) 
                    NxState[WRR]  = 1'b1;
                else 
                    NxState[IDLE] = 1'b1;
            end
        CrState[WRR]: 
            begin
                if(AWVALID & AWREADY)   NxState[IDLE] = 1'b1;
                else                    NxState[WRR]  = 1'b1;
            end
        CrState[RDR]: 
            begin
                if(ARVALID & ARREADY)   NxState[IDLE] = 1'b1;
                else                    NxState[RDR]  = 1'b1;
            end

    endcase

end

always @(posedge ACLK or negedge ARESETn) begin

    if(!ARESETn) begin
        CrState[IDLE] <= 1'b1;
        CrState[WRR]  <= 1'b0;
        CrState[RDR]  <= 1'b0;
    end
    else begin
        CrState <= NxState;
    end
end

// =================================================================
// Generation Selection ID & High priority define
// -----------------------------------------------------------------

always @(PriWID or PriRID) begin

    if(PriWID > PriRID)                             HighPriority_WR_RDB = 1'b0;
    else if(PriWID < PriRID)                        HighPriority_WR_RDB = 1'b1;
    else if(PriWID == PriRID & PRIORITY_WCH_RCHB )  HighPriority_WR_RDB = 1'b0;
    else if(PriWID == PriRID & !PRIORITY_WCH_RCHB ) HighPriority_WR_RDB = 1'b1;

end

always @(AWID2merge)  begin

    case(AWID2merge[SELMASTER_WID-1:0])

       3'd0: SelWID = 3'd0; 
       3'd1: SelWID = 3'd3; 
       3'd2: SelWID = 3'd4; 
       3'd3: SelWID = 3'd5; 
       3'd4: SelWID = 3'd6; 
       3'd5: SelWID = 3'd7; 
       3'd6: SelWID = 3'd4; //low prriority
       3'd7: SelWID = 3'd4; //low prriority
    endcase
end

always @(ARID2merge)  begin

    case(ARID2merge[SELMASTER_WID-1:0])

       3'd0: SelRID = 3'd0; 
       3'd1: SelRID = 3'd1; 
       3'd2: SelRID = 3'd2; 
       3'd3: SelRID = 3'd3; 
       3'd4: SelRID = 3'd4; 
       3'd5: SelRID = 3'd6; 
       3'd6: SelRID = 3'd7; 
       3'd7: SelRID = 3'd4; //low prriority
    endcase
end

always @(SelWID) begin
    case(SelWID) 
        3'd0: PriWID = 3'd5;
        3'd1: PriWID = 3'd6;
        3'd2: PriWID = 3'd0;
        3'd3: PriWID = 3'd2;
        3'd4: PriWID = 3'd7;
        3'd5: PriWID = 3'd1;
        3'd6: PriWID = 3'd3;
        3'd7: PriWID = 3'd4;
    endcase
end

always @(SelRID) begin
    case(SelRID) 
        3'd0: PriRID = 3'd5;
        3'd1: PriRID = 3'd6;
        3'd2: PriRID = 3'd0;
        3'd3: PriRID = 3'd2;
        3'd4: PriRID = 3'd7;
        3'd5: PriRID = 3'd1;
        3'd6: PriRID = 3'd3;
        3'd7: PriRID = 3'd4;
    endcase
end

// =================================================================
//  Output assign
// -----------------------------------------------------------------

assign WID     = WID2merge   ;
assign WDATA   = WDATA2merge ;
assign WSTRB   = WSTRB2merge ;
assign WLAST   = WLAST2merge ;
assign WVALID  = WVALID2merge;
assign WREADY2merge =  WREADY;

assign BID2merge    =  BID;
assign BRESP2merge  =  BRESP;
assign BVALID2merge =  BVALID;
assign BREADY       =  BREADY2merge;

assign RID2merge   = RID;
assign RDATA2merge = RDATA;
assign RRESP2merge = RRESP;
assign RLAST2merge = RLAST;
assign RVALID2merge= RVALID;
assign RREADY      = RREADY2merge;

assign AWID        =  AWID2merge   ;
assign AWADDR      =  AWADDR2merge ;
assign AWLEN       =  AWLEN2merge  ;
assign AWSIZE      =  AWSIZE2merge ;
assign AWBURST     =  AWBURST2merge;
assign AWLOCK      =  AWLOCK2merge ;
assign AWCACHE     =  AWCACHE2merge;
assign AWPROT      =  AWPROT2merge ;

assign ARID        =  ARID2merge   ;
assign ARADDR      =  ARADDR2merge ;
assign ARLEN       =  ARLEN2merge  ;
assign ARSIZE      =  ARSIZE2merge ;
assign ARBURST     =  ARBURST2merge;
assign ARLOCK      =  ARLOCK2merge ;
assign ARCACHE     =  ARCACHE2merge;
assign ARPROT      =  ARPROT2merge ;

// -----------------------------------------------------------------

always @(CrState or 
         AWVALID2merge or
         AWREADY or
         ARVALID2merge or
         ARREADY
         )
begin

    case(CrState)

        CrStateWRR: begin
                    AWVALID =  AWVALID2merge;
                    AWREADY2merge = AWREADY;
                    ARVALID = 1'b0;
                    ARREADY2merge = 1'b0;
              end
        CrStateRDR: begin
                    AWVALID = 1'b0;
                    AWREADY2merge = 1'b0;
                    ARVALID = ARVALID2merge;
                    ARREADY2merge = ARREADY;
              end

        default: begin
                    AWVALID = 1'b0;
                    AWREADY2merge = 1'b0;
                    ARVALID = 1'b0;
                    ARREADY2merge = 1'b0;
              end

    endcase

end

// -----------------------------------------------------------------

endmodule
