// =================================================================
// This confidential and proprietary software may be used only as
// authorised by a licensing agreement from RichenTech
// ALL RIGHTS RESERVED RichenTech 
// -----------------------------------------------------------------
// Version and Release information: NetWorkBus Ver 0.2
//                                  generated by NetWorkBus Gen 0.2 
// 
// File Name           : ?NAME?_ChMerge.v 
// File Revision       : 0.1 
//  ----------------------------------------------------------------
//  Purpose            : for sharing write channel address
//                       and read channel address                       
//  ----------------------------------------------------------------

`timescale 1ns/10ps

module ?NAME?_ChMerge
(
		ACLK     , 
		ARESETn  , 

// =================================================================
//  Slave connection
// -----------------------------------------------------------------
		// Write Address Channel
//ENABLE_AW_ID
        AWID    ,
        AWADDR  ,
        AWLEN   ,
        AWSIZE  ,
        AWBURST ,
//ENABLE_LOCK
        AWLOCK  ,
//ENABLE_CACHE
        AWCACHE ,
//ENABLE_PROT
        AWPROT  ,
        AWVALID ,
        AWREADY ,

		// Write Data Channel
//ENABLE_WID_ID
		WID      ,
		WDATA    ,
//ENABLE_WSTRB
		WSTRB    ,
		WLAST    ,
		WVALID   ,
		WREADY   ,

		// Write Response Channel
//ENABLE_BID_ID
		BID      ,
		BRESP    ,
		BVALID   ,
		BREADY   ,

		// Read Address Channel
//ENABLE_AR_ID
        ARID     ,
        ARADDR   ,
        ARLEN    ,
        ARSIZE   ,
        ARBURST  ,
//ENABLE_LOCK
        ARLOCK   ,
//ENABLE_CACHE
        ARCACHE  ,
//ENABLE_PROT
        ARPROT   ,
        ARVALID  ,
        ARREADY  ,

		// Read Data Channel
//ENABLE_RID_ID
		RID      ,
		RDATA    ,
		RRESP    ,
		RLAST    ,
		RVALID   ,
		RREADY   ,

// =================================================================
//  Bus connection
// -----------------------------------------------------------------

		// Write Address Channel
//ENABLE_AW_ID
		AWID2merge     ,
		AWADDR2merge   ,
		AWLEN2merge    ,
		AWSIZE2merge   ,
		AWBURST2merge  ,
//ENABLE_LOCK
        AWLOCK2merge   ,
//ENABLE_CACHE
        AWCACHE2merge  ,
//ENABLE_PROT
        AWPROT2merge   ,
		AWVALID2merge  ,
		AWREADY2merge  ,

		// Write Data Channel
//ENABLE_WID_ID
		WID2merge      ,
		WDATA2merge    ,
//ENABLE_WSTRB
		WSTRB2merge    ,
		WLAST2merge    ,
		WVALID2merge   ,
		WREADY2merge   ,

		// Write Response Channel
//ENABLE_BID_ID
		BID2merge      ,
		BRESP2merge    ,
		BVALID2merge   ,
		BREADY2merge   ,

		// Read Address Channel
//ENABLE_AR_ID
		ARID2merge     ,
		ARADDR2merge   ,
		ARLEN2merge    ,
		ARSIZE2merge   ,
		ARBURST2merge  ,
//ENABLE_LOCK
        ARLOCK2merge   ,
//ENABLE_CACHE
        ARCACHE2merge  ,
//ENABLE_PROT
        ARPROT2merge   ,
		ARVALID2merge  ,
		ARREADY2merge  ,

		// Read Data Channel
//ENABLE_RID_ID
		RID2merge      ,
		RDATA2merge    ,
		RRESP2merge    ,
		RLAST2merge    ,
		RVALID2merge   ,
		RREADY2merge   
);

// =================================================================
//  Parameter
// -----------------------------------------------------------------

//DEF_STATE

parameter MAXID_WID = (WID_WIDTH >= RID_WIDTH) ? WID_WIDTH : RID_WIDTH;
parameter NUM_BYTE  = BUS_WID/8;

// =================================================================
//  input output definition
// -----------------------------------------------------------------
input  ACLK;
input  ARESETn;

//ENABLE_AW_ID
output [WID_WIDTH-1:0]  AWID;
output [ADDR_WID-1:0]   AWADDR;
output [AWLEN_WID-1:0]  AWLEN;
output [AWSIZE_WID-1:0] AWSIZE;
output [AWBURST_WID-1:0]AWBURST;
//ENABLE_LOCK
output [AWLOCK_WID-1:0] AWLOCK;
//ENABLE_CACHE
output [AWCACHE_WID-1:0]AWCACHE;
//ENABLE_PROT
output [AWPROT_WID-1:0] AWPROT;
output                  AWVALID;
input                   AWREADY;

//ENABLE_WID_ID
output [WID_WIDTH-1:0]  WID;
output [BUS_WID-1:0]    WDATA;
//ENABLE_WSTRB
output [NUM_BYTE-1:0]   WSTRB;
output                  WLAST;
output                  WVALID;
input                   WREADY;


//ENABLE_BID_ID
input  [WID_WIDTH-1:0]  BID;
input  [BRESP_WID-1:0]  BRESP;
input                   BVALID;
output                  BREADY;

//ENABLE_AR_ID
output [RID_WIDTH-1:0]  ARID;
output [ADDR_WID-1:0]   ARADDR;
output [ARLEN_WID-1:0]  ARLEN;
output [ARSIZE_WID-1:0] ARSIZE;
output [ARBURST_WID-1:0]ARBURST;
//ENABLE_LOCK
output [ARLOCK_WID-1:0] ARLOCK;
//ENABLE_CACHE
output [ARCACHE_WID-1:0]ARCACHE;
//ENABLE_PROT
output [ARPROT_WID-1:0] ARPROT;
output                  ARVALID;
input                   ARREADY;

//ENABLE_RID_ID
input  [RID_WIDTH-1:0]  RID;
input  [BUS_WID-1:0]    RDATA;
input  [RRESP_WID-1:0]  RRESP;
input                   RLAST;
input                   RVALID;
output                  RREADY;

//from Bus
//Write address channel
//ENABLE_AW_ID
input   [WID_WIDTH-1:0]    AWID2merge;    
input   [ADDR_WID-1:0]     AWADDR2merge;
input   [AWLEN_WID-1:0]    AWLEN2merge;
input   [AWSIZE_WID-1:0]   AWSIZE2merge;  
input   [AWBURST_WID-1:0]  AWBURST2merge; 
//ENABLE_LOCK
input   [AWLOCK_WID-1:0]   AWLOCK2merge;  
//ENABLE_CACHE
input   [AWCACHE_WID-1:0]  AWCACHE2merge; 
//ENABLE_PROT
input   [AWPROT_WID-1:0]   AWPROT2merge;  
input   AWVALID2merge; 
output  AWREADY2merge; 
    
//Write data channel
//ENABLE_WID_ID
input   [WID_WIDTH-1:0]    WID2merge;     
input   [BUS_WID-1:0]      WDATA2merge;   
//ENABLE_WSTRB
input   [WSTRB_WID-1:0]    WSTRB2merge;   
input   WLAST2merge;   
input   WVALID2merge;  
output  WREADY2merge; 

//Write response channel
//ENABLE_BID_ID
output   [WID_WIDTH-1:0]   BID2merge;     
output   [BRESP_WID-1:0]   BRESP2merge;   
output   BVALID2merge;  
input    BREADY2merge;  


//Read address channel
//ENABLE_AR_ID
input   [RID_WIDTH-1:0]    ARID2merge;    
input   [ADDR_WID-1:0]     ARADDR2merge;
input   [ARLEN_WID-1:0]    ARLEN2merge;
input   [ARSIZE_WID-1:0]   ARSIZE2merge;  
input   [ARBURST_WID-1:0]  ARBURST2merge; 
//ENABLE_LOCK
input   [ARLOCK_WID-1:0]   ARLOCK2merge;  
//ENABLE_CACHE
input   [ARCACHE_WID-1:0] ARCACHE2merge; 
//ENABLE_PROT
input   [ARPROT_WID-1:0]  ARPROT2merge;  
input   ARVALID2merge; 
output  ARREADY2merge; 
    
//Read data channel
//ENABLE_RID_ID
output   [RID_WIDTH-1:0]   RID2merge;     
output   [RRESP_WID-1:0]   RRESP2merge;   
output   [BUS_WID-1:0]     RDATA2merge;
output   RLAST2merge;
output   RVALID2merge;  
input    RREADY2merge;  


//STATE00_START
// =================================================================
//  Disable Output assign
// -----------------------------------------------------------------

//ENABLE_AW_ID
assign AWID        =  AWID2merge   ;
assign AWADDR      =  AWADDR2merge ;
assign AWLEN       =  AWLEN2merge  ;
assign AWSIZE      =  AWSIZE2merge ;
assign AWBURST     =  AWBURST2merge;
//ENABLE_LOCK
assign AWLOCK      =  AWLOCK2merge ;
//ENABLE_CACHE
assign AWCACHE     =  AWCACHE2merge;
//ENABLE_PROT
assign AWPROT      =  AWPROT2merge ;

//ENABLE_WID_ID
assign WID     = WID2merge   ;
assign WDATA   = WDATA2merge ;
//ENABLE_WSTRB
assign WSTRB   = WSTRB2merge ;
assign WLAST   = WLAST2merge ;
assign WVALID  = WVALID2merge;
assign WREADY2merge =  WREADY;

//ENABLE_BID_ID
assign BID2merge    =  BID;
assign BRESP2merge  =  BRESP;
assign BVALID2merge =  BVALID;
assign BREADY       =  BREADY2merge;


//ENABLE_AR_ID
assign ARID        =  ARID2merge   ;
assign ARADDR      =  ARADDR2merge ;
assign ARLEN       =  ARLEN2merge  ;
assign ARSIZE      =  ARSIZE2merge ;
assign ARBURST     =  ARBURST2merge;
//ENABLE_LOCK
assign ARLOCK      =  ARLOCK2merge ;
//ENABLE_CACHE
assign ARCACHE     =  ARCACHE2merge;
//ENABLE_PROT
assign ARPROT      =  ARPROT2merge ;

//ENABLE_RID_ID
assign RID2merge   = RID;
assign RDATA2merge = RDATA;
assign RRESP2merge = RRESP;
assign RLAST2merge = RLAST;
assign RVALID2merge= RVALID;
assign RREADY      = RREADY2merge;


assign AWVALID =  AWVALID2merge;
assign AWREADY2merge = AWREADY;
assign ARVALID = ARVALID2merge;
assign ARREADY2merge = ARREADY;

// -----------------------------------------------------------------
// -----------------------------------------------------------------
endmodule
//STATE_END

//STATE01_START
// =================================================================
//  Wire & Register Define
// -----------------------------------------------------------------

reg [MASTER_NUM_WID-1:0] SelWID;
reg [MASTER_NUM_WID-1:0] SelRID;
reg [MASTER_NUM_WID-1:0] PriWID;
reg [MASTER_NUM_WID-1:0] PriRID;

reg HighPriority_WR_RDB; 
reg [2:0] CrState;
reg [2:0] NxState;

reg AWREADY2merge; 
reg ARREADY2merge; 
reg AWVALID;
reg ARVALID;

// ==============================================================================
//  Merge Channel State 
// ------------------------------------------------------------------------------

parameter IDLE = 0;
parameter WRR  = 1;
parameter RDR  = 2;
parameter CrStateIDLE = 3'd1;
parameter CrStateWRR  = 3'd2;
parameter CrStateRDR  = 3'd4;

always @(AWVALID2merge or ARVALID2merge or 
         AWVALID or AWREADY or
         ARVALID or ARREADY or
         CrState or 
         HighPriority_WR_RDB 
        ) begin

    NxState = 0;
    case(1'b1) 
        CrState[IDLE]: 
            begin
                //Write channel priority is higher then Read channel priority
                if(ARVALID2merge & AWVALID2merge & HighPriority_WR_RDB & !AWREADY)       
                    NxState[WRR] = 1'b1;
                //Read channel priority is higher then Write channel priority
                else if(ARVALID2merge & AWVALID2merge & !HighPriority_WR_RDB & !ARREADY) 
                    NxState[RDR] = 1'b1;
                //Read Channel
                else if(ARVALID2merge & !AWVALID2merge & !ARREADY) 
                    NxState[RDR]  = 1'b1;
                //Write Channel
                else if(!ARVALID2merge & AWVALID2merge & !AWREADY) 
                    NxState[WRR]  = 1'b1;
                else 
                    NxState[IDLE] = 1'b1;
            end
        CrState[WRR]: 
            begin
                if(AWVALID & AWREADY)   NxState[IDLE] = 1'b1;
                else                    NxState[WRR]  = 1'b1;
            end
        CrState[RDR]: 
            begin
                if(ARVALID & ARREADY)   NxState[IDLE] = 1'b1;
                else                    NxState[RDR]  = 1'b1;
            end

    endcase

end

always @(posedge ACLK or negedge ARESETn) begin

    if(!ARESETn) begin
        CrState[IDLE] <= 1'b1;
        CrState[WRR]  <= 1'b0;
        CrState[RDR]  <= 1'b0;
    end
    else begin
        CrState <= NxState;
    end
end

// =================================================================
// Generation Selection ID & High priority define
// -----------------------------------------------------------------

wire PRIORITY_WCH_RCHB = 1; //Read priority Ver2.3
always @(PriWID or PriRID or PRIORITY_WCH_RCHB) begin

    if(PriWID > PriRID)                             HighPriority_WR_RDB = 1'b0;
    else if(PriWID < PriRID)                        HighPriority_WR_RDB = 1'b1;
    else if(PriWID == PriRID & PRIORITY_WCH_RCHB )  HighPriority_WR_RDB = 1'b0;
    else if(PriWID == PriRID & !PRIORITY_WCH_RCHB ) HighPriority_WR_RDB = 1'b1;
    else                                            HighPriority_WR_RDB = 1'b0;

end

always @(AWID2merge)  begin

    case(AWID2merge[SELMASTER_WID-1:0]) // synopsys parallel_case full_case

//STATE02_START
       ?WID?'d?0?: SelWID = ?WID1?'d?1?; 

    endcase
end

always @(ARID2merge)  begin

    case(ARID2merge[SELMASTER_RID-1:0]) // synopsys parallel_case full_case  

//STATE03_START
       ?WID?'d?0?: SelRID = ?WID1?'d?1?; 

    endcase
end

always @(SelWID) begin
    case(SelWID) // synopsys parallel_case full_case

//STATE04_START
       ?WID1?'d?0?: PriWID = ?WID1?'d?1?; 
       default:     PriWID = ?WID1?'d?1?;

    endcase
end

always @(SelRID) begin
    case(SelRID) // synopsys parallel_case full_case

//STATE05_START
       ?WID1?'d?0?: PriRID = ?WID1?'d?1?; 
       default:    PriRID = ?WID1?'d?1?;

    endcase
end

// =================================================================
//  Enable Output assign
// -----------------------------------------------------------------

//ENABLE_AW_ID
assign AWID        =  AWID2merge   ;
assign AWADDR      =  AWADDR2merge ;
assign AWLEN       =  AWLEN2merge  ;
assign AWSIZE      =  AWSIZE2merge ;
assign AWBURST     =  AWBURST2merge;
//ENABLE_LOCK
assign AWLOCK      =  AWLOCK2merge ;
//ENABLE_CACHE
assign AWCACHE     =  AWCACHE2merge;
//ENABLE_PROT
assign AWPROT      =  AWPROT2merge ;

//ENABLE_WID_ID
assign WID     = WID2merge   ;
assign WDATA   = WDATA2merge ;
//ENABLE_WSTRB
assign WSTRB   = WSTRB2merge ;
assign WLAST   = WLAST2merge ;
assign WVALID  = WVALID2merge;
assign WREADY2merge =  WREADY;

//ENABLE_BID_ID
assign BID2merge    =  BID;
assign BRESP2merge  =  BRESP;
assign BVALID2merge =  BVALID;
assign BREADY       =  BREADY2merge;


//ENABLE_AR_ID
assign ARID        =  ARID2merge   ;
assign ARADDR      =  ARADDR2merge ;
assign ARLEN       =  ARLEN2merge  ;
assign ARSIZE      =  ARSIZE2merge ;
assign ARBURST     =  ARBURST2merge;
//ENABLE_LOCK
assign ARLOCK      =  ARLOCK2merge ;
//ENABLE_CACHE
assign ARCACHE     =  ARCACHE2merge;
//ENABLE_PROT
assign ARPROT      =  ARPROT2merge ;

//ENABLE_RID_ID
assign RID2merge   = RID;
assign RDATA2merge = RDATA;
assign RRESP2merge = RRESP;
assign RLAST2merge = RLAST;
assign RVALID2merge= RVALID;
assign RREADY      = RREADY2merge;

// -----------------------------------------------------------------

always @(CrState or 
         AWVALID2merge or
         AWREADY or
         ARVALID2merge or
         ARREADY or
         HighPriority_WR_RDB  
         )
begin

    case(CrState)// synopsys parallel_case full_case

        CrStateIDLE: begin
                    if(ARVALID2merge & AWVALID2merge & HighPriority_WR_RDB ) begin

                        AWVALID =  AWVALID2merge;
                        AWREADY2merge = AWREADY;
                        ARVALID = 1'b0;
                        ARREADY2merge = 1'b0;

                    end
                    else if(ARVALID2merge & AWVALID2merge & !HighPriority_WR_RDB) begin

                        AWVALID = 1'b0;
                        AWREADY2merge = 1'b0;
                        ARVALID = ARVALID2merge;
                        ARREADY2merge = ARREADY;

                    end
                    else if(!ARVALID2merge & AWVALID2merge) begin

                        AWVALID =  AWVALID2merge;
                        AWREADY2merge = AWREADY;
                        ARVALID = 1'b0;
                        ARREADY2merge = 1'b0;

                    end
                    else if(ARVALID2merge & !AWVALID2merge) begin

                        AWVALID = 1'b0;
                        AWREADY2merge = 1'b0;
                        ARVALID = ARVALID2merge;
                        ARREADY2merge = ARREADY;

                    end
                    else begin
                    AWVALID = 1'b0;
                    AWREADY2merge = 1'b0;
                    ARVALID = 1'b0;
                    ARREADY2merge = 1'b0;
                    end
              end

        CrStateWRR: begin
                    AWVALID =  AWVALID2merge;
                    AWREADY2merge = AWREADY;
                    ARVALID = 1'b0;
                    ARREADY2merge = 1'b0;
              end
        CrStateRDR: begin
                    AWVALID = 1'b0;
                    AWREADY2merge = 1'b0;
                    ARVALID = ARVALID2merge;
                    ARREADY2merge = ARREADY;
              end

        default: begin
                    AWVALID = 1'b0;
                    AWREADY2merge = 1'b0;
                    ARVALID = 1'b0;
                    ARREADY2merge = 1'b0;
              end

    endcase

end

// -----------------------------------------------------------------

endmodule
//Code_END
