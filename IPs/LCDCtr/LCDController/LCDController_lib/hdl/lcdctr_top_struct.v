//
// Module LCDController_lib.lcdctr_top.struct
//
// Created:
//          by - gundam.UNKNOWN (RND-D4E2566A1B1)
//          at - 16:49:42 2006-05-01
//
// Generated by Mentor Graphics' HDL Designer(TM) 2004.1 (Build 41)
//

`resetall
`timescale 1ns/10ps
module lcdctr_top( 
   mclk, 
   rstb, 
   HSync_LCDO, 
   VSync_LCDO, 
   bdoutLCDO, 
   de_LCDO, 
   gdout_LCDO, 
   pclk_LCDO, 
   rdout_LCDO
);


// Internal Declarations

input        mclk;
input        rstb;
output       HSync_LCDO;
output       VSync_LCDO;
output [7:0] bdoutLCDO;
output       de_LCDO;
output [7:0] gdout_LCDO;
output       pclk_LCDO;
output [7:0] rdout_LCDO;


wire        mclk;
wire        rstb;
wire        HSync_LCDO;
wire        VSync_LCDO;
wire [7:0]  bdoutLCDO;
wire        de_LCDO;
wire [7:0]  gdout_LCDO;
wire        pclk_LCDO;
wire [7:0]  rdout_LCDO;

// Local declarations

// Internal signal declarations
wire [7:0] bdata_mxr2lcd;
wire       dread_lcd2mxr;
wire       dvalidb_mxr2lcd;
wire [7:0] gdata_mxr2lcd;
wire [7:0] rdata_mxr2lcd;


// Instances 
lcd_ctr I0( 
   .bdata_mxr2lcd   (bdata_mxr2lcd), 
   .dvalidb_mxr2lcd (dvalidb_mxr2lcd), 
   .gdata_mxr2lcd   (gdata_mxr2lcd), 
   .mclk            (mclk), 
   .rdata_mxr2lcd   (rdata_mxr2lcd), 
   .rstb            (rstb), 
   .HSync_LCDO      (HSync_LCDO), 
   .VSync_LCDO      (VSync_LCDO), 
   .bdoutLCDO       (bdoutLCDO), 
   .de_LCDO         (de_LCDO), 
   .dread_lcd2mxr   (dread_lcd2mxr), 
   .gdout_LCDO      (gdout_LCDO), 
   .pclk_LCDO       (pclk_LCDO), 
   .rdout_LCDO      (rdout_LCDO)
); 


endmodule // lcdctr_top

