//
// Module LCDController_lib.lcd_ctr.struct
//
// Created:
//          by - gundam.UNKNOWN (RND-D4E2566A1B1)
//          at - 16:49:42 2006-05-01
//
// Generated by Mentor Graphics' HDL Designer(TM) 2004.1 (Build 41)
//

`resetall
`timescale 1ns/10ps
module lcd_ctr( 
   bdata_mxr2lcd, 
   dvalidb_mxr2lcd, 
   gdata_mxr2lcd, 
   mclk, 
   rdata_mxr2lcd, 
   rstb, 
   HSync_LCDO, 
   VSync_LCDO, 
   bdoutLCDO, 
   de_LCDO, 
   dread_lcd2mxr, 
   gdout_LCDO, 
   pclk_LCDO, 
   rdout_LCDO
);


// Internal Declarations

input  [7:0] bdata_mxr2lcd;
input        dvalidb_mxr2lcd;
input  [7:0] gdata_mxr2lcd;
input        mclk;
input  [7:0] rdata_mxr2lcd;
input        rstb;
output       HSync_LCDO;
output       VSync_LCDO;
output [7:0] bdoutLCDO;
output       de_LCDO;
output       dread_lcd2mxr;
output [7:0] gdout_LCDO;
output       pclk_LCDO;
output [7:0] rdout_LCDO;


wire [7:0]  bdata_mxr2lcd;
wire        dvalidb_mxr2lcd;
wire [7:0]  gdata_mxr2lcd;
wire        mclk;
wire [7:0]  rdata_mxr2lcd;
wire        rstb;
wire        HSync_LCDO;
wire        VSync_LCDO;
wire [7:0]  bdoutLCDO;
wire        de_LCDO;
wire        dread_lcd2mxr;
wire [7:0]  gdout_LCDO;
wire        pclk_LCDO;
wire [7:0]  rdout_LCDO;

// Local declarations

// Internal signal declarations
wire [7:0] bdata_mif2lif;
wire       dreadb_lif2mif;
wire [7:0] gdata_mif2lif;
wire       hsync_lif2mif;
wire [7:0] rdata_mif2lif;
wire       vsync_lif2mif;


// Instances 
lcd_if lcd_if_blk( 
   .bdata_mif2lif  (bdata_mif2lif), 
   .gdata_mif2lif  (gdata_mif2lif), 
   .mclk           (mclk), 
   .rdata_mif2lif  (rdata_mif2lif), 
   .rstb           (rstb), 
   .HSync_LCDO     (HSync_LCDO), 
   .VSync_LCDO     (VSync_LCDO), 
   .bdoutLCDO      (bdoutLCDO), 
   .de_LCDO        (de_LCDO), 
   .dreadb_lif2mif (dreadb_lif2mif), 
   .gdout_LCDO     (gdout_LCDO), 
   .hsync_lif2mif  (hsync_lif2mif), 
   .pclk_LCDO      (pclk_LCDO), 
   .rdout_LCDO     (rdout_LCDO), 
   .vsync_lif2mif  (vsync_lif2mif)
); 

mixer_if mix_if( 
   .bdata_mxr2lcd   (bdata_mxr2lcd), 
   .dreadb_lif2mif  (dreadb_lif2mif), 
   .dvalidb_mxr2lcd (dvalidb_mxr2lcd), 
   .gdata_mxr2lcd   (gdata_mxr2lcd), 
   .hsync_lif2mif   (hsync_lif2mif), 
   .mclk            (mclk), 
   .rdata_mxr2lcd   (rdata_mxr2lcd), 
   .rstb            (rstb), 
   .vsync_lif2mif   (vsync_lif2mif), 
   .bdata_mif2lif   (bdata_mif2lif), 
   .dread_lcd2mxr   (dread_lcd2mxr), 
   .gdata_mif2lif   (gdata_mif2lif), 
   .rdata_mif2lif   (rdata_mif2lif)
); 


endmodule // lcd_ctr

