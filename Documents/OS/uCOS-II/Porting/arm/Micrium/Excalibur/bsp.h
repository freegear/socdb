/*
*********************************************************************************************************
*                                               Philips LPC210x
*                                  LPC210x Kick Start Card Board Support Package
*
*                                    (c) Copyright 2004, Micrium, Weston, FL
*                                              All Rights Reserved
*
*
* File : BSP.C
* By   : Jean J. Labrosse
*********************************************************************************************************
*/

#include "stripe.h"

/*
*********************************************************************************************************
*                                            FUNCTION PROTOTYPES
*********************************************************************************************************
*/

void 
BSP_Init( void );

void
BSP_Init_Interrupts( void );

/*
*********************************************************************************************************
*                                             LED SERVICES
*********************************************************************************************************
*/


/*
*********************************************************************************************************
*                                             TICK SERVICES
*********************************************************************************************************
*/
