/******************************************************************************
	CQ RISC評価キット/SH-4 割り込み処理ベクタ初期化
******************************************************************************/

/*  割り込み処理初期化 */
void CPUInt_Init(int);

/* CPU割り込みマスク設定 */
/* 1で割り込み許可,0で割り込みマスク */
void CPUInt_Mask(int);
