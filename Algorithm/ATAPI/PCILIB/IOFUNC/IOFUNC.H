/*
	32ビット I/O アクセスライブラリ ヘッダファイル Ver.2.0
*/

unsigned long	_IoReadLong(unsigned int);
void		_IoWriteLong(unsigned int , unsigned long);
