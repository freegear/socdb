/********************************
	typedef ��`
*********************************/

#ifndef _TYPEDEF_
#define _TYPEDEF_

#ifdef IDE1
	/* x86�nCPU MS-DOS(16�r�b�g)�� */
	typedef unsigned long		UDWORD;
	typedef unsigned int		UWORD;
	typedef unsigned char		UBYTE;
#endif
#ifdef IDE2
	/* x86�nCPU MS-DOS(16�r�b�g)�� */
	typedef unsigned long		UDWORD;
	typedef unsigned int		UWORD;
	typedef unsigned char		UBYTE;
#endif
#ifdef PCI
	/* x86�nCPU MS-DOS(16�r�b�g)�� */
	typedef unsigned long		UDWORD;
	typedef unsigned int		UWORD;
	typedef unsigned char		UBYTE;
#endif

#endif
