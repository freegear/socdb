/**
 *  armACMP3_Tables.c
 * 
 * (c) Copyright 2005,2006 ARM Limited. All Rights Reserved.
 * 
 * THIS SOFTWARE IS PROVIDED “AS IS”, ARM EXPRESSLY DISCLAIMS ALL REPRESENTATIONS, 
 * WARRANTIES, CONDITIONS OR OTHER TERMS, EXPRESS, IMPLIED OR STATUTORY, INCLUDING 
 * WITHOUT LIMITATION THE IMPLIED WARRANTIES OF NON-INFRINGEMENT, MERCHANTABILITY, 
 * SATISFACTORY QUALITY, AND FITNESS FOR A PARTICULAR PURPOSE. 
 * 
 * Your use of this Software may require additional licenses, including but not 
 * limited to copyright and patent licenses from various entities. Should any 
 * such additional copyright, patent or other licenses be required, ARM expects 
 * that you will and you agree to obtain any such licenses at your own expense. 
 * You are solely responsible for obtaining any such licenses and the copyright 
 * licenses granted herein are conditioned on you obtaining such additional 
 * licenses.
 * 
 *
 * Brief: Defines Tables used for MP3 Codec
 *
 */

#include "omxtypes.h"
#include "armCOMM_Bitstream.h"
#include "armACMP3_Tables.h"

const OMX_S16 armACMP3_SFBTableLong [/* 23 * 6 */] = {
0,6,12,18,24,30,36,44,54,66,80,96,116,140,168,200,238,284,336,396,464,522,576,
0,6,12,18,24,30,36,44,54,66,80,96,114,136,162,194,232,278,330,394,464,540,576,
0,6,12,18,24,30,36,44,54,66,80,96,116,140,168,200,238,284,336,396,464,522,576,
0,4,8,12,16,20,24,30,36,44,52,62,74,90,110,134,162,196,238,288,342,418,576,
0,4,8,12,16,20,24,30,36,42,50,60,72,88,106,128,156,190,230,276,330,384,576,
0,4,8,12,16,20,24,30,36,44,54,66,82,102,126,156,194,240,296,364,448,550,576
};

const OMX_S16 armACMP3_SFBTableShort [/* 14 * 6 */] = {
0,4,8,12,18,24,32,42,56,74,100,132,174,192,
0,4,8,12,18,26,36,48,62,80,104,136,180,192,
0,4,8,12,18,26,36,48,62,80,104,134,174,192,
0,4,8,12,16,22,30,40,52,66,84,106,136,192,
0,4,8,12,16,22,28,38,50,64,80,100,126,192,
0,4,8,12,16,22,30,42,58,78,104,138,180,192
};

const OMX_S16 armACMP3_SFBTableMixed [/* 12 * 1 */] = {
6,2,6,2,6,2,8,0,8,0,8,0
};
 


    /* LinBits */
const OMX_INT armACMP3_LinBits [] = {
    0,0,0,0,0, 
    0,0,0,0,0, 
    0,0,0,0,0, 
    0,1,2,3,4, 
    6,8,10,13,4,
    5,6,7,8,9,
    11,13
};
    /* Pretab */
const OMX_U32     armACMP3_Pretab [22] =
        {0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,2,2,3,3,3,2,0};

    /* Huffman code and code lenth */
const ARM_VLC32 armACMP3_HuffTable1 [] = {
    {1, 0x1}, {3, 0x1}, {2, 0x1}, {3, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable2 [] = {
    {1, 0x1}, {3, 0x2}, {6, 0x1}, {3, 0x3}, {3, 0x1}, {5, 0x1}, {5, 0x3}, 
    {5, 0x2}, {6, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable3 [] = {
    {2, 0x3}, {2, 0x2}, {6, 0x1}, {3, 0x1}, {2, 0x1}, {5, 0x1}, {5, 0x3}, 
    {5, 0x2}, {6, 0x0}, {0, 0x0}
};

/* const ARM_VLC32 armACMP3_HuffTable4 */

const ARM_VLC32 armACMP3_HuffTable5 [] = {
    {1, 0x1}, {3, 0x2}, {6, 0x6}, {7, 0x5}, {3, 0x3}, {3, 0x1}, {6, 0x4}, 
    {7, 0x4}, {6, 0x7}, {6, 0x5}, {7, 0x7}, {8, 0x1}, {7, 0x6}, {6, 0x1}, 
    {7, 0x1}, {8, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable6 [] = {
    {3, 0x7}, {3, 0x3}, {5, 0x5}, {7, 0x1}, {3, 0x6}, {2, 0x2}, {4, 0x3}, 
    {5, 0x2}, {4, 0x5}, {4, 0x4}, {5, 0x4}, {6, 0x1}, {6, 0x3}, {5, 0x3},
    {6, 0x2}, {7, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable7 [] = {
    {1, 0x1}, {3, 0x2}, {6, 0xa}, {8, 0x13}, {8, 0x10}, {9, 0xa}, {3, 0x3}, 
    {4, 0x3}, {6, 0x7}, {7, 0xa}, {7, 0x5}, {8, 0x3}, {6, 0xb}, {5, 0x4}, 
    {7, 0xd}, {8, 0x11}, {8, 0x8}, {9, 0x4}, {7, 0xc}, {7, 0xb}, {8, 0x12}, 
    {9, 0xf}, {9, 0xb}, {9, 0x2}, {7, 0x7}, {7, 0x6}, {8, 0x9}, {9, 0xe}, 
    {9, 0x3}, {10, 0x1}, {8, 0x6}, {8, 0x4}, {9, 0x5}, {10, 0x3}, {10, 0x2},
    {10, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable8 [] = {
    {2, 0x3}, {3, 0x4}, {6, 0x6}, {8, 0x12}, {8, 0xc}, {9, 0x5}, {3, 0x5}, 
    {2, 0x1}, {4, 0x2}, {8, 0x10}, {8, 0x9}, {8, 0x3}, {6, 0x7}, {4, 0x3}, 
    {6, 0x5}, {8, 0xe}, {8, 0x7}, {9, 0x3}, {8, 0x13}, {8, 0x11}, {8, 0xf}, 
    {9, 0xd}, {9, 0xa}, {10, 0x4}, {8, 0xd}, {7, 0x5}, {8, 0x8}, {9, 0xb}, 
    {10, 0x5}, {10, 0x1}, {9, 0xc}, {8, 0x4}, {9, 0x4}, {9, 0x1}, {11, 0x1},
    {11, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable9 [] = {
    {3, 0x7}, {3, 0x5}, {5, 0x9}, {6, 0xe}, {8, 0xf}, {9, 0x7}, {3, 0x6}, 
    {3, 0x4}, {4, 0x5}, {5, 0x5}, {6, 0x6}, {8, 0x7}, {4, 0x7}, {4, 0x6}, 
    {5, 0x8}, {6, 0x8}, {7, 0x8}, {8, 0x5}, {6, 0xf}, {5, 0x6}, {6, 0x9}, 
    {7, 0xa}, {7, 0x5}, {8, 0x1}, {7, 0xb}, {6, 0x7}, {7, 0x9}, {7, 0x6}, 
    {8, 0x4}, {9, 0x1}, {8, 0xe}, {7, 0x4}, {8, 0x6}, {8, 0x2}, {9, 0x6}, 
    {9, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable10 [] = {
    {1, 0x1}, {3, 0x2}, {6, 0xa}, {8, 0x17}, {9, 0x23}, {9, 0x1e}, {9, 0xc},
    {10, 0x11}, {3, 0x3}, {4, 0x3}, {6, 0x8}, {7, 0xc}, {8, 0x12}, {9, 0x15}, 
    {8, 0xc}, {8, 0x7}, {6, 0xb}, {6, 0x9}, {7, 0xf}, {8, 0x15}, {9, 0x20}, 
    {10, 0x28}, {9, 0x13}, {9, 0x6}, {7, 0xe}, {7, 0xd}, {8, 0x16}, {9, 0x22},
    {10, 0x2e}, {10, 0x17}, {9, 0x12}, {10, 0x7}, {8, 0x14}, {8, 0x13}, 
    {9, 0x21}, {10, 0x2f}, {10, 0x1b}, {10, 0x16}, {10, 0x9}, {10, 0x3}, 
    {9, 0x1f}, {9, 0x16}, {10, 0x29}, {10, 0x1a}, {11, 0x15}, {11, 0x14}, 
    {10, 0x5}, {11, 0x3}, {8, 0xe}, {8, 0xd}, {9, 0xa}, {10, 0xb}, {10, 0x10}, 
    {10, 0x6}, {11, 0x5}, {11, 0x1}, {9, 0x9}, {8, 0x8}, {9, 0x7}, {10, 0x8}, 
    {10, 0x4}, {11, 0x4}, {11, 0x2}, {11, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable11 [] = {
    {2, 0x3}, {3, 0x4}, {5, 0xa}, {7, 0x18}, {8, 0x22}, {9, 0x21}, {8, 0x15},
    {9, 0xf}, {3, 0x5}, {3, 0x3}, {4, 0x4}, {6, 0xa}, {8, 0x20}, {8, 0x11}, 
    {7, 0xb}, {8, 0xa}, {5, 0xb}, {5, 0x7}, {6, 0xd}, {7, 0x12}, {8, 0x1e}, 
    {9, 0x1f}, {8, 0x14}, {8, 0x5}, {7, 0x19}, {6, 0xb}, {7, 0x13}, {9, 0x3b}, 
    {8, 0x1b}, {10, 0x12}, {8, 0xc}, {9, 0x5}, {8, 0x23}, {8, 0x21}, {8, 0x1f}, 
    {9, 0x3a}, {9, 0x1e}, {10, 0x10}, {9, 0x7}, {10, 0x5}, {8, 0x1c}, {8, 0x1a}, 
    {9, 0x20}, {10, 0x13}, {10, 0x11}, {11, 0xf}, {10, 0x8}, {11, 0xe}, 
    {8, 0xe}, {7, 0xc}, {7, 0x9}, {8, 0xd}, {9, 0xe}, {10, 0x9}, {10, 0x4},     
    {10, 0x1}, {8, 0xb}, {7, 0x4}, {8, 0x6}, {9, 0x6}, {10, 0x6}, {10, 0x3}, 
    {10, 0x2}, {10, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable12 [] = {
    {4, 0x9}, {3, 0x6}, {5, 0x10}, {7, 0x21}, {8, 0x29}, {9, 0x27}, {9, 0x26}, 
    {9, 0x1a}, {3, 0x7}, {3, 0x5}, {4, 0x6}, {5, 0x9}, {7, 0x17}, {7, 0x10}, 
    {8, 0x1a}, {8, 0xb}, {5, 0x11}, {4, 0x7}, {5, 0xb}, {6, 0xe}, {7, 0x15}, 
    {8, 0x1e}, {7, 0xa}, {8, 0x7}, {6, 0x11}, {5, 0xa}, {6, 0xf}, {6, 0xc}, 
    {7, 0x12}, {8, 0x1c}, {8, 0xe}, {8, 0x5}, {7, 0x20}, {6, 0xd}, {7, 0x16}, 
    {7, 0x13}, {8, 0x12}, {8, 0x10}, {8, 0x9}, {9, 0x5}, {8, 0x28}, {7, 0x11}, 
    {8, 0x1f}, {8, 0x1d}, {8, 0x11}, {9, 0xd}, {8, 0x4}, {9, 0x2}, {8, 0x1b}, 
    {7, 0xc}, {7, 0xb}, {8, 0xf}, {8, 0xa}, {9, 0x7}, {9, 0x4}, {10, 0x1}, 
    {9, 0x1b}, {8, 0xc}, {8, 0x8}, {9, 0xc}, {9, 0x6}, {9, 0x3}, {9, 0x1}, 
    {10, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable13 [] = {
    {1, 0x1}, {4, 0x5}, {6, 0xe}, {7, 0x15}, {8, 0x22}, {9, 0x33}, {9, 0x2e}, 
    {10, 0x47}, {9, 0x2a}, {10, 0x34}, {11, 0x44}, {11, 0x34}, {12, 0x43}, 
    {12, 0x2c}, {13, 0x2b}, {13, 0x13}, {3, 0x3}, {4, 0x4}, {6, 0xc}, {7, 0x13}, 
    {8, 0x1f}, {8, 0x1a}, {9, 0x2c}, {9, 0x21}, {9, 0x1f}, {9, 0x18}, 
    {10, 0x20}, {10, 0x18}, {11, 0x1f}, {12, 0x23}, {12, 0x16}, {12, 0xe}, 
    {6, 0xf}, {6, 0xd}, {7, 0x17}, {8, 0x24}, {9, 0x3b}, {9, 0x31}, {10, 0x4d}, 
    {10, 0x41}, {9, 0x1d}, {10, 0x28}, {10, 0x1e}, {11, 0x28}, {11, 0x1b}, 
    {12, 0x21}, {13, 0x2a}, {13, 0x10}, {7, 0x16}, {7, 0x14}, {8, 0x25}, 
    {9, 0x3d}, {9, 0x38}, {10, 0x4f}, {10, 0x49}, {10, 0x40}, {10, 0x2b}, 
    {11, 0x4c}, {11, 0x38}, {11, 0x25}, {11, 0x1a}, {12, 0x1f}, {13, 0x19}, 
    {13, 0xe}, {8, 0x23}, {7, 0x10}, {9, 0x3c}, {9, 0x39}, {10, 0x61}, 
    {10, 0x4b}, {11, 0x72}, {11, 0x5b}, {10, 0x36}, {11, 0x49}, {11, 0x37}, 
    {12, 0x29}, {12, 0x30}, {13, 0x35}, {13, 0x17}, {14, 0x18}, {9, 0x3a}, 
    {8, 0x1b}, {9, 0x32}, {10, 0x60}, {10, 0x4c}, {10, 0x46}, {11, 0x5d}, 
    {11, 0x54}, {11, 0x4d}, {11, 0x3a}, {12, 0x4f}, {11, 0x1d}, {13, 0x4a}, 
    {13, 0x31}, {14, 0x29}, {14, 0x11}, {9, 0x2f}, {9, 0x2d}, {10, 0x4e}, 
    {10, 0x4a}, {11, 0x73}, {11, 0x5e}, {11, 0x5a}, {11, 0x4f}, {11, 0x45}, 
    {12, 0x53}, {12, 0x47}, {12, 0x32}, {13, 0x3b}, {13, 0x26}, {14, 0x24}, 
    {14, 0xf}, {10, 0x48}, {9, 0x22}, {10, 0x38}, {11, 0x5f}, {11, 0x5c}, 
    {11, 0x55}, {12, 0x5b}, {12, 0x5a}, {12, 0x56}, {12, 0x49}, {13, 0x4d}, 
    {13, 0x41}, {13, 0x33}, {14, 0x2c}, {16, 0x2b}, {16, 0x2a}, {9, 0x2b}, 
    {8, 0x14}, {9, 0x1e}, {10, 0x2c}, {10, 0x37}, {11, 0x4e}, {11, 0x48}, 
    {12, 0x57}, {12, 0x4e}, {12, 0x3d}, {12, 0x2e}, {13, 0x36}, {13, 0x25}, 
    {14, 0x1e}, {15, 0x14}, {15, 0x10}, {10, 0x35}, {9, 0x19}, {10, 0x29}, 
    {10, 0x25}, {11, 0x2c}, {11, 0x3b}, {11, 0x36}, {13, 0x51}, {12, 0x42}, 
    {13, 0x4c}, {13, 0x39}, {14, 0x36}, {14, 0x25}, {14, 0x12}, {16, 0x27}, 
    {15, 0xb}, {10, 0x23}, {10, 0x21}, {10, 0x1f}, {11, 0x39}, {11, 0x2a}, 
    {12, 0x52}, {12, 0x48}, {13, 0x50}, {12, 0x2f}, {13, 0x3a}, {14, 0x37}, 
    {13, 0x15}, {14, 0x16}, {15, 0x1a}, {16, 0x26}, {17, 0x16}, {11, 0x35}, 
    {10, 0x19}, {10, 0x17}, {11, 0x26}, {12, 0x46}, {12, 0x3c}, {12, 0x33}, 
    {12, 0x24}, {13, 0x37}, {13, 0x1a}, {13, 0x22}, {14, 0x17}, {15, 0x1b}, 
    {15, 0xe}, {15, 0x9}, {16, 0x7}, {11, 0x22}, {11, 0x20}, {11, 0x1c}, 
    {12, 0x27}, {12, 0x31}, {13, 0x4b}, {12, 0x1e}, {13, 0x34}, {14, 0x30}, 
    {14, 0x28}, {15, 0x34}, {15, 0x1c}, {15, 0x12}, {16, 0x11}, {16, 0x9}, 
    {16, 0x5}, {12, 0x2d}, {11, 0x15}, {12, 0x22}, {13, 0x40}, {13, 0x38}, 
    {13, 0x32}, {14, 0x31}, {14, 0x2d}, {14, 0x1f}, {14, 0x13}, {14, 0xc}, 
    {15, 0xf}, {16, 0xa}, {15, 0x7}, {16, 0x6}, {16, 0x3}, {13, 0x30}, 
    {12, 0x17}, {12, 0x14}, {13, 0x27}, {13, 0x24}, {13, 0x23}, {15, 0x35}, 
    {14, 0x15}, {14, 0x10}, {17, 0x17}, {15, 0xd}, {15, 0xa}, {15, 0x6}, 
    {17, 0x1}, {16, 0x4}, {16, 0x2}, {12, 0x10}, {12, 0xf}, {13, 0x11}, 
    {14, 0x1b}, {14, 0x19}, {14, 0x14}, {15, 0x1d}, {14, 0xb}, {15, 0x11}, 
    {15, 0xc}, {16, 0x10}, {16, 0x8}, {19, 0x1}, {18, 0x1}, {19, 0x0},
    {16, 0x1}, {0, 0x0}
};

/* const ARM_VLC32 armACMP3_HuffTable14 */

const ARM_VLC32 armACMP3_HuffTable15 [] = {
    {3, 0x7}, {4, 0xc}, {5, 0x12}, {7, 0x35}, {7, 0x2f}, {8, 0x4c}, {9, 0x7c}, 
    {9, 0x6c}, {9, 0x59}, {10, 0x7b}, {10, 0x6c}, {11, 0x77}, {11, 0x6b}, 
    {11, 0x51}, {12, 0x7a}, {13, 0x3f}, {4, 0xd}, {3, 0x5}, {5, 0x10}, 
    {6, 0x1b}, {7, 0x2e}, {7, 0x24}, {8, 0x3d}, {8, 0x33}, {8, 0x2a}, {9, 0x46}, 
    {9, 0x34}, {10, 0x53}, {10, 0x41}, {10, 0x29}, {11, 0x3b}, {11, 0x24}, 
    {5, 0x13}, {5, 0x11}, {5, 0xf}, {6, 0x18}, {7, 0x29}, {7, 0x22}, {8, 0x3b}, 
    {8, 0x30}, {8, 0x28}, {9, 0x40}, {9, 0x32}, {10, 0x4e}, {10, 0x3e}, 
    {11, 0x50}, {11, 0x38}, {11, 0x21}, {6, 0x1d}, {6, 0x1c}, {6, 0x19}, 
    {7, 0x2b}, {7, 0x27}, {8, 0x3f}, {8, 0x37}, {9, 0x5d}, {9, 0x4c}, {9, 0x3b}, 
    {10, 0x5d}, {10, 0x48}, {10, 0x36}, {11, 0x4b}, {11, 0x32}, {11, 0x1d}, 
    {7, 0x34}, {6, 0x16}, {7, 0x2a}, {7, 0x28}, {8, 0x43}, {8, 0x39}, {9, 0x5f}, 
    {9, 0x4f}, {9, 0x48}, {9, 0x39}, {10, 0x59}, {10, 0x45}, {10, 0x31}, 
    {11, 0x42}, {11, 0x2e}, {11, 0x1b}, {8, 0x4d}, {7, 0x25}, {7, 0x23}, 
    {8, 0x42}, {8, 0x3a}, {8, 0x34}, {9, 0x5b}, {9, 0x4a}, {9, 0x3e}, {9, 0x30}, 
    {10, 0x4f}, {10, 0x3f}, {11, 0x5a}, {11, 0x3e}, {11, 0x28}, {12, 0x26}, 
    {9, 0x7d}, {7, 0x20}, {8, 0x3c}, {8, 0x38}, {8, 0x32}, {9, 0x5c}, {9, 0x4e}, 
    {9, 0x41}, {9, 0x37}, {10, 0x57}, {10, 0x47}, {10, 0x33}, {11, 0x49}, 
    {11, 0x33}, {12, 0x46}, {12, 0x1e}, {9, 0x6d}, {8, 0x35}, {8, 0x31}, 
    {9, 0x5e}, {9, 0x58}, {9, 0x4b}, {9, 0x42}, {10, 0x7a}, {10, 0x5b}, 
    {10, 0x49}, {10, 0x38}, {10, 0x2a}, {11, 0x40}, {11, 0x2c}, {11, 0x15}, 
    {12, 0x19}, {9, 0x5a}, {8, 0x2b}, {8, 0x29}, {9, 0x4d}, {9, 0x49}, 
    {9, 0x3f}, {9, 0x38}, {10, 0x5c}, {10, 0x4d}, {10, 0x42}, {10, 0x2f}, 
    {11, 0x43}, {11, 0x30}, {12, 0x35}, {12, 0x24}, {12, 0x14}, {9, 0x47}, 
    {8, 0x22}, {9, 0x43}, {9, 0x3c}, {9, 0x3a}, {9, 0x31}, {10, 0x58}, 
    {10, 0x4c}, {10, 0x43}, {11, 0x6a}, {11, 0x47}, {11, 0x36}, {11, 0x26}, 
    {12, 0x27}, {12, 0x17}, {12, 0xf}, {10, 0x6d}, {9, 0x35}, {9, 0x33}, 
    {9, 0x2f}, {10, 0x5a}, {10, 0x52}, {10, 0x3a}, {10, 0x39}, {10, 0x30}, 
    {11, 0x48}, {11, 0x39}, {11, 0x29}, {11, 0x17}, {12, 0x1b}, {13, 0x3e}, 
    {12, 0x9}, {10, 0x56}, {9, 0x2a}, {9, 0x28}, {9, 0x25}, {10, 0x46}, 
    {10, 0x40}, {10, 0x34}, {10, 0x2b}, {11, 0x46}, {11, 0x37}, {11, 0x2a}, 
    {11, 0x19}, {12, 0x1d}, {12, 0x12}, {12, 0xb}, {13, 0xb}, {11, 0x76}, 
    {10, 0x44}, {9, 0x1e}, {10, 0x37}, {10, 0x32}, {10, 0x2e}, {11, 0x4a}, 
    {11, 0x41}, {11, 0x31}, {11, 0x27}, {11, 0x18}, {11, 0x10}, {12, 0x16}, 
    {12, 0xd}, {13, 0xe}, {13, 0x7}, {11, 0x5b}, {10, 0x2c}, {10, 0x27}, 
    {10, 0x26}, {10, 0x22}, {11, 0x3f}, {11, 0x34}, {11, 0x2d}, {11, 0x1f}, 
    {12, 0x34}, {12, 0x1c}, {12, 0x13}, {12, 0xe}, {12, 0x8}, {13, 0x9}, 
    {13, 0x3}, {12, 0x7b}, {11, 0x3c}, {11, 0x3a}, {11, 0x35}, {11, 0x2f}, 
    {11, 0x2b}, {11, 0x20}, {11, 0x16}, {12, 0x25}, {12, 0x18}, {12, 0x11}, 
    {12, 0xc}, {13, 0xf}, {13, 0xa}, {12, 0x2}, {13, 0x1}, {12, 0x47}, 
    {11, 0x25}, {11, 0x22}, {11, 0x1e}, {11, 0x1c}, {11, 0x14}, {11, 0x11}, 
    {12, 0x1a}, {12, 0x15}, {12, 0x10}, {12, 0xa}, {12, 0x6}, {13, 0x8}, 
    {13, 0x6}, {13, 0x2}, {13, 0x0}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable16 [] = {
    {1, 0x1}, {4, 0x5}, {6, 0xe}, {8, 0x2c}, {9, 0x4a}, {9, 0x3f}, {10, 0x6e}, 
    {10, 0x5d}, {11, 0xac}, {11, 0x95}, {11, 0x8a}, {12, 0xf2}, {12, 0xe1}, 
    {12, 0xc3}, {13, 0x178}, {9, 0x11}, {3, 0x3}, {4, 0x4}, {6, 0xc}, {7, 0x14}, 
    {8, 0x23}, {9, 0x3e}, {9, 0x35}, {9, 0x2f}, {10, 0x53}, {10, 0x4b}, 
    {10, 0x44}, {11, 0x77}, {12, 0xc9}, {11, 0x6b}, {12, 0xcf}, {8, 0x9}, 
    {6, 0xf}, {6, 0xd}, {7, 0x17}, {8, 0x26}, {9, 0x43}, {9, 0x3a}, {10, 0x67}, 
    {10, 0x5a}, {11, 0xa1}, {10, 0x48}, {11, 0x7f}, {11, 0x75}, {11, 0x6e}, 
    {12, 0xd1}, {12, 0xce}, {9, 0x10}, {8, 0x2d}, {7, 0x15}, {8, 0x27}, 
    {9, 0x45}, {9, 0x40}, {10, 0x72}, {10, 0x63}, {10, 0x57}, {11, 0x9e}, 
    {11, 0x8c}, {12, 0xfc}, {12, 0xd4}, {12, 0xc7}, {13, 0x183}, {13, 0x16d}, 
    {10, 0x1a}, {9, 0x4b}, {8, 0x24}, {9, 0x44}, {9, 0x41}, {10, 0x73}, 
    {10, 0x65}, {11, 0xb3}, {11, 0xa4}, {11, 0x9b}, {12, 0x108}, {12, 0xf6}, 
    {12, 0xe2}, {13, 0x18b}, {13, 0x17e}, {13, 0x16a}, {9, 0x9}, {9, 0x42}, 
    {8, 0x1e}, {9, 0x3b}, {9, 0x38}, {10, 0x66}, {11, 0xb9}, {11, 0xad}, 
    {12, 0x109}, {11, 0x8e}, {12, 0xfd}, {12, 0xe8}, {13, 0x190}, {13, 0x184}, 
    {13, 0x17a}, {14, 0x1bd}, {10, 0x10}, {10, 0x6f}, {9, 0x36}, {9, 0x34}, 
    {10, 0x64}, {11, 0xb8}, {11, 0xb2}, {11, 0xa0}, {11, 0x85}, {12, 0x101}, 
    {12, 0xf4}, {12, 0xe4}, {12, 0xd9}, {13, 0x181}, {13, 0x16e}, {14, 0x2cb}, 
    {10, 0xa}, {10, 0x62}, {9, 0x30}, {10, 0x5b}, {10, 0x58}, {11, 0xa5}, 
    {11, 0x9d}, {11, 0x94}, {12, 0x105}, {12, 0xf8}, {13, 0x197}, {13, 0x18d}, 
    {13, 0x174}, {13, 0x17c}, {15, 0x379}, {15, 0x374}, {10, 0x8}, {10, 0x55}, 
    {10, 0x54}, {10, 0x51}, {11, 0x9f}, {11, 0x9c}, {11, 0x8f}, {12, 0x104}, 
    {12, 0xf9}, {13, 0x1ab}, {13, 0x191}, {13, 0x188}, {13, 0x17f}, {14, 0x2d7}, 
    {14, 0x2c9}, {14, 0x2c4}, {10, 0x7}, {11, 0x9a}, {10, 0x4c}, {10, 0x49}, 
    {11, 0x8d}, {11, 0x83}, {12, 0x100}, {12, 0xf5}, {13, 0x1aa}, {13, 0x196}, 
    {13, 0x18a}, {13, 0x180}, {14, 0x2df}, {13, 0x167}, {14, 0x2c6}, 
    {13, 0x160}, {11, 0xb}, {11, 0x8b}, {11, 0x81}, {10, 0x43}, {11, 0x7d}, 
    {12, 0xf7}, {12, 0xe9}, {12, 0xe5}, {12, 0xdb}, {13, 0x189}, {14, 0x2e7}, 
    {14, 0x2e1}, {14, 0x2d0}, {15, 0x375}, {15, 0x372}, {14, 0x1b7}, {10, 0x4}, 
    {12, 0xf3}, {11, 0x78}, {11, 0x76}, {11, 0x73}, {12, 0xe3}, {12, 0xdf}, 
    {13, 0x18c}, {14, 0x2ea}, {14, 0x2e6}, {14, 0x2e0}, {14, 0x2d1}, 
    {14, 0x2c8}, {14, 0x2c2}, {13, 0xdf}, {14, 0x1b4}, {11, 0x6}, {12, 0xca}, 
    {12, 0xe0}, {12, 0xde}, {12, 0xda}, {12, 0xd8}, {13, 0x185}, {13, 0x182}, 
    {13, 0x17d}, {13, 0x16c}, {15, 0x378}, {14, 0x1bb}, {14, 0x2c3}, 
    {14, 0x1b8}, {14, 0x1b5}, {16, 0x6c0}, {11, 0x4}, {14, 0x2eb}, {12, 0xd3}, 
    {12, 0xd2}, {12, 0xd0}, {13, 0x172}, {13, 0x17b}, {14, 0x2de}, {14, 0x2d3}, 
    {14, 0x2ca}, {16, 0x6c7}, {15, 0x373}, {15, 0x36d}, {15, 0x36c}, 
    {17, 0xd83}, {15, 0x361}, {11, 0x2}, {13, 0x179}, {13, 0x171}, {11, 0x66}, 
    {12, 0xbb}, {14, 0x2d6}, {14, 0x2d2}, {13, 0x166}, {14, 0x2c7}, {14, 0x2c5}, 
    {15, 0x362}, {16, 0x6c6}, {15, 0x367}, {17, 0xd82}, {15, 0x366}, 
    {14, 0x1b2}, {11, 0x0}, {9, 0xc}, {8, 0xa}, {8, 0x7}, {9, 0xb}, {9, 0xa}, 
    {10, 0x11}, {10, 0xb}, {10, 0x9}, {11, 0xd}, {11, 0xc}, {11, 0xa}, 
    {11, 0x7}, {11, 0x5}, {11, 0x3}, {11, 0x1}, {8, 0x3}, {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable24 [] = {
    {4, 0xf}, {4, 0xd}, {6, 0x2e}, {7, 0x50}, {8, 0x92}, {9, 0x106}, {9, 0xf8}, 
    {10, 0x1b2}, {10, 0x1aa}, {11, 0x29d}, {11, 0x28d}, {11, 0x289}, 
    {11, 0x26d}, {11, 0x205}, {12, 0x408}, {9, 0x58}, {4, 0xe}, {4, 0xc}, 
    {5, 0x15}, {6, 0x26}, {7, 0x47}, {8, 0x82}, {8, 0x7a}, {9, 0xd8}, {9, 0xd1}, 
    {9, 0xc6}, {10, 0x147}, {10, 0x159}, {10, 0x13f}, {10, 0x129}, {10, 0x117}, 
    {8, 0x2a}, {6, 0x2f}, {5, 0x16}, {6, 0x29}, {7, 0x4a}, {7, 0x44}, {8, 0x80}, 
    {8, 0x78}, {9, 0xdd}, {9, 0xcf}, {9, 0xc2}, {9, 0xb6}, {10, 0x154}, 
    {10, 0x13b}, {10, 0x127}, {11, 0x21d}, {7, 0x12}, {7, 0x51}, {6, 0x27}, 
    {7, 0x4b}, {7, 0x46}, {8, 0x86}, {8, 0x7d}, {8, 0x74}, {9, 0xdc}, {9, 0xcc}, 
    {9, 0xbe}, {9, 0xb2}, {10, 0x145}, {10, 0x137}, {10, 0x125}, {10, 0x10f}, 
    {7, 0x10}, {8, 0x93}, {7, 0x48}, {7, 0x45}, {8, 0x87}, {8, 0x7f}, {8, 0x76}, 
    {8, 0x70}, {9, 0xd2}, {9, 0xc8}, {9, 0xbc}, {10, 0x160}, {10, 0x143}, 
    {10, 0x132}, {10, 0x11d}, {11, 0x21c}, {7, 0xe}, {9, 0x107}, {7, 0x42}, 
    {8, 0x81}, {8, 0x7e}, {8, 0x77}, {8, 0x72}, {9, 0xd6}, {9, 0xca}, {9, 0xc0}, 
    {9, 0xb4}, {10, 0x155}, {10, 0x13d}, {10, 0x12d}, {10, 0x119}, {10, 0x106}, 
    {7, 0xc}, {9, 0xf9}, {8, 0x7b}, {8, 0x79}, {8, 0x75}, {8, 0x71}, {9, 0xd7}, 
    {9, 0xce}, {9, 0xc3}, {9, 0xb9}, {10, 0x15b}, {10, 0x14a}, {10, 0x134}, 
    {10, 0x123}, {10, 0x110}, {11, 0x208}, {7, 0xa}, {10, 0x1b3}, {8, 0x73}, 
    {8, 0x6f}, {8, 0x6d}, {9, 0xd3}, {9, 0xcb}, {9, 0xc4}, {9, 0xbb}, 
    {10, 0x161}, {10, 0x14c}, {10, 0x139}, {10, 0x12a}, {10, 0x11b}, 
    {11, 0x213}, {11, 0x17d}, {8, 0x11}, {10, 0x1ab}, {9, 0xd4}, {9, 0xd0}, 
    {9, 0xcd}, {9, 0xc9}, {9, 0xc1}, {9, 0xba}, {9, 0xb1}, {9, 0xa9}, 
    {10, 0x140}, {10, 0x12f}, {10, 0x11e}, {10, 0x10c}, {11, 0x202}, 
    {11, 0x179}, {8, 0x10}, {10, 0x14f}, {9, 0xc7}, {9, 0xc5}, {9, 0xbf}, 
    {9, 0xbd}, {9, 0xb5}, {9, 0xae}, {10, 0x14d}, {10, 0x141}, {10, 0x131}, 
    {10, 0x121}, {10, 0x113}, {11, 0x209}, {11, 0x17b}, {11, 0x173}, {8, 0xb}, 
    {11, 0x29c}, {9, 0xb8}, {9, 0xb7}, {9, 0xb3}, {9, 0xaf}, {10, 0x158}, 
    {10, 0x14b}, {10, 0x13a}, {10, 0x130}, {10, 0x122}, {10, 0x115}, 
    {11, 0x212}, {11, 0x17f}, {11, 0x175}, {11, 0x16e}, {8, 0xa}, {11, 0x28c}, 
    {10, 0x15a}, {9, 0xab}, {9, 0xa8}, {9, 0xa4}, {10, 0x13e}, {10, 0x135}, 
    {10, 0x12b}, {10, 0x11f}, {10, 0x114}, {10, 0x107}, {11, 0x201}, 
    {11, 0x177}, {11, 0x170}, {11, 0x16a}, {8, 0x6}, {11, 0x288}, {10, 0x142}, 
    {10, 0x13c}, {10, 0x138}, {10, 0x133}, {10, 0x12e}, {10, 0x124}, 
    {10, 0x11c}, {10, 0x10d}, {10, 0x105}, {11, 0x200}, {11, 0x178}, 
    {11, 0x172}, {11, 0x16c}, {11, 0x167}, {8, 0x4}, {11, 0x26c}, {10, 0x12c}, 
    {10, 0x128}, {10, 0x126}, {10, 0x120}, {10, 0x11a}, {10, 0x111}, 
    {10, 0x10a}, {11, 0x203}, {11, 0x17c}, {11, 0x176}, {11, 0x171}, 
    {11, 0x16d}, {11, 0x169}, {11, 0x165}, {8, 0x2}, {12, 0x409}, {10, 0x118}, 
    {10, 0x116}, {10, 0x112}, {10, 0x10b}, {10, 0x108}, {10, 0x103}, 
    {11, 0x17e}, {11, 0x17a}, {11, 0x174}, {11, 0x16f}, {11, 0x16b}, 
    {11, 0x168}, {11, 0x166}, {11, 0x164}, {8, 0x0}, {8, 0x2b}, {7, 0x14}, 
    {7, 0x13}, {7, 0x11}, {7, 0xf}, {7, 0xd}, {7, 0xb}, {7, 0x9}, {7, 0x7}, 
    {7, 0x6}, {7, 0x4}, {8, 0x7}, {8, 0x5}, {8, 0x3}, {8, 0x1}, {4, 0x3},
    {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable32 [] = {
    {1, 0x1},
    {4, 0x5},
    {4, 0x4},
    {5, 0x5},
    {4, 0x6},
    {6, 0x5},
    {5, 0x4},
    {6, 0x4},
    {4, 0x7},
    {5, 0x3},
    {5, 0x6},
    {6, 0x0},
    {5, 0x7},
    {6, 0x2},
    {6, 0x3},
    {6, 0x1},
    {0, 0x0}
};

const ARM_VLC32 armACMP3_HuffTable33 [] = {
    {4, 0xf},
    {4, 0xe},
    {4, 0xd},
    {4, 0xc},
    {4, 0xb},
    {4, 0xa},
    {4, 0x9},
    {4, 0x8},
    {4, 0x7},
    {4, 0x6},
    {4, 0x5},
    {4, 0x4},
    {4, 0x3},
    {4, 0x2},
    {4, 0x1},
    {4, 0x0},
    {0, 0x0}
};

const ARM_VLC32* armACMP3_HuffCodeBook [] = {
    0,
    armACMP3_HuffTable1,
    armACMP3_HuffTable2,
    armACMP3_HuffTable3,
    0,

    armACMP3_HuffTable5,
    armACMP3_HuffTable6,
    armACMP3_HuffTable7,
    armACMP3_HuffTable8,
    armACMP3_HuffTable9,

    armACMP3_HuffTable10,
    armACMP3_HuffTable11,
    armACMP3_HuffTable12,
    armACMP3_HuffTable13,
    0,

    armACMP3_HuffTable15,
    armACMP3_HuffTable16,
    armACMP3_HuffTable16,
    armACMP3_HuffTable16,
    armACMP3_HuffTable16,

    armACMP3_HuffTable16,
    armACMP3_HuffTable16,
    armACMP3_HuffTable16,
    armACMP3_HuffTable16,
    armACMP3_HuffTable24,

    armACMP3_HuffTable24,
    armACMP3_HuffTable24,
    armACMP3_HuffTable24,
    armACMP3_HuffTable24,
    armACMP3_HuffTable24,

    armACMP3_HuffTable24,
    armACMP3_HuffTable24
};
/**********************/


const OMX_S16 armACMP3_TableXY0 [][2] = { {0,0} /* dummy! */
};

const OMX_S16 armACMP3_TableXY1 [][2] = {
    {0, 0}, {0, 1}, {1, 0}, {1, 1}
};

const OMX_S16 armACMP3_TableXY2 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {1, 0}, {1, 1}, {1, 2}, {2, 0}, {2, 1}, {2, 2}
};

const OMX_S16 armACMP3_TableXY3 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {1, 0}, {1, 1}, {1, 2}, {2, 0}, {2, 1}, {2, 2}
};

const OMX_S16 armACMP3_TableXY4 [][2] = {{0,0} /* dummy! */
};

const OMX_S16 armACMP3_TableXY5 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {1, 0}, {1, 1}, {1, 2}, {1, 3}, {2, 0},
    {2, 1}, {2, 2}, {2, 3}, {3, 0}, {3, 1}, {3, 2}, {3, 3}
};

const OMX_S16 armACMP3_TableXY6 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {1, 0}, {1, 1}, {1, 2}, {1, 3}, {2, 0}, 
    {2, 1}, {2, 2}, {2, 3}, {3, 0}, {3, 1}, {3, 2}, {3, 3}
};

const OMX_S16 armACMP3_TableXY7 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {1, 0}, {1, 1}, {1, 2}, 
    {1, 3}, {1, 4}, {1, 5}, {2, 0}, {2, 1}, {2, 2}, {2, 3}, {2, 4}, {2, 5}, 
    {3, 0}, {3, 1}, {3, 2}, {3, 3}, {3, 4}, {3, 5}, {4, 0}, {4, 1}, {4, 2}, 
    {4, 3}, {4, 4}, {4, 5}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5}
};

const OMX_S16 armACMP3_TableXY8 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {1, 0}, {1, 1}, {1, 2},
    {1, 3}, {1, 4}, {1, 5}, {2, 0}, {2, 1}, {2, 2}, {2, 3}, {2, 4}, {2, 5}, 
    {3, 0}, {3, 1}, {3, 2}, {3, 3}, {3, 4}, {3, 5}, {4, 0}, {4, 1}, {4, 2}, 
    {4, 3}, {4, 4}, {4, 5}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5}
};

const OMX_S16 armACMP3_TableXY9 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {1, 0}, {1, 1}, {1, 2}, 
    {1, 3}, {1, 4}, {1, 5}, {2, 0}, {2, 1}, {2, 2}, {2, 3}, {2, 4}, {2, 5}, 
    {3, 0}, {3, 1}, {3, 2}, {3, 3}, {3, 4}, {3, 5}, {4, 0}, {4, 1}, {4, 2}, 
    {4, 3}, {4, 4}, {4, 5}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5}
};

const OMX_S16 armACMP3_TableXY10 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, 
    {5, 5}, {5, 6}, {5, 7}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5}, 
    {6, 6}, {6, 7}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6}, 
    {7, 7}
};

const OMX_S16 armACMP3_TableXY11 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, 
    {5, 5}, {5, 6}, {5, 7}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5}, 
    {6, 6}, {6, 7}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6}, 
    {7, 7}
};

const OMX_S16 armACMP3_TableXY12 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {2, 0}, {2, 1},
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {3, 0}, {3, 1}, {3, 2},
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {4, 0}, {4, 1}, {4, 2}, {4, 3},
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4},
    {5, 5}, {5, 6}, {5, 7}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5},
    {6, 6}, {6, 7}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6},
    {7, 7}
};

const OMX_S16 armACMP3_TableXY13 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {0, 8}, 
    {0, 9}, {0, 10}, {0, 11}, {0, 12}, {0, 13}, {0, 14}, {0, 15}, {1, 0},
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {1, 8}, {1, 9},
    {1, 10}, {1, 11}, {1, 12}, {1, 13}, {1, 14}, {1, 15}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {2, 8}, {2, 9}, {2, 10},
    {2, 11}, {2, 12}, {2, 13}, {2, 14}, {2, 15}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {3, 8}, {3, 9}, {3, 10}, {3, 11}, 
    {3, 12}, {3, 13}, {3, 14}, {3, 15}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {4, 8}, {4, 9}, {4, 10}, {4, 11}, {4, 12},
    {4, 13}, {4, 14}, {4, 15}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5},
    {5, 6}, {5, 7}, {5, 8}, {5, 9}, {5, 10}, {5, 11}, {5, 12}, {5, 13}, 
    {5, 14}, {5, 15}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5}, {6, 6},
    {6, 7}, {6, 8}, {6, 9}, {6, 10}, {6, 11}, {6, 12}, {6, 13}, {6, 14}, 
    {6, 15}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6}, {7, 7}, 
    {7, 8}, {7, 9}, {7, 10}, {7, 11}, {7, 12}, {7, 13}, {7, 14}, {7, 15}, 
    {8, 0}, {8, 1}, {8, 2}, {8, 3}, {8, 4}, {8, 5}, {8, 6}, {8, 7}, {8, 8}, 
    {8, 9}, {8, 10}, {8, 11}, {8, 12}, {8, 13}, {8, 14}, {8, 15}, {9, 0}, 
    {9, 1}, {9, 2}, {9, 3}, {9, 4}, {9, 5}, {9, 6}, {9, 7}, {9, 8}, {9, 9}, 
    {9, 10}, {9, 11}, {9, 12}, {9, 13}, {9, 14}, {9, 15}, {10, 0}, {10, 1}, 
    {10, 2}, {10, 3}, {10, 4}, {10, 5}, {10, 6}, {10, 7}, {10, 8}, {10, 9}, 
    {10, 10}, {10, 11}, {10, 12}, {10, 13}, {10, 14}, {10, 15}, {11, 0}, 
    {11, 1}, {11, 2}, {11, 3}, {11, 4}, {11, 5}, {11, 6}, {11, 7}, {11, 8}, 
    {11, 9}, {11, 10}, {11, 11}, {11, 12}, {11, 13}, {11, 14}, {11, 15}, 
    {12, 0}, {12, 1}, {12, 2}, {12, 3}, {12, 4}, {12, 5}, {12, 6}, {12, 7}, 
    {12, 8}, {12, 9}, {12, 10}, {12, 11}, {12, 12}, {12, 13}, {12, 14}, 
    {12, 15}, {13, 0}, {13, 1}, {13, 2}, {13, 3}, {13, 4}, {13, 5}, {13, 6},
    {13, 7}, {13, 8}, {13, 9}, {13, 10}, {13, 11}, {13, 12}, {13, 13}, 
    {13, 14}, {13, 15}, {14, 0}, {14, 1}, {14, 2}, {14, 3}, {14, 4}, 
    {14, 5}, {14, 6}, {14, 7}, {14, 8}, {14, 9}, {14, 10}, {14, 11}, 
    {14, 12}, {14, 13}, {14, 14}, {14, 15}, {15, 0}, {15, 1}, {15, 2}, 
    {15, 3}, {15, 4}, {15, 5}, {15, 6}, {15, 7}, {15, 8}, {15, 9}, {15, 10},
    {15, 11}, {15, 12}, {15, 13}, {15, 14}, {15, 15}
};

const OMX_S16 armACMP3_TableXY14 [][2] = {{0,0} /* dummy! */
};

const OMX_S16 armACMP3_TableXY15 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {0, 8}, 
    {0, 9}, {0, 10}, {0, 11}, {0, 12}, {0, 13}, {0, 14}, {0, 15}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {1, 8}, {1, 9}, 
    {1, 10}, {1, 11}, {1, 12}, {1, 13}, {1, 14}, {1, 15}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {2, 8}, {2, 9}, {2, 10}, 
    {2, 11}, {2, 12}, {2, 13}, {2, 14}, {2, 15}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {3, 8}, {3, 9}, {3, 10}, {3, 11}, 
    {3, 12}, {3, 13}, {3, 14}, {3, 15}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {4, 8}, {4, 9}, {4, 10}, {4, 11}, 
    {4, 12}, {4, 13}, {4, 14}, {4, 15}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, 
    {5, 4}, {5, 5}, {5, 6}, {5, 7}, {5, 8}, {5, 9}, {5, 10}, {5, 11}, 
    {5, 12}, {5, 13}, {5, 14}, {5, 15}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, 
    {6, 4}, {6, 5}, {6, 6}, {6, 7}, {6, 8}, {6, 9}, {6, 10}, {6, 11}, {6, 12},
    {6, 13}, {6, 14}, {6, 15}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5},
    {7, 6}, {7, 7}, {7, 8}, {7, 9}, {7, 10}, {7, 11}, {7, 12}, {7, 13}, 
    {7, 14}, {7, 15}, {8, 0}, {8, 1}, {8, 2}, {8, 3}, {8, 4}, {8, 5}, {8, 6},
    {8, 7}, {8, 8}, {8, 9}, {8, 10}, {8, 11}, {8, 12}, {8, 13}, {8, 14}, 
    {8, 15}, {9, 0}, {9, 1}, {9, 2}, {9, 3}, {9, 4}, {9, 5}, {9, 6}, {9, 7}, 
    {9, 8}, {9, 9}, {9, 10}, {9, 11}, {9, 12}, {9, 13}, {9, 14}, {9, 15}, 
    {10, 0}, {10, 1}, {10, 2}, {10, 3}, {10, 4}, {10, 5}, {10, 6}, {10, 7}, 
    {10, 8}, {10, 9}, {10, 10}, {10, 11}, {10, 12}, {10, 13}, {10, 14}, 
    {10, 15}, {11, 0}, {11, 1}, {11, 2}, {11, 3}, {11, 4}, {11, 5}, {11, 6},
    {11, 7}, {11, 8}, {11, 9}, {11, 10}, {11, 11}, {11, 12}, {11, 13}, 
    {11, 14}, {11, 15}, {12, 0}, {12, 1}, {12, 2}, {12, 3}, {12, 4}, {12, 5},
    {12, 6}, {12, 7}, {12, 8}, {12, 9}, {12, 10}, {12, 11}, {12, 12}, 
    {12, 13}, {12, 14}, {12, 15}, {13, 0}, {13, 1}, {13, 2}, {13, 3}, {13, 4},
    {13, 5}, {13, 6}, {13, 7}, {13, 8}, {13, 9}, {13, 10}, {13, 11}, {13, 12},
    {13, 13}, {13, 14}, {13, 15}, {14, 0}, {14, 1}, {14, 2}, {14, 3}, {14, 4},
    {14, 5}, {14, 6}, {14, 7}, {14, 8}, {14, 9}, {14, 10}, {14, 11}, {14, 12},
    {14, 13}, {14, 14}, {14, 15}, {15, 0}, {15, 1}, {15, 2}, {15, 3}, {15, 4},
    {15, 5}, {15, 6}, {15, 7}, {15, 8}, {15, 9}, {15, 10}, {15, 11}, {15, 12},
    {15, 13}, {15, 14}, {15, 15}
};

const OMX_S16 armACMP3_TableXY16 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {0, 8}, 
    {0, 9}, {0, 10}, {0, 11}, {0, 12}, {0, 13}, {0, 14}, {0, 15}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {1, 8}, {1, 9}, 
    {1, 10}, {1, 11}, {1, 12}, {1, 13}, {1, 14}, {1, 15}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {2, 8}, {2, 9}, {2, 10}, 
    {2, 11}, {2, 12}, {2, 13}, {2, 14}, {2, 15}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {3, 8}, {3, 9}, {3, 10}, {3, 11},
    {3, 12}, {3, 13}, {3, 14}, {3, 15}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {4, 8}, {4, 9}, {4, 10}, {4, 11}, {4, 12},
    {4, 13}, {4, 14}, {4, 15}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5},
    {5, 6}, {5, 7}, {5, 8}, {5, 9}, {5, 10}, {5, 11}, {5, 12}, {5, 13}, 
    {5, 14}, {5, 15}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5}, {6, 6},
    {6, 7}, {6, 8}, {6, 9}, {6, 10}, {6, 11}, {6, 12}, {6, 13}, {6, 14}, 
    {6, 15}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6}, {7, 7}, 
    {7, 8}, {7, 9}, {7, 10}, {7, 11}, {7, 12}, {7, 13}, {7, 14}, {7, 15}, 
    {8, 0}, {8, 1}, {8, 2}, {8, 3}, {8, 4}, {8, 5}, {8, 6}, {8, 7}, {8, 8}, 
    {8, 9}, {8, 10}, {8, 11}, {8, 12}, {8, 13}, {8, 14}, {8, 15}, {9, 0}, 
    {9, 1}, {9, 2}, {9, 3}, {9, 4}, {9, 5}, {9, 6}, {9, 7}, {9, 8}, {9, 9}, 
    {9, 10}, {9, 11}, {9, 12}, {9, 13}, {9, 14}, {9, 15}, {10, 0}, {10, 1}, 
    {10, 2}, {10, 3}, {10, 4}, {10, 5}, {10, 6}, {10, 7}, {10, 8}, {10, 9}, 
    {10, 10}, {10, 11}, {10, 12}, {10, 13}, {10, 14}, {10, 15}, {11, 0}, 
    {11, 1}, {11, 2}, {11, 3}, {11, 4}, {11, 5}, {11, 6}, {11, 7}, {11, 8}, 
    {11, 9}, {11, 10}, {11, 11}, {11, 12}, {11, 13}, {11, 14}, {11, 15}, 
    {12, 0}, {12, 1}, {12, 2}, {12, 3}, {12, 4}, {12, 5}, {12, 6}, {12, 7}, 
    {12, 8}, {12, 9}, {12, 10}, {12, 11}, {12, 12}, {12, 13}, {12, 14}, 
    {12, 15}, {13, 0}, {13, 1}, {13, 2}, {13, 3}, {13, 4}, {13, 5}, {13, 6},
    {13, 7}, {13, 8}, {13, 9}, {13, 10}, {13, 11}, {13, 12}, {13, 13}, 
    {13, 14}, {13, 15}, {14, 0}, {14, 1}, {14, 2}, {14, 3}, {14, 4}, {14, 5},
    {14, 6}, {14, 7}, {14, 8}, {14, 9}, {14, 10}, {14, 11}, {14, 12}, 
    {14, 13}, {14, 14}, {14, 15}, {15, 0}, {15, 1}, {15, 2}, {15, 3}, {15, 4},
    {15, 5}, {15, 6}, {15, 7}, {15, 8}, {15, 9}, {15, 10}, {15, 11}, {15, 12},
    {15, 13}, {15, 14}, {15, 15}
};

const OMX_S16 armACMP3_TableXY24 [][2] = {
    {0, 0}, {0, 1}, {0, 2}, {0, 3}, {0, 4}, {0, 5}, {0, 6}, {0, 7}, {0, 8}, 
    {0, 9}, {0, 10}, {0, 11}, {0, 12}, {0, 13}, {0, 14}, {0, 15}, {1, 0}, 
    {1, 1}, {1, 2}, {1, 3}, {1, 4}, {1, 5}, {1, 6}, {1, 7}, {1, 8}, {1, 9}, 
    {1, 10}, {1, 11}, {1, 12}, {1, 13}, {1, 14}, {1, 15}, {2, 0}, {2, 1}, 
    {2, 2}, {2, 3}, {2, 4}, {2, 5}, {2, 6}, {2, 7}, {2, 8}, {2, 9}, {2, 10}, 
    {2, 11}, {2, 12}, {2, 13}, {2, 14}, {2, 15}, {3, 0}, {3, 1}, {3, 2}, 
    {3, 3}, {3, 4}, {3, 5}, {3, 6}, {3, 7}, {3, 8}, {3, 9}, {3, 10}, {3, 11},
    {3, 12}, {3, 13}, {3, 14}, {3, 15}, {4, 0}, {4, 1}, {4, 2}, {4, 3}, 
    {4, 4}, {4, 5}, {4, 6}, {4, 7}, {4, 8}, {4, 9}, {4, 10}, {4, 11}, {4, 12},
    {4, 13}, {4, 14}, {4, 15}, {5, 0}, {5, 1}, {5, 2}, {5, 3}, {5, 4}, {5, 5},
    {5, 6}, {5, 7}, {5, 8}, {5, 9}, {5, 10}, {5, 11}, {5, 12}, {5, 13}, 
    {5, 14}, {5, 15}, {6, 0}, {6, 1}, {6, 2}, {6, 3}, {6, 4}, {6, 5}, {6, 6},
    {6, 7}, {6, 8}, {6, 9}, {6, 10}, {6, 11}, {6, 12}, {6, 13}, {6, 14}, 
    {6, 15}, {7, 0}, {7, 1}, {7, 2}, {7, 3}, {7, 4}, {7, 5}, {7, 6}, {7, 7}, 
    {7, 8}, {7, 9}, {7, 10}, {7, 11}, {7, 12}, {7, 13}, {7, 14}, {7, 15}, 
    {8, 0}, {8, 1}, {8, 2}, {8, 3}, {8, 4}, {8, 5}, {8, 6}, {8, 7}, {8, 8}, 
    {8, 9}, {8, 10}, {8, 11}, {8, 12}, {8, 13}, {8, 14}, {8, 15}, {9, 0}, 
    {9, 1}, {9, 2}, {9, 3}, {9, 4}, {9, 5}, {9, 6}, {9, 7}, {9, 8}, {9, 9}, 
    {9, 10}, {9, 11}, {9, 12}, {9, 13}, {9, 14}, {9, 15}, {10, 0}, {10, 1}, 
    {10, 2}, {10, 3}, {10, 4}, {10, 5}, {10, 6}, {10, 7}, {10, 8}, {10, 9}, 
    {10, 10}, {10, 11}, {10, 12}, {10, 13}, {10, 14}, {10, 15}, {11, 0}, 
    {11, 1}, {11, 2}, {11, 3}, {11, 4}, {11, 5}, {11, 6}, {11, 7}, {11, 8}, 
    {11, 9}, {11, 10}, {11, 11}, {11, 12}, {11, 13}, {11, 14}, {11, 15}, 
    {12, 0}, {12, 1}, {12, 2}, {12, 3}, {12, 4}, {12, 5}, {12, 6}, {12, 7}, 
    {12, 8}, {12, 9}, {12, 10}, {12, 11}, {12, 12}, {12, 13}, {12, 14}, 
    {12, 15}, {13, 0}, {13, 1}, {13, 2}, {13, 3}, {13, 4}, {13, 5}, {13, 6},
    {13, 7}, {13, 8}, {13, 9}, {13, 10}, {13, 11}, {13, 12}, {13, 13}, 
    {13, 14}, {13, 15}, {14, 0}, {14, 1}, {14, 2}, {14, 3}, {14, 4}, {14, 5},
    {14, 6}, {14, 7}, {14, 8}, {14, 9}, {14, 10}, {14, 11}, {14, 12}, 
    {14, 13}, {14, 14}, {14, 15}, {15, 0}, {15, 1}, {15, 2}, {15, 3}, {15, 4},
    {15, 5}, {15, 6}, {15, 7}, {15, 8}, {15, 9}, {15, 10}, {15, 11}, {15, 12},
    {15, 13}, {15, 14}, {15, 15}
};

const OMX_S16 armACMP3_TableXY32 [][2] = {
    {0, 15}, {1, 15}, {2, 15}, {3, 15}, {4, 15}, {5, 15}, {6, 15}, {7, 15}, 
    {8, 15}, {9, 15}, {10, 15}, {11, 15}, {12, 15}, {13, 15}, {14, 15}, 
    {15, 15}
};

const OMX_S16 armACMP3_TableXY33 [][2] = {
    {0, 15}, {1, 15}, {2, 15}, {3, 15}, {4, 15}, {5, 15}, {6, 15}, {7, 15}, 
    {8, 15}, {9, 15}, {10, 15}, {11, 15}, {12, 15}, {13, 15}, {14, 15}, 
    {15, 15}
};

const OMX_S16 (*armACMP3_HuffXYValues[]) [2] = {
    0,
    armACMP3_TableXY1,
    armACMP3_TableXY2,
    armACMP3_TableXY3,
    0,

    armACMP3_TableXY5,
    armACMP3_TableXY6,
    armACMP3_TableXY7,
    armACMP3_TableXY8,
    armACMP3_TableXY9,

    armACMP3_TableXY10,
    armACMP3_TableXY11,
    armACMP3_TableXY12,
    armACMP3_TableXY13,
    0,

    armACMP3_TableXY15,
    armACMP3_TableXY16,
    armACMP3_TableXY16,
    armACMP3_TableXY16,
    armACMP3_TableXY16,

    armACMP3_TableXY16,
    armACMP3_TableXY16,
    armACMP3_TableXY16,
    armACMP3_TableXY16,
    armACMP3_TableXY24,

    armACMP3_TableXY24,
    armACMP3_TableXY24,
    armACMP3_TableXY24,
    armACMP3_TableXY24,
    armACMP3_TableXY24,

    armACMP3_TableXY24,
    armACMP3_TableXY24,
    armACMP3_TableXY32,
    armACMP3_TableXY33
};

const OMX_F64 armACMP3_BflyCoeffCS [] = {
    0.8574929257125443,
    0.8817419973177052,
    0.9496286491027328,
    0.9833145924917902,
    0.9955178160675858,
    0.9991605581781475,
    0.9998991952444471,
    0.9999931550702803
};

const OMX_F64 armACMP3_BflyCoeffCA [] = {
    -0.5144957554275266,
    -0.4717319685649723,
    -0.3133774542039018,
    -0.1819131996109812,
    -0.0945741925264207,
    -0.0409655828853041,
    -0.0141985685724712,
    -0.0036999746737600
};

const OMX_F64 armACMP3_LongWindow [] = {
    0.043619387365336, 0.13052619222005157, 
    0.21643961393810288, 0.30070579950427312, 
    0.38268343236508978, 0.46174861323503386, 
    0.53729960834682389, 0.60876142900872054, 
    0.67559020761566024, 0.73727733681012397, 
    0.79335334029123517, 0.84339144581288561, 
    0.88701083317822171, 0.92387953251128674, 
    0.95371695074822693, 0.97629600711993336, 
    0.99144486137381038, 0.9990482215818578, 
    0.9990482215818578, 0.99144486137381049, 
    0.97629600711993347, 0.95371695074822693, 
    0.92387953251128674, 0.8870108331782216, 
    0.84339144581288583, 0.79335334029123517, 
    0.73727733681012408, 0.67559020761566035, 
    0.60876142900872088, 0.53729960834682411, 
    0.46174861323503391, 0.38268343236508984, 
    0.30070579950427329, 0.21643961393810318, 
    0.13052619222005155, 0.043619387365336076
};

const OMX_F64 armACMP3_ShortWindow [] = {
    0.13052619222005157, 
    0.38268343236508978, 
    0.60876142900872066, 
    0.79335334029123505, 
    0.92387953251128674, 
    0.99144486137381038, 
    0.99144486137381038, 
    0.92387953251128685, 
    0.79335334029123517, 
    0.60876142900872088, 
    0.38268343236508984, 
    0.13052619222005199
};

const OMX_F64 armACMP3_DWindow [] = {
     0.000000000,-0.000015259,-0.000015259,-0.000015259,
    -0.000015259,-0.000015259,-0.000015259,-0.000030518,
    -0.000030518,-0.000030518,-0.000030518,-0.000045776,
    -0.000045776,-0.000061035,-0.000061035,-0.000076294,
    -0.000076294,-0.000091553,-0.000106812,-0.000106812,
    -0.000122070,-0.000137329,-0.000152588,-0.000167847,
    -0.000198364,-0.000213623,-0.000244141,-0.000259399,
    -0.000289917,-0.000320435,-0.000366211,-0.000396729,
    -0.000442505,-0.000473022,-0.000534058,-0.000579834,
    -0.000625610,-0.000686646,-0.000747681,-0.000808716,
    -0.000885010,-0.000961304,-0.001037598,-0.001113892,
    -0.001205444,-0.001296997,-0.001388550,-0.001480103,
    -0.001586914,-0.001693726,-0.001785278,-0.001907349,
    -0.002014160,-0.002120972,-0.002243042,-0.002349854,
    -0.002456665,-0.002578735,-0.002685547,-0.002792358,
    -0.002899170,-0.002990723,-0.003082275,-0.003173828,
     0.003250122, 0.003326416, 0.003387451, 0.003433228,
     0.003463745, 0.003479004, 0.003479004, 0.003463745,
     0.003417969, 0.003372192, 0.003280640, 0.003173828,
     0.003051758, 0.002883911, 0.002700806, 0.002487183,
     0.002227783, 0.001937866, 0.001617432, 0.001266479,
     0.000869751, 0.000442505,-0.000030518,-0.000549316,
    -0.001098633,-0.001693726,-0.002334595,-0.003005981,
    -0.003723145,-0.004486084,-0.005294800,-0.006118774,
    -0.007003784,-0.007919312,-0.008865356,-0.009841919,
    -0.010848999,-0.011886597,-0.012939453,-0.014022827,
    -0.015121460,-0.016235352,-0.017349243,-0.018463135,
    -0.019577026,-0.020690918,-0.021789551,-0.022857666,
    -0.023910522,-0.024932861,-0.025909424,-0.026840210,
    -0.027725220,-0.028533936,-0.029281616,-0.029937744,
    -0.030532837,-0.031005859,-0.031387329,-0.031661987,
    -0.031814575,-0.031845093,-0.031738281,-0.031478882,
     0.031082153, 0.030517578, 0.029785156, 0.028884888,
     0.027801514, 0.026535034, 0.025085449, 0.023422241,
     0.021575928, 0.019531250, 0.017257690, 0.014801025,
     0.012115479, 0.009231567, 0.006134033, 0.002822876,
    -0.000686646,-0.004394531,-0.008316040,-0.012420654,
    -0.016708374,-0.021179199,-0.025817871,-0.030609131,
    -0.035552979,-0.040634155,-0.045837402,-0.051132202,
    -0.056533813,-0.061996460,-0.067520142,-0.073059082,
    -0.078628540,-0.084182739,-0.089706421,-0.095169067,
    -0.100540161,-0.105819702,-0.110946655,-0.115921021,
    -0.120697021,-0.125259399,-0.129562378,-0.133590698,
    -0.137298584,-0.140670776,-0.143676758,-0.146255493,
    -0.148422241,-0.150115967,-0.151306152,-0.151962280,
    -0.152069092,-0.151596069,-0.150497437,-0.148773193,
    -0.146362305,-0.143264771,-0.139450073,-0.134887695,
    -0.129577637,-0.123474121,-0.116577148,-0.108856201,
     0.100311279, 0.090927124, 0.080688477, 0.069595337,
     0.057617187, 0.044784546, 0.031082153, 0.016510010,
     0.001068115,-0.015228271,-0.032379150,-0.050354004,
    -0.069168091,-0.088775635,-0.109161377,-0.130310059,
    -0.152206421,-0.174789429,-0.198059082,-0.221984863,
    -0.246505737,-0.271591187,-0.297210693,-0.323318481,
    -0.349868774,-0.376800537,-0.404083252,-0.431655884,
    -0.459472656,-0.487472534,-0.515609741,-0.543823242,
    -0.572036743,-0.600219727,-0.628295898,-0.656219482,
    -0.683914185,-0.711318970,-0.738372803,-0.765029907,
    -0.791213989,-0.816864014,-0.841949463,-0.866363525,
    -0.890090942,-0.913055420,-0.935195923,-0.956481934,
    -0.976852417,-0.996246338,-1.014617920,-1.031936646,
    -1.048156738,-1.063217163,-1.077117920,-1.089782715,
    -1.101211548,-1.111373901,-1.120223999,-1.127746582,
    -1.133926392,-1.138763428,-1.142211914,-1.144287109,
     1.144989014, 1.144287109, 1.142211914, 1.138763428,
     1.133926392, 1.127746582, 1.120223999, 1.111373901,
     1.101211548, 1.089782715, 1.077117920, 1.063217163,
     1.048156738, 1.031936646, 1.014617920, 0.996246338,
     0.976852417, 0.956481934, 0.935195923, 0.913055420,
     0.890090942, 0.866363525, 0.841949463, 0.816864014,
     0.791213989, 0.765029907, 0.738372803, 0.711318970,
     0.683914185, 0.656219482, 0.628295898, 0.600219727,
     0.572036743, 0.543823242, 0.515609741, 0.487472534,
     0.459472656, 0.431655884, 0.404083252, 0.376800537,
     0.349868774, 0.323318481, 0.297210693, 0.271591187,
     0.246505737, 0.221984863, 0.198059082, 0.174789429,
     0.152206421, 0.130310059, 0.109161377, 0.088775635,
     0.069168091, 0.050354004, 0.032379150, 0.015228271,
    -0.001068115,-0.016510010,-0.031082153,-0.044784546,
    -0.057617187,-0.069595337,-0.080688477,-0.090927124,
     0.100311279, 0.108856201, 0.116577148, 0.123474121,
     0.129577637, 0.134887695, 0.139450073, 0.143264771,
     0.146362305, 0.148773193, 0.150497437, 0.151596069,
     0.152069092, 0.151962280, 0.151306152, 0.150115967,
     0.148422241, 0.146255493, 0.143676758, 0.140670776,
     0.137298584, 0.133590698, 0.129562378, 0.125259399,
     0.120697021, 0.115921021, 0.110946655, 0.105819702,
     0.100540161, 0.095169067, 0.089706421, 0.084182739,
     0.078628540, 0.073059082, 0.067520142, 0.061996460,
     0.056533813, 0.051132202, 0.045837402, 0.040634155,
     0.035552979, 0.030609131, 0.025817871, 0.021179199,
     0.016708374, 0.012420654, 0.008316040, 0.004394531,
     0.000686646,-0.002822876,-0.006134033,-0.009231567,
    -0.012115479,-0.014801025,-0.017257690,-0.019531250,
    -0.021575928,-0.023422241,-0.025085449,-0.026535034,
    -0.027801514,-0.028884888,-0.029785156,-0.030517578,
     0.031082153, 0.031478882, 0.031738281, 0.031845093,
     0.031814575, 0.031661987, 0.031387329, 0.031005859,
     0.030532837, 0.029937744, 0.029281616, 0.028533936,
     0.027725220, 0.026840210, 0.025909424, 0.024932861,
     0.023910522, 0.022857666, 0.021789551, 0.020690918,
     0.019577026, 0.018463135, 0.017349243, 0.016235352,
     0.015121460, 0.014022827, 0.012939453, 0.011886597,
     0.010848999, 0.009841919, 0.008865356, 0.007919312,
     0.007003784, 0.006118774, 0.005294800, 0.004486084,
     0.003723145, 0.003005981, 0.002334595, 0.001693726,
     0.001098633, 0.000549316, 0.000030518,-0.000442505,
    -0.000869751,-0.001266479,-0.001617432,-0.001937866,
    -0.002227783,-0.002487183,-0.002700806,-0.002883911,
    -0.003051758,-0.003173828,-0.003280640,-0.003372192,
    -0.003417969,-0.003463745,-0.003479004,-0.003479004,
    -0.003463745,-0.003433228,-0.003387451,-0.003326416,
     0.003250122, 0.003173828, 0.003082275, 0.002990723,
     0.002899170, 0.002792358, 0.002685547, 0.002578735,
     0.002456665, 0.002349854, 0.002243042, 0.002120972,
     0.002014160, 0.001907349, 0.001785278, 0.001693726,
     0.001586914, 0.001480103, 0.001388550, 0.001296997,
     0.001205444, 0.001113892, 0.001037598, 0.000961304,
     0.000885010, 0.000808716, 0.000747681, 0.000686646,
     0.000625610, 0.000579834, 0.000534058, 0.000473022,
     0.000442505, 0.000396729, 0.000366211, 0.000320435,
     0.000289917, 0.000259399, 0.000244141, 0.000213623,
     0.000198364, 0.000167847, 0.000152588, 0.000137329,
     0.000122070, 0.000106812, 0.000106812, 0.000091553,
     0.000076294, 0.000076294, 0.000061035, 0.000061035,
     0.000045776, 0.000045776, 0.000030518, 0.000030518,
     0.000030518, 0.000030518, 0.000015259, 0.000015259,
     0.000015259, 0.000015259, 0.000015259, 0.000015259
};


