/**
 *  armACAAC_IMDCTWindow.c
 * 
 * (c) Copyright 2005,2006 ARM Limited. All Rights Reserved.
 * 
 * THIS SOFTWARE IS PROVIDED “AS IS”, ARM EXPRESSLY DISCLAIMS ALL REPRESENTATIONS, 
 * WARRANTIES, CONDITIONS OR OTHER TERMS, EXPRESS, IMPLIED OR STATUTORY, INCLUDING 
 * WITHOUT LIMITATION THE IMPLIED WARRANTIES OF NON-INFRINGEMENT, MERCHANTABILITY, 
 * SATISFACTORY QUALITY, AND FITNESS FOR A PARTICULAR PURPOSE. 
 * 
 * Your use of this Software may require additional licenses, including but not 
 * limited to copyright and patent licenses from various entities. Should any 
 * such additional copyright, patent or other licenses be required, ARM expects 
 * that you will and you agree to obtain any such licenses at your own expense. 
 * You are solely responsible for obtaining any such licenses and the copyright 
 * licenses granted herein are conditioned on you obtaining such additional 
 * licenses.
 * 
 *
 * Description:
 * Look Up table for Sine and Kaiser - Bessel derived (KBD) windows in floating point format
**/

#include "omxtypes.h"

#include "armAC.h"
#include "armACAAC_Tables.h"

const OMX_F64 armACAAC_winShortKBD[ARM_AAC_WIN_SHORT]  = { 
    
    0.000000062260260087 ,0.000000232923491238 ,0.000002357561314191 ,0.000011613220675512 ,0.000036638310776092 ,0.000089904837287287 ,0.000187686087537625 ,0.000349914931514398 ,
    0.000599951289746134 ,0.000964282437464389 ,0.001472174682892901 ,0.002155290787433046 ,0.003047284517132372 ,0.004183381534921412 ,0.005599954191363990 ,0.007334096480933803 ,
    0.009423204395824544 ,0.011904566061379315 ,0.014814965330075147 ,0.018190301912394215 ,0.022065230609814378 ,0.026472821770684950 ,0.031444244701299424 ,0.037008475422417531 ,
    0.043192029858371637 ,0.050018723275851940 ,0.057509456547825653 ,0.065682029601028577 ,0.074550982209990596 ,0.084127462124071781 ,0.094419120354372638 ,0.105430033302856580 ,
    0.117160651285070620 ,0.129607772879182350 ,0.142764544426548980 ,0.156620483911738000 ,0.171161528361980260 ,0.186370103826717730 ,0.202225216926553620 ,0.218702566896935850 ,
    0.235774676994787690 ,0.253411044085566420 ,0.271578305183460040 ,0.290240419678229830 ,0.309358865948221150 ,0.328892851029965850 ,0.348799531990284850 ,0.369034247626586430 ,
    0.389550759104887680 ,0.410301498132708110 ,0.431237821255186450 ,0.452310268857323670 ,0.473468827452976750 ,0.494663193841936470 ,0.515843039719956490 ,0.536958275332824030 ,
    0.557959310774360890 ,0.578797313539521240 ,0.599424460957463160 ,0.619794186145584130 ,0.639861416144064440 ,0.659582800911524210 ,0.678916931886120680 ,0.697824548843002820 ,
    0.716268733808801290 ,0.734215090827163850 ,0.751631910406757810 ,0.768490317525286960 ,0.784764402110682550 ,0.800431330974655690 ,0.815471440235301710 ,0.829868307335690610 ,
    0.843608801845738940 ,0.856683114326691640 ,0.869084762642919010 ,0.880810575226198880 ,0.891860650935009990 ,0.902238295307333900 ,0.911949933181673830 ,0.921004997858757560 ,
    0.929415797196649460 ,0.937197357275063150 ,0.944367244530105900 ,0.950945367547071490 ,0.956953760003590450 ,0.962416346574435420 ,0.967358693936983930 ,0.971807749345521390 ,
    0.975791569564266940 ,0.979339043252648310 ,0.982479610169912140 ,0.985242980796511510 ,0.987658860143145410 ,0.989756679621150100 ,0.991565340867308850 ,0.993112975340903700 ,
    0.994426723332474950 ,0.995532535737286060 ,0.996455001551282860 ,0.997217203547717480 ,0.997840603998200630 ,0.998344961627782190 ,0.998748280259774910 ,0.999066788836821320 ,
    0.999314951727888650 ,0.999505507476156300 ,0.999649533440346020 ,0.999756533161019090 ,0.999834542770122510 ,0.999890252378866200 ,0.999929138142745750 ,0.999955600623806950 ,
    0.999973105152739740 ,0.999984320133600170 ,0.999991249621184020 ,0.999995357017759210 ,0.999997677358115400 ,0.999998916350266280 ,0.999999535079584280 ,0.999999820029210620 ,
    0.999999938779770340 ,0.999999982386967970 ,0.999999995958561930 ,0.999999999328819000 ,0.999999999932568380 ,0.999999999997222780 ,0.999999999999974800 ,1.000000000000000000 
};

const OMX_F64 armACAAC_winShortSine[ARM_AAC_WIN_SHORT]  = { 
    
    0.006135884649154475 ,0.018406729905804820 ,0.030674803176636626 ,0.042938256934940820 ,0.055195244349689941 ,0.067443919563664051 ,0.079682437971430126 ,0.091908956497132724 ,
    0.104121633872054590 ,0.116318630911904750 ,0.128498110793793170 ,0.140658239332849210 ,0.152797185258443440 ,0.164913120489969920 ,0.177004220412148750 ,0.189068664149806190 ,
    0.201104634842091900 ,0.213110319916091360 ,0.225083911359792830 ,0.237023605994367200 ,0.248927605745720150 ,0.260794117915275510 ,0.272621355449948980 ,0.284407537211271880 ,
    0.296150888243623790 ,0.307849640041534870 ,0.319502030816015690 ,0.331106305759876430 ,0.342660717311994380 ,0.354163525420490340 ,0.365612997804773850 ,0.377007410216418260 ,
    0.388345046698826250 ,0.399624199845646790 ,0.410843171057903910 ,0.422000270799799680 ,0.433093818853151960 ,0.444122144570429200 ,0.455083587126343840 ,0.465976495767966180 ,
    0.476799230063322090 ,0.487550160148436000 ,0.498227666972781810 ,0.508830142543106990 ,0.519355990165589640 ,0.529803624686294610 ,0.540171472729892850 ,0.550457972936604810 ,
    0.560661576197336030 ,0.570780745886967260 ,0.580813958095764530 ,0.590759701858874160 ,0.600616479383868970 ,0.610382806276309480 ,0.620057211763289100 ,0.629638238914926980 ,
    0.639124444863775730 ,0.648514401022112440 ,0.657806693297078640 ,0.666999922303637470 ,0.676092703575315920 ,0.685083667772700360 ,0.693971460889653890 ,0.702754744457225300 ,
    0.711432195745216430 ,0.720002507961381650 ,0.728464390448225200 ,0.736816568877369790 ,0.745057785441465950 ,0.753186799043612410 ,0.761202385484261780 ,0.769103337645579590 ,
    0.776888465673232440 ,0.784556597155575240 ,0.792106577300212280 ,0.799537269107905010 ,0.806847553543799220 ,0.814036329705948300 ,0.821102514991104650 ,0.828045045257755690 ,
    0.834862874986380010 ,0.841554977436898330 ,0.848120344803297120 ,0.854557988365400530 ,0.860866938637767310 ,0.867046245515692650 ,0.873094978418289980 ,0.879012226428633410 ,
    0.884797098430937790 ,0.890448723244757880 ,0.895966249756185110 ,0.901348847046022030 ,0.906595704514915330 ,0.911706032005429880 ,0.916679059921042700 ,0.921514039342041900 ,
    0.926210242138311380 ,0.930766961078983710 ,0.935183509938947500 ,0.939459223602189920 ,0.943593458161960390 ,0.947585591017741090 ,0.951435020969008340 ,0.955141168305770670 ,
    0.958703474895871600 ,0.962121404269041580 ,0.965394441697689400 ,0.968522094274417270 ,0.971503890986251780 ,0.974339382785575860 ,0.977028142657754390 ,0.979569765685440520 ,
    0.981963869109555240 ,0.984210092386929030 ,0.986308097244598670 ,0.988257567730749460 ,0.990058210262297120 ,0.991709753669099530 ,0.993211949234794500 ,0.994564570734255420 ,
    0.995767414467659820 ,0.996820299291165670 ,0.997723066644191640 ,0.998475580573294770 ,0.999077727752645360 ,0.999529417501093140 ,0.999830581795823400 ,0.999981175282601110 
};
const OMX_F64 armACAAC_winLongKBD[ARM_AAC_WIN_LONG]   = { 

    0.000000564149397116 ,0.000000829129083519 ,0.000001054185629471 ,0.000001262423576171 ,0.000001462478387831 ,0.000001658700182861 ,0.000001853710789943 ,0.000002049346596080 ,
    0.000002247111447241 ,0.000002448460189601 ,0.000002655030932598 ,0.000002868877915863 ,0.000003092729230265 ,0.000003330277365869 ,0.000003586496242451 ,0.000003867962693209 ,
    0.000004183143722739 ,0.000004542597538193 ,0.000004959034244982 ,0.000005447199516632 ,0.000006023583465905 ,0.000006706006486323 ,0.000007513171800169 ,0.000008464280396819 ,
    0.000009578774845032 ,0.000010876231113412 ,0.000012376375883503 ,0.000014099185517104 ,0.000016065022013645 ,0.000018294772445515 ,0.000020809972394593 ,0.000023632905409733 ,
    0.000026786677825642 ,0.000030295271962072 ,0.000034183581975284 ,0.000038477436566971 ,0.000043203612121771 ,0.000048389839067921 ,0.000054064803537603 ,0.000060258145815945 ,
    0.000067000456618798 ,0.000074323271910992 ,0.000082259066743541 ,0.000090841248426199 ,0.000100104149240963 ,0.000110083018827494 ,0.000120814016321877 ,0.000132334202297617 ,
    0.000144681530536885 ,0.000157894839646862 ,0.000172013844527960 ,0.000187079127696057 ,0.000203132130458325 ,0.000220215143941128 ,0.000238371299968159 ,0.000257644561787176 ,
    0.000278079714644211 ,0.000299722356204721 ,0.000322618886821800 ,0.000346816499652246 ,0.000372363170621842 ,0.000399307648241792 ,0.000427699443278699 ,0.000457588818280912 ,
    0.000489026776964405 ,0.000522065053461652 ,0.000556756101437189 ,0.000593153083073775 ,0.000631309857933181 ,0.000671280971695777 ,0.000713121644783167 ,0.000756887760868173 ,
    0.000802635855276514 ,0.000850423103284534 ,0.000900307308317348 ,0.000952346890051732 ,0.001006600872428104 ,0.001063128871575849 ,0.001121991083656270 ,0.001183248272627318 ,
    0.001246961757934282 ,0.001313193402130484 ,0.001382005598432035 ,0.001453461258210578 ,0.001527623798427931 ,0.001604557129016450 ,0.001684325640208851 ,0.001766994189821202 ,
    0.001852628090492689 ,0.001941293096885700 ,0.002033055392849726 ,0.002127981578552470 ,0.002226138657581518 ,0.002327594024019853 ,0.002432415449498413 ,0.002540671070228845 ,
    0.002652429374019539 ,0.002767759187277947 ,0.002886729662002163 ,0.003009410262764637 ,0.003135870753690875 ,0.003266181185435891 ,0.003400411882161129 ,0.003538633428514523 ,
    0.003680916656616285 ,0.003827332633052993 ,0.003977952645882454 ,0.004132848191651807 ,0.004292090962431235 ,0.004455752832865656 ,0.004623905847246667 ,0.004796622206606990 ,
    0.004973974255839619 ,0.005156034470843828 ,0.005342875445700126 ,0.005534569879876238 ,0.005731190565466120 ,0.005932810374463984 ,0.006139502246075275 ,0.006351339174066464 ,
    0.006568394194155550 ,0.006790740371445046 ,0.007018450787899233 ,0.007251598529867427 ,0.007490256675654946 ,0.007734498283143434 ,0.007984396377462186 ,0.008240023938712027 ,
    0.008501453889743354 ,0.008768759083989807 ,0.009042012293359098 ,0.009321286196182421 ,0.009606653365223899 ,0.009898186255751435 ,0.010195957193670332 ,0.010500038363721025 ,
    0.010810501797742204 ,0.011127419363000633 ,0.011450862750588858 ,0.011780903463892069 ,0.012117612807125283 ,0.012461061873941972 ,0.012811321536115342 ,0.013168462432293290 ,
    0.013532554956828192 ,0.013903669248682506 ,0.014281875180411272 ,0.014667242347222498 ,0.015059840056116389 ,0.015459737315104426 ,0.015867002822509167 ,0.016281704956345729 ,
    0.016703911763785807 ,0.017133690950705122 ,0.017571109871315108 ,0.018016235517879682 ,0.018469134510517897 ,0.018929873087093242 ,0.019398517093190348 ,0.019875131972179862 ,
    0.020359782755372167 ,0.020852534052260681 ,0.021353450040855395 ,0.021862594458107301 ,0.022380030590424378 ,0.022905821264279723 ,0.023440028836912454 ,0.023982715187121972 ,
    0.024533941706156106 ,0.025093769288693779 ,0.025662258323922608 ,0.026239468686712068 ,0.026825459728882627 ,0.027420290270571419 ,0.028024018591694816 ,0.028636702423508451 ,
    0.029258398940265069 ,0.029889164750970629 ,0.030529055891239068 ,0.031178127815246103 ,0.031836435387782462 ,0.032504032876406901 ,0.033180973943699267 ,0.033867311639614150 ,
    0.034563098393935093 ,0.035268386008830047 ,0.035983225651508070 ,0.036707667846977626 ,0.037441762470906824 ,0.038185558742585744 ,0.038939105217991092 ,0.039702449782953432 ,
    0.040475639646427253 ,0.041258721333863893 ,0.042051740680687726 ,0.042854742825875577 ,0.043667772205639700 ,0.044490872547214295 ,0.045324086862745812 ,0.046167457443287145 ,
    0.047021025852895783 ,0.047884832922836067 ,0.048758918745885574 ,0.049643322670745817 ,0.050538083296557172 ,0.051443238467518235 ,0.052358825267609543 ,0.053284880015421775 ,
    0.054221438259088338 ,0.055168534771322567 ,0.056126203544559231 ,0.057094477786200637 ,0.058073389913967148 ,0.059062971551352074 ,0.060063253523181030 ,0.061074265851275546 ,
    0.062096037750221073 ,0.063128597623239052 ,0.064171973058163273 ,0.065226190823520186 ,0.066291276864713242 ,0.067367256300311054 ,0.068454153418439329 ,0.069551991673276428 ,
    0.070660793681652428 ,0.071780581219751588 ,0.072911375219917945 ,0.074053195767564084 ,0.075206062098182785 ,0.076369992594461394 ,0.077545004783498739 ,0.078731115334124468 ,
    0.079928340054320618 ,0.081136693888745018 ,0.082356190916356625 ,0.083586844348142370 ,0.084828666524945320 ,0.086081668915393983 ,0.087345862113932499 ,0.088621255838951404 ,
    0.089907858931018825 ,0.091205679351211835 ,0.092514724179547550 ,0.093834999613513950 ,0.095166510966699855 ,0.096509262667524048 ,0.097863258258063121 ,0.099228500392977648 ,
    0.100604990838536650 ,0.101992730471739680 ,0.103391719279536620 ,0.104801956358144500 ,0.106223439912461290 ,0.107656167255576060 ,0.109100134808375450 ,0.110555338099245930 ,
    0.112021771763871510 ,0.113499429545126600 ,0.114988304293063530 ,0.116488387964994750 ,0.117999671625668590 ,0.119522145447538990 ,0.121055798711128470 ,0.122600619805483720 ,
    0.124156596228723900 ,0.125723714588680810 ,0.127301960603630940 ,0.128891319103118460 ,0.130491774028869360 ,0.132103308435795680 ,0.133725904493089990 ,0.135359543485409350 ,
    0.137004205814148210 ,0.138659870998800230 ,0.140326517678408170 ,0.142004123613101660 ,0.143692665685722230 ,0.145392119903535260 ,0.147102461400028330 ,0.148823664436795460 ,
    0.150555702405506950 ,0.152298547829964100 ,0.154052172368238450 ,0.155816546814895230 ,0.157591641103300100 ,0.159377424308009140 ,0.161173864647241400 ,0.162980929485433440 ,
    0.164798585335875460 ,0.166626797863428460 ,0.168465531887322160 ,0.170314751384032540 ,0.172174419490239430 ,0.174044498505862590 ,0.175924949897176660 ,0.177815734300003860 ,
    0.179716811522984100 ,0.181628140550922130 ,0.183549679548210910 ,0.185481385862330820 ,0.187423216027424070 ,0.189375125767944020 ,0.191337070002378510 ,0.193309002847046750 ,
    0.195290877619969550 ,0.197282646844811670 ,0.199284262254896510 ,0.201295674797291800 ,0.203316834636966400 ,0.205347691161017170 ,0.207388192982965570 ,0.209438287947123300 ,
    0.211497923133026590 ,0.213567044859938160 ,0.215645598691416830 ,0.217733529439953780 ,0.219830781171674760 ,0.221937297211108300 ,0.224053020146018630 ,0.226177891832303000 ,
    0.228311853398952960 ,0.230454845253078690 ,0.232606807084995980 ,0.234767677873375210 ,0.236937395890451760 ,0.239115898707296990 ,0.241303123199149790 ,0.243499005550807140 ,
    0.245703481262074170 ,0.247916485153272080 ,0.250137951370804080 ,0.252367813392778310 ,0.254606004034686970 ,0.256852455455141850 ,0.259107099161664580 ,0.261369866016531450 ,
    0.263640686242672780 ,0.265919489429624730 ,0.268206204539534480 ,0.270500759913217370 ,0.272803083276265010 ,0.275113101745204700 ,0.277430741833708750 ,0.279755929458853250 ,
    0.282088589947426030 ,0.284428648042282180 ,0.286776027908747950 ,0.289130653141070890 ,0.291492446768916780 ,0.293861331263911780 ,0.296237228546229800 ,0.298620059991224150 ,
    0.301009746436103010 ,0.303406208186647370 ,0.305809365023972210 ,0.308219136211328570 ,0.310635440500947320 ,0.313058196140922670 ,0.315487320882136100 ,0.317922731985218920 ,
    0.320364346227553440 ,0.322812079910311740 ,0.325265848865531730 ,0.327725568463229480 ,0.330191153618547390 ,0.332662518798937550 ,0.335139578031379280 ,0.337622244909630780 ,
    0.340110432601513470 ,0.342604053856229160 ,0.345103021011708980 ,0.347607246001992780 ,0.350116640364639850 ,0.352631115248168870 ,0.355150581419526930 ,0.357674949271587270 ,
    0.360204128830674210 ,0.362738029764116010 ,0.365276561387823380 ,0.367819632673893840 ,0.370367152258241460 ,0.372919028448250640 ,0.375475169230453820 ,0.378035482278232080 ,
    0.380599874959537950 ,0.383168254344640470 ,0.385740527213890290 ,0.388316600065506220 ,0.390896379123380490 ,0.393479770344903450 ,0.396066679428806360 ,0.398657011823022270 ,
    0.401250672732562990 ,0.403847567127412990 ,0.406447599750438870 ,0.409050675125313350 ,0.411656697564453720 ,0.414265571176974050 ,0.416877199876649780 ,0.419491487389895000 ,
    0.422108337263750910 ,0.424727652873885480 ,0.427349337432602840 ,0.429973293996862400 ,0.432599425476306980 ,0.435227634641298770 ,0.437857824130962800 ,0.440489896461237260 ,
    0.443123754032930080 ,0.445759299139780800 ,0.448396433976526900 ,0.451035060646974910 ,0.453675081172074390 ,0.456316397497994690 ,0.458958911504204090 ,0.461602525011549970 ,
    0.464247139790339880 ,0.466892657568422740 ,0.469538980039269250 ,0.472186008870051020 ,0.474833645709717590 ,0.477481792197071320 ,0.480130349968838520 ,0.482779220667736380 ,
    0.485428305950536040 ,0.488077507496119440 ,0.490726727013531090 ,0.493375866250022110 ,0.496024826999088010 ,0.498673511108497780 ,0.501321820488314530 ,0.503969657118907070 ,
    0.506616923058950560 ,0.509263520453418380 ,0.511909351541560140 ,0.514554318664870110 ,0.517198324275041640 ,0.519841270941908350 ,0.522483061361372240 ,0.525123598363315680 ,
    0.527762784919500020 ,0.530400524151446560 ,0.533036719338301770 ,0.535671273924685390 ,0.538304091528519880 ,0.540935075948842380 ,0.543564131173596250 ,0.546191161387403870 ,
    0.548816070979318060 ,0.551438764550552960 ,0.554059146922192710 ,0.556677123142877870 ,0.559292598496468510 ,0.561905478509683860 ,0.564515668959717500 ,0.567123075881826870 ,
    0.569727605576898280 ,0.572329164618984640 ,0.574927659862816460 ,0.577522998451285410 ,0.580115087822899440 ,0.582703835719209360 ,0.585289150192205290 ,0.587870939611683570 ,
    0.590449112672582490 ,0.593023578402287030 ,0.595594246167900800 ,0.598161025683485950 ,0.600723827017269900 ,0.603282560598817570 ,0.605837137226169050 ,0.608387468072942970 ,
    0.610933464695402990 ,0.613475039039488410 ,0.616012103447807550 ,0.618544570666594070 ,0.621072353852623830 ,0.623595366580093850 ,0.626113522847461690 ,0.628626737084243990 ,
    0.631134924157775170 ,0.633637999379923930 ,0.636135878513768850 ,0.638628477780230460 ,0.641115713864660490 ,0.643597503923387550 ,0.646073765590218340 ,0.648544416982894220 ,
    0.651009376709500880 ,0.653468563874833990 ,0.655921898086716420 ,0.658369299462268850 ,0.660810688634132170 ,0.663245986756641930 ,0.665675115511952690 ,0.668097997116113840 ,
    0.670514554325094330 ,0.672924710440756750 ,0.675328389316780520 ,0.677725515364532180 ,0.680116013558883740 ,0.682499809443978030 ,0.684876829138939660 ,0.687246999343532510 ,
    0.689610247343761530 ,0.691966501017419970 ,0.694315688839580390 ,0.696657739888028590 ,0.698992583848641270 ,0.701320151020705550 ,0.703640372322180910 ,0.705953179294901310 ,
    0.708258504109719360 ,0.710556279571589620 ,0.712846439124592220 ,0.715128916856895500 ,0.717403647505656550 ,0.719670566461860560 ,0.721929609775097900 ,0.724180714158277230 ,
    0.726423816992275540 ,0.728658856330524520 ,0.730885770903531910 ,0.733104500123337500 ,0.735314984087904740 ,0.737517163585444500 ,0.739710980098673420 ,0.741896375809005030 ,
    0.744073293600673090 ,0.746241677064786280 ,0.748401470503315290 ,0.750552618933010170 ,0.752695068089248020 ,0.754828764429811280 ,0.756953655138594580 ,0.759069688129241250 ,
    0.761176812048708020 ,0.763274976280758130 ,0.765364130949381270 ,0.767444226922141310 ,0.769515215813451060 ,0.771577049987771320 ,0.773629682562738670 ,0.775673067412215760 ,
    0.777707159169267910 ,0.779731913229064430 ,0.781747285751702830 ,0.783753233664957530 ,0.785749714666951090 ,0.787736687228749010 ,0.789714110596875800 ,0.791681944795753930 ,
    0.793640150630063660 ,0.795588689687024450 ,0.797527524338596420 ,0.799456617743603100 ,0.801375933849773350 ,0.803285437395703240 ,0.805185093912736850 ,0.807074869726766010 ,
    0.808954731959948830 ,0.810824648532346040 ,0.812684588163475110 ,0.814534520373781380 ,0.816374415486027520 ,0.818204244626598130 ,0.820023979726722140 ,0.821833593523610300 ,
    0.823633059561508900 ,0.825422352192669350 ,0.827201446578232020 ,0.828970318689025490 ,0.830728945306280830 ,0.832477304022258950 ,0.834215373240793420 ,0.835943132177746070 ,
    0.837660560861376300 ,0.839367640132623880 ,0.841064351645304580 ,0.842750677866218820 ,0.844426602075172170 ,0.846092108364909000 ,0.847747181640957970 ,0.849391807621388660 ,
    0.851025972836481510 ,0.852649664628307490 ,0.854262871150220370 ,0.855865581366259450 ,0.857457785050463990 ,0.859039472786097270 ,0.860610635964782380 ,0.862171266785548670 ,
    0.863721358253787600 ,0.865260904180119810 ,0.866789899179172150 ,0.868308338668264400 ,0.869816218866006690 ,0.871313536790806360 ,0.872800290259284850 ,0.874276477884604500 ,
    0.875742099074704460 ,0.877197154030447730 ,0.878641643743676150 ,0.880075569995176440 ,0.881498935352555300 ,0.882911743168024120 ,0.884313997576093970 ,0.885705703491179390 ,
    0.887086866605113160 ,0.888457493384569590 ,0.889817591068398970 ,0.891167167664870810 ,0.892506231948828500 ,0.893834793458752390 ,0.895152862493735050 ,0.896460450110365790 ,
    0.897757568119525670 ,0.899044229083094230 ,0.900320446310565850 ,0.901586233855578230 ,0.902841606512351680 ,0.904086579812039770 ,0.905321170018992040 ,0.906545394126928360 ,
    0.907759269855025970 ,0.908962815643918450 ,0.910156050651607650 ,0.911338994749288700 ,0.912511668517088980 ,0.913674093239719380 ,0.914826290902041150 ,0.915968284184546460 ,
    0.917100096458753570 ,0.918221751782517640 ,0.919333274895257070 ,0.920434691213095620 ,0.921526026823921040 ,0.922607308482360940 ,0.923678563604675820 ,0.924739820263570380 ,
    0.925791107182922120 ,0.926832453732430840 ,0.927863889922185380 ,0.928885446397152430 ,0.929897154431584600 ,0.930899045923350600 ,0.931891153388186180 ,0.932873509953869200 ,
    0.933846149354316310 ,0.934809105923604220 ,0.935762414589915600 ,0.936706110869409250 ,0.937640230860017470 ,0.938564811235169110 ,0.939479889237441080 ,0.940385502672137050 ,
    0.941281689900795750 ,0.942168489834629090 ,0.943045941927890930 ,0.943914086171177670 ,0.944772963084660630 ,0.945622613711253000 ,0.946463079609709320 ,0.947294402847662090 ,
    0.948116625994593120 ,0.948929792114742710 ,0.949733944759956540 ,0.950529127962472800 ,0.951315386227648110 ,0.952092764526625170 ,0.952861308288943780 ,0.953621063395093890 ,
    0.954372076169014090 ,0.955114393370535280 ,0.955848062187771630 ,0.956573130229459670 ,0.957289645517245940 ,0.957997656477925670 ,0.958697211935633060 ,0.959388361103984620 ,
    0.960071153578176070 ,0.960745639327035720 ,0.961411868685034030 ,0.962069892344251550 ,0.962719761346305990 ,0.963361527074241280 ,0.963995241244376850 ,0.964620955898123360 ,
    0.965238723393760820 ,0.965848596398184990 ,0.966450627878621130 ,0.967044871094307480 ,0.967631379588149040 ,0.968210207178345160 ,0.968781407949989680 ,0.969345036246647580 ,
    0.969901146661908410 ,0.970449794030918800 ,0.970991033421894410 ,0.971524920127614820 ,0.972051509656900900 ,0.972570857726078650 ,0.973083020250428810 ,0.973588053335625040 ,
    0.974086013269162890 ,0.974576956511780450 ,0.975060939688871530 ,0.975538019581896230 ,0.976008253119786670 ,0.976471697370352440 ,0.976928409531686250 ,0.977378446923571790 ,
    0.977821866978896500 ,0.978258727235069010 ,0.978689085325445180 ,0.979112998970762980 ,0.979530525970589540 ,0.979941724194780090 ,0.980346651574952820 ,0.980745366095980510 ,
    0.981137925787499700 ,0.981524388715441790 ,0.981904812973585560 ,0.982279256675134270 ,0.982647777944318120 ,0.983010434908025750 ,0.983367285687464450 ,0.983718388389852700 ,
    0.984063801100145800 ,0.984403581872797080 ,0.984737788723556440 ,0.985066479621307560 ,0.985389712479946780 ,0.985707545150304010 ,0.986020035412109140 ,0.986327240966004660 ,
    0.986629219425606220 ,0.986926028309614290 ,0.987217725033977420 ,0.987504366904109250 ,0.987786011107162130 ,0.988062714704357030 ,0.988334534623373950 ,0.988601527650802890 ,
    0.988863750424658350 ,0.989121259426957280 ,0.989374110976365180 ,0.989622361220909410 ,0.989866066130762890 ,0.990105281491098890 ,0.990340062895020410 ,0.990570465736563040 ,
    0.990796545203776140 ,0.991018356271881510 ,0.991235953696512070 ,0.991449392007032970 ,0.991658725499944940 ,0.991864008232372860 ,0.992065294015641360 ,0.992262636408937080 ,
    0.992456088713061570 ,0.992645703964273320 ,0.992831534928224620 ,0.993013634093989460 ,0.993192053668188630 ,0.993366845569210180 ,0.993538061421528010 ,0.993705752550119950 ,
    0.993869969974985560 ,0.994030764405765990 ,0.994188186236467430 ,0.994342285540286700 ,0.994493112064544600 ,0.994640715225723500 ,0.994785144104613380 ,0.994926447441566110 ,
    0.995064673631859130 ,0.995199870721169780 ,0.995332086401161000 ,0.995461368005179040 ,0.995587762504064330 ,0.995711316502077120 ,0.995832076232936570 ,0.995950087555976470 ,
    0.996065395952416610 ,0.996178046521750680 ,0.996288083978252640 ,0.996395552647600380 ,0.996500496463617820 ,0.996602958965136730 ,0.996702983292977460 ,0.996800612187050290 ,
    0.996895887983575870 ,0.996988852612427420 ,0.997079547594593500 ,0.997168014039761410 ,0.997254292644021880 ,0.997338423687695870 ,0.997420447033282030 ,0.997500402123526310 ,
    0.997578327979611880 ,0.997654263199472480 ,0.997728245956225220 ,0.997800313996725310 ,0.997870504640242070 ,0.997938854777255300 ,0.998005400868372420 ,0.998070178943364920 ,
    0.998133224600326050 ,0.998194573004946520 ,0.998254258889909040 ,0.998312316554402560 ,0.998368779863752720 ,0.998423682249170220 ,0.998477056707615440 ,0.998528935801779040 ,
    0.998579351660177080 ,0.998628335977361230 ,0.998675920014241440 ,0.998722134598521770 ,0.998767010125247270 ,0.998810576557461970 ,0.998852863426976100 ,0.998893899835242130 ,
    0.998933714454337430 ,0.998972335528054420 ,0.999009790873095050 ,0.999046107880368960 ,0.999081313516395180 ,0.999115434324803990 ,0.999148496427939460 ,0.999180525528560400 ,
    0.999211546911638600 ,0.999241585446252300 ,0.999270665587574490 ,0.999298811378953710 ,0.999326046454085740 ,0.999352394039275000 ,0.999377876955783840 ,0.999402517622268500 ,
    0.999426338057299190 ,0.999449359881962710 ,0.999471604322547560 ,0.999493092213306510 ,0.999513843999298320 ,0.999533879739304850 ,0.999553219108821110 ,0.999571881403118480 ,
    0.999589885540377530 ,0.999607250064889260 ,0.999623993150322130 ,0.999640132603054180 ,0.999655685865566750 ,0.999670670019899070 ,0.999685101791160770 ,0.999698997551101140 ,
    0.999712373321732460 ,0.999725244779005370 ,0.999737627256534920 ,0.999749535749374200 ,0.999760984917834160 ,0.999771989091347900 ,0.999782562272375720 ,0.999792718140351200 ,
    0.999802470055663580 ,0.999811831063677100 ,0.999820813898782630 ,0.999829430988481200 ,0.999837694457496480 ,0.999845616131914580 ,0.999853207543349050 ,0.999860479933128100 ,
    0.999867444256503420 ,0.999874111186877300 ,0.999880491120046620 ,0.999886594178460710 ,0.999892430215493340 ,0.999898008819723900 ,0.999903339319226810 ,0.999908430785868550 ,
    0.999913292039608210 ,0.999917931652801070 ,0.999922357954502020 ,0.999926579034768000 ,0.999930602748956730 ,0.999934436722020540 ,0.999938088352792630 ,0.999941564818264020 ,
    0.999944873077850180 ,0.999948019877644590 ,0.999951011754657840 ,0.999953855041040280 ,0.999956555868286910 ,0.999959120171421970 ,0.999961553693162970 ,0.999963861988061090 ,
    0.999966050426616680 ,0.999968124199369200 ,0.999970088320958460 ,0.999971947634157530 ,0.999973706813873760 ,0.999975370371118390 ,0.999976942656942040 ,0.999978427866335400 ,
    0.999979830042093120 ,0.999981153078640660 ,0.999982400725821900 ,0.999983576592645810 ,0.999984684150993510 ,0.999985726739281660 ,0.999986707566082100 ,0.999987629713697810 ,
    0.999988496141692830 ,0.999989309690375250 ,0.999990073084233160 ,0.999990788935322010 ,0.999991459746603310 ,0.999992087915231860 ,0.999992675735794420 ,0.999993225403494780 ,
    0.999993739017288160 ,0.999994218582962340 ,0.999994666016165050 ,0.999995083145379220 ,0.999995471714841380 ,0.999995833387407830 ,0.999996169747364050 ,0.999996482303179720 ,
    0.999996772490207020 ,0.999997041673323590 ,0.999997291149519740 ,0.999997522150427700 ,0.999997735844796340 ,0.999997933340908250 ,0.999998115688939590 ,0.999998283883265620 ,
    0.999998438864706960 ,0.999998581522721810 ,0.999998712697540260 ,0.999998833182243580 ,0.999998943724786590 ,0.999999045029965950 ,0.999999137761331540 ,0.999999222543043850 ,
    0.999999299961676580 ,0.999999370567965060 ,0.999999434878500510 ,0.999999493377372480 ,0.999999546517756690 ,0.999999594723452120 ,0.999999638390366320 ,0.999999677887949080 ,
    0.999999713560576710 ,0.999999745728886610 ,0.999999774691062160 ,0.999999800724070910 ,0.999999824084853660 ,0.999999845011468770 ,0.999999863724189700 ,0.999999880426557630 ,
    0.999999895306390330 ,0.999999908536747920 ,0.999999920276856800 ,0.999999930672991200 ,0.999999939859315010 ,0.999999947958684630 ,0.999999955083412550 ,0.999999961335994450 ,
    0.999999966809798410 ,0.999999971589720320 ,0.999999975752803970 ,0.999999979368827670 ,0.999999982500858970 ,0.999999985205777600 ,0.999999987534768820 ,0.999999989533786330 ,
    0.999999991243988420 ,0.999999992702145680 ,0.999999993941023460 ,0.999999994989738680 ,0.999999995874092830 ,0.999999996616881990 ,0.999999997238184670 ,0.999999997755628420 ,
    0.999999998184636920 ,0.999999998538657510 ,0.999999998829370740 ,0.999999999066882970 ,0.999999999259902570 ,0.999999999415900450 ,0.999999999541257400 ,0.999999999641396080 ,
    0.999999999720902030 ,0.999999999783631630 ,0.999999999832809740 ,0.999999999871116650 ,0.999999999900765600 ,0.999999999923571690 ,0.999999999941012850 ,0.999999999954282570 ,
    0.999999999964336970 ,0.999999999971935120 ,0.999999999977673640 ,0.999999999982017160 ,0.999999999985322960 ,0.999999999987862930 ,0.999999999989841350 ,0.999999999991409650 ,
    0.999999999992678410 ,0.999999999993727570 ,0.999999999994613640 ,0.999999999995376590 ,0.999999999996043830 ,0.999999999996634470 ,0.999999999997161600 ,0.999999999997634340 ,
    0.999999999998059220 ,0.999999999998440910 ,0.999999999998783420 ,0.999999999999089620 ,0.999999999999362290 ,0.999999999999603430 ,0.999999999999815370 ,1.000000000000000000 

};

const OMX_F64 armACAAC_winLongSine[ARM_AAC_WIN_LONG]   = {     

    0.000766990318742704 ,0.002300969151425805 ,0.003834942569706228 ,0.005368906963996342 ,0.006902858724729756 ,0.008436794242369799 ,0.009970709907418031 ,0.011504602110422714 ,
    0.013038467241987334 ,0.014572301692779064 ,0.016106101853537287 ,0.017639864115082053 ,0.019173584868322623 ,0.020707260504265895 ,0.022240887414024961 ,0.023774461988827555 ,
    0.025307980620024571 ,0.026841439699098531 ,0.028374835617672099 ,0.029908164767516555 ,0.031441423540560301 ,0.032974608328897335 ,0.034507715524795750 ,0.036040741520706229 ,
    0.037573682709270494 ,0.039106535483329888 ,0.040639296235933736 ,0.042171961360347947 ,0.043704527250063421 ,0.045236990298804590 ,0.046769346900537863 ,0.048301593449480144 ,
    0.049833726340107277 ,0.051365741967162593 ,0.052897636725665324 ,0.054429407010919133 ,0.055961049218520569 ,0.057492559744367566 ,0.059023934984667931 ,0.060555171335947788 ,
    0.062086265195060088 ,0.063617212959193106 ,0.065148011025878833 ,0.066678655793001557 ,0.068209143658806329 ,0.069739471021907307 ,0.071269634281296401 ,0.072799629836351673 ,
    0.074329454086845756 ,0.075859103432954447 ,0.077388574275265049 ,0.078917863014784942 ,0.080446966052950014 ,0.081975879791633066 ,0.083504600633152432 ,0.085033124980280275 ,
    0.086561449236251170 ,0.088089569804770507 ,0.089617483090022959 ,0.091145185496681005 ,0.092672673429913310 ,0.094199943295393204 ,0.095726991499307162 ,0.097253814448363271 ,
    0.098780408549799623 ,0.100306770211392860 ,0.101832895841466530 ,0.103358781848899610 ,0.104884424643134970 ,0.106409820634187680 ,0.107934966232653650 ,0.109459857849717980 ,
    0.110984491897163390 ,0.112508864787378690 ,0.114032972933367200 ,0.115556812748755260 ,0.117080380647800590 ,0.118603673045400720 ,0.120126686357101510 ,0.121649416999105530 ,
    0.123171861388280480 ,0.124694015942167640 ,0.126215877078990350 ,0.127737441217662310 ,0.129258704777796140 ,0.130779664179711710 ,0.132300315844444650 ,0.133820656193754720 ,
    0.135340681650134210 ,0.136860388636816380 ,0.138379773577783890 ,0.139898832897777210 ,0.141417563022303020 ,0.142935960377642670 ,0.144454021390860470 ,0.145971742489812210 ,
    0.147489120103153570 ,0.149006150660348450 ,0.150522830591677400 ,0.152039156328246050 ,0.153555124301993450 ,0.155070730945700510 ,0.156585972692998430 ,0.158100845978376980 ,
    0.159615347237193060 ,0.161129472905678810 ,0.162643219420950310 ,0.164156583221015810 ,0.165669560744784120 ,0.167182148432072940 ,0.168694342723617330 ,0.170206140061078070 ,
    0.171717536887049970 ,0.173228529645070320 ,0.174739114779627200 ,0.176249288736167910 ,0.177759047961107170 ,0.179268388901835750 ,0.180777308006728590 ,0.182285801725153300 ,
    0.183793866507478450 ,0.185301498805081900 ,0.186808695070359270 ,0.188315451756732120 ,0.189821765318656410 ,0.191327632211630900 ,0.192833048892205230 ,0.194338011817988600 ,
    0.195842517447657850 ,0.197346562240965920 ,0.198850142658750090 ,0.200353255162940450 ,0.201855896216568050 ,0.203358062283773320 ,0.204859749829814420 ,0.206360955321075510 ,
    0.207861675225075070 ,0.209361906010474160 ,0.210861644147084860 ,0.212360886105878420 ,0.213859628358993750 ,0.215357867379745550 ,0.216855599642632620 ,0.218352821623346320 ,
    0.219849529798778700 ,0.221345720647030810 ,0.222841390647421120 ,0.224336536280493600 ,0.225831154028026170 ,0.227325240373038860 ,0.228818791799802220 ,0.230311804793845440 ,
    0.231804275841964780 ,0.233296201432231620 ,0.234787578054000970 ,0.236278402197919570 ,0.237768670355934190 ,0.239258379021299980 ,0.240747524688588430 ,0.242236103853696010 ,
    0.243724113013852160 ,0.245211548667627540 ,0.246698407314942410 ,0.248184685457074780 ,0.249670379596668550 ,0.251155486237741920 ,0.252640001885695520 ,0.254123923047320620 ,
    0.255607246230807380 ,0.257089967945753120 ,0.258572084703170340 ,0.260053593015495190 ,0.261534489396595520 ,0.263014770361779000 ,0.264494432427801630 ,0.265973472112875590 ,
    0.267451885936677620 ,0.268929670420357260 ,0.270406822086544820 ,0.271883337459359720 ,0.273359213064418680 ,0.274834445428843940 ,0.276309031081271080 ,0.277782966551857640 ,
    0.279256248372291180 ,0.280728873075797190 ,0.282200837197147560 ,0.283672137272668430 ,0.285142769840248670 ,0.286612731439347790 ,0.288082018611004130 ,0.289550627897843030 ,
    0.291018555844085090 ,0.292485798995553880 ,0.293952353899684660 ,0.295418217105532010 ,0.296883385163778270 ,0.298347854626741400 ,0.299811622048383350 ,0.301274683984317950 ,
    0.302737036991819140 ,0.304198677629829110 ,0.305659602458966120 ,0.307119808041533100 ,0.308579290941525030 ,0.310038047724637890 ,0.311496074958275910 ,0.312953369211560200 ,
    0.314409927055336660 ,0.315865745062183960 ,0.317320819806421740 ,0.318775147864118480 ,0.320228725813099860 ,0.321681550232956580 ,0.323133617705052330 ,0.324584924812532150 ,
    0.326035468140330240 ,0.327485244275178000 ,0.328934249805612200 ,0.330382481321982780 ,0.331829935416461110 ,0.333276608683047870 ,0.334722497717581220 ,0.336167599117744520 ,
    0.337611909483074620 ,0.339055425414969640 ,0.340498143516697160 ,0.341940060393402190 ,0.343381172652115040 ,0.344821476901759290 ,0.346260969753160010 ,0.347699647819051380 ,
    0.349137507714084970 ,0.350574546054837510 ,0.352010759459819080 ,0.353446144549480810 ,0.354880697946222790 ,0.356314416274402410 ,0.357747296160341900 ,0.359179334232336500 ,
    0.360610527120662270 ,0.362040871457584180 ,0.363470363877363760 ,0.364899001016267270 ,0.366326779512573590 ,0.367753696006581980 ,0.369179747140620020 ,0.370604929559051670 ,
    0.372029239908285010 ,0.373452674836780300 ,0.374875230995057540 ,0.376296905035704790 ,0.377717693613385640 ,0.379137593384847320 ,0.380556601008928520 ,0.381974713146567220 ,
    0.383391926460808660 ,0.384808237616812880 ,0.386223643281862980 ,0.387638140125372730 ,0.389051724818894380 ,0.390464394036126590 ,0.391876144452922350 ,0.393286972747296400 ,
    0.394696875599433560 ,0.396105849691696270 ,0.397513891708632330 ,0.398920998336982910 ,0.400327166265690090 ,0.401732392185905010 ,0.403136672790995300 ,0.404540004776553000 ,
    0.405942384840402510 ,0.407343809682607970 ,0.408744276005481360 ,0.410143780513590240 ,0.411542319913765220 ,0.412939890915108080 ,0.414336490228999100 ,0.415732114569105360 ,
    0.417126760651387870 ,0.418520425194109700 ,0.419913104917843620 ,0.421304796545479640 ,0.422695496802232950 ,0.424085202415651560 ,0.425473910115623800 ,0.426861616634386430 ,
    0.428248318706531960 ,0.429634013069016380 ,0.431018696461167030 ,0.432402365624690140 ,0.433785017303678580 ,0.435166648244619260 ,0.436547255196401200 ,0.437926834910322860 ,
    0.439305384140099950 ,0.440682899641872900 ,0.442059378174214700 ,0.443434816498138480 ,0.444809211377104880 ,0.446182559577030070 ,0.447554857866293010 ,0.448926103015743260 ,
    0.450296291798708610 ,0.451665420991002490 ,0.453033487370931580 ,0.454400487719303580 ,0.455766418819434640 ,0.457131277457156980 ,0.458495060420826270 ,0.459857764501329540 ,
    0.461219386492092380 ,0.462579923189086810 ,0.463939371390838520 ,0.465297727898434600 ,0.466654989515530920 ,0.468011153048359830 ,0.469366215305737520 ,0.470720173099071600 ,
    0.472073023242368660 ,0.473424762552241530 ,0.474775387847917120 ,0.476124895951243630 ,0.477473283686698060 ,0.478820547881393890 ,0.480166685365088390 ,0.481511692970189860 ,
    0.482855567531765670 ,0.484198305887549030 ,0.485539904877946960 ,0.486880361346047340 ,0.488219672137626790 ,0.489557834101157440 ,0.490894844087815140 ,0.492230698951486020 ,
    0.493565395548774770 ,0.494898930739011260 ,0.496231301384258250 ,0.497562504349319150 ,0.498892536501744590 ,0.500221394711840680 ,0.501549075852675390 ,0.502875576800086990 ,
    0.504200894432690340 ,0.505525025631885390 ,0.506847967281863210 ,0.508169716269614600 ,0.509490269484936360 ,0.510809623820439040 ,0.512127776171554690 ,0.513444723436543460 ,
    0.514760462516501200 ,0.516074990315366630 ,0.517388303739929060 ,0.518700399699834950 ,0.520011275107596040 ,0.521320926878595660 ,0.522629351931096610 ,0.523936547186248600 ,
    0.525242509568094710 ,0.526547236003579440 ,0.527850723422555230 ,0.529152968757790610 ,0.530453968944976320 ,0.531753720922733320 ,0.533052221632619450 ,0.534349468019137520 ,
    0.535645457029741090 ,0.536940185614842910 ,0.538233650727821700 ,0.539525849325028890 ,0.540816778365796670 ,0.542106434812443920 ,0.543394815630284800 ,0.544681917787634530 ,
    0.545967738255817570 ,0.547252274009174090 ,0.548535522025067390 ,0.549817479283890910 ,0.551098142769075430 ,0.552377509467096070 ,0.553655576367479310 ,0.554932340462810370 ,
    0.556207798748739930 ,0.557481948223991550 ,0.558754785890368310 ,0.560026308752760380 ,0.561296513819151470 ,0.562565398100626450 ,0.563832958611378170 ,0.565099192368713980 ,
    0.566364096393063840 ,0.567627667707986230 ,0.568889903340175860 ,0.570150800319470300 ,0.571410355678857230 ,0.572668566454481160 ,0.573925429685650750 ,0.575180942414845080 ,
    0.576435101687721830 ,0.577687904553122800 ,0.578939348063081780 ,0.580189429272831680 ,0.581438145240810170 ,0.582685493028668460 ,0.583931469701276180 ,0.585176072326730410 ,
    0.586419297976360500 ,0.587661143724736660 ,0.588901606649675720 ,0.590140683832248820 ,0.591378372356787580 ,0.592614669310891130 ,0.593849571785433630 ,0.595083076874569960 ,
    0.596315181675743710 ,0.597545883289693160 ,0.598775178820458720 ,0.600003065375388940 ,0.601229540065148500 ,0.602454600003723750 ,0.603678242308430370 ,0.604900464099919820 ,
    0.606121262502186120 ,0.607340634642572930 ,0.608558577651779450 ,0.609775088663868430 ,0.610990164816271660 ,0.612203803249797950 ,0.613416001108638590 ,0.614626755540375050 ,
    0.615836063695985090 ,0.617043922729849760 ,0.618250329799760250 ,0.619455282066924020 ,0.620658776695972140 ,0.621860810854965360 ,0.623061381715401260 ,0.624260486452220650 ,
    0.625458122243814250 ,0.626654286272029350 ,0.627848975722176570 ,0.629042187783036000 ,0.630233919646864370 ,0.631424168509401860 ,0.632612931569877410 ,0.633800206031017280 ,
    0.634985989099049460 ,0.636170277983712170 ,0.637353069898259130 ,0.638534362059466790 ,0.639714151687640450 ,0.640892436006621270 ,0.642069212243792540 ,0.643244477630085850 ,
    0.644418229399988380 ,0.645590464791548690 ,0.646761181046383920 ,0.647930375409685340 ,0.649098045130225950 ,0.650264187460365850 ,0.651428799656059820 ,0.652591878976862440 ,
    0.653753422685936060 ,0.654913428050056150 ,0.656071892339617600 ,0.657228812828642540 ,0.658384186794785050 ,0.659538011519338660 ,0.660690284287242300 ,0.661841002387086870 ,
    0.662990163111121470 ,0.664137763755260010 ,0.665283801619087180 ,0.666428274005865350 ,0.667571178222540310 ,0.668712511579748090 ,0.669852271391821020 ,0.670990454976794220 ,
    0.672127059656411730 ,0.673262082756132970 ,0.674395521605138940 ,0.675527373536338520 ,0.676657635886374950 ,0.677786305995631500 ,0.678913381208238410 ,0.680038858872078930 ,
    0.681162736338795430 ,0.682285010963795570 ,0.683405680106258680 ,0.684524741129142300 ,0.685642191399187470 ,0.686758028286925890 ,0.687872249166685550 ,0.688984851416597040 ,
    0.690095832418599950 ,0.691205189558448450 ,0.692312920225718220 ,0.693419021813811760 ,0.694523491719965520 ,0.695626327345254870 ,0.696727526094601090 ,0.697827085376777290 ,
    0.698925002604414150 ,0.700021275194006250 ,0.701115900565918660 ,0.702208876144391870 ,0.703300199357548730 ,0.704389867637400410 ,0.705477878419852100 ,0.706564229144709510 ,
    0.707648917255684240 ,0.708731940200400650 ,0.709813295430400730 ,0.710892980401151680 ,0.711970992572049990 ,0.713047329406429230 ,0.714121988371564710 ,0.715194966938680010 ,
    0.716266262582953120 ,0.717335872783521620 ,0.718403795023489720 ,0.719470026789932990 ,0.720534565573905270 ,0.721597408870443660 ,0.722658554178575610 ,0.723717999001323390 ,
    0.724775740845711170 ,0.725831777222770260 ,0.726886105647544860 ,0.727938723639098620 ,0.728989628720519310 ,0.730038818418926150 ,0.731086290265474230 ,0.732132041795361290 ,
    0.733176070547832740 ,0.734218374066188170 ,0.735258949897786730 ,0.736297795594053060 ,0.737334908710482790 ,0.738370286806648510 ,0.739403927446205760 ,0.740435828196898020 ,
    0.741465986630563290 ,0.742494400323139180 ,0.743521066854669010 ,0.744545983809307250 ,0.745569148775325320 ,0.746590559345117200 ,0.747610213115205150 ,0.748628107686245330 ,
    0.749644240663033480 ,0.750658609654510590 ,0.751671212273768430 ,0.752682046138055230 ,0.753691108868781210 ,0.754698398091524390 ,0.755703911436035770 ,0.756707646536245670 ,
    0.757709601030268080 ,0.758709772560407280 ,0.759708158773163330 ,0.760704757319236810 ,0.761699565853535270 ,0.762692582035177870 ,0.763683803527501760 ,0.764673227998067030 ,
    0.765660853118662390 ,0.766646676565310380 ,0.767630696018273270 ,0.768612909162058270 ,0.769593313685422940 ,0.770571907281380700 ,0.771548687647206300 ,0.772523652484441210 ,
    0.773496799498899050 ,0.774468126400670750 ,0.775437630904130430 ,0.776405310727940280 ,0.777371163595056200 ,0.778335187232733090 ,0.779297379372530300 ,0.780257737750316590 ,
    0.781216260106275980 ,0.782172944184912900 ,0.783127787735057310 ,0.784080788509869950 ,0.785031944266847970 ,0.785981252767830040 ,0.786928711779001700 ,0.787874319070900110 ,
    0.788818072418420170 ,0.789759969600819070 ,0.790700008401721610 ,0.791638186609125770 ,0.792574502015407580 ,0.793508952417326550 ,0.794441535616030480 ,0.795372249417061190 ,
    0.796301091630359000 ,0.797228060070268700 ,0.798153152555543750 ,0.799076366909352350 ,0.799997700959281910 ,0.800917152537344300 ,0.801834719479981310 ,0.802750399628069040 ,
    0.803664190826924090 ,0.804576090926307000 ,0.805486097780429120 ,0.806394209247956240 ,0.807300423192014450 ,0.808204737480194720 ,0.809107149984558130 ,0.810007658581641140 ,
    0.810906261152459670 ,0.811802955582515360 ,0.812697739761799490 ,0.813590611584798510 ,0.814481568950498610 ,0.815370609762391170 ,0.816257731928477390 ,0.817142933361272970 ,
    0.818026211977813440 ,0.818907565699658830 ,0.819786992452898880 ,0.820664490168157460 ,0.821540056780597490 ,0.822413690229926390 ,0.823285388460400110 ,0.824155149420828570 ,
    0.825022971064580110 ,0.825888851349586780 ,0.826752788238348520 ,0.827614779697938400 ,0.828474823700007130 ,0.829332918220788140 ,0.830189061241102260 ,0.831043250746362210 ,
    0.831895484726577590 ,0.832745761176359460 ,0.833594078094925140 ,0.834440433486103080 ,0.835284825358337260 ,0.836127251724692160 ,0.836967710602857020 ,0.837806200015150830 ,
    0.838642717988527300 ,0.839477262554578440 ,0.840309831749540660 ,0.841140423614297970 ,0.841969036194387680 ,0.842795667540004120 ,0.843620315706004040 ,0.844442978751910660 ,
    0.845263654741918220 ,0.846082341744896940 ,0.846899037834397240 ,0.847713741088654270 ,0.848526449590592650 ,0.849337161427830670 ,0.850145874692685210 ,0.850952587482175730 ,
    0.851757297898029010 ,0.852560004046683970 ,0.853360704039295430 ,0.854159395991738730 ,0.854956078024614820 ,0.855750748263253920 ,0.856543404837719960 ,0.857334045882815590 ,
    0.858122669538086020 ,0.858909273947823900 ,0.859693857261072610 ,0.860476417631632070 ,0.861256953218062060 ,0.862035462183687210 ,0.862811942696600330 ,0.863586392929667990 ,
    0.864358811060534030 ,0.865129195271623690 ,0.865897543750148820 ,0.866663854688111020 ,0.867428126282306920 ,0.868190356734331310 ,0.868950544250582380 ,0.869708687042265560 ,
    0.870464783325397670 ,0.871218831320810900 ,0.871970829254157700 ,0.872720775355914300 ,0.873468667861384880 ,0.874214505010706190 ,0.874958285048851540 ,0.875700006225634600 ,
    0.876439666795713610 ,0.877177265018595940 ,0.877912799158641730 ,0.878646267485068130 ,0.879377668271953180 ,0.880106999798240360 ,0.880834260347742040 ,0.881559448209143780 ,
    0.882282561676008600 ,0.883003599046780720 ,0.883722558624789660 ,0.884439438718253700 ,0.885154237640285110 ,0.885866953708892790 ,0.886577585246987040 ,0.887286130582383150 ,
    0.887992588047805560 ,0.888696955980891710 ,0.889399232724195520 ,0.890099416625192210 ,0.890797506036281490 ,0.891493499314791380 ,0.892187394822982480 ,0.892879190928051680 ,
    0.893568886002136020 ,0.894256478422316150 ,0.894941966570620750 ,0.895625348834030000 ,0.896306623604479660 ,0.896985789278863970 ,0.897662844259040750 ,0.898337786951834190 ,
    0.899010615769039070 ,0.899681329127423930 ,0.900349925448735600 ,0.901016403159702330 ,0.901680760692037730 ,0.902342996482444200 ,0.903003108972617040 ,0.903661096609247980 ,
    0.904316957844028320 ,0.904970691133653250 ,0.905622294939825160 ,0.906271767729257660 ,0.906919107973678030 ,0.907564314149832520 ,0.908207384739488700 ,0.908848318229439120 ,
    0.909487113111505430 ,0.910123767882541570 ,0.910758281044437570 ,0.911390651104122320 ,0.912020876573568230 ,0.912648955969793900 ,0.913274887814867760 ,0.913898670635911680 ,
    0.914520302965104450 ,0.915139783339685260 ,0.915757110301956720 ,0.916372282399289140 ,0.916985298184122890 ,0.917596156213972950 ,0.918204855051430900 ,0.918811393264169940 ,
    0.919415769424946960 ,0.920017982111606570 ,0.920618029907083860 ,0.921215911399408730 ,0.921811625181708120 ,0.922405169852209880 ,0.922996544014246250 ,0.923585746276256560 ,
    0.924172775251791200 ,0.924757629559513910 ,0.925340307823206310 ,0.925920808671769960 ,0.926499130739230510 ,0.927075272664740100 ,0.927649233092581180 ,0.928221010672169440 ,
    0.928790604058057020 ,0.929358011909935500 ,0.929923232892639560 ,0.930486265676149780 ,0.931047108935595280 ,0.931605761351257830 ,0.932162221608574320 ,0.932716488398140250 ,
    0.933268560415712050 ,0.933818436362210960 ,0.934366114943725900 ,0.934911594871516090 ,0.935454874862014620 ,0.935995953636831300 ,0.936534829922755500 ,0.937071502451759190 ,
    0.937605969960999990 ,0.938138231192824360 ,0.938668284894770170 ,0.939196129819569900 ,0.939721764725153340 ,0.940245188374650880 ,0.940766399536396070 ,0.941285396983928660 ,
    0.941802179495997650 ,0.942316745856563780 ,0.942829094854802710 ,0.943339225285107720 ,0.943847135947092690 ,0.944352825645594750 ,0.944856293190677210 ,0.945357537397632290 ,
    0.945856557086983910 ,0.946353351084490590 ,0.946847918221148000 ,0.947340257333191940 ,0.947830367262101010 ,0.948318246854599090 ,0.948803894962658380 ,0.949287310443502010 ,
    0.949768492159606680 ,0.950247438978705230 ,0.950724149773789610 ,0.951198623423113230 ,0.951670858810193860 ,0.952140854823815830 ,0.952608610358033240 ,0.953074124312172200 ,
    0.953537395590833280 ,0.953998423103894490 ,0.954457205766513490 ,0.954913742499130520 ,0.955368032227470240 ,0.955820073882545420 ,0.956269866400658140 ,0.956717408723403050 ,
    0.957162699797670100 ,0.957605738575646240 ,0.958046524014818600 ,0.958485055077976100 ,0.958921330733213170 ,0.959355349953930790 ,0.959787111718839900 ,0.960216615011963430 ,
    0.960643858822638470 ,0.961068842145519350 ,0.961491563980579000 ,0.961912023333112100 ,0.962330219213737400 ,0.962746150638399410 ,0.963159816628371360 ,0.963571216210257210 ,
    0.963980348415994110 ,0.964387212282854290 ,0.964791806853447900 ,0.965194131175724720 ,0.965594184302976830 ,0.965991965293840570 ,0.966387473212298790 ,0.966780707127683270 ,
    0.967171666114676640 ,0.967560349253314360 ,0.967946755628987800 ,0.968330884332445190 ,0.968712734459794780 ,0.969092305112506100 ,0.969469595397412950 ,0.969844604426714830 ,
    0.970217331317979160 ,0.970587775194143630 ,0.970955935183517970 ,0.971321810419786160 ,0.971685400042008540 ,0.972046703194623380 ,0.972405719027449770 ,0.972762446695688570 ,
    0.973116885359925130 ,0.973469034186130950 ,0.973818892345666100 ,0.974166459015280320 ,0.974511733377115720 ,0.974854714618708430 ,0.975195401932990370 ,0.975533794518291360 ,
    0.975869891578341030 ,0.976203692322270560 ,0.976535195964614470 ,0.976864401725312640 ,0.977191308829712280 ,0.977515916508569280 ,0.977838223998050430 ,0.978158230539735050 ,
    0.978475935380616830 ,0.978791337773105670 ,0.979104436975029250 ,0.979415232249634780 ,0.979723722865591170 ,0.980029908096990090 ,0.980333787223347960 ,0.980635359529608120 ,
    0.980934624306141640 ,0.981231580848749730 ,0.981526228458664660 ,0.981818566442552500 ,0.982108594112513610 ,0.982396310786084690 ,0.982681715786240860 ,0.982964808441396440 ,
    0.983245588085407070 ,0.983524054057571260 ,0.983800205702631490 ,0.984074042370776450 ,0.984345563417641900 ,0.984614768204312600 ,0.984881656097323700 ,0.985146226468662230 ,
    0.985408478695768420 ,0.985668412161537550 ,0.985926026254321130 ,0.986181320367928270 ,0.986434293901627070 ,0.986684946260146690 ,0.986933276853677710 ,0.987179285097874340 ,
    0.987422970413855410 ,0.987664332228205710 ,0.987903369972977790 ,0.988140083085692570 ,0.988374471009341280 ,0.988606533192386450 ,0.988836269088763540 ,0.989063678157881540 ,
    0.989288759864625170 ,0.989511513679355190 ,0.989731939077910570 ,0.989950035541608990 ,0.990165802557248400 ,0.990379239617108160 ,0.990590346218950150 ,0.990799121866020370 ,
    0.991005566067049370 ,0.991209678336254060 ,0.991411458193338540 ,0.991610905163495370 ,0.991808018777406430 ,0.992002798571244520 ,0.992195244086673920 ,0.992385354870851670 ,
    0.992573130476428810 ,0.992758570461551140 ,0.992941674389860470 ,0.993122441830495580 ,0.993300872358093280 ,0.993476965552789190 ,0.993650721000219120 ,0.993822138291519660 ,
    0.993991217023329380 ,0.994157956797789730 ,0.994322357222545810 ,0.994484417910747600 ,0.994644138481050710 ,0.994801518557617110 ,0.994956557770116380 ,0.995109255753726110 ,
    0.995259612149133390 ,0.995407626602534900 ,0.995553298765638470 ,0.995696628295663520 ,0.995837614855341610 ,0.995976258112917790 ,0.996112557742151130 ,0.996246513422315520 ,
    0.996378124838200210 ,0.996507391680110820 ,0.996634313643869900 ,0.996758890430818000 ,0.996881121747813850 ,0.997001007307235290 ,0.997118546826979980 ,0.997233740030466160 ,
    0.997346586646633230 ,0.997457086409941910 ,0.997565239060375750 ,0.997671044343441000 ,0.997774502010167820 ,0.997875611817110150 ,0.997974373526346990 ,0.998070786905482340 ,
    0.998164851727646240 ,0.998256567771495180 ,0.998345934821212370 ,0.998432952666508440 ,0.998517621102622210 ,0.998599939930320370 ,0.998679908955899090 ,0.998757527991183340 ,
    0.998832796853527990 ,0.998905715365818290 ,0.998976283356469820 ,0.999044500659429290 ,0.999110367114174890 ,0.999173882565716380 ,0.999235046864595850 ,0.999293859866887790 ,
    0.999350321434199440 ,0.999404431433671300 ,0.999456189737977340 ,0.999505596225325310 ,0.999552650779456990 ,0.999597353289648380 ,0.999639703650710200 ,0.999679701762987930 ,
    0.999717347532362190 ,0.999752640870248840 ,0.999785581693599210 ,0.999816169924900410 ,0.999844405492175240 ,0.999870288328982950 ,0.999893818374418490 ,0.999914995573113470 ,
    0.999933819875236000 ,0.999950291236490480 ,0.999964409618118280 ,0.999976174986897610 ,0.999985587315143200 ,0.999992646580707190 ,0.999997352766978210 ,0.999999705862882230 
};

/*End of File*/
