/**
 *  armICJP_QuantTable.c
 * 
 * (c) Copyright 2005,2006 ARM Limited. All Rights Reserved.
 * 
 * THIS SOFTWARE IS PROVIDED “AS IS”, ARM EXPRESSLY DISCLAIMS ALL REPRESENTATIONS, 
 * WARRANTIES, CONDITIONS OR OTHER TERMS, EXPRESS, IMPLIED OR STATUTORY, INCLUDING 
 * WITHOUT LIMITATION THE IMPLIED WARRANTIES OF NON-INFRINGEMENT, MERCHANTABILITY, 
 * SATISFACTORY QUALITY, AND FITNESS FOR A PARTICULAR PURPOSE. 
 * 
 * Your use of this Software may require additional licenses, including but not 
 * limited to copyright and patent licenses from various entities. Should any 
 * such additional copyright, patent or other licenses be required, ARM expects 
 * that you will and you agree to obtain any such licenses at your own expense. 
 * You are solely responsible for obtaining any such licenses and the copyright 
 * licenses granted herein are conditioned on you obtaining such additional 
 * licenses.
 * 
 *   
 * Description:
 * This file defines the table used for initialization of quantization table for FDCT/IDCT
 *
 */

#include "omxtypes.h"
#include "armIC.h"

const OMX_F64 armICJP_QuantTable[64] = 
{
    0.125000000000000000,  0.173379980665268440,  0.163320370609547070,  0.146984450302419860,  0.125000000000000030,  0.098211869798387794,  0.067649512518274640,  0.034487422410367889,  
    0.173379980665268440,  0.240484941563910870,  0.226531861588222030,  0.203873289212229330,  0.173379980665268470,  0.136223776693954690,  0.093832569379466338,  0.047835429045636244,  
    0.163320370609547070,  0.226531861588222030,  0.213388347648318490,  0.192044439177854100,  0.163320370609547100,  0.128319991789834250,  0.088388347648318474,  0.045059988875434262,  
    0.146984450302419860,  0.203873289212229330,  0.192044439177854100,  0.172835429045636230,  0.146984450302419860,  0.115484941563910880,  0.079547411285802144,  0.040552918602682231,  
    0.125000000000000030,  0.173379980665268470,  0.163320370609547100,  0.146984450302419860,  0.125000000000000030,  0.098211869798387808,  0.067649512518274654,  0.034487422410367889,  
    0.098211869798387794,  0.136223776693954690,  0.128319991789834250,  0.115484941563910880,  0.098211869798387808,  0.077164570954363812,  0.053151880922953552,  0.027096593915592420,  
    0.067649512518274640,  0.093832569379466338,  0.088388347648318474,  0.079547411285802144,  0.067649512518274654,  0.053151880922953552,  0.036611652351681581,  0.018664458512585660,  
    0.034487422410367889,  0.047835429045636244,  0.045059988875434262,  0.040552918602682231,  0.034487422410367889,  0.027096593915592420,  0.018664458512585660,  0.009515058436089161
};

/*End of File*/
