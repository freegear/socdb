/**
 *  omxICJP_DCTQuantFwdTableInit.c
 * 
 * (c) Copyright 2005,2006 ARM Limited. All Rights Reserved.
 * 
 * THIS SOFTWARE IS PROVIDED “AS IS”, ARM EXPRESSLY DISCLAIMS ALL REPRESENTATIONS, 
 * WARRANTIES, CONDITIONS OR OTHER TERMS, EXPRESS, IMPLIED OR STATUTORY, INCLUDING 
 * WITHOUT LIMITATION THE IMPLIED WARRANTIES OF NON-INFRINGEMENT, MERCHANTABILITY, 
 * SATISFACTORY QUALITY, AND FITNESS FOR A PARTICULAR PURPOSE. 
 * 
 * Your use of this Software may require additional licenses, including but not 
 * limited to copyright and patent licenses from various entities. Should any 
 * such additional copyright, patent or other licenses be required, ARM expects 
 * that you will and you agree to obtain any such licenses at your own expense. 
 * You are solely responsible for obtaining any such licenses and the copyright 
 * licenses granted herein are conditioned on you obtaining such additional 
 * licenses.
 * 
 *
 * Description:
 * This file contains module for table initialization for IDCT
 *
 */

#include "omxtypes.h"
#include "omxIC.h"

#include "armIC.h"
#include "armCOMM.h"

/**
 * Function: omxICJP_DCTQuantFwdTableInit
 *
 * Brief:
 * Quantization table initialization function.
 *
 * Description:
 * Generate the quantization table for optimized FDCT and quantization functions.
 * Output matrix is automatically transposed for compatibility with quantization and DCT functions.
 *
 * Parameters:
 * [in]  pQuantRawTable  pointer to the raw quantization table; must be aligned on an 8-byte boundary.  
 *                       The table must contain 64 entries.
 * [out] pQuantFwdTable  pointer to the pre-scaled quantization table; must be aligned on an  8 byte boundary. 
 *                       Table must contain 64 entries that are computed as follows: pQuantFwdTable[i][j]=(c[i][j]/pQuantRawTable[i][j]) + 0.5, 
 *                       where c(i,j) = 1/(x(i)*x(j)*8), x(0)=x(4)=1, x(n)=1/sqrt(2)*cos(n*pi/16)) for n=1,2,3,5,6,7, 
 *                       and the indices i and j are defined as:  0 <= i, j <= 7. 
 *                       Scaling (Q-format) of the table entries may be implementation-specific, but the Q-format of the table entries generated by this function 
 *                       must match the input Q-format on the table entries expected by the associated set of forward DCT quantization functions in the same OpenMAX DL implementation, 
 *                       including the functions DCTQuantFwd_S16, DCTQuantFwd_S16_I, and DCTQuantFwd_Multiple_S16.
 *
 * Return Value:
 * Standard OMXResult result. See enumeration for possible result codes.
 *
 */

OMXResult omxICJP_DCTQuantFwdTableInit(
     const OMX_U8 *pQuantRawTable,
     OMX_U32 *pQuantFwdTable
 )
{
    OMX_INT i;
    OMX_U8  j;
    OMX_F64 coef;
    
    /* Argument Checks */
    armRetArgErrIf( pQuantRawTable == NULL, OMX_StsBadArgErr)
    armRetArgErrIf( pQuantFwdTable == NULL, OMX_StsBadArgErr)
    
    armRetArgErrIf( armNot8ByteAligned(pQuantFwdTable), OMX_StsBadArgErr)
    armRetArgErrIf( armNot8ByteAligned(pQuantRawTable), OMX_StsBadArgErr)

    /* Processing */
    for (i = 0; i < 64 ; i++ )
    {
        coef = (1.0/pQuantRawTable[i]);
        j    = armICJP_ZigZagTable[i];
        
        pQuantFwdTable[j] = (OMX_U32)armSatRoundFloatToU32(coef * (1 << ARM_ICJP_QUANT_Q) );
    }

    return OMX_StsNoErr;
}

/*End of File*/

