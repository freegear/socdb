/**
 *  omxICJP_DCTQuantInvTableInit.c
 * 
 * (c) Copyright 2005,2006 ARM Limited. All Rights Reserved.
 * 
 * THIS SOFTWARE IS PROVIDED “AS IS”, ARM EXPRESSLY DISCLAIMS ALL REPRESENTATIONS, 
 * WARRANTIES, CONDITIONS OR OTHER TERMS, EXPRESS, IMPLIED OR STATUTORY, INCLUDING 
 * WITHOUT LIMITATION THE IMPLIED WARRANTIES OF NON-INFRINGEMENT, MERCHANTABILITY, 
 * SATISFACTORY QUALITY, AND FITNESS FOR A PARTICULAR PURPOSE. 
 * 
 * Your use of this Software may require additional licenses, including but not 
 * limited to copyright and patent licenses from various entities. Should any 
 * such additional copyright, patent or other licenses be required, ARM expects 
 * that you will and you agree to obtain any such licenses at your own expense. 
 * You are solely responsible for obtaining any such licenses and the copyright 
 * licenses granted herein are conditioned on you obtaining such additional 
 * licenses.
 * 
 *
 * Description:
 * This file contains module for table initialization for IDCT
 *
 */

#include "omxtypes.h"
#include "omxIC.h"

#include "armIC.h"
#include "armCOMM.h"

/**
 * Function: omxICJP_DCTQuantInvTableInit
 *
 * Brief:
 * Dequantization table initialization function.
 *
 * Description:
 * Generates the JPEG IDCT inverse quantization table for 8-bit image data.
 *
 * Parameters:
 * [in]  pQuantRawTable pointer to the raw (unprocessed) quantization table, containing 64 entries; must be 
 *                      aligned on an 8-byte boundary.
 * [out] pQuantInvTable pointer to the pre-scaled quantization table; must be aligned on an  8 byte boundary.  
 *                      Table must contain 64 entries each 32-bits wide.
 *                      Scaling (Q-format) of the table entries may be implementation-specific, 
 *                      but the Q-format of the table entries generated by this function must match the input Q-format on the table entries expected by the 
 *                      associated set of inverse DCT quantization functions in the same OpenMAX DL implementation, including the functions DCTQuantInv_S16,
 *                      DCTQuantInv_S16_I, and DCTQuantInv_Multiple_S16.
 *
 * Return Value:
 * OMX_StsNoErr - no error
 * OMX_StsBadArgErr - Bad arguments. Returned for any of the following conditions:
 *      - a pointer was NULL
 *      - the start address of a pointer was not 8-byte aligned.
 *
 */

OMXResult omxICJP_DCTQuantInvTableInit (
     const OMX_U8 *pQuantRawTable,
     OMX_U32 *pQuantInvTable
 )
{
    OMX_INT i;
    OMX_U8  j,coef;
    
    /* Argument Checks */
    armRetArgErrIf( pQuantRawTable == NULL, OMX_StsBadArgErr)
    armRetArgErrIf( pQuantInvTable == NULL, OMX_StsBadArgErr)
    
    armRetArgErrIf( armNot8ByteAligned(pQuantInvTable), OMX_StsBadArgErr)
    armRetArgErrIf( armNot8ByteAligned(pQuantRawTable), OMX_StsBadArgErr)

    /* Processing */
    for (i = 0; i < 64 ; i++ )
    {
        coef = pQuantRawTable[i];
        j    = armICJP_ZigZagTable[i];
        
        pQuantInvTable[j] = (OMX_U32)coef;
    }


    return OMX_StsNoErr;
}

/*End of File*/


